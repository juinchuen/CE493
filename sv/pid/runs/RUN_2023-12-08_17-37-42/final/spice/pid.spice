* NGSPICE file created from pid.ext - technology: sky130A

.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
X0 a_377_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.365 ps=1.73 w=1 l=0.15
X1 a_47_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.3 ps=2.6 w=1 l=0.15
X2 a_129_47# B a_47_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_285_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 Y a_47_47# a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_129_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0683 ps=0.86 w=0.65 l=0.15
X6 VPWR A a_47_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.365 pd=1.73 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_47_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.165 ps=1.33 w=1 l=0.15
X8 Y B a_377_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.05
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.05
.ends

.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=0.59
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=0.59
.ends

.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=2.89
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=2.89
.ends

.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.97
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.97
.ends

.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_109_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A a_113_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_113_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_2 A1 A2 B1_N VGND VNB VPB VPWR X
X0 VGND B1_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VGND A2 a_478_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.106 ps=0.975 w=0.65 l=0.15
X2 a_478_47# a_27_93# a_174_21# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_478_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 X a_174_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X5 VPWR a_174_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_174_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X7 VPWR A1 a_574_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.105 ps=1.21 w=1 l=0.15
X8 VGND a_174_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR B1_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X10 a_574_297# A2 a_174_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X11 a_174_21# a_27_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.395 ps=1.79 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
X0 VGND A a_68_297# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_68_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_68_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR A a_150_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 X a_68_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.34 pd=2.68 as=0.146 ps=1.34 w=1 l=0.15
X5 a_150_297# B a_68_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VPWR C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 a_181_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VGND C a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.132 pd=1.14 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 a_27_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X6 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.132 ps=1.14 w=0.65 l=0.15
X7 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 Y B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X1 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.135 ps=1.27 w=1 l=0.15
X3 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_381_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_109_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VGND A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0683 ps=0.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 Y a_61_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.183 ps=1.24 w=0.65 l=0.15
X1 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_217_297# a_61_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_479_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X4 a_217_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X5 Y a_61_47# a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 VPWR A1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_61_47# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VGND A2 a_637_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_61_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A1 a_479_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0683 ps=0.86 w=0.65 l=0.15
X11 VGND B1_N a_61_47# VNB sky130_fd_pr__nfet_01v8 ad=0.183 pd=1.24 as=0.126 ps=1.44 w=0.42 l=0.15
X12 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X13 a_637_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
X0 a_297_47# a_27_47# a_193_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_369_47# B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0441 ps=0.63 w=0.42 l=0.15
X2 VPWR D a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.0662 ps=0.735 w=0.42 l=0.15
X3 X a_193_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.103 ps=1 w=0.65 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND D a_469_47# VNB sky130_fd_pr__nfet_01v8 ad=0.103 pd=1 as=0.0609 ps=0.71 w=0.42 l=0.15
X6 X a_193_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR B a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.128 pd=1.03 as=0.0987 ps=0.89 w=0.42 l=0.15
X8 a_193_413# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.128 ps=1.03 w=0.42 l=0.15
X9 a_193_413# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0987 pd=0.89 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 a_469_47# C a_369_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.0735 ps=0.77 w=0.42 l=0.15
X11 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_382_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X1 a_297_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X2 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.327 pd=1.65 as=0.28 ps=2.56 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.327 ps=1.65 w=1 l=0.15
X6 a_382_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.195 ps=1.39 w=1 l=0.15
X7 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.149 ps=1.33 w=1 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.149 pd=1.33 as=0.166 ps=1.8 w=0.64 l=0.15
X3 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X4 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 a_81_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.257 ps=1.44 w=0.65 l=0.15
X1 a_299_297# B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_299_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 a_384_47# A1 a_81_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_199_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_113_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.147 ps=1.29 w=1 l=0.15
X2 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X3 VPWR A1 a_113_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.29 as=0.14 ps=1.28 w=1 l=0.15
X4 a_113_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A2 a_199_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0959 ps=0.945 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X2 a_193_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y A a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X4 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 a_109_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.16 ps=1.32 w=1 l=0.15
X1 a_27_297# B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X2 VGND A2 a_373_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.114 ps=1 w=0.65 l=0.15
X3 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X4 a_27_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.253 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.253 ps=2.52 w=1 l=0.15
X6 a_373_47# A1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.96 w=0.65 l=0.15
X8 a_109_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_222_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X1 VPWR A1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.105 ps=1.21 w=1 l=0.15
X2 VGND a_79_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_222_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.186 ps=1.41 w=0.42 l=0.15
X4 VGND A2 a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_448_47# a_222_93# a_79_199# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_79_199# a_222_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.3 ps=2.6 w=1 l=0.15
X7 a_544_297# A2 a_79_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X8 a_448_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.186 pd=1.41 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X1 a_80_21# C1 a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X2 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_300_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.26 ps=1.45 w=0.65 l=0.15
X6 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_80_21# A1 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 a_472_297# B1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X9 a_80_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
X0 X a_35_297# a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.26 ps=2.52 w=1 l=0.15
X1 X B a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.25 pd=1.42 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_117_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 VPWR B a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.25 ps=1.42 w=0.65 l=0.15
X7 a_285_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A a_117_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
X0 VPWR B a_207_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.228 pd=1.74 as=0.0609 ps=0.71 w=0.42 l=0.15
X1 X a_207_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.228 ps=1.74 w=1 l=0.15
X2 a_297_47# a_27_413# a_207_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0504 pd=0.66 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_207_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.99 w=0.65 l=0.15
X4 a_207_413# a_27_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0609 pd=0.71 as=0.0714 ps=0.76 w=0.42 l=0.15
X5 VPWR A_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0714 pd=0.76 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VGND B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.99 as=0.0504 ps=0.66 w=0.42 l=0.15
X7 a_27_413# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
X0 VPWR B a_59_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 X a_59_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.475 pd=2.95 as=0.167 ps=1.39 w=1 l=0.15
X2 VGND B a_145_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_59_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X4 X a_59_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.112 ps=1.04 w=0.65 l=0.15
X5 a_145_75# A a_59_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_300_297# a_27_413# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X3 Y a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.102 ps=0.99 w=0.65 l=0.15
X4 VPWR A1 a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 a_384_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.143 ps=1.09 w=0.65 l=0.15
X6 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.111 ps=1.37 w=0.42 l=0.15
X7 a_300_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfxtp_1 CLK D VGND VNB VPB VPWR Q
X0 Q a_1059_315# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_891_413# a_193_47# a_634_159# VNB sky130_fd_pr__nfet_01v8 ad=0.0684 pd=0.74 as=0.0989 ps=0.995 w=0.36 l=0.15
X2 a_561_413# a_27_47# a_466_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0767 pd=0.785 as=0.0683 ps=0.745 w=0.42 l=0.15
X3 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X4 Q a_1059_315# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_381_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0578 pd=0.695 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VGND a_634_159# a_592_47# VNB sky130_fd_pr__nfet_01v8 ad=0.121 pd=1.09 as=0.0696 ps=0.765 w=0.42 l=0.15
X7 VPWR a_891_413# a_1059_315# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.27 ps=2.54 w=1 l=0.15
X8 a_466_413# a_193_47# a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.0578 ps=0.695 w=0.42 l=0.15
X9 VPWR a_634_159# a_561_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.179 pd=1.26 as=0.0767 ps=0.785 w=0.42 l=0.15
X10 a_634_159# a_466_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0989 pd=0.995 as=0.121 ps=1.09 w=0.64 l=0.15
X11 a_634_159# a_466_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.08 as=0.179 ps=1.26 w=0.75 l=0.15
X12 a_975_413# a_193_47# a_891_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0882 pd=0.84 as=0.0567 ps=0.69 w=0.42 l=0.15
X13 VGND a_1059_315# a_1017_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.066 ps=0.745 w=0.42 l=0.15
X14 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X15 a_891_413# a_27_47# a_634_159# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.08 w=0.42 l=0.15
X16 a_592_47# a_193_47# a_466_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0696 pd=0.765 as=0.0621 ps=0.705 w=0.36 l=0.15
X17 a_1017_47# a_27_47# a_891_413# VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.0684 ps=0.74 w=0.36 l=0.15
X18 VPWR a_1059_315# a_975_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.0882 ps=0.84 w=0.42 l=0.15
X19 a_466_413# a_27_47# a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0621 pd=0.705 as=0.0813 ps=0.83 w=0.36 l=0.15
X20 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X21 VGND a_891_413# a_1059_315# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X22 a_381_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0813 pd=0.83 as=0.109 ps=1.36 w=0.42 l=0.15
X23 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0683 ps=0.86 w=0.65 l=0.15
X1 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=2.1 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A1 a_114_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
X3 a_114_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.185 ps=1.87 w=0.65 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.28 ps=2.56 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X10 a_285_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.091 ps=0.93 w=0.65 l=0.15
X11 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.42 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0703 pd=0.755 as=0.111 ps=1.37 w=0.42 l=0.15
X6 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.14 ps=1.28 w=1 l=0.15
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0703 ps=0.755 w=0.42 l=0.15
X8 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.165 ps=1.33 w=1 l=0.15
X9 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_56_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A2 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_139_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.266 ps=2.12 w=0.65 l=0.15
X4 a_311_297# B1 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X5 Y C1 a_311_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X7 Y A1 a_139_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
X0 a_109_93# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_215_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 VGND a_109_93# a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND A a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 VPWR A a_369_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_369_297# B a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_215_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X7 a_297_297# a_109_93# a_215_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_109_93# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 X a_215_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.1 ps=0.985 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
X0 a_27_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_560_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X2 VGND B a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0991 ps=0.955 w=0.65 l=0.15
X3 Y B a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_297# a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_474_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X7 VGND A a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# B a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X12 a_474_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_560_47# a_27_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X14 VPWR A a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X15 Y a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X16 VPWR a_27_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X17 a_560_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
X0 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X5 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X17 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X21 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X23 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X36 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X39 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
X0 X a_29_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.148 ps=1.34 w=1 l=0.15
X1 a_111_297# C a_29_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_29_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.102 ps=0.99 w=0.65 l=0.15
X3 a_183_297# B a_111_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 VPWR A a_183_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X5 a_29_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VGND C a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_197_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0798 pd=0.8 as=0.0609 ps=0.71 w=0.42 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.312 ps=1.68 w=1 l=0.15
X3 a_303_47# C a_197_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0798 ps=0.8 w=0.42 l=0.15
X4 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.68 as=0.0588 ps=0.7 w=0.42 l=0.15
X6 VGND D a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.196 pd=1.33 as=0.0693 ps=0.75 w=0.42 l=0.15
X7 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X8 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.196 ps=1.33 w=0.65 l=0.15
X9 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 Y A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.174 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.182 pd=1.92 as=0.174 ps=1.39 w=0.7 l=0.15
X2 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X3 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfxtp_4 CLK D VGND VNB VPB VPWR Q
X0 Q a_1062_300# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.142 ps=1.28 w=1 l=0.15
X1 a_1020_47# a_27_47# a_891_413# VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.0657 ps=0.725 w=0.36 l=0.15
X2 a_572_47# a_193_47# a_475_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0687 pd=0.76 as=0.0594 ps=0.69 w=0.36 l=0.15
X3 VPWR a_1062_300# a_975_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.122 pd=1.42 as=0.0913 ps=0.855 w=0.42 l=0.15
X4 a_634_183# a_475_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0989 pd=0.995 as=0.149 ps=1.22 w=0.64 l=0.15
X5 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X6 a_381_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.74 as=0.109 ps=1.36 w=0.42 l=0.15
X7 a_475_413# a_27_47# a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X8 VGND a_1062_300# a_1020_47# VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.41 as=0.066 ps=0.745 w=0.42 l=0.15
X9 VPWR a_634_183# a_568_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.179 pd=1.26 as=0.0693 ps=0.75 w=0.42 l=0.15
X10 Q a_1062_300# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0926 ps=0.935 w=0.65 l=0.15
X11 a_568_413# a_27_47# a_475_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0662 ps=0.735 w=0.42 l=0.15
X12 a_634_183# a_475_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.08 as=0.179 ps=1.26 w=0.75 l=0.15
X13 a_975_413# a_193_47# a_891_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0913 pd=0.855 as=0.0567 ps=0.69 w=0.42 l=0.15
X14 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X15 a_891_413# a_27_47# a_634_183# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.08 w=0.42 l=0.15
X16 Q a_1062_300# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.106 ps=0.975 w=0.65 l=0.15
X17 VGND a_891_413# a_1062_300# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
X18 VPWR a_1062_300# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X19 VGND a_1062_300# Q VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Q a_1062_300# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.162 ps=1.33 w=1 l=0.15
X21 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X22 VGND a_1062_300# Q VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 a_381_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.109 ps=1.36 w=0.42 l=0.15
X24 VPWR a_891_413# a_1062_300# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.28 ps=2.56 w=1 l=0.15
X25 a_891_413# a_193_47# a_634_183# VNB sky130_fd_pr__nfet_01v8 ad=0.0657 pd=0.725 as=0.0989 ps=0.995 w=0.36 l=0.15
X26 a_475_413# a_193_47# a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.0672 ps=0.74 w=0.42 l=0.15
X27 VGND a_634_183# a_572_47# VNB sky130_fd_pr__nfet_01v8 ad=0.149 pd=1.22 as=0.0687 ps=0.76 w=0.42 l=0.15
X28 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X29 VPWR a_1062_300# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VGND A1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
X1 a_510_47# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.143 ps=1.09 w=0.65 l=0.15
X2 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.175 ps=1.35 w=1 l=0.15
X3 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.22 ps=1.44 w=1 l=0.15
X4 a_79_21# A2 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.22 pd=1.44 as=0.162 ps=1.33 w=1 l=0.15
X5 a_297_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X6 a_79_21# C1 a_510_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.114 ps=1 w=0.65 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X8 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
X9 a_215_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.106 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
X0 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_161_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X2 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_161_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A a_161_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_161_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_388_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.127 pd=1.25 as=0.153 ps=1.3 w=1 l=0.15
X1 a_105_352# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_297_47# a_105_352# Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A1 a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.127 ps=1.25 w=1 l=0.15
X5 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X6 VPWR B1_N a_105_352# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.178 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 Y a_105_352# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.178 ps=1.4 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X21 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_298_297# a_27_413# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.265 ps=2.53 w=1 l=0.15
X1 a_215_297# a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.136 ps=1.1 w=0.65 l=0.15
X2 a_298_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.258 ps=1.45 w=0.65 l=0.15
X4 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X6 a_382_47# A1 a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.136 pd=1.1 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VPWR A1 a_298_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND A2 a_382_47# VNB sky130_fd_pr__nfet_01v8 ad=0.258 pd=1.45 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
X0 VPWR A a_304_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X1 a_304_297# B a_220_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND C a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X3 a_220_297# C a_114_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X4 a_32_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_32_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X11 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X13 a_114_297# D a_32_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.26 ps=2.52 w=1 l=0.15
X14 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
X0 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.165 ps=1.33 w=1 l=0.15
X2 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_193_47# C a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_277_47# B a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.35 as=0.265 ps=2.53 w=1 l=0.15
X1 a_209_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.172 ps=1.35 w=1 l=0.15
X2 a_303_47# A2 a_209_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.104 ps=0.97 w=0.65 l=0.15
X3 a_209_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.112 ps=0.995 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.172 ps=1.83 w=0.65 l=0.15
X5 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.107 ps=0.98 w=0.65 l=0.15
X6 a_80_21# A1 a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X7 VPWR A2 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.16 ps=1.32 w=1 l=0.15
X8 a_80_21# B1 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X9 a_209_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 a_78_199# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 VPWR A1 a_493_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X2 a_493_297# A2 a_78_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.235 ps=1.47 w=1 l=0.15
X3 VPWR a_78_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.373 pd=1.75 as=0.28 ps=2.56 w=1 l=0.15
X4 VGND A2 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X5 a_78_199# B2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.235 pd=1.47 as=0.117 ps=1.24 w=1 l=0.15
X6 a_215_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_215_47# B2 a_78_199# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_292_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.117 pd=1.24 as=0.373 ps=1.75 w=1 l=0.15
X9 VGND a_78_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.745 as=0.111 ps=1.37 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.162 ps=1.33 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.26 ps=1.45 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.4 ps=1.8 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.205 pd=1.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.135 ps=1.27 w=1 l=0.15
X5 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_109_297# C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.272 ps=2.56 w=1 l=0.15
X15 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X17 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X19 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X24 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.257 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X30 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X38 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
X0 VPWR D a_343_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.46 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_223_47# B_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.5 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 a_515_93# a_223_47# a_429_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 a_223_47# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.134 pd=1.48 as=0.0588 ps=0.7 w=0.42 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.168 ps=1.64 w=0.42 l=0.15
X5 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.168 ps=1.64 w=0.42 l=0.15
X6 X a_343_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.172 ps=1.46 w=1 l=0.15
X7 a_429_93# a_27_47# a_343_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.118 ps=1.4 w=0.42 l=0.15
X8 VGND D a_615_93# VNB sky130_fd_pr__nfet_01v8 ad=0.126 pd=1.11 as=0.0777 ps=0.79 w=0.42 l=0.15
X9 a_343_93# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X10 a_343_93# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.122 ps=1.42 w=0.42 l=0.15
X11 a_615_93# C a_515_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X12 X a_343_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.82 as=0.126 ps=1.11 w=0.65 l=0.15
X13 VPWR a_223_47# a_343_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_470_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_470_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_470_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.106 ps=0.975 w=0.65 l=0.15
X6 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X8 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X10 a_470_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.162 ps=1.33 w=1 l=0.15
X11 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 VPWR B a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X13 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X16 X a_112_47# a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 a_470_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X18 X B a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.385 pd=1.77 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X9 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.385 ps=1.77 w=1 l=0.15
X14 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X21 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X31 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
X0 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.157 ps=1.17 w=0.42 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.157 pd=1.17 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X6 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
X0 VPWR A a_49_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VGND a_285_47# a_391_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.5
X2 X a_391_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VGND A a_49_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR a_285_47# a_391_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.5
X5 a_285_47# a_49_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X6 a_285_47# a_49_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X7 X a_391_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_206_369# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.146 ps=1.34 w=0.42 l=0.15
X1 a_206_369# A2_N a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 VGND B2 a_489_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_585_369# B2 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0672 ps=0.74 w=0.42 l=0.15
X4 a_489_47# a_206_369# a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_489_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VPWR A2_N a_206_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.209 pd=1.35 as=0.129 ps=1.18 w=0.42 l=0.15
X7 a_76_199# a_206_369# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.74 as=0.209 ps=1.35 w=0.42 l=0.15
X8 a_205_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0662 pd=0.735 as=0.0986 ps=0.98 w=0.42 l=0.15
X9 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.26 ps=2.52 w=1 l=0.15
X10 VPWR B1 a_585_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0986 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VGND A2 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR A1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_37_297# B1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_485_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_292_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VPWR A2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X8 a_485_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X11 a_37_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 Y A1 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X13 Y C1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_292_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X15 a_292_297# B1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
D0 VNB DIODE sky130_fd_pr__diode_pw2nd_05v5 pj=2.64e+06 area=4.347e+11
.ends

.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
X0 VPWR a_75_212# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 a_75_212# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 a_75_212# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND a_75_212# X VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
X0 VPWR a_505_21# a_535_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_505_21# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.0693 ps=0.75 w=0.42 l=0.15
X2 a_218_374# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0767 pd=0.785 as=0.158 ps=1.39 w=0.42 l=0.15
X3 VGND a_505_21# a_439_47# VNB sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.11 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 a_76_199# A0 a_218_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.193 pd=1.34 as=0.0767 ps=0.785 w=0.42 l=0.15
X5 a_505_21# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.145 ps=1.11 w=0.42 l=0.15
X6 a_439_47# A0 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0997 ps=0.895 w=0.42 l=0.15
X7 a_535_374# A1 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.193 ps=1.34 w=0.42 l=0.15
X8 a_76_199# A1 a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0997 pd=0.895 as=0.0693 ps=0.75 w=0.42 l=0.15
X9 a_218_47# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.113 ps=1.04 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.158 pd=1.39 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.04 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_226_47# A2_N a_226_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_489_413# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_226_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.167 ps=1.43 w=0.42 l=0.15
X3 VPWR B2 a_489_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_489_413# a_226_47# a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_76_199# a_226_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.139 ps=1.08 w=0.42 l=0.15
X6 VGND B1 a_556_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_556_47# B2 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VGND A2_N a_226_47# VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.08 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_226_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.12 ps=1.09 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.43 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.09 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_27_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_277_297# B a_205_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VPWR A a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X5 a_205_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X6 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X7 VGND C a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0693 ps=0.75 w=0.42 l=0.15
X8 a_109_297# D a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X9 VGND A a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
X0 VGND A a_311_413# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 VPWR A a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0598 ps=0.705 w=0.42 l=0.15
X2 a_393_413# a_205_93# a_311_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.122 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND C_N a_27_410# VNB sky130_fd_pr__nfet_01v8 ad=0.0619 pd=0.715 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR C_N a_27_410# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.123 pd=1.32 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_311_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X6 VGND a_27_410# a_311_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0598 ps=0.705 w=0.42 l=0.15
X7 a_561_297# B a_489_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0598 pd=0.705 as=0.0441 ps=0.63 w=0.42 l=0.15
X8 a_205_93# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0619 ps=0.715 w=0.42 l=0.15
X9 a_205_93# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.123 ps=1.32 w=0.42 l=0.15
X10 a_489_297# a_27_410# a_393_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.122 ps=1.33 w=0.42 l=0.15
X11 a_311_413# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X12 a_311_413# a_205_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0598 pd=0.705 as=0.109 ps=1.36 w=0.42 l=0.15
X13 X a_311_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.102 ps=0.99 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
X0 VGND C a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 a_277_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_47# B a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.135 ps=1.27 w=1 l=0.15
X8 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_277_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 a_676_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.213 ps=1.42 w=1 l=0.15
X1 a_512_47# B1 a_409_47# VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.119 ps=1.01 w=0.65 l=0.15
X2 a_306_47# D1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.198 ps=1.91 w=0.65 l=0.15
X3 VGND A2 a_512_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.198 ps=1.26 w=0.65 l=0.15
X4 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.218 ps=1.43 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.305 ps=1.61 w=1 l=0.15
X6 VPWR A1 a_676_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.105 ps=1.21 w=1 l=0.15
X7 a_512_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_409_47# C1 a_306_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.119 ps=1.01 w=0.65 l=0.15
X9 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.382 pd=1.76 as=0.26 ps=2.52 w=1 l=0.15
X10 a_79_21# D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.218 pd=1.43 as=0.382 ps=1.76 w=1 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X7 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.38 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X11 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X18 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
X0 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X5 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X7 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
X0 Y a_251_21# a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y a_251_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X5 VGND a_251_21# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X7 VPWR B_N a_251_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X8 VGND B_N a_251_21# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_27_297# a_251_21# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_286_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X2 a_286_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X3 Y A2 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 VGND A1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X6 VGND A2 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X7 a_487_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# B1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR A1 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_27_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X13 a_487_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X14 a_286_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
X0 VGND a_91_199# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.221 ps=1.98 w=0.65 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A a_245_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.135 ps=1.27 w=1 l=0.15
X3 a_91_199# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_245_297# B a_161_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_91_199# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.146 ps=1.34 w=0.42 l=0.15
X7 a_161_297# a_91_199# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.32 ps=2.64 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111a_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.365 pd=1.73 as=0.14 ps=1.28 w=1 l=0.15
X1 X a_80_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 a_80_21# D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.365 ps=1.73 w=1 l=0.15
X3 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VPWR C1 a_80_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.14 ps=1.28 w=1 l=0.15
X5 X a_80_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X6 a_80_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X7 a_674_297# A2 a_80_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X8 a_386_47# D1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X9 VPWR A1 a_674_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.195 ps=1.39 w=1 l=0.15
X10 a_566_47# B1 a_458_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X11 VGND A2 a_566_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X12 a_566_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.127 ps=1.04 w=0.65 l=0.15
X13 a_458_47# C1 a_386_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.0683 ps=0.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
X0 X a_61_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.167 ps=1.39 w=1 l=0.15
X1 VPWR a_61_75# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.195 ps=1.39 w=1 l=0.15
X2 VPWR B a_61_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 VGND B a_147_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 X a_61_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.112 ps=1.04 w=0.65 l=0.15
X5 VGND a_61_75# X VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.127 ps=1.04 w=0.65 l=0.15
X6 a_61_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X7 a_147_75# A a_61_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_397_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR B1_N a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X2 Y A2 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VGND A2 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND A1 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_28_297# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X6 Y a_28_297# a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VPWR a_28_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_397_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X9 a_229_47# a_28_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y a_28_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X11 a_229_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_229_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A1 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.172 ps=1.83 w=0.65 l=0.15
X2 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X3 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X5 a_326_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.127 ps=1.04 w=0.65 l=0.15
X6 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.635 pd=3.27 as=0.195 ps=1.39 w=1 l=0.15
X7 Y C1 a_326_47# VNB sky130_fd_pr__nfet_01v8 ad=0.393 pd=2.51 as=0.0683 ps=0.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.091 ps=0.93 w=0.65 l=0.15
X1 Y B1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.175 ps=1.35 w=1 l=0.15
X4 a_29_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y A2 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND A1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 a_112_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X8 a_112_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.14 ps=1.28 w=1 l=0.15
X9 a_29_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X11 a_29_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
X0 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X1 a_471_47# B a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.42 pd=2.84 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_47# C a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=1.67 w=1 l=0.15
X8 a_277_47# B a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X9 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.335 pd=1.67 as=0.135 ps=1.27 w=1 l=0.15
X10 Y A a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_277_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X13 a_471_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X16 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X17 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X20 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
X0 VGND A_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X1 Y a_27_93# a_206_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_206_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR a_27_93# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X5 VPWR A_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VGND A1 a_474_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.104 ps=0.97 w=0.65 l=0.15
X1 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 VPWR A1 a_1122_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.252 pd=1.5 as=0.14 ps=1.28 w=1 l=0.15
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.192 pd=1.89 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.252 ps=1.5 w=1 l=0.15
X8 a_950_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X9 a_557_47# B1 a_474_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X10 a_474_47# B1 a_748_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X11 VGND A2 a_474_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_79_21# C1 a_557_47# VNB sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.1 as=0.0683 ps=0.86 w=0.65 l=0.15
X15 a_474_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X16 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.14 ps=1.28 w=1 l=0.15
X17 a_748_47# C1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.145 ps=1.1 w=0.65 l=0.15
X18 a_474_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
X19 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.195 ps=1.39 w=1 l=0.15
X20 a_79_21# A2 a_950_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X21 a_1122_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X23 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.16 ps=1.32 w=1 l=0.15
X1 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.4 ps=1.8 w=1 l=0.15
X2 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0894 ps=0.925 w=0.65 l=0.15
X3 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_470_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.138 ps=1.27 w=1 l=0.15
X6 a_384_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 a_384_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.104 ps=0.97 w=0.65 l=0.15
X8 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
X0 VPWR a_212_413# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_297_47# a_27_413# a_212_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_212_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.229 ps=1.75 w=1 l=0.15
X3 X a_212_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_212_413# a_27_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0609 pd=0.71 as=0.0767 ps=0.785 w=0.42 l=0.15
X5 VPWR A_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0767 pd=0.785 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VPWR B a_212_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.229 pd=1.75 as=0.0609 ps=0.71 w=0.42 l=0.15
X7 VGND B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VGND a_212_413# X VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_413# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a221o_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.135 ps=1.27 w=1 l=0.15
X1 a_465_47# A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.157 ps=1.32 w=1 l=0.15
X3 a_109_297# B1 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 a_193_297# B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.965 w=0.65 l=0.15
X6 a_205_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X7 VPWR A2 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.165 ps=1.33 w=1 l=0.15
X8 a_193_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X9 a_27_47# B1 a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X10 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_109_297# C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X12 VGND C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X13 VGND A2 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
X0 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0894 ps=0.925 w=0.65 l=0.15
X1 a_191_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.13 ps=1.26 w=1 l=0.15
X2 VPWR A a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.119 ps=1.01 w=0.65 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_297_297# B a_191_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X6 a_109_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.13 pd=1.26 as=0.26 ps=2.52 w=1 l=0.15
X7 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
X0 Y C a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 a_281_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X6 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X10 a_281_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_297# B a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2b_4 A B_N VGND VNB VPB VPWR Y
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# a_419_21# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X6 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_419_21# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND a_419_21# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 Y a_419_21# a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X11 Y a_419_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VGND B_N a_419_21# VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.182 ps=1.86 w=0.65 l=0.15
X13 Y a_419_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VPWR B_N a_419_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.27 ps=2.54 w=1 l=0.15
X15 a_27_297# a_419_21# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 Y a_419_21# a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
X0 a_109_93# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_209_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X2 a_109_93# A_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_296_53# a_109_93# a_209_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.108 ps=1.36 w=0.42 l=0.15
X4 VPWR C a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0744 ps=0.815 w=0.42 l=0.15
X5 a_368_53# B a_296_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_209_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.122 ps=1.08 w=0.65 l=0.15
X7 a_209_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VPWR a_109_93# a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.108 ps=1.36 w=0.42 l=0.15
X9 VGND C a_368_53# VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.08 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfxtp_2 CLK D VGND VNB VPB VPWR Q
X0 Q a_1059_315# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_891_413# a_193_47# a_634_159# VNB sky130_fd_pr__nfet_01v8 ad=0.0684 pd=0.74 as=0.0989 ps=0.995 w=0.36 l=0.15
X2 VPWR a_1059_315# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 a_561_413# a_27_47# a_466_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0767 pd=0.785 as=0.0683 ps=0.745 w=0.42 l=0.15
X4 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X5 Q a_1059_315# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_381_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0578 pd=0.695 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND a_634_159# a_592_47# VNB sky130_fd_pr__nfet_01v8 ad=0.121 pd=1.09 as=0.0696 ps=0.765 w=0.42 l=0.15
X8 VGND a_1059_315# Q VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_891_413# a_1059_315# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.27 ps=2.54 w=1 l=0.15
X10 a_466_413# a_193_47# a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.0578 ps=0.695 w=0.42 l=0.15
X11 VPWR a_634_159# a_561_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.179 pd=1.26 as=0.0767 ps=0.785 w=0.42 l=0.15
X12 a_634_159# a_466_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0989 pd=0.995 as=0.121 ps=1.09 w=0.64 l=0.15
X13 a_634_159# a_466_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.08 as=0.179 ps=1.26 w=0.75 l=0.15
X14 a_975_413# a_193_47# a_891_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0882 pd=0.84 as=0.0567 ps=0.69 w=0.42 l=0.15
X15 VGND a_1059_315# a_1017_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.066 ps=0.745 w=0.42 l=0.15
X16 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X17 a_891_413# a_27_47# a_634_159# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.08 w=0.42 l=0.15
X18 a_592_47# a_193_47# a_466_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0696 pd=0.765 as=0.0621 ps=0.705 w=0.36 l=0.15
X19 a_1017_47# a_27_47# a_891_413# VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.0684 ps=0.74 w=0.36 l=0.15
X20 VPWR a_1059_315# a_975_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.0882 ps=0.84 w=0.42 l=0.15
X21 a_466_413# a_27_47# a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0621 pd=0.705 as=0.0813 ps=0.83 w=0.36 l=0.15
X22 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X23 VGND a_891_413# a_1059_315# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X24 a_381_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0813 pd=0.83 as=0.109 ps=1.36 w=0.42 l=0.15
X25 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
X0 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.107 ps=0.98 w=0.65 l=0.15
X1 VGND D a_304_47# VNB sky130_fd_pr__nfet_01v8 ad=0.175 pd=1.26 as=0.0693 ps=0.75 w=0.42 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.28 ps=1.62 w=1 l=0.15
X3 a_198_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0798 pd=0.8 as=0.0619 ps=0.715 w=0.42 l=0.15
X4 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0777 ps=0.79 w=0.42 l=0.15
X5 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.165 ps=1.33 w=1 l=0.15
X6 a_304_47# C a_198_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0798 ps=0.8 w=0.42 l=0.15
X7 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0746 pd=0.775 as=0.109 ps=1.36 w=0.42 l=0.15
X8 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=1.62 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.175 ps=1.26 w=0.65 l=0.15
X10 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0746 ps=0.775 w=0.42 l=0.15
X11 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0619 pd=0.715 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
X0 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND a_215_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR a_215_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_109_93# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X4 a_215_297# a_109_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.165 ps=1.82 w=0.65 l=0.15
X5 VGND C a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X6 VGND A a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X8 a_215_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_109_93# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X10 VPWR A a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND a_215_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_487_297# B a_403_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_403_297# C a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X14 VPWR a_215_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X15 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X16 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_297_297# a_109_93# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 Y A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.109 ps=0.985 w=0.65 l=0.15
X4 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_949_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 Y C1 a_949_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.15 ps=1.3 w=1 l=0.15
X10 a_781_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_27_297# B1 a_781_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_781_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_1301_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.15 ps=1.3 w=1 l=0.15
X16 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 Y C1 a_781_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.14 ps=1.28 w=1 l=0.15
X18 a_109_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_109_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_109_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.091 ps=0.93 w=0.65 l=0.15
X27 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X28 a_27_297# B1 a_1301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X29 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0894 ps=0.925 w=0.65 l=0.15
X30 a_109_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X31 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
X0 VGND B1 a_84_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_741_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.101 ps=0.96 w=0.65 l=0.15
X2 a_84_21# A1 a_741_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0747 ps=0.88 w=0.65 l=0.15
X3 VGND A2 a_901_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR a_84_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR A2 a_483_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_483_297# B1 a_84_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_84_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X8 a_84_21# B1 a_483_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 VGND a_84_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.265 pd=1.47 as=0.091 ps=0.93 w=0.65 l=0.15
X10 VPWR a_84_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_483_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=2.79 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR A1 a_483_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 VGND a_84_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 X a_84_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.285 ps=2.57 w=1 l=0.15
X15 a_84_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.265 ps=1.47 w=0.65 l=0.15
X16 a_483_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 X a_84_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 a_901_47# A1 a_84_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_84_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 a_103_199# B1 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.107 ps=0.98 w=0.65 l=0.15
X1 VPWR a_103_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.36 ps=2.72 w=1 l=0.15
X2 a_337_297# A2 a_253_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_103_199# A3 a_337_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.165 ps=1.33 w=1 l=0.15
X4 a_253_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.195 ps=1.39 w=1 l=0.15
X5 VPWR B1 a_103_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.345 pd=2.69 as=0.213 ps=1.42 w=1 l=0.15
X6 VGND a_103_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.234 ps=2.02 w=0.65 l=0.15
X7 a_253_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X8 a_253_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X9 VGND A2 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a41o_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 a_639_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_639_47# A2 a_889_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A3 a_467_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.385 pd=1.77 as=0.145 ps=1.29 w=1 l=0.15
X4 a_889_47# A2 a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_889_47# A3 a_1079_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_467_297# A4 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_467_297# B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X13 a_467_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR A4 a_467_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_1079_47# A3 a_889_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_79_21# B1 a_467_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 a_79_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0943 ps=0.94 w=0.65 l=0.15
X18 a_1079_47# A4 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 VPWR A2 a_467_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_467_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_79_21# A1 a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X23 VPWR A1 a_467_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X24 a_467_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.385 ps=1.77 w=1 l=0.15
X25 VGND A4 a_1079_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X27 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X1 X a_80_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 VGND a_80_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=0.99 as=0.091 ps=0.93 w=0.65 l=0.15
X3 a_386_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.157 ps=1.32 w=1 l=0.15
X4 X a_80_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_80_199# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.162 pd=1.15 as=0.111 ps=0.99 w=0.65 l=0.15
X6 a_386_297# B1 a_80_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_458_47# A1 a_80_199# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.162 ps=1.15 w=0.65 l=0.15
X8 VPWR A1 a_386_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X9 VGND A2 a_458_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.123 ps=1.03 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_467_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_467_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_109_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A2 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_109_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
X0 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=1.67 w=1 l=0.15
X1 VGND A_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0.194 pd=1.95 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VGND B a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y a_27_93# a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 a_229_47# a_27_93# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.147 ps=1.34 w=1 l=0.15
X6 VPWR a_27_93# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.335 pd=1.67 as=0.165 ps=1.33 w=1 l=0.15
X7 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.135 ps=1.27 w=1 l=0.15
X8 a_229_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR A_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 VPWR a_27_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.107 ps=0.98 w=0.65 l=0.15
X2 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.965 w=0.65 l=0.15
X3 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.157 ps=1.32 w=1 l=0.15
X4 a_27_297# B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X5 a_27_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_27_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X8 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.165 ps=1.33 w=1 l=0.15
X9 a_381_47# A1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X10 a_109_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
X0 VPWR A a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_218_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.156 ps=1.16 w=0.42 l=0.15
X2 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.156 pd=1.16 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_300_297# a_27_53# a_218_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_218_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 VPWR a_218_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_218_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X7 VGND a_218_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 VGND A a_218_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X7 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X11 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X12 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X14 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X15 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X16 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.155 ps=1.31 w=1 l=0.15
X20 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32oi_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.338 pd=1.67 as=0.135 ps=1.27 w=1 l=0.15
X5 a_1249_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_1249_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.252 pd=1.5 as=0.338 ps=1.67 w=1 l=0.15
X12 a_803_47# A2 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X16 a_803_47# A2 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X20 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X21 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_1249_47# A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.133 ps=1.06 w=0.65 l=0.15
X23 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 a_1249_47# A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.252 ps=1.5 w=1 l=0.15
X28 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X30 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X32 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X35 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 VGND A3 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X37 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VGND A3 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32oi_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 Y A1 a_478_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.377 ps=1.75 w=1 l=0.15
X2 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.305 ps=1.61 w=1 l=0.15
X3 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.335 ps=1.67 w=1 l=0.15
X4 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.335 pd=1.67 as=0.138 ps=1.27 w=1 l=0.15
X5 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.377 pd=1.75 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_478_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_478_47# A2 a_730_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND A3 a_730_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.12 ps=1.02 w=0.65 l=0.15
X10 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_730_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.02 as=0.205 ps=1.93 w=0.65 l=0.15
X16 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.15 ps=1.3 w=1 l=0.15
X18 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X19 a_730_47# A2 a_478_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_93_21# A1 a_346_47# VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.146 ps=1.1 w=0.65 l=0.15
X1 a_93_21# B1 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.185 ps=1.37 w=1 l=0.15
X2 a_584_47# B1 a_93_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.143 ps=1.09 w=0.65 l=0.15
X3 VPWR a_93_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.243 pd=1.49 as=0.33 ps=2.66 w=1 l=0.15
X4 VGND B2 a_584_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 a_256_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.167 ps=1.16 w=0.65 l=0.15
X6 a_250_297# B2 a_93_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 VGND a_93_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.167 pd=1.16 as=0.214 ps=1.96 w=0.65 l=0.15
X8 a_250_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.243 ps=1.49 w=1 l=0.15
X9 VPWR A2 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.225 pd=1.45 as=0.165 ps=1.33 w=1 l=0.15
X10 a_250_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.225 ps=1.45 w=1 l=0.15
X11 a_346_47# A2 a_256_47# VNB sky130_fd_pr__nfet_01v8 ad=0.146 pd=1.1 as=0.0975 ps=0.95 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
X0 VPWR a_30_53# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.315 pd=2.63 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND a_30_53# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_30_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X3 a_112_297# C a_30_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_30_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 VGND A a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 a_30_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 VGND C a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_184_297# B a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X9 VPWR A a_184_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
X0 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
X0 X a_80_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_475_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X2 X a_80_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_762_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.31 ps=1.62 w=1 l=0.15
X5 a_475_47# B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VGND A2 a_475_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 X a_80_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X10 a_80_21# A2 a_762_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_80_21# B1 a_475_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X12 a_80_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.15 ps=1.3 w=1 l=0.15
X13 a_475_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.117 ps=1.01 w=0.65 l=0.15
X14 X a_80_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 VPWR A1 a_934_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X16 a_934_297# A2 a_80_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 VPWR B1 a_80_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=1.62 as=0.14 ps=1.28 w=1 l=0.15
X18 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND A1 a_475_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.117 ps=1.01 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 a_108_21# B1 a_346_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.107 ps=0.98 w=0.65 l=0.15
X1 a_346_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X2 X a_108_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.263 ps=2.11 w=0.65 l=0.15
X3 a_108_21# A3 a_430_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.165 ps=1.33 w=1 l=0.15
X4 a_430_297# A2 a_346_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR a_108_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.175 ps=1.35 w=1 l=0.15
X6 a_346_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.195 ps=1.39 w=1 l=0.15
X7 VGND A2 a_346_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_108_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.405 ps=2.81 w=1 l=0.15
X9 VPWR B1 a_108_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.34 pd=2.68 as=0.213 ps=1.42 w=1 l=0.15
X10 VGND a_108_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.114 ps=1 w=0.65 l=0.15
X11 a_346_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
X0 Y a_74_47# a_265_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 VPWR B_N a_74_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.39 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_265_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.157 ps=1.39 w=1 l=0.15
X3 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X4 VGND B_N a_74_47# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND a_74_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X8 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X11 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=1.37 as=0.0588 ps=0.7 w=0.42 l=0.15
X18 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X20 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X21 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X22 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X23 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X25 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X26 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X27 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X28 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X29 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X30 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X31 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X32 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X33 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X34 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X35 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X36 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X37 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X38 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X39 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0578 ps=0.695 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X6 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X11 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
X0 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X1 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND B a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 X a_79_204# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A1 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_473_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.195 ps=1.39 w=1 l=0.15
X3 X a_79_204# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X4 VGND C1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.104 ps=0.97 w=0.65 l=0.15
X5 a_79_204# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0926 ps=0.935 w=0.65 l=0.15
X6 VPWR a_79_204# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X7 a_473_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X8 a_473_297# B1 a_727_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.16 ps=1.32 w=1 l=0.15
X9 X a_79_204# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X10 VGND B1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.127 ps=1.04 w=0.65 l=0.15
X11 a_79_204# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.109 ps=0.985 w=0.65 l=0.15
X12 VGND a_79_204# X VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.0959 ps=0.945 w=0.65 l=0.15
X13 a_1123_47# A1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_555_297# B1 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X15 VPWR A2 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X16 VGND A2 a_1123_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.091 ps=0.93 w=0.65 l=0.15
X17 a_951_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.14 ps=1.08 w=0.65 l=0.15
X18 VPWR a_79_204# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_79_204# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X20 a_79_204# A1 a_951_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 a_79_204# C1 a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 a_727_297# C1 a_79_204# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X23 X a_79_204# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_277_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_277_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_277_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X5 a_277_47# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X6 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND a_277_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND a_277_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_193_47# A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_361_47# A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 X a_277_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A3 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X15 X a_277_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X16 a_277_47# A1 a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_445_47# A2 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND B1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_27_297# B1 a_277_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X21 VPWR a_277_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.5 pd=3 as=0.135 ps=1.27 w=1 l=0.15
X22 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X23 a_277_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311o_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_79_21# C1 a_635_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.21 ps=1.42 w=1 l=0.15
X1 VPWR A2 a_319_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.17 ps=1.34 w=1 l=0.15
X2 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.133 ps=1.06 w=0.65 l=0.15
X3 a_417_47# A2 a_319_47# VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.02 as=0.111 ps=0.99 w=0.65 l=0.15
X4 a_79_21# A1 a_417_47# VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.12 ps=1.02 w=0.65 l=0.15
X5 a_319_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=0.99 as=0.156 ps=1.13 w=0.65 l=0.15
X6 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.24 pd=1.48 as=0.135 ps=1.27 w=1 l=0.15
X7 a_319_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.21 pd=1.42 as=0.185 ps=1.37 w=1 l=0.15
X8 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.156 pd=1.13 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_319_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.17 pd=1.34 as=0.24 ps=1.48 w=1 l=0.15
X10 a_79_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.14 ps=1.08 w=0.65 l=0.15
X11 a_635_297# B1 a_319_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.21 pd=1.42 as=0.21 ps=1.42 w=1 l=0.15
X12 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_475_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A1 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X9 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.27 pd=1.48 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X12 a_475_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 Y A2 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X14 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.27 ps=1.48 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_465_47# A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.157 ps=1.32 w=1 l=0.15
X2 a_109_297# B1 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 a_193_297# B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.102 ps=0.965 w=0.65 l=0.15
X5 a_205_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X6 VPWR A2 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.165 ps=1.33 w=1 l=0.15
X7 a_193_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X8 a_27_47# B1 a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X9 a_109_297# C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 VGND C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND A2 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
X0 a_27_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y A a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y A a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_445_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X12 a_445_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_445_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X17 a_445_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X23 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
X0 VPWR a_29_311# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_29_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.151 ps=1.35 w=1 l=0.15
X2 VPWR A a_29_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND a_29_311# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_184_53# B a_112_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X5 VPWR C a_29_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.151 pd=1.35 as=0.0744 ps=0.815 w=0.42 l=0.15
X6 X a_29_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.13 ps=1.11 w=0.65 l=0.15
X7 a_112_53# A a_29_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_29_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 VGND C a_184_53# VNB sky130_fd_pr__nfet_01v8 ad=0.13 pd=1.11 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 VPWR a_82_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.186 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X1 a_646_47# B2 a_82_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_574_369# a_313_47# a_82_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0976 pd=0.945 as=0.166 ps=1.8 w=0.64 l=0.15
X3 a_574_369# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X4 VGND a_82_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.09 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR B2 a_574_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.0976 ps=0.945 w=0.64 l=0.15
X6 X a_82_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.172 ps=1.83 w=0.65 l=0.15
X7 X a_82_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.265 ps=2.53 w=1 l=0.15
X8 a_313_47# A2_N a_313_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.17 pd=1.81 as=0.0672 ps=0.85 w=0.64 l=0.15
X9 a_313_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.12 ps=1.09 w=0.42 l=0.15
X10 a_313_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.85 as=0.186 ps=1.43 w=0.64 l=0.15
X11 VGND A2_N a_313_47# VNB sky130_fd_pr__nfet_01v8 ad=0.142 pd=1.1 as=0.0567 ps=0.69 w=0.42 l=0.15
X12 a_82_21# a_313_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.142 ps=1.1 w=0.42 l=0.15
X13 VGND B1 a_646_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
X0 VPWR a_219_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.295 pd=2.59 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.202 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.17 pd=1.34 as=0.105 ps=1.21 w=1 l=0.15
X3 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.111 ps=0.99 w=0.65 l=0.15
X5 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X6 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=0.99 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_219_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND a_219_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.17 ps=1.34 w=1 l=0.15
X11 VGND a_219_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.214 pd=1.96 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.202 ps=1.4 w=0.65 l=0.15
X13 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.28 ps=2.56 w=1 l=0.15
X1 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X4 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.177 ps=1.36 w=1 l=0.15
X7 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.105 ps=1.21 w=1 l=0.15
X9 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
X0 VPWR S a_591_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.0672 ps=0.85 w=0.64 l=0.15
X1 a_591_369# A0 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.85 as=0.131 ps=1.05 w=0.64 l=0.15
X2 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.178 pd=1.41 as=0.135 ps=1.27 w=1 l=0.15
X3 a_79_21# A1 a_306_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.131 pd=1.05 as=0.229 ps=1.36 w=0.64 l=0.15
X4 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND S a_578_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0578 ps=0.695 w=0.42 l=0.15
X6 a_306_369# a_257_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.229 pd=1.36 as=0.178 ps=1.41 w=0.64 l=0.15
X7 a_79_21# A0 a_288_47# VNB sky130_fd_pr__nfet_01v8 ad=0.173 pd=1.25 as=0.0683 ps=0.745 w=0.42 l=0.15
X8 a_288_47# a_257_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.745 as=0.097 ps=0.975 w=0.42 l=0.15
X9 a_257_199# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 a_578_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.173 ps=1.25 w=0.42 l=0.15
X11 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X12 a_257_199# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.173 pd=1.82 as=0.0864 ps=0.91 w=0.64 l=0.15
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
X0 a_558_47# a_381_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X1 VGND X a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_841_47# a_664_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VPWR A a_62_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A a_62_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_558_47# a_381_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X6 X a_62_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR X a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_841_47# a_664_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X9 X a_62_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X10 VPWR a_558_47# a_664_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND a_558_47# a_664_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_39_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=1 w=0.65 l=0.15
X2 VPWR a_39_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_39_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.156 ps=1.36 w=1 l=0.15
X4 VGND a_39_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.156 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VGND A a_39_297# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=1 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_39_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 a_79_21# A1 a_348_47# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.133 ps=1.06 w=0.65 l=0.15
X1 a_79_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X2 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.2 pd=1.26 as=0.091 ps=0.93 w=0.65 l=0.15
X3 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 a_79_21# C1 a_585_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X5 VPWR A2 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.26 ps=2.52 w=1 l=0.15
X6 a_299_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.195 ps=1.39 w=1 l=0.15
X7 a_585_297# B1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X8 a_348_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.2 ps=1.26 w=0.65 l=0.15
X9 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.115 ps=1 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4bb_4 A_N B_N C D VGND VNB VPB VPWR Y
X0 Y a_27_47# a_432_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y a_27_47# a_432_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 a_850_47# a_193_47# a_432_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND D a_1266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.555 ps=2.11 w=1 l=0.15
X8 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.135 ps=1.27 w=1 l=0.15
X10 a_432_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_432_47# a_193_47# a_850_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_432_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_432_47# a_193_47# a_850_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VPWR a_193_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.555 pd=2.11 as=0.135 ps=1.27 w=1 l=0.15
X16 a_193_47# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.495 pd=2.99 as=0.135 ps=1.27 w=1 l=0.15
X17 Y a_193_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 a_193_47# B_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.322 pd=2.29 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 a_850_47# C a_1266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.189 ps=1.88 w=0.65 l=0.15
X22 a_850_47# a_193_47# a_432_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 a_850_47# C a_1266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 VGND D a_1266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 VPWR a_193_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_1266_47# C a_850_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y a_193_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 a_1266_47# C a_850_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_1266_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X32 a_1266_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X34 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X35 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_806_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_47# B1 a_1314_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=2.09 as=0.104 ps=0.97 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X17 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.0943 ps=0.94 w=0.65 l=0.15
X19 Y C1 a_978_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_27_47# B1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 a_806_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.675 pd=3.35 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.091 ps=0.93 w=0.65 l=0.15
X27 a_978_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.091 ps=0.93 w=0.65 l=0.15
X28 a_1314_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X31 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311o_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_277_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.325 ps=1.65 w=1 l=0.15
X2 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_861_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.211 ps=1.3 w=0.65 l=0.15
X4 a_27_297# B1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_1059_47# A2 a_861_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_1059_47# A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_277_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0943 ps=0.94 w=0.65 l=0.15
X9 a_27_297# C1 a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.211 pd=1.3 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A3 a_861_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VGND C1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_109_47# A1 a_1059_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_109_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 VPWR A3 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X21 VPWR A2 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.325 pd=1.65 as=0.135 ps=1.27 w=1 l=0.15
X22 a_109_47# C1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X23 VPWR A1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X24 a_277_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 a_277_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X26 a_109_47# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X27 a_861_47# A2 a_1059_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.117 ps=1.01 w=0.65 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.41 pd=1.82 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.175 ps=1.35 w=1 l=0.15
X4 a_277_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.41 ps=1.82 w=1 l=0.15
X10 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.18 ps=1.36 w=1 l=0.15
X11 a_277_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.114 ps=1 w=0.65 l=0.15
X13 Y A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.0975 ps=0.95 w=0.65 l=0.15
X14 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 VGND A2 a_660_47# VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.0829 ps=0.905 w=0.65 l=0.15
X1 VGND C1 a_85_193# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.101 ps=0.96 w=0.65 l=0.15
X2 a_414_297# C1 a_334_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.125 ps=1.25 w=1 l=0.15
X3 VGND a_85_193# X VNB sky130_fd_pr__nfet_01v8 ad=0.275 pd=1.5 as=0.214 ps=1.96 w=0.65 l=0.15
X4 a_334_297# D1 a_85_193# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.125 pd=1.25 as=0.385 ps=2.77 w=1 l=0.15
X5 a_516_297# B1 a_414_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=1.56 as=0.18 ps=1.36 w=1 l=0.15
X6 a_516_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.135 ps=1.27 w=1 l=0.15
X7 a_660_47# A1 a_85_193# VNB sky130_fd_pr__nfet_01v8 ad=0.0829 pd=0.905 as=0.185 ps=1.22 w=0.65 l=0.15
X8 a_85_193# D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.275 ps=1.5 w=0.65 l=0.15
X9 VPWR A1 a_516_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=1.56 w=1 l=0.15
X10 a_85_193# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.22 as=0.117 ps=1.01 w=0.65 l=0.15
X11 VPWR a_85_193# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.29 ps=2.58 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
X0 a_204_297# A1 a_396_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.16 ps=1.32 w=1 l=0.15
X1 VPWR a_396_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_396_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR S a_314_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_204_297# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.162 ps=1.33 w=1 l=0.15
X5 a_396_47# A0 a_314_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.26 ps=2.52 w=1 l=0.15
X6 a_206_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.109 ps=0.985 w=0.65 l=0.15
X7 X a_396_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_396_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_396_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_490_47# A1 a_396_47# VNB sky130_fd_pr__nfet_01v8 ad=0.275 pd=1.5 as=0.104 ps=0.97 w=0.65 l=0.15
X11 VGND S a_490_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.275 ps=1.5 w=0.65 l=0.15
X12 VGND a_396_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_396_47# A0 a_206_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.26 ps=1.45 w=0.65 l=0.15
X14 VGND a_396_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR S a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X16 X a_396_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND S a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR A2 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 a_277_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X2 a_79_21# B1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X3 a_277_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_361_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_277_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.127 ps=1.04 w=0.65 l=0.15
X9 a_79_21# A1 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_4 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_1021_47# A1 a_205_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 X a_205_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 VPWR a_205_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_205_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VGND A2 a_1021_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND a_42_47# a_205_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_861_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.101 ps=0.96 w=0.65 l=0.15
X7 a_205_21# A1 a_861_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0747 ps=0.88 w=0.65 l=0.15
X8 X a_205_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 a_603_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND B1_N a_42_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.25 ps=2.07 w=0.65 l=0.15
X11 VPWR A2 a_603_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_603_297# a_42_47# a_205_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 VPWR a_205_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.14 ps=1.28 w=1 l=0.15
X14 a_205_21# a_42_47# a_603_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND a_205_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.263 pd=1.46 as=0.091 ps=0.93 w=0.65 l=0.15
X16 VPWR B1_N a_42_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X17 VGND a_205_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VPWR A1 a_603_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 a_603_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 a_205_21# a_42_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.263 ps=1.46 w=0.65 l=0.15
X21 X a_205_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X1 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0926 ps=0.935 w=0.65 l=0.15
X2 VPWR A1 a_307_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.105 ps=1.21 w=1 l=0.15
X3 a_307_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.233 ps=1.47 w=1 l=0.15
X4 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.233 pd=1.47 as=0.112 ps=1.23 w=1 l=0.15
X6 a_109_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.112 pd=1.23 as=0.26 ps=2.52 w=1 l=0.15
X7 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32ai_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 a_1224_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 VPWR A1 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.183 ps=1.37 w=1 l=0.15
X2 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_806_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.205 ps=1.28 w=0.65 l=0.15
X8 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.205 pd=1.28 as=0.14 ps=1.08 w=0.65 l=0.15
X10 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_806_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A3 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y A3 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X19 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.119 ps=1.01 w=0.65 l=0.15
X22 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0926 ps=0.935 w=0.65 l=0.15
X24 a_806_297# A2 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X25 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.142 ps=1.28 w=1 l=0.15
X28 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_1224_297# A2 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 a_1224_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.183 pd=1.37 as=0.135 ps=1.27 w=1 l=0.15
X32 a_806_297# A2 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 VPWR A1 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X35 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X36 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X37 a_1224_297# A2 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X38 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X39 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22a_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 a_301_47# B2 a_81_21# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND A2 a_301_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X2 a_383_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.39 ps=1.78 w=1 l=0.15
X3 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.39 pd=1.78 as=0.135 ps=1.27 w=1 l=0.15
X4 a_301_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 X a_81_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_81_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X8 VPWR A1 a_579_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.105 ps=1.21 w=1 l=0.15
X9 a_81_21# B1 a_301_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X10 a_579_297# A2 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.235 ps=1.47 w=1 l=0.15
X11 a_81_21# B2 a_383_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.235 pd=1.47 as=0.105 ps=1.21 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 VGND a_415_21# a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_415_21# A2_N a_717_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_717_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VGND A2_N a_415_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_193_47# a_415_21# a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR a_193_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_193_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_193_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_415_21# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X11 a_415_21# A2_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_193_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_193_47# B2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VGND a_193_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND A1_N a_415_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND a_193_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_109_47# B2 a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_193_47# a_415_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR a_193_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_27_297# a_415_21# a_193_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X23 X a_193_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 VPWR A1_N a_717_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X26 a_717_297# A2_N a_415_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_109_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2bb2a_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_294_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0662 pd=0.735 as=0.0986 ps=0.98 w=0.42 l=0.15
X1 VPWR A2_N a_295_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.227 pd=1.35 as=0.173 ps=1.4 w=0.64 l=0.15
X2 VPWR B1 a_665_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X3 VGND a_84_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0986 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 X a_84_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.185 ps=1.87 w=0.65 l=0.15
X5 a_581_47# a_295_369# a_84_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VPWR a_84_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.154 pd=1.34 as=0.135 ps=1.27 w=1 l=0.15
X7 a_665_369# B2 a_84_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.0928 ps=0.93 w=0.64 l=0.15
X8 VGND B2 a_581_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_295_369# A2_N a_294_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0662 ps=0.735 w=0.42 l=0.15
X10 X a_84_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.285 ps=2.57 w=1 l=0.15
X11 a_84_21# a_295_369# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0928 pd=0.93 as=0.227 ps=1.35 w=0.64 l=0.15
X12 a_295_369# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.173 pd=1.4 as=0.154 ps=1.34 w=0.64 l=0.15
X13 a_581_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 a_281_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X1 a_281_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X6 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X7 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X9 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.127 ps=1.04 w=0.65 l=0.15
X10 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.198 ps=1.26 w=0.65 l=0.15
X11 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.127 ps=1.04 w=0.65 l=0.15
X12 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y A3 a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.195 ps=1.39 w=1 l=0.15
X15 a_27_297# A2 a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_75_199# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.135 ps=1.07 w=0.65 l=0.15
X1 a_208_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.112 ps=0.995 w=0.65 l=0.15
X2 a_315_47# A2 a_208_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.17 as=0.125 ps=1.03 w=0.65 l=0.15
X3 VGND B1 a_75_199# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.07 as=0.106 ps=0.975 w=0.65 l=0.15
X4 a_75_199# A1 a_315_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.17 w=0.65 l=0.15
X5 a_75_199# C1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.207 ps=1.41 w=1 l=0.15
X6 a_544_297# B1 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.207 pd=1.41 as=0.162 ps=1.33 w=1 l=0.15
X7 VPWR a_75_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.285 ps=2.57 w=1 l=0.15
X8 a_201_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.142 ps=1.28 w=1 l=0.15
X9 VPWR A2 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.165 ps=1.33 w=1 l=0.15
X10 a_201_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.305 ps=1.61 w=1 l=0.15
X11 VGND a_75_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
X0 a_27_47# C a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# C a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_445_47# B a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_445_47# B a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y A a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X14 Y A a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_803_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X17 a_803_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_445_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 a_803_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X23 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X24 a_445_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_803_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X30 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X31 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_585_47# B1 a_266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.119 ps=1.01 w=0.65 l=0.15
X1 VGND A2 a_266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.137 pd=1.07 as=0.117 ps=1.01 w=0.65 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.62 as=0.26 ps=2.52 w=1 l=0.15
X3 a_81_21# C1 a_585_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.203 pd=1.27 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_266_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.312 ps=1.62 w=1 l=0.15
X6 a_368_297# A2 a_266_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.21 pd=1.42 as=0.18 ps=1.36 w=1 l=0.15
X7 a_266_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.137 ps=1.07 w=0.65 l=0.15
X8 a_266_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.203 ps=1.27 w=0.65 l=0.15
X9 a_81_21# A3 a_368_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.21 ps=1.42 w=1 l=0.15
X10 a_81_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.15 ps=1.3 w=1 l=0.15
X11 VPWR B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.138 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
X0 Y a_53_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.192 ps=1.38 w=1 l=0.15
X1 a_232_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.192 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A_N a_53_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A_N a_53_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_316_47# B a_232_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y a_53_93# a_316_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.125 ps=1.03 w=0.65 l=0.15
X7 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32oi_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X1 VGND A3 a_383_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X2 a_309_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0715 pd=0.87 as=0.153 ps=1.12 w=0.65 l=0.15
X3 Y B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.153 pd=1.12 as=0.0747 ps=0.88 w=0.65 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X5 a_383_47# A2 a_309_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0715 ps=0.87 w=0.65 l=0.15
X6 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X7 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X9 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2b_4 A_N B VGND VNB VPB VPWR Y
X0 VGND B a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0926 ps=0.935 w=0.65 l=0.15
X1 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.142 ps=1.28 w=1 l=0.15
X2 Y a_27_47# a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 VGND B a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y a_27_47# a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_215_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_215_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.254 pd=2.08 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.39 pd=2.78 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X9 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_215_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_215_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X16 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X17 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o221ai_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
X0 a_109_47# B1 a_213_123# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.165 ps=1.82 w=0.65 l=0.15
X1 Y B2 a_295_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.225 pd=1.45 as=0.12 ps=1.24 w=1 l=0.15
X2 VPWR A1 a_493_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X3 a_213_123# B2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_295_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.12 pd=1.24 as=0.38 ps=1.76 w=1 l=0.15
X5 a_493_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.225 ps=1.45 w=1 l=0.15
X6 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=1.76 as=0.28 ps=2.56 w=1 l=0.15
X7 VGND A2 a_213_123# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.117 ps=1.01 w=0.65 l=0.15
X8 a_213_123# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_109_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
X0 VPWR A a_94_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.198 pd=1.39 as=0.305 ps=2.61 w=1 l=0.15
X1 a_294_47# B a_185_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.128 ps=1.04 w=0.65 l=0.15
X2 a_185_47# A a_94_47# VNB sky130_fd_pr__nfet_01v8 ad=0.128 pd=1.04 as=0.198 ps=1.91 w=0.65 l=0.15
X3 VPWR a_94_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND C a_294_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 a_94_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.198 ps=1.39 w=1 l=0.15
X6 X a_94_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X7 X a_94_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 VPWR C a_94_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X9 X a_94_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X10 VGND a_94_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X11 VPWR a_94_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND a_94_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 X a_94_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 a_27_47# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.368 pd=1.74 as=0.14 ps=1.28 w=1 l=0.15
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.231 pd=2.01 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VPWR A1 a_373_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X4 a_182_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.165 ps=1.82 w=0.65 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.195 ps=1.39 w=1 l=0.15
X6 a_182_47# B1 a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X8 a_373_297# A2 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.368 ps=1.74 w=1 l=0.15
X9 a_110_47# C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X10 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X11 VGND A1 a_182_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_8 A B VGND VNB VPB VPWR Y
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X11 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X16 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X18 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_449_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 Y C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_449_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X10 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X15 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_33_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND A1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_33_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_797_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_797_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y B2 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR B1 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_33_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 a_33_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_33_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_33_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_797_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.16 ps=1.32 w=1 l=0.15
X17 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR B1 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND A2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_33_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 a_797_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.135 ps=1.27 w=1 l=0.15
X24 Y B2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 Y B2 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 Y B1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.104 ps=0.97 w=0.65 l=0.15
X27 Y B2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 Y B1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_33_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.29 ps=2.58 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_4 A1 A2 B1_N VGND VNB VPB VPWR X
X0 VPWR B1_N a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.38 ps=2.76 w=1 l=0.15
X1 VPWR A1 a_743_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_743_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X3 a_575_47# a_27_297# a_187_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_743_297# A2 a_187_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR a_27_297# a_187_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X6 a_187_21# A2 a_743_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_187_21# a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_187_21# a_27_297# a_575_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VGND B1_N a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.198 ps=1.91 w=0.65 l=0.15
X10 VGND A2 a_575_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR a_187_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A1 a_575_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND a_187_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 X a_187_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VPWR a_187_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 a_575_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_575_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 X a_187_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 X a_187_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 X a_187_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VGND a_187_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o41a_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 VGND A2 a_393_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.114 ps=1 w=0.65 l=0.15
X1 a_496_297# A4 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.303 ps=1.61 w=1 l=0.15
X2 a_393_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.115 ps=1 w=0.65 l=0.15
X3 VPWR A1 a_697_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.41 pd=2.82 as=0.175 ps=1.35 w=1 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.303 pd=1.61 as=0.305 ps=1.61 w=1 l=0.15
X7 VGND A4 a_393_47# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.119 ps=1.01 w=0.65 l=0.15
X8 a_697_297# A2 a_597_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.175 ps=1.35 w=1 l=0.15
X9 a_393_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.266 pd=2.12 as=0.114 ps=1 w=0.65 l=0.15
X10 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 a_393_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.208 ps=1.94 w=0.65 l=0.15
X12 a_597_297# A3 a_496_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.177 ps=1.36 w=1 l=0.15
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4b_2 A B C D_N VGND VNB VPB VPWR X
X0 a_176_21# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 VGND D_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X4 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.168 pd=1.5 as=0.135 ps=1.27 w=1 l=0.15
X5 a_555_297# C a_483_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 a_176_21# a_27_53# a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0693 ps=0.75 w=0.42 l=0.15
X7 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.169 ps=1.5 w=1 l=0.15
X8 a_387_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.168 ps=1.5 w=0.42 l=0.15
X9 a_483_297# B a_387_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X10 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0693 ps=0.75 w=0.42 l=0.15
X11 VGND a_27_53# a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X12 VPWR D_N a_27_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.169 pd=1.5 as=0.109 ps=1.36 w=0.42 l=0.15
X13 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.1 ps=0.985 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
X0 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X1 a_109_53# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_215_297# a_109_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_392_297# C a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0452 pd=0.635 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_465_297# B a_392_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.064 pd=0.725 as=0.0452 ps=0.635 w=0.42 l=0.15
X6 a_215_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 VPWR A a_465_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.064 ps=0.725 w=0.42 l=0.15
X8 a_297_297# a_109_53# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_109_53# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X10 VGND C a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.064 ps=0.725 w=0.42 l=0.15
X11 VGND A a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_240_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_51_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A1 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_51_297# B2 a_245_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.412 pd=1.83 as=0.105 ps=1.21 w=1 l=0.15
X4 a_149_47# C1 a_51_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.201 ps=1.92 w=0.65 l=0.15
X5 a_240_47# B1 a_149_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0991 ps=0.955 w=0.65 l=0.15
X6 VPWR A1 a_512_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X7 X a_51_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.165 ps=1.33 w=1 l=0.15
X8 a_149_47# B2 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_245_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X10 VPWR C1 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.34 ps=2.68 w=1 l=0.15
X11 a_512_297# A2 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.412 ps=1.83 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311ai_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
X0 a_39_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR A1 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X4 a_125_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0943 ps=0.94 w=0.65 l=0.15
X5 a_125_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_125_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_1163_47# B1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_39_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_1163_47# B1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A3 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND A3 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_39_297# A2 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_125_47# B1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X17 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 a_125_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X19 VGND A2 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_125_47# B1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VGND A2 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y C1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y C1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_461_297# A2 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 Y A3 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X26 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 Y A3 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 a_125_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 VPWR A1 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X31 a_461_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 a_461_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X33 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 a_125_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X35 a_1163_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X36 a_1163_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X37 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X38 a_39_297# A2 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X39 a_461_297# A2 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
X0 a_281_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND a_531_21# Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR C_N a_531_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X7 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X9 a_281_297# a_531_21# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X10 Y a_531_21# a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X11 VGND C_N a_531_21# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X12 a_27_297# B a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X13 Y a_531_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
X0 a_27_47# C1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_803_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_47# C1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0943 ps=0.94 w=0.65 l=0.15
X4 a_1163_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0959 ps=0.945 w=0.65 l=0.15
X7 Y D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 Y A2 a_1163_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_1163_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.147 ps=1.29 w=1 l=0.15
X10 a_445_47# B1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR D1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_445_47# B1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 Y D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR A1 a_1163_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_47# D1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_47# D1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0959 ps=0.945 w=0.65 l=0.15
X18 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X20 a_1163_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 a_803_47# B1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.237 pd=1.48 as=0.135 ps=1.27 w=1 l=0.15
X24 VPWR A1 a_1163_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 a_803_47# B1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y D1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.237 ps=1.48 w=1 l=0.15
X28 a_445_47# C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_803_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 a_1163_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.253 ps=2.52 w=1 l=0.15
X32 Y A2 a_1163_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.253 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X33 a_445_47# C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X34 a_803_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.0878 ps=0.92 w=0.65 l=0.15
X35 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 a_803_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.0878 ps=0.92 w=0.65 l=0.15
X37 VPWR D1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 Y D1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X39 VGND A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
X0 a_176_21# a_27_47# a_626_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X1 a_626_297# B a_542_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_542_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X8 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X12 a_176_21# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X13 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2111o_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 a_30_297# C1 a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X1 VGND C1 a_44_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.091 ps=0.93 w=0.65 l=0.15
X2 a_44_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.266 ps=1.47 w=0.65 l=0.15
X3 VGND a_44_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VPWR A1 a_477_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.257 ps=1.51 w=1 l=0.15
X5 VPWR a_44_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 X a_44_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VGND B1 a_44_47# VNB sky130_fd_pr__nfet_01v8 ad=0.266 pd=1.47 as=0.109 ps=0.985 w=0.65 l=0.15
X8 X a_44_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 a_477_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X10 a_285_297# B1 a_477_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND D1 a_44_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X12 a_770_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.182 ps=1.86 w=0.65 l=0.15
X13 X a_44_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X14 a_30_297# D1 a_44_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 VGND A2 a_770_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X16 a_44_47# D1 a_30_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X17 a_477_297# B1 a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.257 pd=1.51 as=0.14 ps=1.28 w=1 l=0.15
X18 a_770_47# A1 a_44_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0926 ps=0.935 w=0.65 l=0.15
X19 a_477_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X20 VPWR a_44_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X21 a_285_297# C1 a_30_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 a_44_47# D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_44_47# A1 a_770_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.091 ps=0.93 w=0.65 l=0.15
X24 VGND a_44_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X25 VPWR A2 a_477_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X26 X a_44_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X27 a_44_47# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.102 ps=0.965 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
X0 VPWR a_315_380# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_315_380# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X2 a_315_380# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND C_N a_27_410# VNB sky130_fd_pr__nfet_01v8 ad=0.0619 pd=0.715 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR C_N a_27_410# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.123 pd=1.32 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VPWR A a_583_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_27_410# a_315_380# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X7 a_583_297# B a_499_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_315_380# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_397_297# a_205_93# a_315_380# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.258 ps=2.52 w=1 l=0.15
X10 X a_315_380# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X11 X a_315_380# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_499_297# a_27_410# a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.18 ps=1.36 w=1 l=0.15
X13 VPWR a_315_380# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 a_205_93# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0619 ps=0.715 w=0.42 l=0.15
X15 a_205_93# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.4 as=0.123 ps=1.32 w=0.42 l=0.15
X16 VGND a_315_380# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND a_315_380# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_315_380# a_205_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.169 ps=1.82 w=0.65 l=0.15
X19 X a_315_380# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 a_465_47# A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND A4 a_561_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X2 VPWR A3 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X3 a_297_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X4 a_297_297# A4 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X5 VPWR A1 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_381_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.184 ps=1.22 w=0.65 l=0.15
X7 a_297_297# B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X8 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X9 a_79_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.184 pd=1.22 as=0.161 ps=1.14 w=0.65 l=0.15
X10 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.161 pd=1.14 as=0.169 ps=1.82 w=0.65 l=0.15
X11 a_561_47# A3 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor4_4 A B C D VGND VNB VPB VPWR Y
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_807_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y D a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X9 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X13 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 a_807_297# C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 VGND D Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 VGND D Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_807_297# C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X22 a_449_297# C a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_449_297# C a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X26 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_807_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X28 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 Y D a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
X0 VPWR A1 a_485_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_485_297# a_297_93# a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X2 a_297_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.108 ps=1.01 w=0.42 l=0.15
X3 a_581_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X4 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.01 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_79_21# a_297_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X6 VGND A2 a_581_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.182 pd=1.51 as=0.14 ps=1.28 w=1 l=0.15
X8 a_297_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.182 ps=1.51 w=0.42 l=0.15
X9 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X10 a_485_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X11 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkinvlp_2 A VGND VNB VPB VPWR Y
X0 Y A a_150_67# VNB sky130_fd_pr__nfet_01v8 ad=0.157 pd=1.67 as=0.066 ps=0.79 w=0.55 l=0.15
X1 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.39 pd=2.78 as=0.14 ps=1.28 w=1 l=0.25
X2 a_150_67# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.79 as=0.157 ps=1.67 w=0.55 l=0.15
X3 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.25
.ends

.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y A3 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_449_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 Y A3 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y B1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_449_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.263 ps=2.57 w=1 l=0.15
X8 Y B1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_31_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_297# A2 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.261 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 a_31_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 a_31_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_31_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_449_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X20 VGND A2 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 VGND A2 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VGND A3 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.223 pd=1.34 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_31_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.223 ps=1.34 w=0.65 l=0.15
X25 a_27_297# A2 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND A3 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 a_31_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X28 a_449_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 a_31_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 a_31_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32a_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_429_297# A2 a_345_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND A2 a_345_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_345_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.14 ps=1.08 w=0.65 l=0.15
X5 a_345_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.305 ps=1.61 w=1 l=0.15
X6 a_629_297# B2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR B1 a_629_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.33 pd=2.66 as=0.19 ps=1.38 w=1 l=0.15
X8 a_79_21# B2 a_345_47# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_345_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.214 pd=1.96 as=0.123 ps=1.03 w=0.65 l=0.15
X10 a_79_21# A3 a_429_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X11 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X12 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_345_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.198 ps=1.26 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y A1 a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.119 ps=1.01 w=0.65 l=0.15
X1 a_181_47# A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.0683 ps=0.86 w=0.65 l=0.15
X2 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.106 ps=0.975 w=0.65 l=0.15
X3 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.162 ps=1.33 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.153 ps=1.3 w=1 l=0.15
X6 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2111oi_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
X0 Y D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_455_297# B1 a_821_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X2 a_28_297# D1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 a_821_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X4 a_28_297# C1 a_455_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 a_455_297# C1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND D1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 VPWR A2 a_821_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.2 ps=1.4 w=1 l=0.15
X9 Y D1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X10 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X11 VGND D1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X13 a_821_297# B1 a_455_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X14 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X15 Y D1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.117 ps=1.01 w=0.65 l=0.15
X17 a_1205_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X18 a_28_297# C1 a_455_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X19 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
X20 a_1205_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 a_821_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.14 ps=1.28 w=1 l=0.15
X22 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.091 ps=0.93 w=0.65 l=0.15
X23 Y A1 a_1205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X24 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X25 VPWR A1 a_821_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X26 Y A1 a_1205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.182 ps=1.86 w=0.65 l=0.15
X27 a_1205_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.02 as=0.091 ps=0.93 w=0.65 l=0.15
X28 a_28_297# D1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X29 VGND A2 a_1205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X30 a_455_297# B1 a_821_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X31 a_821_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.2 pd=1.4 as=0.15 ps=1.3 w=1 l=0.15
X32 a_1205_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X33 VGND A2 a_1205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.122 ps=1.02 w=0.65 l=0.15
X34 VPWR A1 a_821_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.14 ps=1.28 w=1 l=0.15
X35 a_821_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X36 VPWR A2 a_821_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.185 ps=1.37 w=1 l=0.15
X37 a_455_297# C1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X38 a_821_297# B1 a_455_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.14 ps=1.28 w=1 l=0.15
X39 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32o_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 VPWR A3 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_299_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X2 a_352_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.21 ps=1.29 w=0.65 l=0.15
X3 a_549_47# A1 a_21_199# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.107 ps=0.98 w=0.65 l=0.15
X4 X a_21_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_21_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.21 pd=1.29 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_665_47# A2 a_549_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.14 ps=1.08 w=0.65 l=0.15
X7 VPWR A1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X8 a_299_297# B1 a_21_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_21_199# B2 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 VGND A3 a_665_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR a_21_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X12 X a_21_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_21_199# B1 a_352_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.115 ps=1 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a41oi_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
X0 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.29 ps=1.58 w=1 l=0.15
X1 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.338 ps=1.67 w=1 l=0.15
X2 Y A1 a_493_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 VPWR A4 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y A1 a_493_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.305 ps=1.61 w=1 l=0.15
X6 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.183 ps=1.37 w=1 l=0.15
X7 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_911_47# A2 a_493_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_911_47# A3 a_1269_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A4 a_1269_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A4 a_1269_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=1.58 as=0.135 ps=1.27 w=1 l=0.15
X14 a_493_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_493_47# A2 a_911_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_493_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_493_47# A2 a_911_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 a_911_47# A2 a_493_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 a_1269_47# A4 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.183 pd=1.37 as=0.135 ps=1.27 w=1 l=0.15
X26 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X27 a_911_47# A3 a_1269_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X28 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.338 pd=1.67 as=0.135 ps=1.27 w=1 l=0.15
X31 a_27_297# A4 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.135 ps=1.27 w=1 l=0.15
X32 VPWR A4 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 a_1269_47# A3 a_911_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X34 a_27_297# A4 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X35 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X36 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 a_1269_47# A3 a_911_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X38 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X39 a_1269_47# A4 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4bb_1 A_N B_N C D VGND VNB VPB VPWR Y
X0 VGND B_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.04 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_496_21# A_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.183 pd=1.71 as=0.109 ps=1.36 w=0.42 l=0.15
X2 Y a_496_21# a_426_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.114 ps=1 w=0.65 l=0.15
X3 VPWR a_496_21# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.175 ps=1.35 w=1 l=0.15
X4 a_426_47# a_27_93# a_326_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.114 ps=1 w=0.65 l=0.15
X5 VPWR B_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.176 pd=1.39 as=0.109 ps=1.36 w=0.42 l=0.15
X6 a_496_21# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.183 pd=1.71 as=0.109 ps=1.36 w=0.42 l=0.15
X7 Y a_27_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.175 ps=1.35 w=1 l=0.15
X8 a_218_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.12 ps=1.04 w=0.65 l=0.15
X9 a_326_47# C a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.127 ps=1.04 w=0.65 l=0.15
X10 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.176 ps=1.39 w=1 l=0.15
X11 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.195 ps=1.39 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2bb2ai_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
X0 VPWR A2_N a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.42 pd=1.84 as=0.135 ps=1.27 w=1 l=0.15
X1 Y a_112_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.42 ps=1.84 w=1 l=0.15
X2 VGND B2 a_394_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_112_297# A2_N a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.241 pd=2.04 as=0.0683 ps=0.86 w=0.65 l=0.15
X4 a_112_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.179 ps=1.85 w=0.65 l=0.15
X5 a_112_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X6 VPWR B1 a_478_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.135 ps=1.27 w=1 l=0.15
X7 a_394_47# a_112_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X8 a_394_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_478_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_77_199# B2 a_227_47# VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.127 ps=1.04 w=0.65 l=0.15
X1 a_323_297# A2 a_227_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.165 ps=1.33 w=1 l=0.15
X2 a_227_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_227_47# B1 a_77_199# VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.133 ps=1.06 w=0.65 l=0.15
X4 VGND a_77_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR B1 a_539_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.205 ps=1.41 w=1 l=0.15
X6 a_227_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X7 VPWR a_77_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=2.67 w=1 l=0.15
X8 a_77_199# A3 a_323_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X9 VGND A2 a_227_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 a_227_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_539_297# B2 a_77_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=1.41 as=0.195 ps=1.39 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
X0 a_408_47# B a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_408_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y a_27_47# a_408_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.176 pd=1.39 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND C a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X6 a_218_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.12 ps=1.04 w=0.65 l=0.15
X7 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_218_47# B a_408_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X11 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.176 ps=1.39 w=1 l=0.15
X12 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.04 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2b_4 A_N B VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.137 ps=1.07 w=0.65 l=0.15
X1 VGND B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.137 pd=1.07 as=0.0715 ps=0.87 w=0.65 l=0.15
X2 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.135 ps=1.27 w=1 l=0.15
X3 a_33_199# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=1.37 as=0.107 ps=1 w=0.42 l=0.15
X4 a_33_199# A_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.156 ps=1.36 w=0.42 l=0.15
X5 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.156 pd=1.36 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=1 as=0.091 ps=0.93 w=0.65 l=0.15
X7 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.15 ps=1.3 w=1 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.185 ps=1.37 w=1 l=0.15
X11 a_27_47# a_33_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X12 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 a_109_47# a_33_199# a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0715 pd=0.87 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311oi_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
X0 Y A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_641_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=1.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 a_109_297# B1 a_641_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X5 a_277_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR A3 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.17 w=0.65 l=0.15
X11 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.14 ps=1.28 w=1 l=0.15
X12 a_641_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X13 a_277_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0975 ps=0.95 w=0.65 l=0.15
X15 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 Y C1 a_641_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=1.52 w=1 l=0.15
X18 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X19 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.17 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
X0 a_27_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_27_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_277_297# B a_205_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VPWR A a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 a_205_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X6 VPWR a_27_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=2.61 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND a_27_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.91 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X9 VGND C a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0693 ps=0.75 w=0.42 l=0.15
X10 a_109_297# D a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND A a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor4_2 A B C D VGND VNB VPB VPWR Y
X0 a_281_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_475_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y D a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND D Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X9 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X12 a_475_297# C a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_281_297# C a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X14 a_27_297# B a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X15 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
X0 a_388_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.148 ps=1.34 w=0.42 l=0.15
X1 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X4 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X7 a_176_21# a_27_47# a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 a_472_297# B a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.102 ps=0.99 w=0.42 l=0.15
X10 a_176_21# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
X0 VGND C a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y a_27_47# a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y a_27_47# a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_633_47# B a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_633_47# B a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_215_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 a_215_47# B a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_215_47# B a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 a_633_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X17 a_633_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X20 a_215_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X23 VGND C a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X25 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
X0 X a_299_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X1 VPWR a_193_47# a_299_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 VGND a_193_47# a_299_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X6 X a_299_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 Y a_33_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_225_47# a_33_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR a_33_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_33_297# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.182 ps=1.86 w=0.65 l=0.15
X4 Y a_33_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A2 a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 Y a_33_297# a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 Y a_33_297# a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND A2 a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND A2 a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_561_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X11 a_225_47# a_33_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR A1 a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_225_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_225_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_225_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_225_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VPWR A1 a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 a_561_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR B1_N a_33_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X20 a_561_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VGND A1 a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y A2 a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VGND A1 a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_561_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 VPWR a_33_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 VGND A4 a_321_47# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_321_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.123 ps=1.03 w=0.65 l=0.15
X2 a_103_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=1.52 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR a_103_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.425 ps=2.85 w=1 l=0.15
X4 VGND a_103_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.247 ps=2.06 w=0.65 l=0.15
X5 VGND A2 a_321_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X6 a_321_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.127 ps=1.04 w=0.65 l=0.15
X7 a_511_297# A3 a_393_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.22 ps=1.44 w=1 l=0.15
X8 a_619_297# A2 a_511_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X9 a_321_47# B1 a_103_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X10 a_393_297# A4 a_103_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.22 pd=1.44 as=0.26 ps=1.52 w=1 l=0.15
X11 VPWR A1 a_619_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.195 ps=1.39 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_223_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 Y A1 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X3 a_223_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X4 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 VGND A2 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_223_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X7 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.123 ps=1.03 w=0.65 l=0.15
X8 VPWR A2 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 a_658_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.201 ps=1.27 w=0.65 l=0.15
X10 VPWR A1 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_223_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 a_658_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 Y a_27_47# a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_223_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X15 VPWR A2 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.155 ps=1.31 w=1 l=0.15
X16 VPWR A1 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 a_658_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VGND B1_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.27 ps=2.13 w=0.65 l=0.15
X19 a_223_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X20 a_658_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 VGND A2 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.27 as=0.091 ps=0.93 w=0.65 l=0.15
X23 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X24 Y A1 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X25 Y a_27_47# a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_4 A B C D VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_188_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.0796 ps=0.895 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND D a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.141 ps=1.09 w=0.65 l=0.15
X5 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.215 ps=1.43 w=1 l=0.15
X6 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X7 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.106 ps=0.975 w=0.65 l=0.15
X10 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.155 ps=1.31 w=1 l=0.15
X12 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X14 a_285_47# C a_188_47# VNB sky130_fd_pr__nfet_01v8 ad=0.141 pd=1.09 as=0.109 ps=0.985 w=0.65 l=0.15
X15 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0796 pd=0.895 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.221 pd=1.98 as=0.198 ps=1.26 w=0.65 l=0.15
X1 Y A3 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.393 pd=1.78 as=0.135 ps=1.27 w=1 l=0.15
X2 a_193_297# A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.393 ps=1.78 w=1 l=0.15
X5 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt pid VGND VPWR clock iterate_enable measurement[0] measurement[10] measurement[11]
+ measurement[12] measurement[13] measurement[14] measurement[15] measurement[16]
+ measurement[17] measurement[1] measurement[2] measurement[3] measurement[4] measurement[5]
+ measurement[6] measurement[7] measurement[8] measurement[9] out_clocked[0] out_clocked[10]
+ out_clocked[11] out_clocked[12] out_clocked[13] out_clocked[14] out_clocked[15]
+ out_clocked[16] out_clocked[17] out_clocked[1] out_clocked[2] out_clocked[3] out_clocked[4]
+ out_clocked[5] out_clocked[6] out_clocked[7] out_clocked[8] out_clocked[9] reg_addr[0]
+ reg_addr[10] reg_addr[11] reg_addr[12] reg_addr[13] reg_addr[14] reg_addr[15] reg_addr[16]
+ reg_addr[17] reg_addr[1] reg_addr[2] reg_addr[3] reg_addr[4] reg_addr[5] reg_addr[6]
+ reg_addr[7] reg_addr[8] reg_addr[9] reg_data[0] reg_data[10] reg_data[11] reg_data[12]
+ reg_data[13] reg_data[14] reg_data[15] reg_data[16] reg_data[17] reg_data[1] reg_data[2]
+ reg_data[3] reg_data[4] reg_data[5] reg_data[6] reg_data[7] reg_data[8] reg_data[9]
+ reset target[0] target[10] target[11] target[12] target[13] target[14] target[15]
+ target[16] target[17] target[1] target[2] target[3] target[4] target[5] target[6]
+ target[7] target[8] target[9] write_enable
X_09671_ _00469_ _00481_ VGND VGND VPWR VPWR _00482_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_118_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_6_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09105_ _07178_ _07189_ VGND VGND VPWR VPWR _07200_ sky130_fd_sc_hd__nor2_1
XFILLER_0_150_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09036_ net321 _05033_ VGND VGND VPWR VPWR _06441_ sky130_fd_sc_hd__nand2_1
XFILLER_0_142_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09938_ _00746_ _00747_ _00748_ VGND VGND VPWR VPWR _00749_ sky130_fd_sc_hd__o21ba_2
X_09869_ _00675_ _00678_ VGND VGND VPWR VPWR _00680_ sky130_fd_sc_hd__or2_1
X_11900_ _02662_ _02678_ _02680_ VGND VGND VPWR VPWR _02711_ sky130_fd_sc_hd__and3_1
XFILLER_0_99_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12880_ net204 _03217_ _03223_ net207 VGND VGND VPWR VPWR _03724_ sky130_fd_sc_hd__a22oi_1
X_11831_ _02604_ _02640_ _02641_ VGND VGND VPWR VPWR _02642_ sky130_fd_sc_hd__a21boi_2
X_14550_ _06342_ VGND VGND VPWR VPWR _05547_ sky130_fd_sc_hd__inv_2
XFILLER_0_67_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11762_ _02571_ _02572_ net426 net143 VGND VGND VPWR VPWR _02573_ sky130_fd_sc_hd__and4b_1
XFILLER_0_56_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13501_ _04364_ _04391_ _04392_ VGND VGND VPWR VPWR _04393_ sky130_fd_sc_hd__o21a_1
X_10713_ _01523_ VGND VGND VPWR VPWR _01524_ sky130_fd_sc_hd__buf_2
X_14481_ _06606_ _06826_ _05470_ VGND VGND VPWR VPWR _05471_ sky130_fd_sc_hd__a21o_1
X_11693_ _02406_ _02464_ VGND VGND VPWR VPWR _02504_ sky130_fd_sc_hd__nor2_1
X_16220_ _07353_ _07383_ VGND VGND VPWR VPWR _07384_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_64_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13432_ net521 VGND VGND VPWR VPWR _04317_ sky130_fd_sc_hd__buf_4
X_10644_ _08659_ _01453_ _01452_ VGND VGND VPWR VPWR _01455_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_130_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16151_ _07293_ _07296_ _07294_ VGND VGND VPWR VPWR _07308_ sky130_fd_sc_hd__nand3_1
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10575_ _01368_ _01371_ _01385_ VGND VGND VPWR VPWR _01386_ sky130_fd_sc_hd__o21a_1
X_13363_ net233 _03221_ _03282_ net236 VGND VGND VPWR VPWR _04242_ sky130_fd_sc_hd__a22o_1
Xrebuffer7 _07920_ VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__buf_1
X_15102_ net255 _05666_ _06153_ VGND VGND VPWR VPWR _06154_ sky130_fd_sc_hd__and3_1
XFILLER_0_23_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12314_ _02723_ _02785_ _03145_ VGND VGND VPWR VPWR _03146_ sky130_fd_sc_hd__o21ba_1
X_16082_ _07230_ _07229_ _07228_ _07218_ VGND VGND VPWR VPWR _07232_ sky130_fd_sc_hd__a211o_1
XFILLER_0_106_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13294_ net241 _03320_ _04074_ _04075_ VGND VGND VPWR VPWR _04166_ sky130_fd_sc_hd__a22o_1
XFILLER_0_133_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15033_ _06064_ _06075_ VGND VGND VPWR VPWR _06079_ sky130_fd_sc_hd__xor2_1
X_12245_ _03045_ _03044_ VGND VGND VPWR VPWR _03075_ sky130_fd_sc_hd__and2b_1
X_12176_ _02997_ _03000_ VGND VGND VPWR VPWR _03001_ sky130_fd_sc_hd__nor2_1
XFILLER_0_102_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11127_ net449 net107 VGND VGND VPWR VPWR _01938_ sky130_fd_sc_hd__and2_1
X_16984_ _08220_ _08172_ _08222_ VGND VGND VPWR VPWR _08225_ sky130_fd_sc_hd__and3_1
X_15935_ _07062_ _07069_ _07070_ VGND VGND VPWR VPWR _07071_ sky130_fd_sc_hd__a21boi_1
X_11058_ _01863_ _01868_ VGND VGND VPWR VPWR _01869_ sky130_fd_sc_hd__and2_1
X_10009_ _00818_ _00791_ VGND VGND VPWR VPWR _00820_ sky130_fd_sc_hd__and2_1
X_15866_ _06946_ _06993_ _06994_ VGND VGND VPWR VPWR _06995_ sky130_fd_sc_hd__nand3_1
XFILLER_0_149_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14817_ net304 _05840_ VGND VGND VPWR VPWR _05841_ sky130_fd_sc_hd__and2_1
X_15797_ _06917_ _06918_ VGND VGND VPWR VPWR _06919_ sky130_fd_sc_hd__xor2_1
XFILLER_0_147_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17536_ clknet_4_7_0_clock _00025_ VGND VGND VPWR VPWR kd_2\[16\] sky130_fd_sc_hd__dfxtp_1
X_14748_ _05623_ _05764_ VGND VGND VPWR VPWR _05765_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_129_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17467_ clknet_4_0_0_clock _00063_ VGND VGND VPWR VPWR kp\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_104_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14679_ net308 net293 VGND VGND VPWR VPWR _05689_ sky130_fd_sc_hd__or2_1
XFILLER_0_27_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16418_ i_error\[7\] _07601_ VGND VGND VPWR VPWR _07602_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17398_ clknet_4_10_0_clock _00076_ VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_116_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16349_ _05827_ _05830_ _07525_ VGND VGND VPWR VPWR _07526_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_70_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_124_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout105 net106 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__buf_2
Xfanout116 net117 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__buf_2
Xfanout127 net128 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__buf_1
Xfanout138 net141 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__clkbuf_4
Xfanout149 kd_2\[7\] VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__buf_2
X_09723_ _00532_ _00533_ VGND VGND VPWR VPWR _00534_ sky130_fd_sc_hd__nor2_1
X_09654_ _00464_ VGND VGND VPWR VPWR _00465_ sky130_fd_sc_hd__inv_2
XFILLER_0_69_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09585_ _00293_ _00295_ VGND VGND VPWR VPWR _00396_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_148_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10360_ _01167_ _01170_ VGND VGND VPWR VPWR _01171_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09019_ net377 net360 net520 VGND VGND VPWR VPWR _06254_ sky130_fd_sc_hd__and3_1
XFILLER_0_14_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10291_ _01097_ _01100_ _01077_ _01078_ VGND VGND VPWR VPWR _01102_ sky130_fd_sc_hd__a211oi_1
X_12030_ _02787_ _02788_ _02846_ VGND VGND VPWR VPWR _02847_ sky130_fd_sc_hd__or3b_1
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13981_ _04919_ _04920_ VGND VGND VPWR VPWR _04921_ sky130_fd_sc_hd__xnor2_2
X_15720_ _06832_ _06833_ VGND VGND VPWR VPWR _06834_ sky130_fd_sc_hd__xnor2_1
X_12932_ _03691_ _03775_ VGND VGND VPWR VPWR _03776_ sky130_fd_sc_hd__or2_1
XFILLER_0_125_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15651_ _06722_ _06757_ VGND VGND VPWR VPWR _06758_ sky130_fd_sc_hd__xor2_1
X_12863_ _03705_ _03706_ VGND VGND VPWR VPWR _03707_ sky130_fd_sc_hd__nand2_1
X_14602_ _05603_ VGND VGND VPWR VPWR _05604_ sky130_fd_sc_hd__clkbuf_4
X_11814_ _02622_ _02614_ _02620_ VGND VGND VPWR VPWR _02625_ sky130_fd_sc_hd__nand3_1
X_15582_ _06643_ _06680_ VGND VGND VPWR VPWR _06682_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_96_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12794_ _03636_ _03637_ VGND VGND VPWR VPWR _03638_ sky130_fd_sc_hd__nor2_1
X_17321_ net465 net517 VGND VGND VPWR VPWR _08559_ sky130_fd_sc_hd__or2_1
XFILLER_0_96_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14533_ net321 _06881_ _06463_ VGND VGND VPWR VPWR _05529_ sky130_fd_sc_hd__a21oi_1
X_11745_ _02554_ _02555_ VGND VGND VPWR VPWR _02556_ sky130_fd_sc_hd__nor2_1
X_17252_ _08498_ net91 VGND VGND VPWR VPWR _08512_ sky130_fd_sc_hd__and2_1
X_14464_ _05450_ _05452_ VGND VGND VPWR VPWR _05453_ sky130_fd_sc_hd__xnor2_4
XPHY_EDGE_ROW_78_Left_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11676_ _02468_ _02470_ _02469_ VGND VGND VPWR VPWR _02487_ sky130_fd_sc_hd__a21o_1
XFILLER_0_36_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16203_ _07252_ _07364_ _07302_ VGND VGND VPWR VPWR _07366_ sky130_fd_sc_hd__a21oi_1
X_13415_ _04298_ VGND VGND VPWR VPWR _04299_ sky130_fd_sc_hd__inv_2
XFILLER_0_114_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17183_ _08409_ _08442_ VGND VGND VPWR VPWR _08444_ sky130_fd_sc_hd__xnor2_1
X_10627_ _01435_ _01436_ _00266_ _01434_ VGND VGND VPWR VPWR _01438_ sky130_fd_sc_hd__a211o_1
X_14395_ _03507_ _03509_ _05375_ VGND VGND VPWR VPWR _05377_ sky130_fd_sc_hd__and3_1
XFILLER_0_3_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16134_ _07261_ _07287_ _07289_ VGND VGND VPWR VPWR _07290_ sky130_fd_sc_hd__or3_1
X_13346_ _04222_ _04143_ VGND VGND VPWR VPWR _04223_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_122_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10558_ _01310_ _01317_ VGND VGND VPWR VPWR _01369_ sky130_fd_sc_hd__xor2_1
X_16065_ _07210_ _07213_ VGND VGND VPWR VPWR _07214_ sky130_fd_sc_hd__xor2_1
XFILLER_0_121_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13277_ _04012_ _04146_ VGND VGND VPWR VPWR _04147_ sky130_fd_sc_hd__nor2_1
XFILLER_0_122_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10489_ net375 _00241_ _01298_ _01299_ VGND VGND VPWR VPWR _01300_ sky130_fd_sc_hd__and4_1
X_15016_ _05985_ _06059_ VGND VGND VPWR VPWR _06060_ sky130_fd_sc_hd__nor2_1
X_12228_ _03054_ _03053_ VGND VGND VPWR VPWR _03056_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_20_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_87_Left_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12159_ _02944_ _02983_ VGND VGND VPWR VPWR _02984_ sky130_fd_sc_hd__nor2_1
XFILLER_0_75_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16967_ _08204_ _08205_ VGND VGND VPWR VPWR _08206_ sky130_fd_sc_hd__nor2_1
X_15918_ _06992_ _06986_ _06990_ VGND VGND VPWR VPWR _07052_ sky130_fd_sc_hd__and3_1
X_16898_ _05441_ _08066_ _08129_ VGND VGND VPWR VPWR _08130_ sky130_fd_sc_hd__a21oi_2
X_15849_ _06932_ _06968_ _06967_ VGND VGND VPWR VPWR _06976_ sky130_fd_sc_hd__and3_1
XFILLER_0_91_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09370_ _08627_ _08652_ _08651_ VGND VGND VPWR VPWR _00181_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_93_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17519_ clknet_4_4_0_clock _00008_ VGND VGND VPWR VPWR kd_1\[17\] sky130_fd_sc_hd__dfxtp_4
XFILLER_0_129_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_96_Left_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09706_ _04076_ _00516_ VGND VGND VPWR VPWR _00517_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_4_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09637_ _00418_ _00447_ VGND VGND VPWR VPWR _00448_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_139_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09568_ _00368_ _00377_ _00378_ VGND VGND VPWR VPWR _00379_ sky130_fd_sc_hd__o21a_1
XFILLER_0_78_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09499_ _04065_ _04109_ _04043_ VGND VGND VPWR VPWR _00310_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_148_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11530_ _02340_ VGND VGND VPWR VPWR _02341_ sky130_fd_sc_hd__inv_2
XFILLER_0_19_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_137_Right_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11461_ _02251_ _02270_ _02271_ VGND VGND VPWR VPWR _02272_ sky130_fd_sc_hd__nand3_1
XFILLER_0_34_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13200_ _04052_ _04050_ VGND VGND VPWR VPWR _04062_ sky130_fd_sc_hd__and2b_1
XFILLER_0_150_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10412_ _01174_ _01176_ VGND VGND VPWR VPWR _01223_ sky130_fd_sc_hd__xor2_1
X_14180_ _05015_ net101 _05139_ VGND VGND VPWR VPWR _05140_ sky130_fd_sc_hd__a21oi_1
X_11392_ _02202_ _02171_ VGND VGND VPWR VPWR _02203_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_103_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13131_ _03981_ _03985_ VGND VGND VPWR VPWR _03986_ sky130_fd_sc_hd__nor2_1
X_10343_ _01149_ _01152_ _01095_ _01153_ VGND VGND VPWR VPWR _01154_ sky130_fd_sc_hd__o211a_1
XFILLER_0_131_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10274_ net367 net486 _07387_ net372 VGND VGND VPWR VPWR _01085_ sky130_fd_sc_hd__a22o_1
X_13062_ _03785_ _03909_ VGND VGND VPWR VPWR _03910_ sky130_fd_sc_hd__nor2_1
X_12013_ _02801_ _02800_ VGND VGND VPWR VPWR _02829_ sky130_fd_sc_hd__and2b_1
X_16821_ _08039_ _08043_ VGND VGND VPWR VPWR _08045_ sky130_fd_sc_hd__and2b_1
XFILLER_0_136_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16752_ _07968_ VGND VGND VPWR VPWR _07969_ sky130_fd_sc_hd__buf_6
X_13964_ _04819_ _04886_ _04898_ VGND VGND VPWR VPWR _04903_ sky130_fd_sc_hd__o21bai_1
X_15703_ _06526_ _06531_ VGND VGND VPWR VPWR _06816_ sky130_fd_sc_hd__xnor2_1
Xmax_cap5 _03665_ VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__buf_8
X_12915_ _03744_ _03746_ _03758_ VGND VGND VPWR VPWR _03759_ sky130_fd_sc_hd__a21bo_1
X_16683_ _05866_ _07892_ VGND VGND VPWR VPWR _07894_ sky130_fd_sc_hd__xnor2_2
X_13895_ net218 _03791_ _03935_ net214 VGND VGND VPWR VPWR _04827_ sky130_fd_sc_hd__a22o_1
X_15634_ _06668_ _06669_ _06673_ VGND VGND VPWR VPWR _06740_ sky130_fd_sc_hd__a21o_1
X_12846_ _03688_ _03689_ VGND VGND VPWR VPWR _03690_ sky130_fd_sc_hd__nand2_2
XFILLER_0_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15565_ _06629_ _06627_ VGND VGND VPWR VPWR _06664_ sky130_fd_sc_hd__and2b_1
XFILLER_0_29_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12777_ net211 _03337_ _03620_ VGND VGND VPWR VPWR _03621_ sky130_fd_sc_hd__and3_1
XFILLER_0_139_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17304_ _08536_ _04626_ _08548_ net450 VGND VGND VPWR VPWR _00100_ sky130_fd_sc_hd__o211a_1
X_14516_ _06969_ _07002_ _05509_ VGND VGND VPWR VPWR _05510_ sky130_fd_sc_hd__o21a_1
X_11728_ _02471_ _02487_ _02520_ VGND VGND VPWR VPWR _02539_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_44_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15496_ _06556_ _06587_ VGND VGND VPWR VPWR _06588_ sky130_fd_sc_hd__xor2_1
XFILLER_0_126_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17235_ net494 _08495_ _08484_ VGND VGND VPWR VPWR _08500_ sky130_fd_sc_hd__a21oi_2
X_14447_ _00639_ _05433_ VGND VGND VPWR VPWR _05434_ sky130_fd_sc_hd__xnor2_4
XPHY_EDGE_ROW_104_Right_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11659_ _02461_ _02465_ _02467_ VGND VGND VPWR VPWR _02470_ sky130_fd_sc_hd__nand3_1
XFILLER_0_142_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17166_ _08337_ _08338_ VGND VGND VPWR VPWR _08425_ sky130_fd_sc_hd__and2b_1
X_14378_ _03482_ _03484_ _03483_ VGND VGND VPWR VPWR _05358_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_40_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16117_ _07246_ _07268_ _07269_ _07270_ VGND VGND VPWR VPWR _07271_ sky130_fd_sc_hd__or4_4
X_13329_ _04201_ _04202_ VGND VGND VPWR VPWR _04204_ sky130_fd_sc_hd__xnor2_1
X_17097_ _08310_ _08348_ VGND VGND VPWR VPWR _08349_ sky130_fd_sc_hd__xor2_1
XFILLER_0_110_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16048_ net290 _06161_ _07193_ _07194_ VGND VGND VPWR VPWR _07195_ sky130_fd_sc_hd__nand4_1
XFILLER_0_86_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08870_ _04604_ VGND VGND VPWR VPWR _04615_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_35_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09422_ net326 _07420_ _07343_ net330 VGND VGND VPWR VPWR _00233_ sky130_fd_sc_hd__a22oi_1
X_09353_ _00146_ _00162_ _00163_ VGND VGND VPWR VPWR _00164_ sky130_fd_sc_hd__o21a_1
XFILLER_0_19_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09284_ _08608_ _08645_ _08647_ VGND VGND VPWR VPWR _08648_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_129_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08999_ net323 _04934_ _05693_ _05682_ VGND VGND VPWR VPWR _06034_ sky130_fd_sc_hd__a31o_1
XFILLER_0_15_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10961_ _01578_ _01591_ VGND VGND VPWR VPWR _01772_ sky130_fd_sc_hd__xor2_1
X_12700_ _03374_ _03343_ _03536_ _03538_ VGND VGND VPWR VPWR _03539_ sky130_fd_sc_hd__o22a_1
XFILLER_0_57_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13680_ net206 _03791_ _03935_ net202 VGND VGND VPWR VPWR _04590_ sky130_fd_sc_hd__a22oi_1
X_10892_ _01701_ _01702_ VGND VGND VPWR VPWR _01703_ sky130_fd_sc_hd__or2_1
X_12631_ _03401_ _03469_ VGND VGND VPWR VPWR _03470_ sky130_fd_sc_hd__nor2_1
XFILLER_0_66_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15350_ net281 _05620_ _06301_ VGND VGND VPWR VPWR _06427_ sky130_fd_sc_hd__a21o_1
XFILLER_0_136_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12562_ _03399_ _03400_ VGND VGND VPWR VPWR _03401_ sky130_fd_sc_hd__and2b_1
XFILLER_0_108_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xwire100 _07375_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__clkbuf_2
X_14301_ _05167_ _05168_ _05169_ VGND VGND VPWR VPWR _05273_ sky130_fd_sc_hd__or3_4
XFILLER_0_135_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11513_ _02234_ _02323_ VGND VGND VPWR VPWR _02324_ sky130_fd_sc_hd__nand2_1
X_15281_ net253 _06162_ _06206_ net250 VGND VGND VPWR VPWR _06351_ sky130_fd_sc_hd__a22o_1
XFILLER_0_18_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12493_ net207 net203 _03322_ _03328_ VGND VGND VPWR VPWR _03330_ sky130_fd_sc_hd__and4_1
XFILLER_0_53_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17020_ _03264_ _03286_ VGND VGND VPWR VPWR _08264_ sky130_fd_sc_hd__or2_1
X_14232_ _03609_ _05196_ VGND VGND VPWR VPWR _05197_ sky130_fd_sc_hd__xor2_4
XFILLER_0_123_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11444_ _02253_ _02254_ net407 net148 VGND VGND VPWR VPWR _02255_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_22_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14163_ _04948_ _04959_ VGND VGND VPWR VPWR _05122_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11375_ _02033_ _02035_ _01481_ VGND VGND VPWR VPWR _02186_ sky130_fd_sc_hd__o21a_1
XFILLER_0_150_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13114_ _03960_ _03967_ VGND VGND VPWR VPWR _03968_ sky130_fd_sc_hd__xor2_2
X_10326_ _01081_ _01088_ VGND VGND VPWR VPWR _01137_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_131_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14094_ _05038_ _05042_ _05043_ _05045_ VGND VGND VPWR VPWR _05046_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_21_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13045_ net216 _03222_ VGND VGND VPWR VPWR _03892_ sky130_fd_sc_hd__nand2_1
X_10257_ _01058_ _01067_ VGND VGND VPWR VPWR _01068_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10188_ _00991_ _00994_ _00990_ VGND VGND VPWR VPWR _00999_ sky130_fd_sc_hd__o21a_1
XFILLER_0_56_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16804_ _07722_ _05557_ _08026_ net482 VGND VGND VPWR VPWR _08027_ sky130_fd_sc_hd__a22o_1
X_14996_ net284 _05711_ _06033_ _06037_ VGND VGND VPWR VPWR _06038_ sky130_fd_sc_hd__a31oi_4
X_16735_ _07884_ _07950_ VGND VGND VPWR VPWR _07951_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_88_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13947_ _04832_ _04833_ VGND VGND VPWR VPWR _04884_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_879 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16666_ _07873_ _07874_ VGND VGND VPWR VPWR _07875_ sky130_fd_sc_hd__and2_1
X_13878_ _04765_ _04806_ VGND VGND VPWR VPWR _04808_ sky130_fd_sc_hd__nor2_1
XFILLER_0_88_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15617_ _06690_ _06702_ VGND VGND VPWR VPWR _06721_ sky130_fd_sc_hd__nor2_1
XFILLER_0_119_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12829_ _03661_ _03672_ VGND VGND VPWR VPWR _03673_ sky130_fd_sc_hd__and2b_1
XFILLER_0_57_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16597_ _05449_ _05453_ VGND VGND VPWR VPWR _07799_ sky130_fd_sc_hd__and2_1
XFILLER_0_146_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15548_ _06566_ _06565_ VGND VGND VPWR VPWR _06645_ sky130_fd_sc_hd__and2b_1
XFILLER_0_16_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15479_ net304 _05701_ _06568_ VGND VGND VPWR VPWR _06569_ sky130_fd_sc_hd__and3_1
XFILLER_0_72_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17218_ _08481_ _08103_ VGND VGND VPWR VPWR _08482_ sky130_fd_sc_hd__xor2_1
XFILLER_0_142_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17149_ _01484_ _08339_ _01480_ VGND VGND VPWR VPWR _08406_ sky130_fd_sc_hd__o21ba_1
Xfanout7 _05596_ VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__buf_2
XFILLER_0_13_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09971_ _00759_ _00781_ VGND VGND VPWR VPWR _00782_ sky130_fd_sc_hd__and2_1
X_08922_ _05121_ _05176_ VGND VGND VPWR VPWR _05187_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08853_ _04417_ VGND VGND VPWR VPWR _04428_ sky130_fd_sc_hd__buf_4
XFILLER_0_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08784_ net55 _03553_ _03586_ net343 VGND VGND VPWR VPWR _00071_ sky130_fd_sc_hd__a22o_1
XFILLER_0_98_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09405_ net337 _04439_ _00215_ VGND VGND VPWR VPWR _00216_ sky130_fd_sc_hd__and3_1
XFILLER_0_94_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09336_ _08691_ _00144_ _00145_ VGND VGND VPWR VPWR _00147_ sky130_fd_sc_hd__or3b_1
XFILLER_0_118_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09267_ net322 _07343_ _08629_ _08630_ VGND VGND VPWR VPWR _08631_ sky130_fd_sc_hd__a31o_1
XFILLER_0_118_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09198_ _08135_ _08179_ VGND VGND VPWR VPWR _08223_ sky130_fd_sc_hd__or2b_1
XFILLER_0_50_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11160_ _01881_ _01883_ VGND VGND VPWR VPWR _01971_ sky130_fd_sc_hd__nor2_1
X_10111_ _00921_ _00821_ VGND VGND VPWR VPWR _00922_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_101_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11091_ _01896_ _01901_ VGND VGND VPWR VPWR _01902_ sky130_fd_sc_hd__and2_1
X_10042_ _00833_ _00838_ _00839_ VGND VGND VPWR VPWR _00853_ sky130_fd_sc_hd__a21oi_1
Xhold41 net82 VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__dlygate4sd3_1
X_14850_ net265 _05703_ VGND VGND VPWR VPWR _05877_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13801_ _04639_ _04721_ _04717_ _04720_ VGND VGND VPWR VPWR _04723_ sky130_fd_sc_hd__o211a_1
X_14781_ _05724_ VGND VGND VPWR VPWR _05801_ sky130_fd_sc_hd__buf_2
X_11993_ net402 net174 _02742_ _02743_ VGND VGND VPWR VPWR _02807_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_97_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16520_ _07712_ _07713_ VGND VGND VPWR VPWR _07714_ sky130_fd_sc_hd__nor2_1
X_13732_ _04610_ _04646_ VGND VGND VPWR VPWR _04647_ sky130_fd_sc_hd__xor2_4
X_10944_ net394 net399 net137 net129 VGND VGND VPWR VPWR _01755_ sky130_fd_sc_hd__and4_1
XFILLER_0_86_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16451_ _07613_ _07635_ _07636_ _07637_ VGND VGND VPWR VPWR _07638_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_85_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13663_ net246 _03222_ _03260_ net227 VGND VGND VPWR VPWR _04572_ sky130_fd_sc_hd__a22o_1
XFILLER_0_128_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10875_ net401 _01489_ VGND VGND VPWR VPWR _01686_ sky130_fd_sc_hd__and2_1
X_15402_ _06380_ _06377_ _06379_ VGND VGND VPWR VPWR _06484_ sky130_fd_sc_hd__a21o_1
X_12614_ _03450_ _03452_ VGND VGND VPWR VPWR _03453_ sky130_fd_sc_hd__and2b_1
X_16382_ _05916_ _05900_ VGND VGND VPWR VPWR _07562_ sky130_fd_sc_hd__or2b_1
X_13594_ net246 net229 _03283_ _03248_ VGND VGND VPWR VPWR _04496_ sky130_fd_sc_hd__nand4_1
XFILLER_0_143_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15333_ net259 _06017_ VGND VGND VPWR VPWR _06409_ sky130_fd_sc_hd__nand2_1
X_12545_ _03380_ _03383_ VGND VGND VPWR VPWR _03384_ sky130_fd_sc_hd__or2_1
XFILLER_0_109_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15264_ _06242_ _06316_ VGND VGND VPWR VPWR _06333_ sky130_fd_sc_hd__nand2_1
XFILLER_0_124_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12476_ prev_error\[16\] _05660_ VGND VGND VPWR VPWR _03311_ sky130_fd_sc_hd__and2b_1
XFILLER_0_34_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17003_ _05428_ _08206_ _08204_ VGND VGND VPWR VPWR _08246_ sky130_fd_sc_hd__a21oi_1
X_14215_ _04569_ _05177_ _05178_ VGND VGND VPWR VPWR _05179_ sky130_fd_sc_hd__a21o_1
XANTENNA_5 net518 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11427_ _02153_ _02152_ VGND VGND VPWR VPWR _02238_ sky130_fd_sc_hd__nor2_1
XFILLER_0_124_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15195_ _06256_ _06098_ _06097_ VGND VGND VPWR VPWR _06257_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14146_ _05059_ _05089_ VGND VGND VPWR VPWR _05103_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_67_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11358_ _02092_ _02168_ VGND VGND VPWR VPWR _02169_ sky130_fd_sc_hd__nor2_1
XFILLER_0_120_840 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10309_ _01116_ _01119_ VGND VGND VPWR VPWR _01120_ sky130_fd_sc_hd__and2_1
X_14077_ _05025_ _05026_ VGND VGND VPWR VPWR _05027_ sky130_fd_sc_hd__xor2_1
XFILLER_0_120_884 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11289_ _02097_ _02099_ VGND VGND VPWR VPWR _02100_ sky130_fd_sc_hd__or2_1
X_13028_ _03870_ _03872_ VGND VGND VPWR VPWR _03873_ sky130_fd_sc_hd__or2b_1
XFILLER_0_83_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer17 _08229_ VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__buf_6
Xrebuffer28 net507 VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__clkbuf_1
X_14979_ _05595_ _06017_ _06018_ VGND VGND VPWR VPWR _06019_ sky130_fd_sc_hd__or3_1
XFILLER_0_89_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16718_ _07887_ _07888_ _07889_ VGND VGND VPWR VPWR _07932_ sky130_fd_sc_hd__mux2_1
XFILLER_0_107_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16649_ _07832_ _07855_ net472 _07828_ VGND VGND VPWR VPWR _07856_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_147_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09121_ _05132_ _07365_ VGND VGND VPWR VPWR _07376_ sky130_fd_sc_hd__and2_1
X_09052_ _06518_ _06419_ VGND VGND VPWR VPWR _06617_ sky130_fd_sc_hd__and2b_1
XFILLER_0_32_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09954_ net334 _08676_ VGND VGND VPWR VPWR _00765_ sky130_fd_sc_hd__nand2_1
XFILLER_0_110_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08905_ _04989_ VGND VGND VPWR VPWR _05000_ sky130_fd_sc_hd__buf_8
X_09885_ _00686_ _00695_ VGND VGND VPWR VPWR _00696_ sky130_fd_sc_hd__nor2_1
XFILLER_0_148_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08836_ _04197_ _04230_ VGND VGND VPWR VPWR _04241_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08767_ net44 _03307_ _03340_ net253 VGND VGND VPWR VPWR _00042_ sky130_fd_sc_hd__a22o_1
XFILLER_0_68_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08698_ net37 net36 net22 net21 VGND VGND VPWR VPWR _02795_ sky130_fd_sc_hd__or4_1
X_10660_ net415 net105 VGND VGND VPWR VPWR _01471_ sky130_fd_sc_hd__nand2_1
XFILLER_0_137_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09319_ net318 _07948_ _08682_ net314 VGND VGND VPWR VPWR _08683_ sky130_fd_sc_hd__a22o_1
XFILLER_0_146_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10591_ _01283_ _01319_ _01316_ _01318_ VGND VGND VPWR VPWR _01402_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_90_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12330_ _02219_ _03161_ VGND VGND VPWR VPWR _03162_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12261_ _03073_ _03091_ net448 net166 VGND VGND VPWR VPWR _03092_ sky130_fd_sc_hd__or4bb_1
X_14000_ _04876_ _04941_ VGND VGND VPWR VPWR _04942_ sky130_fd_sc_hd__and2_1
XFILLER_0_105_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11212_ _01994_ _02020_ _02022_ VGND VGND VPWR VPWR _02023_ sky130_fd_sc_hd__o21a_1
X_12192_ _03014_ _03016_ VGND VGND VPWR VPWR _03017_ sky130_fd_sc_hd__nor2_1
X_11143_ _01866_ _01865_ VGND VGND VPWR VPWR _01954_ sky130_fd_sc_hd__nor2_1
XFILLER_0_128_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput86 net86 VGND VGND VPWR VPWR out_clocked[2] sky130_fd_sc_hd__buf_2
X_15951_ _07073_ _07086_ _07087_ _07008_ VGND VGND VPWR VPWR _07088_ sky130_fd_sc_hd__a211o_1
X_11074_ _01863_ _01870_ _01872_ VGND VGND VPWR VPWR _01885_ sky130_fd_sc_hd__a21o_1
X_14902_ _05696_ _05926_ VGND VGND VPWR VPWR _05934_ sky130_fd_sc_hd__and2_1
X_10025_ net345 _08682_ _00834_ _00835_ VGND VGND VPWR VPWR _00836_ sky130_fd_sc_hd__a31o_1
X_15882_ net267 _06349_ _06919_ VGND VGND VPWR VPWR _07012_ sky130_fd_sc_hd__a21oi_1
X_14833_ _05818_ _05815_ _05816_ VGND VGND VPWR VPWR _05859_ sky130_fd_sc_hd__or3_1
XFILLER_0_144_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14764_ _05648_ _05652_ _05782_ VGND VGND VPWR VPWR _05783_ sky130_fd_sc_hd__a21o_1
X_11976_ _02780_ _02779_ _02754_ VGND VGND VPWR VPWR _02788_ sky130_fd_sc_hd__a21oi_1
X_16503_ _07693_ _05871_ VGND VGND VPWR VPWR _07696_ sky130_fd_sc_hd__or2b_1
X_13715_ _04612_ _04613_ _04628_ VGND VGND VPWR VPWR _04629_ sky130_fd_sc_hd__nand3_2
X_17483_ clknet_4_1_0_clock _00062_ VGND VGND VPWR VPWR kp\[17\] sky130_fd_sc_hd__dfxtp_1
X_10927_ _01735_ _01737_ VGND VGND VPWR VPWR _01738_ sky130_fd_sc_hd__and2b_1
X_14695_ _05700_ _05705_ _05706_ VGND VGND VPWR VPWR _05707_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_86_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16434_ _07617_ _07619_ VGND VGND VPWR VPWR _07620_ sky130_fd_sc_hd__xnor2_1
X_13646_ _04470_ _04473_ _04471_ VGND VGND VPWR VPWR _04553_ sky130_fd_sc_hd__o21ai_1
X_10858_ net381 net121 net116 net385 VGND VGND VPWR VPWR _01669_ sky130_fd_sc_hd__a22o_1
XFILLER_0_94_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16365_ _07543_ net265 _05876_ VGND VGND VPWR VPWR _07544_ sky130_fd_sc_hd__mux2_1
XFILLER_0_137_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13577_ _04475_ _04458_ VGND VGND VPWR VPWR _04477_ sky130_fd_sc_hd__and2b_1
XFILLER_0_143_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10789_ _01593_ _01599_ VGND VGND VPWR VPWR _01600_ sky130_fd_sc_hd__xnor2_1
X_15316_ _06388_ _06389_ VGND VGND VPWR VPWR _06390_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_54_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12528_ _03366_ VGND VGND VPWR VPWR _03367_ sky130_fd_sc_hd__buf_2
X_16296_ _07465_ _06349_ _07427_ _07466_ _07467_ VGND VGND VPWR VPWR _07468_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_2_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15247_ _06307_ _06310_ _06312_ VGND VGND VPWR VPWR _06314_ sky130_fd_sc_hd__a21o_1
X_12459_ net176 _03234_ VGND VGND VPWR VPWR _03292_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15178_ _06233_ _06236_ _06237_ VGND VGND VPWR VPWR _06238_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_10_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14129_ _05042_ _05074_ _05071_ _05073_ VGND VGND VPWR VPWR _05084_ sky130_fd_sc_hd__a211oi_1
Xfanout309 ki\[0\] VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__clkbuf_2
X_09670_ _00478_ _00480_ _00475_ VGND VGND VPWR VPWR _00481_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_118_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_882 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_15_0_clock clknet_0_clock VGND VGND VPWR VPWR clknet_4_15_0_clock sky130_fd_sc_hd__clkbuf_8
XFILLER_0_128_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09104_ _07167_ _07123_ _07156_ VGND VGND VPWR VPWR _07189_ sky130_fd_sc_hd__nor3_1
XFILLER_0_45_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09035_ _05770_ _06408_ VGND VGND VPWR VPWR _06430_ sky130_fd_sc_hd__nor2_2
XFILLER_0_130_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_107_Left_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09937_ net354 net350 _07398_ _07321_ VGND VGND VPWR VPWR _00748_ sky130_fd_sc_hd__and4_1
X_09868_ _00675_ _00678_ VGND VGND VPWR VPWR _00679_ sky130_fd_sc_hd__nand2_1
X_08819_ net67 net12 VGND VGND VPWR VPWR _04054_ sky130_fd_sc_hd__nor2b_2
X_09799_ _00498_ _00497_ _00483_ VGND VGND VPWR VPWR _00610_ sky130_fd_sc_hd__a21oi_2
X_11830_ _02635_ _02639_ _02606_ VGND VGND VPWR VPWR _02641_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_116_Left_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11761_ net431 net140 net124 net447 VGND VGND VPWR VPWR _02572_ sky130_fd_sc_hd__a22o_1
XFILLER_0_138_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13500_ _04390_ _04366_ VGND VGND VPWR VPWR _04392_ sky130_fd_sc_hd__or2b_1
XFILLER_0_49_871 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10712_ _01464_ _01483_ _01466_ VGND VGND VPWR VPWR _01523_ sky130_fd_sc_hd__a21bo_1
X_14480_ _06815_ _06628_ VGND VGND VPWR VPWR _05470_ sky130_fd_sc_hd__and2b_1
X_11692_ _02501_ _02502_ VGND VGND VPWR VPWR _02503_ sky130_fd_sc_hd__and2_1
XFILLER_0_126_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13431_ _04315_ VGND VGND VPWR VPWR _04316_ sky130_fd_sc_hd__clkbuf_2
X_10643_ _01452_ _01453_ VGND VGND VPWR VPWR _01454_ sky130_fd_sc_hd__and2b_1
XFILLER_0_119_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16150_ _07293_ _07296_ _07294_ VGND VGND VPWR VPWR _07307_ sky130_fd_sc_hd__a21o_1
XFILLER_0_51_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13362_ net236 net233 _03221_ _03282_ VGND VGND VPWR VPWR _04240_ sky130_fd_sc_hd__nand4_1
X_10574_ _01373_ _01384_ VGND VGND VPWR VPWR _01385_ sky130_fd_sc_hd__nand2_1
X_15101_ _06006_ _06152_ VGND VGND VPWR VPWR _06153_ sky130_fd_sc_hd__xor2_1
Xrebuffer8 net477 VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12313_ _02786_ _03144_ VGND VGND VPWR VPWR _03145_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_125_Left_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16081_ _07218_ _07228_ _07229_ _07230_ VGND VGND VPWR VPWR _07231_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_121_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13293_ _04070_ _04079_ VGND VGND VPWR VPWR _04165_ sky130_fd_sc_hd__xnor2_1
X_15032_ _06043_ _06057_ VGND VGND VPWR VPWR _06077_ sky130_fd_sc_hd__xor2_2
X_12244_ net444 net166 VGND VGND VPWR VPWR _03074_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12175_ _02997_ _02998_ _02999_ VGND VGND VPWR VPWR _03000_ sky130_fd_sc_hd__nor3b_1
X_11126_ _01859_ _01936_ VGND VGND VPWR VPWR _01937_ sky130_fd_sc_hd__or2b_1
X_16983_ _08220_ _08172_ _08222_ VGND VGND VPWR VPWR _08224_ sky130_fd_sc_hd__a21oi_1
X_15934_ _07054_ _07061_ _07055_ VGND VGND VPWR VPWR _07070_ sky130_fd_sc_hd__nand3_1
X_11057_ _01460_ _01860_ _01862_ VGND VGND VPWR VPWR _01868_ sky130_fd_sc_hd__or3_1
X_10008_ _00818_ _00791_ VGND VGND VPWR VPWR _00819_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_134_Left_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15865_ _06941_ _06944_ _06945_ _06943_ VGND VGND VPWR VPWR _06994_ sky130_fd_sc_hd__a22o_1
X_14816_ _03316_ net499 _05687_ net296 net300 VGND VGND VPWR VPWR _05840_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_58_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15796_ net271 _06204_ VGND VGND VPWR VPWR _06918_ sky130_fd_sc_hd__nand2_1
XFILLER_0_148_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17535_ clknet_4_7_0_clock _00024_ VGND VGND VPWR VPWR kd_2\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_129_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14747_ _05640_ _05637_ VGND VGND VPWR VPWR _05764_ sky130_fd_sc_hd__or2_1
XFILLER_0_59_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11959_ _02736_ _02734_ VGND VGND VPWR VPWR _02770_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_74_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14678_ _03316_ net499 _05687_ net293 net308 VGND VGND VPWR VPWR _05688_ sky130_fd_sc_hd__o2111a_2
X_17466_ clknet_4_0_0_clock _00054_ VGND VGND VPWR VPWR kp\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_55_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16417_ _07600_ VGND VGND VPWR VPWR _07601_ sky130_fd_sc_hd__buf_2
X_13629_ _04532_ _04533_ VGND VGND VPWR VPWR _04534_ sky130_fd_sc_hd__and2_2
XFILLER_0_117_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17397_ clknet_4_11_0_clock _00075_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_15_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_143_Left_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16348_ _07523_ _07524_ VGND VGND VPWR VPWR _07525_ sky130_fd_sc_hd__nand2_1
X_16279_ _07422_ _07448_ VGND VGND VPWR VPWR _07449_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout106 net107 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__clkbuf_2
Xfanout117 net120 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__clkbuf_2
Xfanout128 kd_2\[12\] VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__buf_2
XFILLER_0_129_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout139 net140 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__buf_2
XFILLER_0_129_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09722_ _00528_ _00529_ _00531_ VGND VGND VPWR VPWR _00533_ sky130_fd_sc_hd__and3_1
X_09653_ _00460_ _00462_ _00463_ VGND VGND VPWR VPWR _00464_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_97_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09584_ _00387_ _00393_ _00394_ VGND VGND VPWR VPWR _00395_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_96_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_118_Right_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09018_ net356 _05418_ VGND VGND VPWR VPWR _06243_ sky130_fd_sc_hd__and2_1
XFILLER_0_60_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10290_ _01077_ _01078_ _01097_ _01100_ VGND VGND VPWR VPWR _01101_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_130_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13980_ net225 _03934_ VGND VGND VPWR VPWR _04920_ sky130_fd_sc_hd__nand2_1
X_12931_ _03693_ _03771_ _03774_ VGND VGND VPWR VPWR _03775_ sky130_fd_sc_hd__o21a_1
XFILLER_0_88_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15650_ _06750_ _06756_ VGND VGND VPWR VPWR _06757_ sky130_fd_sc_hd__xnor2_1
X_12862_ _03702_ _03704_ VGND VGND VPWR VPWR _03706_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14601_ _05602_ VGND VGND VPWR VPWR _05603_ sky130_fd_sc_hd__clkbuf_4
X_11813_ _02583_ _02581_ VGND VGND VPWR VPWR _02624_ sky130_fd_sc_hd__xnor2_1
X_15581_ _06643_ _06680_ VGND VGND VPWR VPWR _06681_ sky130_fd_sc_hd__nand2_1
X_12793_ net204 _03223_ _03284_ net209 VGND VGND VPWR VPWR _03637_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_95_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14532_ _06430_ _05497_ _06408_ VGND VGND VPWR VPWR _05527_ sky130_fd_sc_hd__a21o_1
X_17320_ _08094_ _08095_ VGND VGND VPWR VPWR _08558_ sky130_fd_sc_hd__and2_1
X_11744_ _02546_ _02553_ VGND VGND VPWR VPWR _02555_ sky130_fd_sc_hd__and2_1
XFILLER_0_138_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14463_ _01426_ _00896_ VGND VGND VPWR VPWR _05452_ sky130_fd_sc_hd__and2b_1
X_17251_ _08510_ _08511_ net454 VGND VGND VPWR VPWR _00078_ sky130_fd_sc_hd__o21a_1
X_11675_ _02432_ _02474_ _02476_ VGND VGND VPWR VPWR _02486_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_24_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16202_ net283 _04313_ VGND VGND VPWR VPWR _07364_ sky130_fd_sc_hd__nand2_1
X_13414_ _04271_ _04297_ VGND VGND VPWR VPWR _04298_ sky130_fd_sc_hd__nor2_1
X_17182_ _08418_ _08441_ VGND VGND VPWR VPWR _08442_ sky130_fd_sc_hd__xnor2_1
X_10626_ _00266_ _01434_ _01435_ _01436_ VGND VGND VPWR VPWR _01437_ sky130_fd_sc_hd__o211a_1
X_14394_ _03507_ _03509_ _05375_ VGND VGND VPWR VPWR _05376_ sky130_fd_sc_hd__a21oi_1
X_16133_ _07228_ _07286_ _07285_ _07281_ VGND VGND VPWR VPWR _07289_ sky130_fd_sc_hd__o211a_1
XFILLER_0_106_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13345_ net199 _03578_ VGND VGND VPWR VPWR _04222_ sky130_fd_sc_hd__nand2_1
XFILLER_0_52_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10557_ _01364_ _01366_ _01367_ VGND VGND VPWR VPWR _01368_ sky130_fd_sc_hd__o21ai_2
X_16064_ _07212_ _07147_ VGND VGND VPWR VPWR _07213_ sky130_fd_sc_hd__xnor2_1
X_13276_ net186 net519 _04011_ VGND VGND VPWR VPWR _04146_ sky130_fd_sc_hd__a21oi_1
X_10488_ net371 _00314_ _00370_ net366 VGND VGND VPWR VPWR _01299_ sky130_fd_sc_hd__a22o_1
X_15015_ _05984_ _05983_ VGND VGND VPWR VPWR _06059_ sky130_fd_sc_hd__and2b_1
XFILLER_0_20_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12227_ _03053_ _03054_ VGND VGND VPWR VPWR _03055_ sky130_fd_sc_hd__and2b_1
X_12158_ net442 net157 _02942_ _02943_ VGND VGND VPWR VPWR _02983_ sky130_fd_sc_hd__o2bb2a_1
X_11109_ _01459_ _01917_ _01918_ VGND VGND VPWR VPWR _01920_ sky130_fd_sc_hd__nor3_1
X_16966_ _08199_ _08203_ VGND VGND VPWR VPWR _08205_ sky130_fd_sc_hd__and2_1
X_12089_ _02910_ _02902_ VGND VGND VPWR VPWR _02912_ sky130_fd_sc_hd__and2b_1
X_15917_ _07034_ _07040_ _07039_ VGND VGND VPWR VPWR _07051_ sky130_fd_sc_hd__o21a_1
X_16897_ _08062_ _08065_ VGND VGND VPWR VPWR _08129_ sky130_fd_sc_hd__and2b_1
X_15848_ _06971_ _06970_ VGND VGND VPWR VPWR _06975_ sky130_fd_sc_hd__xor2_2
XFILLER_0_91_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15779_ net291 _05603_ _06896_ _06898_ VGND VGND VPWR VPWR _06899_ sky130_fd_sc_hd__a31o_1
XFILLER_0_47_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17518_ clknet_4_5_0_clock _00007_ VGND VGND VPWR VPWR kd_1\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_47_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17449_ clknet_4_11_0_clock _00127_ VGND VGND VPWR VPWR prev_d_error\[1\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_145_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09705_ net11 net66 VGND VGND VPWR VPWR _00516_ sky130_fd_sc_hd__xor2_2
X_09636_ _00419_ _00443_ _00446_ VGND VGND VPWR VPWR _00447_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09567_ _00366_ _00367_ VGND VGND VPWR VPWR _00378_ sky130_fd_sc_hd__xor2_1
X_09498_ net319 net315 _00243_ _08677_ VGND VGND VPWR VPWR _00309_ sky130_fd_sc_hd__nand4_1
XFILLER_0_77_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11460_ _02199_ _02250_ _02237_ _02249_ VGND VGND VPWR VPWR _02271_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_34_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10411_ _01207_ _01209_ _00970_ _01206_ VGND VGND VPWR VPWR _01222_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_116_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11391_ _02172_ _02159_ VGND VGND VPWR VPWR _02202_ sky130_fd_sc_hd__nor2_1
XFILLER_0_150_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13130_ _03982_ _03984_ VGND VGND VPWR VPWR _03985_ sky130_fd_sc_hd__and2b_1
XFILLER_0_60_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10342_ _01093_ _01094_ VGND VGND VPWR VPWR _01153_ sky130_fd_sc_hd__nand2_1
XFILLER_0_131_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13061_ net186 _03578_ _03784_ VGND VGND VPWR VPWR _03909_ sky130_fd_sc_hd__a21oi_1
X_10273_ net372 net367 net486 _07398_ VGND VGND VPWR VPWR _01084_ sky130_fd_sc_hd__nand4_2
X_12012_ _02819_ _02824_ _02826_ VGND VGND VPWR VPWR _02827_ sky130_fd_sc_hd__a21o_1
X_16820_ _08039_ _08043_ VGND VGND VPWR VPWR _08044_ sky130_fd_sc_hd__xnor2_2
Xfanout470 net1 VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__buf_2
XFILLER_0_136_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16751_ _07920_ _07966_ _07967_ VGND VGND VPWR VPWR _07968_ sky130_fd_sc_hd__o21ai_4
X_13963_ _04871_ _04877_ VGND VGND VPWR VPWR _04902_ sky130_fd_sc_hd__xor2_1
XFILLER_0_88_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15702_ _06811_ _06813_ VGND VGND VPWR VPWR _06814_ sky130_fd_sc_hd__nand2b_1
X_12914_ _03747_ _03756_ _03757_ VGND VGND VPWR VPWR _03758_ sky130_fd_sc_hd__o21ai_1
X_16682_ _07890_ _07891_ VGND VGND VPWR VPWR _07892_ sky130_fd_sc_hd__nor2_1
X_13894_ _04822_ _04825_ VGND VGND VPWR VPWR _04826_ sky130_fd_sc_hd__xor2_1
X_12845_ _03611_ _03687_ VGND VGND VPWR VPWR _03689_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15633_ _06736_ _06735_ _06734_ _06733_ VGND VGND VPWR VPWR _06739_ sky130_fd_sc_hd__o211a_4
XFILLER_0_69_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15564_ _06644_ _06662_ VGND VGND VPWR VPWR _06663_ sky130_fd_sc_hd__xnor2_2
X_12776_ _03617_ _03618_ VGND VGND VPWR VPWR _03620_ sky130_fd_sc_hd__xor2_1
X_17303_ net462 prev_error\[10\] VGND VGND VPWR VPWR _08548_ sky130_fd_sc_hd__or2_1
X_14515_ _05493_ _05508_ VGND VGND VPWR VPWR _05509_ sky130_fd_sc_hd__xnor2_1
X_11727_ _02535_ _02536_ _02528_ _02532_ VGND VGND VPWR VPWR _02538_ sky130_fd_sc_hd__a211o_1
X_15495_ net289 _05621_ _06301_ _06586_ VGND VGND VPWR VPWR _06587_ sky130_fd_sc_hd__a31o_1
XFILLER_0_56_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17234_ _08498_ net85 VGND VGND VPWR VPWR _08499_ sky130_fd_sc_hd__and2_1
XFILLER_0_25_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14446_ _00727_ _01430_ VGND VGND VPWR VPWR _05433_ sky130_fd_sc_hd__nand2_2
X_11658_ _02414_ _02412_ VGND VGND VPWR VPWR _02469_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_36_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10609_ _01110_ _01162_ _01417_ _01418_ VGND VGND VPWR VPWR _01420_ sky130_fd_sc_hd__a22o_1
X_14377_ _03477_ _03494_ _03492_ VGND VGND VPWR VPWR _05357_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17165_ _05320_ _08329_ _08330_ VGND VGND VPWR VPWR _08424_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_141_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11589_ _02394_ _02387_ _02396_ VGND VGND VPWR VPWR _02400_ sky130_fd_sc_hd__or3b_1
XFILLER_0_141_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16116_ _07242_ _07245_ _07243_ VGND VGND VPWR VPWR _07270_ sky130_fd_sc_hd__a21oi_1
X_13328_ _04201_ _04202_ VGND VGND VPWR VPWR _04203_ sky130_fd_sc_hd__nand2_1
X_17096_ _08346_ _08347_ VGND VGND VPWR VPWR _08348_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16047_ net311 net294 _06016_ _05588_ VGND VGND VPWR VPWR _07194_ sky130_fd_sc_hd__nand4_2
X_13259_ net217 _03233_ VGND VGND VPWR VPWR _04127_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16949_ _08139_ _08142_ VGND VGND VPWR VPWR _08186_ sky130_fd_sc_hd__or2b_1
XFILLER_0_79_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09421_ net327 _07343_ _00231_ VGND VGND VPWR VPWR _00232_ sky130_fd_sc_hd__and3_1
XFILLER_0_126_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09352_ _08643_ _08642_ VGND VGND VPWR VPWR _00163_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09283_ _08047_ _08646_ VGND VGND VPWR VPWR _08647_ sky130_fd_sc_hd__or2_1
XFILLER_0_145_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08998_ _06001_ _06012_ VGND VGND VPWR VPWR _06023_ sky130_fd_sc_hd__nand2_1
XFILLER_0_98_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10960_ _01724_ _01727_ _01744_ VGND VGND VPWR VPWR _01771_ sky130_fd_sc_hd__a21oi_1
X_09619_ net364 net529 VGND VGND VPWR VPWR _00430_ sky130_fd_sc_hd__nand2_1
X_10891_ _01487_ _01649_ _01480_ VGND VGND VPWR VPWR _01702_ sky130_fd_sc_hd__a21oi_1
X_12630_ _03400_ _03399_ VGND VGND VPWR VPWR _03469_ sky130_fd_sc_hd__and2b_1
XFILLER_0_109_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12561_ _03386_ _03364_ VGND VGND VPWR VPWR _03400_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_31_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14300_ _05269_ _05271_ VGND VGND VPWR VPWR _05272_ sky130_fd_sc_hd__and2_1
X_11512_ _02232_ _02233_ VGND VGND VPWR VPWR _02323_ sky130_fd_sc_hd__or2_1
X_15280_ _05593_ _06349_ VGND VGND VPWR VPWR _06350_ sky130_fd_sc_hd__or2_1
XFILLER_0_65_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12492_ net501 VGND VGND VPWR VPWR _03328_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14231_ _03690_ _05195_ _03688_ VGND VGND VPWR VPWR _05196_ sky130_fd_sc_hd__o21a_2
XFILLER_0_150_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11443_ prev_d_error\[8\] net140 net143 net413 VGND VGND VPWR VPWR _02254_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_34_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_890 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14162_ _04935_ _04980_ VGND VGND VPWR VPWR _05120_ sky130_fd_sc_hd__nor2_1
X_11374_ _02182_ _02184_ VGND VGND VPWR VPWR _02185_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13113_ _03962_ _03963_ _03965_ VGND VGND VPWR VPWR _03967_ sky130_fd_sc_hd__o21ai_2
X_10325_ _01100_ _01135_ VGND VGND VPWR VPWR _01136_ sky130_fd_sc_hd__nand2_1
X_14093_ _04999_ _05006_ _05005_ VGND VGND VPWR VPWR _05045_ sky130_fd_sc_hd__a21oi_1
X_13044_ _03886_ _03888_ VGND VGND VPWR VPWR _03891_ sky130_fd_sc_hd__xnor2_1
X_10256_ _00996_ _01065_ _01066_ VGND VGND VPWR VPWR _01067_ sky130_fd_sc_hd__o21ba_1
X_10187_ _00996_ _00818_ _00997_ VGND VGND VPWR VPWR _00998_ sky130_fd_sc_hd__o21a_1
X_16803_ _07768_ _05468_ _08024_ VGND VGND VPWR VPWR _08026_ sky130_fd_sc_hd__o21a_1
X_14995_ net277 _05738_ _06036_ VGND VGND VPWR VPWR _06037_ sky130_fd_sc_hd__and3_1
X_16734_ _07867_ _07870_ _07949_ VGND VGND VPWR VPWR _07950_ sky130_fd_sc_hd__o21bai_1
X_13946_ _04837_ _04849_ _04848_ VGND VGND VPWR VPWR _04883_ sky130_fd_sc_hd__a21o_1
X_16665_ _07688_ _07690_ _07872_ VGND VGND VPWR VPWR _07874_ sky130_fd_sc_hd__nand3_1
XFILLER_0_72_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13877_ _04765_ _04806_ VGND VGND VPWR VPWR _04807_ sky130_fd_sc_hd__xor2_2
X_15616_ _06711_ _06719_ VGND VGND VPWR VPWR _06720_ sky130_fd_sc_hd__xor2_1
X_12828_ _03662_ _03663_ _03671_ VGND VGND VPWR VPWR _03672_ sky130_fd_sc_hd__o21ai_1
X_16596_ _07613_ _07635_ VGND VGND VPWR VPWR _07798_ sky130_fd_sc_hd__xor2_2
XFILLER_0_56_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15547_ _06580_ _06594_ VGND VGND VPWR VPWR _06644_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12759_ _03600_ _03566_ _03598_ VGND VGND VPWR VPWR _03603_ sky130_fd_sc_hd__or3_1
XFILLER_0_29_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15478_ net308 _05709_ VGND VGND VPWR VPWR _06568_ sky130_fd_sc_hd__and2_1
XFILLER_0_21_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17217_ _08104_ _08089_ VGND VGND VPWR VPWR _08481_ sky130_fd_sc_hd__or2b_1
X_14429_ _05356_ _05413_ VGND VGND VPWR VPWR _05414_ sky130_fd_sc_hd__nand2_1
XFILLER_0_115_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17148_ _08317_ _08323_ _08404_ VGND VGND VPWR VPWR _08405_ sky130_fd_sc_hd__a21o_1
Xfanout8 net127 VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__clkbuf_4
X_09970_ _00759_ _00760_ _00780_ VGND VGND VPWR VPWR _00781_ sky130_fd_sc_hd__nand3_1
XFILLER_0_110_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17079_ _08313_ _08328_ VGND VGND VPWR VPWR _08329_ sky130_fd_sc_hd__nor2_1
XFILLER_0_97_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08921_ net317 _04527_ _04626_ net313 VGND VGND VPWR VPWR _05176_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_0_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08852_ _03922_ _04406_ VGND VGND VPWR VPWR _04417_ sky130_fd_sc_hd__xor2_4
XFILLER_0_137_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08783_ net54 _03553_ _03586_ net346 VGND VGND VPWR VPWR _00070_ sky130_fd_sc_hd__a22o_1
XFILLER_0_137_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09404_ net341 _04505_ VGND VGND VPWR VPWR _00215_ sky130_fd_sc_hd__and2_1
XFILLER_0_88_880 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09335_ _08691_ _00144_ _00145_ VGND VGND VPWR VPWR _00146_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_47_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09266_ net330 _04527_ _08628_ VGND VGND VPWR VPWR _08630_ sky130_fd_sc_hd__and3_1
XFILLER_0_62_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09197_ _07497_ _08201_ VGND VGND VPWR VPWR _08212_ sky130_fd_sc_hd__or2_1
XFILLER_0_50_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10110_ _00556_ _00799_ VGND VGND VPWR VPWR _00921_ sky130_fd_sc_hd__or2_1
X_11090_ _01891_ _01893_ _01895_ VGND VGND VPWR VPWR _01901_ sky130_fd_sc_hd__or3_1
X_10041_ _00842_ _00850_ _00851_ VGND VGND VPWR VPWR _00852_ sky130_fd_sc_hd__o21a_2
Xhold42 net81 VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13800_ _04717_ _04720_ _04639_ _04721_ VGND VGND VPWR VPWR _04722_ sky130_fd_sc_hd__a211oi_2
X_14780_ _05797_ _05799_ VGND VGND VPWR VPWR _05800_ sky130_fd_sc_hd__xnor2_1
X_11992_ _02796_ _02802_ _02804_ VGND VGND VPWR VPWR _02805_ sky130_fd_sc_hd__or3_1
X_13731_ _04641_ _04645_ VGND VGND VPWR VPWR _04646_ sky130_fd_sc_hd__and2b_2
X_10943_ _01753_ VGND VGND VPWR VPWR _01754_ sky130_fd_sc_hd__inv_2
X_16450_ i_error\[4\] _07612_ VGND VGND VPWR VPWR _07637_ sky130_fd_sc_hd__and2_1
XFILLER_0_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13662_ _04564_ _04566_ VGND VGND VPWR VPWR _04570_ sky130_fd_sc_hd__xnor2_4
X_10874_ _01683_ _01684_ VGND VGND VPWR VPWR _01685_ sky130_fd_sc_hd__and2_1
XFILLER_0_38_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15401_ _06480_ _06481_ _06482_ VGND VGND VPWR VPWR _06483_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_66_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12613_ _03451_ VGND VGND VPWR VPWR _03452_ sky130_fd_sc_hd__buf_2
X_16381_ _07509_ _07560_ VGND VGND VPWR VPWR _07561_ sky130_fd_sc_hd__xnor2_1
X_13593_ _03365_ _03244_ VGND VGND VPWR VPWR _04495_ sky130_fd_sc_hd__nor2_1
X_15332_ _06358_ _06406_ VGND VGND VPWR VPWR _06407_ sky130_fd_sc_hd__nand2_1
X_12544_ _03370_ _03379_ VGND VGND VPWR VPWR _03383_ sky130_fd_sc_hd__nor2_1
XFILLER_0_93_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15263_ _06325_ _06330_ VGND VGND VPWR VPWR _06332_ sky130_fd_sc_hd__nor2_1
X_12475_ _03309_ _04923_ _03218_ _03220_ _03279_ VGND VGND VPWR VPWR _03310_ sky130_fd_sc_hd__a221o_2
X_17002_ _08238_ _08243_ VGND VGND VPWR VPWR _08244_ sky130_fd_sc_hd__or2_1
X_14214_ _04485_ _04568_ VGND VGND VPWR VPWR _05178_ sky130_fd_sc_hd__nor2_1
X_11426_ _02226_ _02234_ _02236_ VGND VGND VPWR VPWR _02237_ sky130_fd_sc_hd__a21o_1
X_15194_ _05703_ _05840_ VGND VGND VPWR VPWR _06256_ sky130_fd_sc_hd__nand2_1
XANTENNA_6 net518 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14145_ _04918_ _05091_ VGND VGND VPWR VPWR _05102_ sky130_fd_sc_hd__nand2_1
XFILLER_0_104_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11357_ net391 net155 _02090_ _02091_ VGND VGND VPWR VPWR _02168_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10308_ _01117_ _01118_ VGND VGND VPWR VPWR _01119_ sky130_fd_sc_hd__xnor2_1
X_14076_ net231 _04106_ VGND VGND VPWR VPWR _05026_ sky130_fd_sc_hd__nand2_1
X_11288_ _01562_ net166 _02097_ _02098_ VGND VGND VPWR VPWR _02099_ sky130_fd_sc_hd__nor4_1
X_13027_ _03770_ _03871_ VGND VGND VPWR VPWR _03872_ sky130_fd_sc_hd__and2_1
X_10239_ net354 _08675_ _01049_ VGND VGND VPWR VPWR _01050_ sky130_fd_sc_hd__a21o_1
Xrebuffer18 net527 VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer29 _05686_ VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__buf_1
X_14978_ _05971_ _06014_ VGND VGND VPWR VPWR _06018_ sky130_fd_sc_hd__xnor2_1
X_16717_ net251 _05705_ VGND VGND VPWR VPWR _07931_ sky130_fd_sc_hd__nand2_1
X_13929_ net226 _03750_ _04575_ VGND VGND VPWR VPWR _04864_ sky130_fd_sc_hd__and3_1
XFILLER_0_147_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16648_ _07851_ _07852_ VGND VGND VPWR VPWR _07855_ sky130_fd_sc_hd__and2_1
XFILLER_0_76_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16579_ _07626_ _07778_ VGND VGND VPWR VPWR _07779_ sky130_fd_sc_hd__nor2_1
X_09120_ _04252_ _04318_ _04329_ VGND VGND VPWR VPWR _07365_ sky130_fd_sc_hd__or3_4
XFILLER_0_57_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09051_ _06133_ _06144_ VGND VGND VPWR VPWR _06606_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09953_ net334 _00242_ _00763_ VGND VGND VPWR VPWR _00764_ sky130_fd_sc_hd__and3_1
XFILLER_0_111_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08904_ _04945_ _04978_ VGND VGND VPWR VPWR _04989_ sky130_fd_sc_hd__xor2_4
X_09884_ _00674_ _00685_ VGND VGND VPWR VPWR _00695_ sky130_fd_sc_hd__and2_1
Xclkbuf_4_11_0_clock clknet_0_clock VGND VGND VPWR VPWR clknet_4_11_0_clock sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_29_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08835_ _04208_ _04219_ VGND VGND VPWR VPWR _04230_ sky130_fd_sc_hd__and2b_2
X_08766_ net43 _03307_ _03340_ net256 VGND VGND VPWR VPWR _00041_ sky130_fd_sc_hd__a22o_1
X_08697_ net29 VGND VGND VPWR VPWR _02784_ sky130_fd_sc_hd__inv_2
XFILLER_0_79_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09318_ _08681_ VGND VGND VPWR VPWR _08682_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_91_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10590_ _01368_ _01348_ _01371_ VGND VGND VPWR VPWR _01401_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_35_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09249_ _08611_ _08612_ VGND VGND VPWR VPWR _08613_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12260_ net440 net175 _03071_ VGND VGND VPWR VPWR _03091_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_120_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11211_ _01933_ _02021_ VGND VGND VPWR VPWR _02022_ sky130_fd_sc_hd__nor2_1
XFILLER_0_120_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12191_ _03013_ _03015_ VGND VGND VPWR VPWR _03016_ sky130_fd_sc_hd__or2_1
XFILLER_0_102_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11142_ _01459_ _01950_ _01952_ VGND VGND VPWR VPWR _01953_ sky130_fd_sc_hd__o21a_1
XFILLER_0_101_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput76 net76 VGND VGND VPWR VPWR out_clocked[0] sky130_fd_sc_hd__clkbuf_4
Xoutput87 net87 VGND VGND VPWR VPWR out_clocked[3] sky130_fd_sc_hd__clkbuf_4
X_15950_ _06995_ _06996_ _07007_ VGND VGND VPWR VPWR _07087_ sky130_fd_sc_hd__a21oi_1
X_11073_ _01881_ _01883_ VGND VGND VPWR VPWR _01884_ sky130_fd_sc_hd__and2_1
X_14901_ _05931_ _05932_ VGND VGND VPWR VPWR _05933_ sky130_fd_sc_hd__and2b_1
X_10024_ net354 net350 net523 _07398_ VGND VGND VPWR VPWR _00835_ sky130_fd_sc_hd__and4_1
X_15881_ _07009_ _06978_ VGND VGND VPWR VPWR _07011_ sky130_fd_sc_hd__xor2_1
X_14832_ _05819_ VGND VGND VPWR VPWR _05857_ sky130_fd_sc_hd__inv_2
XFILLER_0_144_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14763_ _05779_ _05780_ VGND VGND VPWR VPWR _05782_ sky130_fd_sc_hd__nand2_1
X_11975_ _02754_ _02780_ _02779_ VGND VGND VPWR VPWR _02787_ sky130_fd_sc_hd__and3_1
XFILLER_0_98_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16502_ _05871_ _07693_ VGND VGND VPWR VPWR _07694_ sky130_fd_sc_hd__or2b_1
X_13714_ _04616_ _04625_ _04627_ VGND VGND VPWR VPWR _04628_ sky130_fd_sc_hd__o21ai_1
X_17482_ clknet_4_1_0_clock _00061_ VGND VGND VPWR VPWR kp\[16\] sky130_fd_sc_hd__dfxtp_1
X_10926_ _01535_ _01736_ VGND VGND VPWR VPWR _01737_ sky130_fd_sc_hd__nor2_1
X_14694_ _05697_ _05699_ _05703_ net277 VGND VGND VPWR VPWR _05706_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_128_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16433_ _07489_ _07049_ VGND VGND VPWR VPWR _07619_ sky130_fd_sc_hd__nor2_1
X_13645_ _04548_ _04550_ _04551_ VGND VGND VPWR VPWR _04552_ sky130_fd_sc_hd__nor3_2
X_10857_ net381 net385 net121 net116 VGND VGND VPWR VPWR _01668_ sky130_fd_sc_hd__and4_1
XFILLER_0_27_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16364_ net265 _05697_ VGND VGND VPWR VPWR _07543_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13576_ _04458_ _04475_ VGND VGND VPWR VPWR _04476_ sky130_fd_sc_hd__xnor2_4
X_10788_ _01596_ _01598_ VGND VGND VPWR VPWR _01599_ sky130_fd_sc_hd__nor2_1
XFILLER_0_143_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15315_ _06272_ _06273_ VGND VGND VPWR VPWR _06389_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_5_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12527_ net245 net228 _03344_ VGND VGND VPWR VPWR _03366_ sky130_fd_sc_hd__and3_1
XFILLER_0_124_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16295_ net311 net307 _04315_ _06417_ VGND VGND VPWR VPWR _07467_ sky130_fd_sc_hd__and4_1
X_15246_ _06307_ _06310_ _06312_ VGND VGND VPWR VPWR _06313_ sky130_fd_sc_hd__nand3_1
XFILLER_0_112_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12458_ net185 _03288_ _03290_ VGND VGND VPWR VPWR _03291_ sky130_fd_sc_hd__and3_1
XFILLER_0_41_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11409_ net441 net114 _02182_ _02183_ VGND VGND VPWR VPWR _02220_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_2_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15177_ _06234_ _06235_ VGND VGND VPWR VPWR _06237_ sky130_fd_sc_hd__nor2_1
X_12389_ _03218_ _03220_ VGND VGND VPWR VPWR _03221_ sky130_fd_sc_hd__xor2_4
X_14128_ _05049_ _05075_ VGND VGND VPWR VPWR _05083_ sky130_fd_sc_hd__xnor2_1
X_14059_ _04999_ _05005_ _05006_ VGND VGND VPWR VPWR _05007_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09103_ _07123_ _07156_ _07167_ VGND VGND VPWR VPWR _07178_ sky130_fd_sc_hd__o21a_1
XFILLER_0_134_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09034_ _06408_ _05792_ VGND VGND VPWR VPWR _06419_ sky130_fd_sc_hd__or2b_1
XFILLER_0_143_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09936_ net345 _07937_ VGND VGND VPWR VPWR _00747_ sky130_fd_sc_hd__nand2_1
X_09867_ net334 _08677_ _00676_ _00677_ VGND VGND VPWR VPWR _00678_ sky130_fd_sc_hd__a31o_1
X_08818_ net12 net67 VGND VGND VPWR VPWR _04043_ sky130_fd_sc_hd__nor2b_4
X_09798_ _00498_ _00483_ _00497_ VGND VGND VPWR VPWR _00609_ sky130_fd_sc_hd__and3_1
X_08749_ _02872_ _03296_ net451 VGND VGND VPWR VPWR _03329_ sky130_fd_sc_hd__o21a_1
XFILLER_0_68_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11760_ net431 net446 net140 net124 VGND VGND VPWR VPWR _02571_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10711_ _01487_ _01521_ VGND VGND VPWR VPWR _01522_ sky130_fd_sc_hd__xnor2_1
X_11691_ _02494_ _02491_ VGND VGND VPWR VPWR _02502_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_55_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10642_ _08497_ _01451_ _01450_ VGND VGND VPWR VPWR _01453_ sky130_fd_sc_hd__a21o_1
X_13430_ _04314_ VGND VGND VPWR VPWR _04315_ sky130_fd_sc_hd__buf_4
XFILLER_0_36_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13361_ _04237_ _04238_ VGND VGND VPWR VPWR _04239_ sky130_fd_sc_hd__xnor2_2
X_10573_ _01380_ _01381_ _01383_ VGND VGND VPWR VPWR _01384_ sky130_fd_sc_hd__and3b_1
X_15100_ net260 _05604_ VGND VGND VPWR VPWR _06152_ sky130_fd_sc_hd__nand2_1
XFILLER_0_51_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer9 _05617_ VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__buf_6
X_12312_ _02851_ _03142_ _03143_ VGND VGND VPWR VPWR _03144_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_106_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16080_ _07160_ _07161_ _07172_ VGND VGND VPWR VPWR _07230_ sky130_fd_sc_hd__or3_1
X_13292_ _04126_ _04132_ VGND VGND VPWR VPWR _04163_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_134_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15031_ _06064_ _06075_ VGND VGND VPWR VPWR _06076_ sky130_fd_sc_hd__or2_1
X_12243_ net440 net175 _03071_ VGND VGND VPWR VPWR _03073_ sky130_fd_sc_hd__and3_1
XFILLER_0_121_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12174_ _02991_ _02989_ VGND VGND VPWR VPWR _02999_ sky130_fd_sc_hd__and2b_1
X_11125_ _01909_ _01934_ _01935_ VGND VGND VPWR VPWR _01936_ sky130_fd_sc_hd__a21bo_1
X_16982_ _08217_ _08221_ VGND VGND VPWR VPWR _08222_ sky130_fd_sc_hd__nand2_1
XFILLER_0_101_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15933_ _07063_ _07067_ VGND VGND VPWR VPWR _07069_ sky130_fd_sc_hd__xnor2_1
X_11056_ _01864_ _01865_ _01866_ VGND VGND VPWR VPWR _01867_ sky130_fd_sc_hd__o21ba_1
X_10007_ net328 _00519_ VGND VGND VPWR VPWR _00818_ sky130_fd_sc_hd__nand2_1
X_15864_ _06986_ _06990_ _06992_ VGND VGND VPWR VPWR _06993_ sky130_fd_sc_hd__a21bo_1
X_14815_ _05783_ _05838_ VGND VGND VPWR VPWR _05839_ sky130_fd_sc_hd__xnor2_1
X_15795_ net274 _06161_ VGND VGND VPWR VPWR _06917_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17534_ clknet_4_7_0_clock _00023_ VGND VGND VPWR VPWR kd_2\[14\] sky130_fd_sc_hd__dfxtp_1
X_14746_ _05757_ _05761_ VGND VGND VPWR VPWR _05763_ sky130_fd_sc_hd__xor2_1
XFILLER_0_59_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11958_ _02761_ _02766_ _02768_ VGND VGND VPWR VPWR _02769_ sky130_fd_sc_hd__a21o_1
XFILLER_0_104_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17465_ clknet_4_13_0_clock _00143_ VGND VGND VPWR VPWR prev_d_error\[17\] sky130_fd_sc_hd__dfxtp_2
X_10909_ net418 net111 net107 net421 VGND VGND VPWR VPWR _01720_ sky130_fd_sc_hd__a22oi_1
X_14677_ prev_error\[17\] _05418_ VGND VGND VPWR VPWR _05687_ sky130_fd_sc_hd__or2_1
XFILLER_0_73_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11889_ _02623_ _02625_ _02624_ VGND VGND VPWR VPWR _02700_ sky130_fd_sc_hd__a21o_1
XFILLER_0_129_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16416_ _07591_ _07599_ VGND VGND VPWR VPWR _07600_ sky130_fd_sc_hd__and2_1
XFILLER_0_67_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13628_ _04523_ _04531_ VGND VGND VPWR VPWR _04533_ sky130_fd_sc_hd__nand2_1
XFILLER_0_104_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17396_ clknet_4_11_0_clock _00074_ VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16347_ _07513_ _07522_ VGND VGND VPWR VPWR _07524_ sky130_fd_sc_hd__nand2_1
X_13559_ _04419_ _04432_ VGND VGND VPWR VPWR _04457_ sky130_fd_sc_hd__xor2_4
X_16278_ _07424_ _07423_ VGND VGND VPWR VPWR _07448_ sky130_fd_sc_hd__nor2_1
XFILLER_0_125_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15229_ _06214_ _06251_ _06249_ VGND VGND VPWR VPWR _06294_ sky130_fd_sc_hd__a21o_1
XFILLER_0_112_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout107 kd_2\[17\] VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout118 net119 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__buf_2
Xfanout129 net133 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__buf_2
X_09721_ _00528_ _00529_ _00531_ VGND VGND VPWR VPWR _00532_ sky130_fd_sc_hd__a21oi_1
X_09652_ net348 _04516_ _00461_ VGND VGND VPWR VPWR _00463_ sky130_fd_sc_hd__and3_1
XFILLER_0_145_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09583_ _00382_ _00384_ _00386_ VGND VGND VPWR VPWR _00394_ sky130_fd_sc_hd__o21a_1
XFILLER_0_145_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09017_ net373 net369 net364 _05385_ VGND VGND VPWR VPWR _06232_ sky130_fd_sc_hd__and4_2
XFILLER_0_20_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09919_ _00698_ _00729_ VGND VGND VPWR VPWR _00730_ sky130_fd_sc_hd__xnor2_4
X_12930_ _03772_ _03773_ VGND VGND VPWR VPWR _03774_ sky130_fd_sc_hd__or2b_1
XFILLER_0_34_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12861_ _03702_ _03704_ VGND VGND VPWR VPWR _03705_ sky130_fd_sc_hd__or2_1
XFILLER_0_68_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14600_ _05601_ VGND VGND VPWR VPWR _05602_ sky130_fd_sc_hd__buf_2
XFILLER_0_96_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11812_ _02614_ _02620_ _02622_ VGND VGND VPWR VPWR _02623_ sky130_fd_sc_hd__a21o_1
X_15580_ _06663_ _06679_ VGND VGND VPWR VPWR _06680_ sky130_fd_sc_hd__xor2_2
XFILLER_0_68_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12792_ net206 net204 _03223_ _03284_ VGND VGND VPWR VPWR _03636_ sky130_fd_sc_hd__and4_1
X_14531_ _05499_ _05525_ VGND VGND VPWR VPWR _05526_ sky130_fd_sc_hd__xor2_1
XFILLER_0_68_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11743_ _02546_ _02553_ VGND VGND VPWR VPWR _02554_ sky130_fd_sc_hd__nor2_1
X_17250_ _08462_ _08495_ _08472_ VGND VGND VPWR VPWR _08511_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14462_ _01425_ _05438_ VGND VGND VPWR VPWR _05450_ sky130_fd_sc_hd__nor2_2
X_11674_ _02401_ _02484_ VGND VGND VPWR VPWR _02485_ sky130_fd_sc_hd__or2_1
X_16201_ _07347_ _07349_ VGND VGND VPWR VPWR _07363_ sky130_fd_sc_hd__nand2_1
XFILLER_0_64_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13413_ _04269_ _04270_ VGND VGND VPWR VPWR _04297_ sky130_fd_sc_hd__nor2_1
XFILLER_0_126_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17181_ _08419_ _08440_ VGND VGND VPWR VPWR _08441_ sky130_fd_sc_hd__xnor2_1
X_10625_ _00327_ _00359_ VGND VGND VPWR VPWR _01436_ sky130_fd_sc_hd__or2b_1
X_14393_ _05372_ _05373_ VGND VGND VPWR VPWR _05375_ sky130_fd_sc_hd__nand2_1
X_16132_ _07281_ _07285_ _07286_ _07228_ VGND VGND VPWR VPWR _07287_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_24_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10556_ _01341_ _01342_ VGND VGND VPWR VPWR _01367_ sky130_fd_sc_hd__xor2_1
XFILLER_0_107_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13344_ _04217_ _04218_ _04220_ VGND VGND VPWR VPWR _04221_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_24_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16063_ net278 _06349_ VGND VGND VPWR VPWR _07212_ sky130_fd_sc_hd__nand2_1
X_10487_ net371 net366 _00314_ _00371_ VGND VGND VPWR VPWR _01298_ sky130_fd_sc_hd__nand4_1
X_13275_ _04138_ _04144_ VGND VGND VPWR VPWR _04145_ sky130_fd_sc_hd__xor2_1
X_15014_ _06043_ _06057_ _06041_ VGND VGND VPWR VPWR _06058_ sky130_fd_sc_hd__o21ai_2
X_12226_ _03022_ _03024_ VGND VGND VPWR VPWR _03054_ sky130_fd_sc_hd__xnor2_1
X_12157_ _02980_ _02981_ net444 net161 VGND VGND VPWR VPWR _02982_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_20_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11108_ _01459_ _01917_ _01918_ VGND VGND VPWR VPWR _01919_ sky130_fd_sc_hd__o21a_1
X_16965_ _08199_ _08203_ VGND VGND VPWR VPWR _08204_ sky130_fd_sc_hd__nor2_1
X_12088_ _02902_ _02910_ VGND VGND VPWR VPWR _02911_ sky130_fd_sc_hd__and2b_1
X_15916_ _07045_ _07047_ VGND VGND VPWR VPWR _07050_ sky130_fd_sc_hd__xnor2_2
X_11039_ _01824_ _01801_ _01822_ VGND VGND VPWR VPWR _01850_ sky130_fd_sc_hd__and3_1
X_16896_ _05453_ _08123_ VGND VGND VPWR VPWR _08128_ sky130_fd_sc_hd__xnor2_2
X_15847_ _06895_ _06972_ _06973_ VGND VGND VPWR VPWR _06974_ sky130_fd_sc_hd__a21o_1
XFILLER_0_99_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15778_ net295 _05626_ _05628_ _06897_ VGND VGND VPWR VPWR _06898_ sky130_fd_sc_hd__and4_1
XFILLER_0_87_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17517_ clknet_4_4_0_clock _00006_ VGND VGND VPWR VPWR kd_1\[15\] sky130_fd_sc_hd__dfxtp_1
X_14729_ _05625_ _05635_ VGND VGND VPWR VPWR _05744_ sky130_fd_sc_hd__and2_1
XFILLER_0_47_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17448_ clknet_4_12_0_clock _00126_ VGND VGND VPWR VPWR prev_d_error\[0\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17379_ net466 net405 net456 _08594_ VGND VGND VPWR VPWR _00136_ sky130_fd_sc_hd__o211a_1
XFILLER_0_132_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09704_ net316 _00373_ VGND VGND VPWR VPWR _00515_ sky130_fd_sc_hd__nand2_1
X_09635_ _00444_ _00445_ VGND VGND VPWR VPWR _00446_ sky130_fd_sc_hd__or2b_1
XFILLER_0_97_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09566_ _00374_ _00376_ VGND VGND VPWR VPWR _00377_ sky130_fd_sc_hd__and2_1
XFILLER_0_78_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09497_ _00305_ _00307_ VGND VGND VPWR VPWR _00308_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10410_ _01204_ _01205_ _01220_ VGND VGND VPWR VPWR _01221_ sky130_fd_sc_hd__and3_1
XFILLER_0_150_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11390_ _02061_ _02181_ _02200_ VGND VGND VPWR VPWR _02201_ sky130_fd_sc_hd__or3_1
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10341_ _01150_ _01151_ VGND VGND VPWR VPWR _01152_ sky130_fd_sc_hd__and2_1
X_13060_ _03906_ _03907_ VGND VGND VPWR VPWR _03908_ sky130_fd_sc_hd__nor2_1
X_10272_ _01082_ _01011_ VGND VGND VPWR VPWR _01083_ sky130_fd_sc_hd__xor2_4
XFILLER_0_104_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12011_ _02766_ _02825_ VGND VGND VPWR VPWR _02826_ sky130_fd_sc_hd__nand2_1
Xfanout460 net56 VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__buf_4
X_16750_ _07963_ _07965_ VGND VGND VPWR VPWR _07967_ sky130_fd_sc_hd__nand2_2
X_13962_ _04899_ VGND VGND VPWR VPWR _04900_ sky130_fd_sc_hd__inv_2
X_15701_ _06093_ _06811_ _06812_ _05745_ VGND VGND VPWR VPWR _06813_ sky130_fd_sc_hd__or4b_4
X_12913_ _03744_ _03746_ VGND VGND VPWR VPWR _03757_ sky130_fd_sc_hd__xor2_1
X_16681_ _07889_ _07887_ _07888_ VGND VGND VPWR VPWR _07891_ sky130_fd_sc_hd__nor3_1
X_13893_ _04744_ _04823_ VGND VGND VPWR VPWR _04825_ sky130_fd_sc_hd__nor2_1
X_15632_ _06733_ _06734_ _06735_ _06736_ VGND VGND VPWR VPWR _06737_ sky130_fd_sc_hd__a211oi_4
X_12844_ _03611_ _03687_ VGND VGND VPWR VPWR _03688_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15563_ _06649_ _06660_ VGND VGND VPWR VPWR _06662_ sky130_fd_sc_hd__xor2_2
X_12775_ _03617_ _03618_ VGND VGND VPWR VPWR _03619_ sky130_fd_sc_hd__nor2_1
X_17302_ _08536_ _07343_ _08546_ net450 VGND VGND VPWR VPWR _00099_ sky130_fd_sc_hd__o211a_1
X_14514_ _05505_ _05507_ VGND VGND VPWR VPWR _05508_ sky130_fd_sc_hd__and2b_1
X_11726_ _02528_ _02532_ _02535_ _02536_ VGND VGND VPWR VPWR _02537_ sky130_fd_sc_hd__o211ai_2
X_15494_ net284 _05620_ _05745_ net289 VGND VGND VPWR VPWR _06586_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_84_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17233_ _03867_ VGND VGND VPWR VPWR _08498_ sky130_fd_sc_hd__clkbuf_2
X_14445_ _01439_ _05431_ VGND VGND VPWR VPWR _05432_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_126_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11657_ _02461_ _02465_ _02467_ VGND VGND VPWR VPWR _02468_ sky130_fd_sc_hd__a21o_1
XFILLER_0_37_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10608_ _01414_ _01409_ _01417_ _01418_ VGND VGND VPWR VPWR _01419_ sky130_fd_sc_hd__o22a_1
X_17164_ _08332_ _08343_ _08341_ VGND VGND VPWR VPWR _08423_ sky130_fd_sc_hd__a21o_1
X_14376_ _05354_ _05355_ VGND VGND VPWR VPWR _05356_ sky130_fd_sc_hd__xnor2_1
X_11588_ _02393_ _02397_ _02398_ VGND VGND VPWR VPWR _02399_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_25_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16115_ _07187_ _07262_ _07267_ VGND VGND VPWR VPWR _07269_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_3_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13327_ _04128_ _04129_ VGND VGND VPWR VPWR _04202_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_51_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10539_ _01334_ _01349_ VGND VGND VPWR VPWR _01350_ sky130_fd_sc_hd__nor2b_2
X_17095_ _08312_ _05344_ _08345_ VGND VGND VPWR VPWR _08347_ sky130_fd_sc_hd__and3_1
XFILLER_0_122_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16046_ net294 _06016_ _05588_ net311 VGND VGND VPWR VPWR _07193_ sky130_fd_sc_hd__a22o_1
X_13258_ _04124_ _04125_ VGND VGND VPWR VPWR _04126_ sky130_fd_sc_hd__or2b_1
X_12209_ _03010_ _03033_ _03034_ VGND VGND VPWR VPWR _03035_ sky130_fd_sc_hd__a21oi_1
X_13189_ _04041_ _04045_ _04049_ VGND VGND VPWR VPWR _04050_ sky130_fd_sc_hd__a21oi_1
X_16948_ _05463_ _08181_ VGND VGND VPWR VPWR _08185_ sky130_fd_sc_hd__xor2_1
X_16879_ _08077_ _08105_ _08108_ VGND VGND VPWR VPWR _08109_ sky130_fd_sc_hd__a21o_4
XFILLER_0_126_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09420_ net331 _05132_ _07365_ VGND VGND VPWR VPWR _00231_ sky130_fd_sc_hd__and3_1
XFILLER_0_149_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09351_ _00148_ _00161_ VGND VGND VPWR VPWR _00162_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09282_ _07783_ _08036_ VGND VGND VPWR VPWR _08646_ sky130_fd_sc_hd__and2_1
XFILLER_0_118_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_10_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08997_ _05572_ _05814_ VGND VGND VPWR VPWR _06012_ sky130_fd_sc_hd__xnor2_1
X_09618_ _00344_ _00345_ _00343_ VGND VGND VPWR VPWR _00429_ sky130_fd_sc_hd__o21ai_1
X_10890_ _01486_ _01700_ VGND VGND VPWR VPWR _01701_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09549_ _00327_ _00359_ VGND VGND VPWR VPWR _00360_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_78_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12560_ _03397_ _03291_ _03398_ _03395_ VGND VGND VPWR VPWR _03399_ sky130_fd_sc_hd__o31a_1
X_11511_ _02319_ _02321_ VGND VGND VPWR VPWR _02322_ sky130_fd_sc_hd__nand2_1
Xwire102 _05676_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12491_ _03326_ VGND VGND VPWR VPWR _03327_ sky130_fd_sc_hd__buf_6
XFILLER_0_81_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14230_ _03778_ _05194_ _03776_ VGND VGND VPWR VPWR _05195_ sky130_fd_sc_hd__o21a_2
XFILLER_0_136_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11442_ net414 net144 _02071_ VGND VGND VPWR VPWR _02253_ sky130_fd_sc_hd__and3_1
XFILLER_0_34_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14161_ _04979_ _04961_ VGND VGND VPWR VPWR _05119_ sky130_fd_sc_hd__and2b_1
X_11373_ _02182_ _02183_ net441 net115 VGND VGND VPWR VPWR _02184_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_150_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10324_ _01097_ _01099_ _01098_ VGND VGND VPWR VPWR _01135_ sky130_fd_sc_hd__a21o_1
X_13112_ _03429_ _03964_ VGND VGND VPWR VPWR _03965_ sky130_fd_sc_hd__nand2_1
X_14092_ _04999_ _05005_ _05006_ VGND VGND VPWR VPWR _05043_ sky130_fd_sc_hd__and3_1
XFILLER_0_131_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10255_ _01061_ _01064_ _01060_ VGND VGND VPWR VPWR _01066_ sky130_fd_sc_hd__o21a_1
X_13043_ _03886_ _03888_ VGND VGND VPWR VPWR _03890_ sky130_fd_sc_hd__nand2_1
XFILLER_0_147_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10186_ net328 _00654_ _00520_ kp\[12\] VGND VGND VPWR VPWR _00997_ sky130_fd_sc_hd__a22o_1
X_16802_ _07768_ _05468_ _07975_ VGND VGND VPWR VPWR _08024_ sky130_fd_sc_hd__a21oi_1
X_14994_ _06035_ _06033_ VGND VGND VPWR VPWR _06036_ sky130_fd_sc_hd__xnor2_1
Xfanout290 net291 VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__clkbuf_4
X_16733_ _07868_ _07869_ VGND VGND VPWR VPWR _07949_ sky130_fd_sc_hd__nor2_1
XFILLER_0_88_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13945_ _04870_ _04878_ _04881_ VGND VGND VPWR VPWR _04882_ sky130_fd_sc_hd__a21oi_1
X_16664_ _07688_ _07690_ _07872_ VGND VGND VPWR VPWR _07873_ sky130_fd_sc_hd__a21o_1
X_13876_ net232 _03666_ VGND VGND VPWR VPWR _04806_ sky130_fd_sc_hd__nand2_1
X_15615_ _06717_ _06718_ VGND VGND VPWR VPWR _06719_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12827_ _03263_ _03669_ _03670_ VGND VGND VPWR VPWR _03671_ sky130_fd_sc_hd__or3b_1
XFILLER_0_56_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16595_ _07784_ _07788_ _07792_ _07796_ VGND VGND VPWR VPWR _07797_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_69_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15546_ net498 _06642_ VGND VGND VPWR VPWR _06643_ sky130_fd_sc_hd__or2_1
X_12758_ _03589_ _03594_ VGND VGND VPWR VPWR _03602_ sky130_fd_sc_hd__and2b_1
XFILLER_0_127_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11709_ _02506_ _02518_ _02519_ VGND VGND VPWR VPWR _02520_ sky130_fd_sc_hd__a21bo_1
X_15477_ _06565_ _06566_ VGND VGND VPWR VPWR _06567_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12689_ _03523_ _03526_ _03527_ VGND VGND VPWR VPWR _03528_ sky130_fd_sc_hd__o21a_1
XFILLER_0_142_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17216_ _08105_ _08479_ VGND VGND VPWR VPWR _08480_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_114_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14428_ _05411_ _05412_ VGND VGND VPWR VPWR _05413_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_71_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17147_ _08316_ _08324_ VGND VGND VPWR VPWR _08404_ sky130_fd_sc_hd__and2b_1
X_14359_ _05327_ _05336_ VGND VGND VPWR VPWR _05337_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_141_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout9 net312 VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__buf_4
XFILLER_0_97_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17078_ _08326_ _08327_ VGND VGND VPWR VPWR _08328_ sky130_fd_sc_hd__and2_1
XFILLER_0_21_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08920_ _05143_ _05154_ VGND VGND VPWR VPWR _05165_ sky130_fd_sc_hd__nand2_1
X_16029_ _07088_ _07089_ _07107_ VGND VGND VPWR VPWR _07174_ sky130_fd_sc_hd__a21o_1
X_08851_ _03933_ _03944_ _04021_ _04384_ _04395_ VGND VGND VPWR VPWR _04406_ sky130_fd_sc_hd__a41o_4
X_08782_ net53 _03553_ _03586_ net350 VGND VGND VPWR VPWR _00069_ sky130_fd_sc_hd__a22o_1
X_09403_ net337 _04516_ _04439_ net340 VGND VGND VPWR VPWR _00214_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_48_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09334_ _08618_ _08620_ VGND VGND VPWR VPWR _00145_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09265_ _07794_ _08628_ VGND VGND VPWR VPWR _08629_ sky130_fd_sc_hd__or2_1
XFILLER_0_63_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09196_ net322 _04527_ _07486_ VGND VGND VPWR VPWR _08201_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_16_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10040_ _00764_ _00843_ _00849_ VGND VGND VPWR VPWR _00851_ sky130_fd_sc_hd__or3b_1
Xhold43 net83 VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11991_ _02749_ _02803_ VGND VGND VPWR VPWR _02804_ sky130_fd_sc_hd__and2_1
XFILLER_0_98_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13730_ _04641_ _04643_ _04644_ VGND VGND VPWR VPWR _04645_ sky130_fd_sc_hd__or3_4
XFILLER_0_97_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10942_ _01731_ _01751_ _01557_ _01752_ VGND VGND VPWR VPWR _01753_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_79_870 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13661_ _04485_ _04568_ VGND VGND VPWR VPWR _04569_ sky130_fd_sc_hd__xor2_4
X_10873_ _01627_ _01682_ VGND VGND VPWR VPWR _01684_ sky130_fd_sc_hd__nand2_1
X_15400_ _06477_ _06479_ VGND VGND VPWR VPWR _06482_ sky130_fd_sc_hd__nand2_1
X_12612_ _03380_ _03419_ VGND VGND VPWR VPWR _03451_ sky130_fd_sc_hd__or2_1
X_16380_ _07558_ _07559_ VGND VGND VPWR VPWR _07560_ sky130_fd_sc_hd__xor2_1
X_13592_ net246 _03283_ _03248_ net229 VGND VGND VPWR VPWR _04493_ sky130_fd_sc_hd__a22o_1
XFILLER_0_108_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15331_ _06355_ _06357_ VGND VGND VPWR VPWR _06406_ sky130_fd_sc_hd__or2_1
X_12543_ _03376_ _03381_ VGND VGND VPWR VPWR _03382_ sky130_fd_sc_hd__or2_1
XFILLER_0_53_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15262_ _06326_ _06329_ VGND VGND VPWR VPWR _06330_ sky130_fd_sc_hd__and2_1
XFILLER_0_136_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12474_ prev_error\[14\] VGND VGND VPWR VPWR _03309_ sky130_fd_sc_hd__inv_2
XFILLER_0_123_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17001_ _05424_ _08237_ VGND VGND VPWR VPWR _08243_ sky130_fd_sc_hd__nor2_1
X_14213_ _04651_ _05174_ _05175_ VGND VGND VPWR VPWR _05177_ sky130_fd_sc_hd__a21o_2
XFILLER_0_62_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11425_ _02192_ _02235_ VGND VGND VPWR VPWR _02236_ sky130_fd_sc_hd__or2_1
X_15193_ _06253_ _06099_ _06098_ VGND VGND VPWR VPWR _06255_ sky130_fd_sc_hd__or3b_1
XFILLER_0_123_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_7 net518 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_105_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14144_ _05095_ _05093_ VGND VGND VPWR VPWR _05101_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11356_ _02165_ _02163_ VGND VGND VPWR VPWR _02167_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10307_ _01051_ _01050_ VGND VGND VPWR VPWR _01118_ sky130_fd_sc_hd__and2b_1
X_14075_ net235 _04002_ VGND VGND VPWR VPWR _05025_ sky130_fd_sc_hd__nand2_1
X_11287_ net387 net159 net163 net383 VGND VGND VPWR VPWR _02098_ sky130_fd_sc_hd__a22oi_2
X_13026_ _03767_ _03769_ VGND VGND VPWR VPWR _03871_ sky130_fd_sc_hd__or2_1
X_10238_ net351 _00238_ _00239_ VGND VGND VPWR VPWR _01049_ sky130_fd_sc_hd__and3_1
X_10169_ net354 net350 _08681_ _08675_ VGND VGND VPWR VPWR _00980_ sky130_fd_sc_hd__and4_1
XFILLER_0_107_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14977_ _06016_ VGND VGND VPWR VPWR _06017_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer19 _07592_ VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16716_ net254 _05705_ _07884_ _07687_ VGND VGND VPWR VPWR _07930_ sky130_fd_sc_hd__a31o_1
X_13928_ _04575_ _04862_ VGND VGND VPWR VPWR _04863_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_77_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16647_ _07817_ _07832_ _07842_ _07853_ VGND VGND VPWR VPWR _07854_ sky130_fd_sc_hd__or4_4
X_13859_ _04783_ _04782_ VGND VGND VPWR VPWR _04787_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_119_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16578_ i_error\[0\] _07625_ VGND VGND VPWR VPWR _07778_ sky130_fd_sc_hd__nor2_1
XFILLER_0_123_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15529_ _06622_ _06623_ VGND VGND VPWR VPWR _06624_ sky130_fd_sc_hd__or2_1
XFILLER_0_84_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09050_ _06562_ _06584_ VGND VGND VPWR VPWR _06595_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09952_ _00761_ _00762_ VGND VGND VPWR VPWR _00763_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08903_ _04956_ _04967_ VGND VGND VPWR VPWR _04978_ sky130_fd_sc_hd__nand2_1
X_09883_ _00629_ _00628_ _00608_ VGND VGND VPWR VPWR _00694_ sky130_fd_sc_hd__a21o_1
XFILLER_0_57_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08834_ net70 net15 VGND VGND VPWR VPWR _04219_ sky130_fd_sc_hd__nand2b_2
XFILLER_0_99_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08765_ net42 _03307_ _03340_ net259 VGND VGND VPWR VPWR _00040_ sky130_fd_sc_hd__a22o_1
XFILLER_0_95_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09317_ _08680_ VGND VGND VPWR VPWR _08681_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09248_ _08168_ _08157_ VGND VGND VPWR VPWR _08612_ sky130_fd_sc_hd__and2b_1
XFILLER_0_133_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09179_ _07871_ _08003_ VGND VGND VPWR VPWR _08014_ sky130_fd_sc_hd__nor2_1
XFILLER_0_16_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11210_ _01929_ _01932_ _01931_ VGND VGND VPWR VPWR _02021_ sky130_fd_sc_hd__o21a_1
X_12190_ net440 net168 net172 net436 VGND VGND VPWR VPWR _03015_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_102_842 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11141_ _01917_ _01951_ VGND VGND VPWR VPWR _01952_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput77 net77 VGND VGND VPWR VPWR out_clocked[10] sky130_fd_sc_hd__clkbuf_4
X_11072_ _01828_ _01882_ VGND VGND VPWR VPWR _01883_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput88 net88 VGND VGND VPWR VPWR out_clocked[4] sky130_fd_sc_hd__buf_2
X_14900_ _05848_ _05901_ VGND VGND VPWR VPWR _05932_ sky130_fd_sc_hd__xor2_1
X_10023_ net350 _07937_ _07398_ net354 VGND VGND VPWR VPWR _00834_ sky130_fd_sc_hd__a22o_1
X_15880_ _06978_ _07009_ VGND VGND VPWR VPWR _07010_ sky130_fd_sc_hd__and2b_1
X_14831_ _05851_ _05855_ VGND VGND VPWR VPWR _05856_ sky130_fd_sc_hd__and2b_1
XFILLER_0_98_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14762_ _05771_ _05778_ VGND VGND VPWR VPWR _05780_ sky130_fd_sc_hd__or2_1
XFILLER_0_53_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11974_ _02723_ _02785_ VGND VGND VPWR VPWR _02786_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16501_ _07685_ _07692_ VGND VGND VPWR VPWR _07693_ sky130_fd_sc_hd__xor2_1
X_13713_ _04619_ _04624_ VGND VGND VPWR VPWR _04627_ sky130_fd_sc_hd__nand2_1
X_17481_ clknet_4_3_0_clock _00060_ VGND VGND VPWR VPWR kp\[15\] sky130_fd_sc_hd__dfxtp_1
X_10925_ net401 net121 _01533_ _01534_ VGND VGND VPWR VPWR _01736_ sky130_fd_sc_hd__o2bb2a_1
X_14693_ _05703_ VGND VGND VPWR VPWR _05705_ sky130_fd_sc_hd__buf_2
X_16432_ _07126_ _07488_ _07490_ VGND VGND VPWR VPWR _07617_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_129_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13644_ _04492_ _04501_ VGND VGND VPWR VPWR _04551_ sky130_fd_sc_hd__xnor2_1
X_10856_ _01637_ _01638_ VGND VGND VPWR VPWR _01667_ sky130_fd_sc_hd__nor2_1
XFILLER_0_66_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16363_ _07539_ _07540_ VGND VGND VPWR VPWR _07542_ sky130_fd_sc_hd__or2_1
XFILLER_0_66_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13575_ _04470_ _04474_ VGND VGND VPWR VPWR _04475_ sky130_fd_sc_hd__and2b_2
X_10787_ _01563_ net134 _01594_ _01597_ VGND VGND VPWR VPWR _01598_ sky130_fd_sc_hd__o22a_1
X_15314_ _06382_ _06385_ _06387_ VGND VGND VPWR VPWR _06388_ sky130_fd_sc_hd__a21oi_2
X_12526_ net222 VGND VGND VPWR VPWR _03365_ sky130_fd_sc_hd__inv_2
X_16294_ _07462_ VGND VGND VPWR VPWR _07466_ sky130_fd_sc_hd__inv_2
XFILLER_0_26_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15245_ _06215_ _06311_ VGND VGND VPWR VPWR _06312_ sky130_fd_sc_hd__xnor2_1
X_12457_ _03287_ _03289_ VGND VGND VPWR VPWR _03290_ sky130_fd_sc_hd__nor2_1
XFILLER_0_124_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11408_ _02217_ _02213_ _02216_ VGND VGND VPWR VPWR _02219_ sky130_fd_sc_hd__or3_1
X_15176_ _06234_ _06235_ VGND VGND VPWR VPWR _06236_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_50_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12388_ _03219_ _04439_ _03179_ _03214_ VGND VGND VPWR VPWR _03220_ sky130_fd_sc_hd__a22o_2
XFILLER_0_1_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14127_ _05080_ _05081_ VGND VGND VPWR VPWR _05082_ sky130_fd_sc_hd__nand2_1
X_11339_ _02144_ _02146_ _02149_ VGND VGND VPWR VPWR _02150_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_10_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14058_ _04998_ _04990_ _04997_ VGND VGND VPWR VPWR _05006_ sky130_fd_sc_hd__or3_1
XFILLER_0_94_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13009_ net230 _03321_ _03422_ VGND VGND VPWR VPWR _03853_ sky130_fd_sc_hd__and3_1
XFILLER_0_27_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09102_ _05869_ _05880_ VGND VGND VPWR VPWR _07167_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_73_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09033_ net341 net336 net332 _05759_ VGND VGND VPWR VPWR _06408_ sky130_fd_sc_hd__and4_2
XFILLER_0_60_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09935_ net350 _07398_ _07332_ net352 VGND VGND VPWR VPWR _00746_ sky130_fd_sc_hd__a22oi_2
X_09866_ net343 net338 net523 _08681_ VGND VGND VPWR VPWR _00677_ sky130_fd_sc_hd__and4_1
X_08817_ net68 net13 VGND VGND VPWR VPWR _04032_ sky130_fd_sc_hd__or2b_2
X_09797_ _00597_ _00607_ VGND VGND VPWR VPWR _00608_ sky130_fd_sc_hd__and2_1
X_08748_ _03307_ VGND VGND VPWR VPWR _03318_ sky130_fd_sc_hd__buf_2
Xclkbuf_4_9_0_clock clknet_0_clock VGND VGND VPWR VPWR clknet_4_9_0_clock sky130_fd_sc_hd__clkbuf_8
X_10710_ _01503_ _01520_ VGND VGND VPWR VPWR _01521_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_83_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11690_ _02498_ _02500_ VGND VGND VPWR VPWR _02501_ sky130_fd_sc_hd__nor2_1
XFILLER_0_64_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10641_ _01450_ _08497_ _01451_ VGND VGND VPWR VPWR _01452_ sky130_fd_sc_hd__and3_1
XFILLER_0_64_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13360_ _04168_ _04167_ VGND VGND VPWR VPWR _04238_ sky130_fd_sc_hd__or2b_1
X_10572_ _01366_ _01382_ VGND VGND VPWR VPWR _01383_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12311_ _02847_ _02849_ VGND VGND VPWR VPWR _03143_ sky130_fd_sc_hd__nor2_1
XFILLER_0_134_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13291_ _04066_ _04082_ VGND VGND VPWR VPWR _04162_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_106_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15030_ _06068_ _06071_ _06074_ VGND VGND VPWR VPWR _06075_ sky130_fd_sc_hd__o21a_1
XFILLER_0_121_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12242_ net444 net171 VGND VGND VPWR VPWR _03071_ sky130_fd_sc_hd__and2_1
XFILLER_0_121_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_2_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12173_ _02960_ _02973_ _02996_ VGND VGND VPWR VPWR _02998_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_102_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11124_ _01929_ _01933_ _01911_ VGND VGND VPWR VPWR _01935_ sky130_fd_sc_hd__o21ai_1
X_16981_ _08216_ net485 VGND VGND VPWR VPWR _08221_ sky130_fd_sc_hd__or2b_1
X_15932_ _07065_ _07066_ VGND VGND VPWR VPWR _07067_ sky130_fd_sc_hd__and2b_1
X_11055_ net419 net423 net118 net114 VGND VGND VPWR VPWR _01866_ sky130_fd_sc_hd__and4_1
X_10006_ _00808_ _00811_ _00809_ _00810_ VGND VGND VPWR VPWR _00817_ sky130_fd_sc_hd__o211a_1
X_15863_ _06979_ _06985_ _06981_ VGND VGND VPWR VPWR _06992_ sky130_fd_sc_hd__nand3_1
X_14814_ _05835_ _05837_ VGND VGND VPWR VPWR _05838_ sky130_fd_sc_hd__and2_1
X_15794_ _06849_ _06850_ VGND VGND VPWR VPWR _06916_ sky130_fd_sc_hd__xnor2_1
X_14745_ _05757_ _05761_ VGND VGND VPWR VPWR _05762_ sky130_fd_sc_hd__and2b_1
X_17533_ clknet_4_7_0_clock _00022_ VGND VGND VPWR VPWR kd_2\[13\] sky130_fd_sc_hd__dfxtp_2
XPHY_EDGE_ROW_48_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11957_ _02692_ _02767_ VGND VGND VPWR VPWR _02768_ sky130_fd_sc_hd__nand2_1
X_17464_ clknet_4_13_0_clock _00142_ VGND VGND VPWR VPWR prev_d_error\[16\] sky130_fd_sc_hd__dfxtp_1
X_10908_ net418 net421 net111 net106 VGND VGND VPWR VPWR _01719_ sky130_fd_sc_hd__and4_1
X_14676_ _03324_ _05684_ _05685_ VGND VGND VPWR VPWR _05686_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_80_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11888_ _02695_ _02697_ _02698_ VGND VGND VPWR VPWR _02699_ sky130_fd_sc_hd__and3_1
XFILLER_0_27_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16415_ _07589_ _07493_ _06798_ _07590_ VGND VGND VPWR VPWR _07599_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_67_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13627_ _04523_ _04531_ VGND VGND VPWR VPWR _04532_ sky130_fd_sc_hd__or2_1
X_17395_ clknet_4_10_0_clock _00073_ VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dfxtp_1
X_10839_ _01486_ _01649_ VGND VGND VPWR VPWR _01650_ sky130_fd_sc_hd__xor2_1
XFILLER_0_144_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16346_ _07513_ _07522_ VGND VGND VPWR VPWR _07523_ sky130_fd_sc_hd__or2_1
XFILLER_0_13_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13558_ _04386_ _04388_ VGND VGND VPWR VPWR _04456_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_42_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_132_Right_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12509_ net205 _03346_ VGND VGND VPWR VPWR _03347_ sky130_fd_sc_hd__nand2_1
XFILLER_0_54_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16277_ _07439_ _07446_ VGND VGND VPWR VPWR _07447_ sky130_fd_sc_hd__or2b_1
XFILLER_0_140_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13489_ _04377_ _04328_ _04378_ _04379_ VGND VGND VPWR VPWR _04380_ sky130_fd_sc_hd__or4_1
XFILLER_0_140_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15228_ _06289_ _06291_ VGND VGND VPWR VPWR _06293_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_124_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15159_ net284 _05626_ _05628_ VGND VGND VPWR VPWR _06217_ sky130_fd_sc_hd__and3_1
XFILLER_0_1_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout108 net109 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__buf_2
Xfanout119 net120 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__clkbuf_4
X_09720_ _00381_ _00530_ VGND VGND VPWR VPWR _00531_ sky130_fd_sc_hd__or2_1
XFILLER_0_129_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09651_ net348 _04516_ _00461_ VGND VGND VPWR VPWR _00462_ sky130_fd_sc_hd__a21oi_1
X_09582_ _00388_ _00391_ _00392_ VGND VGND VPWR VPWR _00393_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_77_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_879 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09016_ _05297_ _06210_ _06188_ VGND VGND VPWR VPWR _06221_ sky130_fd_sc_hd__a21o_1
XFILLER_0_103_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09918_ _00702_ _00704_ VGND VGND VPWR VPWR _00729_ sky130_fd_sc_hd__xnor2_2
X_09849_ _00574_ _00659_ VGND VGND VPWR VPWR _00660_ sky130_fd_sc_hd__xnor2_1
X_12860_ _03621_ _03703_ VGND VGND VPWR VPWR _03704_ sky130_fd_sc_hd__or2_1
X_11811_ _02503_ _02621_ VGND VGND VPWR VPWR _02622_ sky130_fd_sc_hd__or2_1
X_12791_ net200 _03278_ _03525_ VGND VGND VPWR VPWR _03635_ sky130_fd_sc_hd__a21oi_1
X_14530_ _05524_ _05507_ _05505_ VGND VGND VPWR VPWR _05525_ sky130_fd_sc_hd__a21oi_1
X_11742_ _02550_ _02552_ VGND VGND VPWR VPWR _02553_ sky130_fd_sc_hd__nand2_1
XFILLER_0_83_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14461_ _05441_ _05445_ _05448_ VGND VGND VPWR VPWR _05449_ sky130_fd_sc_hd__or3_4
XFILLER_0_139_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11673_ _02451_ _02483_ _02481_ VGND VGND VPWR VPWR _02484_ sky130_fd_sc_hd__o21a_1
XFILLER_0_83_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16200_ _07345_ _07346_ _07361_ VGND VGND VPWR VPWR _07362_ sky130_fd_sc_hd__and3_1
XFILLER_0_37_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13412_ _04287_ _04289_ VGND VGND VPWR VPWR _04295_ sky130_fd_sc_hd__xnor2_1
X_10624_ _00358_ _00329_ VGND VGND VPWR VPWR _01435_ sky130_fd_sc_hd__or2b_1
X_17180_ _08420_ _08439_ VGND VGND VPWR VPWR _08440_ sky130_fd_sc_hd__xnor2_1
X_14392_ _05369_ _05371_ VGND VGND VPWR VPWR _05373_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16131_ _07218_ _07219_ _07227_ VGND VGND VPWR VPWR _07286_ sky130_fd_sc_hd__o21a_1
X_13343_ _03371_ _03244_ _04139_ VGND VGND VPWR VPWR _04220_ sky130_fd_sc_hd__or3b_1
X_10555_ _01355_ _01365_ VGND VGND VPWR VPWR _01366_ sky130_fd_sc_hd__and2_1
XFILLER_0_122_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16062_ _07194_ _07195_ VGND VGND VPWR VPWR _07210_ sky130_fd_sc_hd__nand2_1
X_13274_ net199 _03578_ _04143_ _04140_ VGND VGND VPWR VPWR _04144_ sky130_fd_sc_hd__a31o_1
X_10486_ _01296_ _01265_ VGND VGND VPWR VPWR _01297_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_51_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15013_ _05947_ _06044_ _06049_ _06052_ _06055_ VGND VGND VPWR VPWR _06057_ sky130_fd_sc_hd__a32oi_4
X_12225_ _03043_ _03046_ _03052_ VGND VGND VPWR VPWR _03053_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_20_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12156_ net440 net162 net165 net436 VGND VGND VPWR VPWR _02981_ sky130_fd_sc_hd__a22oi_1
X_11107_ _01464_ _01914_ VGND VGND VPWR VPWR _01918_ sky130_fd_sc_hd__xor2_1
X_16964_ _07976_ _08033_ _08202_ VGND VGND VPWR VPWR _08203_ sky130_fd_sc_hd__o21ai_2
X_12087_ _02903_ _02909_ VGND VGND VPWR VPWR _02910_ sky130_fd_sc_hd__xnor2_1
X_15915_ _06976_ _06977_ _07044_ _07048_ VGND VGND VPWR VPWR _07049_ sky130_fd_sc_hd__o211a_1
X_11038_ _01847_ _01848_ VGND VGND VPWR VPWR _01849_ sky130_fd_sc_hd__or2_1
X_16895_ _08116_ _08126_ VGND VGND VPWR VPWR _08127_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_56_Left_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15846_ _06765_ _06894_ _06888_ _06893_ VGND VGND VPWR VPWR _06973_ sky130_fd_sc_hd__o211a_1
XFILLER_0_149_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15777_ net308 _05588_ VGND VGND VPWR VPWR _06897_ sky130_fd_sc_hd__and2_1
X_12989_ _03829_ _03832_ _03827_ VGND VGND VPWR VPWR _03833_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_59_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17516_ clknet_4_4_0_clock _00005_ VGND VGND VPWR VPWR kd_1\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_19_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14728_ _05731_ _05742_ VGND VGND VPWR VPWR _05743_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17447_ clknet_4_8_0_clock _00125_ VGND VGND VPWR VPWR i_error\[17\] sky130_fd_sc_hd__dfxtp_1
X_14659_ _05591_ _05662_ VGND VGND VPWR VPWR _05667_ sky130_fd_sc_hd__xor2_1
XFILLER_0_144_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17378_ net466 _08209_ VGND VGND VPWR VPWR _08594_ sky130_fd_sc_hd__nand2_1
XFILLER_0_131_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16329_ _05918_ _06002_ VGND VGND VPWR VPWR _07504_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_65_Left_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09703_ net320 _00316_ VGND VGND VPWR VPWR _00514_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_74_Left_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09634_ _00419_ _00443_ VGND VGND VPWR VPWR _00445_ sky130_fd_sc_hd__xor2_1
X_09565_ _00368_ _00375_ VGND VGND VPWR VPWR _00376_ sky130_fd_sc_hd__and2b_1
XFILLER_0_78_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09496_ _00244_ _00306_ VGND VGND VPWR VPWR _00307_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_83_Left_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10340_ _01137_ _01148_ VGND VGND VPWR VPWR _01151_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_131_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10271_ net376 _04604_ VGND VGND VPWR VPWR _01082_ sky130_fd_sc_hd__nand2_2
XFILLER_0_103_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12010_ _02763_ _02765_ VGND VGND VPWR VPWR _02825_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_92_Left_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout450 net451 VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__clkbuf_4
Xfanout461 net462 VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__buf_2
X_13961_ _04819_ _04886_ _04898_ VGND VGND VPWR VPWR _04899_ sky130_fd_sc_hd__or3b_1
X_15700_ net303 _06527_ _06528_ _05581_ net299 VGND VGND VPWR VPWR _06812_ sky130_fd_sc_hd__a32oi_2
X_12912_ _03753_ _03755_ VGND VGND VPWR VPWR _03756_ sky130_fd_sc_hd__and2_1
X_16680_ _07887_ _07888_ _07889_ VGND VGND VPWR VPWR _07890_ sky130_fd_sc_hd__o21a_1
X_13892_ net210 _03936_ _04743_ VGND VGND VPWR VPWR _04823_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_88_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12843_ _03612_ _03683_ _03686_ VGND VGND VPWR VPWR _03687_ sky130_fd_sc_hd__o21a_1
X_15631_ _06486_ _06487_ _06488_ VGND VGND VPWR VPWR _06736_ sky130_fd_sc_hd__nor3_2
X_15562_ _06652_ _06659_ VGND VGND VPWR VPWR _06660_ sky130_fd_sc_hd__xnor2_1
X_12774_ net215 net501 VGND VGND VPWR VPWR _03618_ sky130_fd_sc_hd__nand2_1
X_14513_ _06309_ _05494_ _05504_ VGND VGND VPWR VPWR _05507_ sky130_fd_sc_hd__or3b_1
X_17301_ net461 prev_error\[9\] VGND VGND VPWR VPWR _08546_ sky130_fd_sc_hd__or2_1
X_11725_ _02513_ _02516_ _02534_ VGND VGND VPWR VPWR _02536_ sky130_fd_sc_hd__nand3_1
X_15493_ net289 _05621_ _06521_ _06583_ VGND VGND VPWR VPWR _06585_ sky130_fd_sc_hd__a31o_1
XFILLER_0_84_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14444_ _00451_ _00544_ _01433_ _05430_ VGND VGND VPWR VPWR _05431_ sky130_fd_sc_hd__a31o_1
X_17232_ _03889_ _08496_ net453 VGND VGND VPWR VPWR _00072_ sky130_fd_sc_hd__o21a_1
XFILLER_0_127_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11656_ _02322_ _02466_ VGND VGND VPWR VPWR _02467_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10607_ _01158_ _01410_ _01412_ _01413_ _01181_ VGND VGND VPWR VPWR _01418_ sky130_fd_sc_hd__a32o_1
X_17163_ net389 _05329_ _01688_ VGND VGND VPWR VPWR _08422_ sky130_fd_sc_hd__a21o_1
X_14375_ _01715_ _03175_ _01713_ VGND VGND VPWR VPWR _05355_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_25_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_870 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11587_ _02303_ _02302_ VGND VGND VPWR VPWR _02398_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16114_ _07187_ _07262_ _07267_ VGND VGND VPWR VPWR _07268_ sky130_fd_sc_hd__and3_1
XFILLER_0_12_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13326_ net227 _03223_ _04199_ _04200_ VGND VGND VPWR VPWR _04201_ sky130_fd_sc_hd__a31o_1
X_10538_ net375 _00314_ _01332_ _01333_ VGND VGND VPWR VPWR _01349_ sky130_fd_sc_hd__a22o_1
X_17094_ _08312_ _05344_ _08345_ VGND VGND VPWR VPWR _08346_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_12_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16045_ _07131_ _07190_ _07188_ VGND VGND VPWR VPWR _07192_ sky130_fd_sc_hd__a21oi_1
X_13257_ _04117_ _04121_ _04123_ VGND VGND VPWR VPWR _04125_ sky130_fd_sc_hd__or3_1
X_10469_ net342 _00654_ VGND VGND VPWR VPWR _01280_ sky130_fd_sc_hd__nand2_1
XFILLER_0_110_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12208_ _03011_ _03031_ VGND VGND VPWR VPWR _03034_ sky130_fd_sc_hd__and2_1
XFILLER_0_86_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13188_ _04046_ _04048_ VGND VGND VPWR VPWR _04049_ sky130_fd_sc_hd__and2b_1
X_12139_ net410 net173 _02860_ _02865_ VGND VGND VPWR VPWR _02964_ sky130_fd_sc_hd__a211oi_1
X_16947_ _08174_ _08183_ VGND VGND VPWR VPWR _08184_ sky130_fd_sc_hd__xor2_1
X_16878_ _08107_ _08076_ _08067_ VGND VGND VPWR VPWR _08108_ sky130_fd_sc_hd__a21boi_1
X_15829_ _06827_ _06836_ _06835_ VGND VGND VPWR VPWR _06954_ sky130_fd_sc_hd__o21ai_1
X_09350_ _00156_ _00159_ _00160_ VGND VGND VPWR VPWR _00161_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_19_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09281_ _08610_ _08622_ VGND VGND VPWR VPWR _08645_ sky130_fd_sc_hd__or2_1
XFILLER_0_142_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08996_ _05957_ _05990_ _05935_ VGND VGND VPWR VPWR _06001_ sky130_fd_sc_hd__a21bo_1
X_09617_ _00426_ _00427_ VGND VGND VPWR VPWR _00428_ sky130_fd_sc_hd__xnor2_1
X_09548_ _00329_ _00358_ VGND VGND VPWR VPWR _00359_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_65_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09479_ _00288_ _00289_ VGND VGND VPWR VPWR _00290_ sky130_fd_sc_hd__nor2_1
XFILLER_0_66_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11510_ _02315_ _02320_ VGND VGND VPWR VPWR _02321_ sky130_fd_sc_hd__and2_1
XFILLER_0_109_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12490_ _03324_ _03325_ VGND VGND VPWR VPWR _03326_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_18_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11441_ net403 net148 _02160_ _02161_ VGND VGND VPWR VPWR _02252_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_22_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14160_ net206 net518 _04933_ VGND VGND VPWR VPWR _05118_ sky130_fd_sc_hd__and3_1
X_11372_ net435 net118 prev_d_error\[17\] VGND VGND VPWR VPWR _02183_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_150_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13111_ _03962_ _03963_ VGND VGND VPWR VPWR _03964_ sky130_fd_sc_hd__xor2_1
X_10323_ _01130_ _01132_ _01133_ _01129_ _01127_ VGND VGND VPWR VPWR _01134_ sky130_fd_sc_hd__a32oi_4
XFILLER_0_104_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14091_ _05037_ _05040_ _05041_ VGND VGND VPWR VPWR _05042_ sky130_fd_sc_hd__or3_2
XFILLER_0_131_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13042_ _03815_ _03887_ VGND VGND VPWR VPWR _03888_ sky130_fd_sc_hd__nor2_1
X_10254_ _01060_ _01061_ _01064_ VGND VGND VPWR VPWR _01065_ sky130_fd_sc_hd__nor3_1
X_10185_ net331 _00654_ VGND VGND VPWR VPWR _00996_ sky130_fd_sc_hd__nand2_4
X_16801_ _07730_ _08020_ _05557_ _07722_ VGND VGND VPWR VPWR _08023_ sky130_fd_sc_hd__o22a_1
X_14993_ net284 _05710_ VGND VGND VPWR VPWR _06035_ sky130_fd_sc_hd__nand2_1
Xfanout280 ki\[8\] VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__buf_2
Xfanout291 ki\[5\] VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__clkbuf_4
X_16732_ _07873_ _07946_ VGND VGND VPWR VPWR _07947_ sky130_fd_sc_hd__nand2_1
X_13944_ _04847_ _04880_ VGND VGND VPWR VPWR _04881_ sky130_fd_sc_hd__or2_1
XFILLER_0_88_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16663_ _07867_ _07870_ VGND VGND VPWR VPWR _07872_ sky130_fd_sc_hd__xnor2_1
X_13875_ net241 _03243_ _04766_ _04767_ VGND VGND VPWR VPWR _04805_ sky130_fd_sc_hd__a22o_1
XFILLER_0_88_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15614_ _06713_ _06715_ VGND VGND VPWR VPWR _06718_ sky130_fd_sc_hd__or2_1
X_12826_ _03662_ _03663_ VGND VGND VPWR VPWR _03670_ sky130_fd_sc_hd__xor2_1
X_16594_ _07725_ _07795_ VGND VGND VPWR VPWR _07796_ sky130_fd_sc_hd__or2_1
XFILLER_0_57_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12757_ _03566_ _03598_ _03600_ VGND VGND VPWR VPWR _03601_ sky130_fd_sc_hd__o21ai_1
X_15545_ _06596_ _06597_ _06641_ VGND VGND VPWR VPWR _06642_ sky130_fd_sc_hd__nor3_2
XFILLER_0_72_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11708_ _02495_ _02503_ _02505_ VGND VGND VPWR VPWR _02519_ sky130_fd_sc_hd__o21ai_1
X_15476_ _06371_ _06475_ VGND VGND VPWR VPWR _06566_ sky130_fd_sc_hd__xnor2_1
X_12688_ _03389_ _03391_ VGND VGND VPWR VPWR _03527_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_115_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14427_ _03609_ _05196_ _03607_ VGND VGND VPWR VPWR _05412_ sky130_fd_sc_hd__o21a_4
XFILLER_0_21_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17215_ _08108_ _08077_ VGND VGND VPWR VPWR _08479_ sky130_fd_sc_hd__and2b_1
X_11639_ _02439_ _02446_ _02448_ _02449_ VGND VGND VPWR VPWR _02450_ sky130_fd_sc_hd__a22o_1
XFILLER_0_52_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17146_ _08262_ _08272_ _08270_ VGND VGND VPWR VPWR _08403_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_108_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14358_ _05334_ _05335_ VGND VGND VPWR VPWR _05336_ sky130_fd_sc_hd__and2_1
XFILLER_0_40_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13309_ _04161_ _04180_ _04181_ VGND VGND VPWR VPWR _04182_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_141_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17077_ _08315_ _08325_ VGND VGND VPWR VPWR _08327_ sky130_fd_sc_hd__or2_1
X_14289_ _02719_ _03147_ VGND VGND VPWR VPWR _05260_ sky130_fd_sc_hd__nor2_1
XFILLER_0_150_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16028_ _07160_ _07161_ _07172_ VGND VGND VPWR VPWR _07173_ sky130_fd_sc_hd__nor3_1
XFILLER_0_0_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08850_ net59 net4 VGND VGND VPWR VPWR _04395_ sky130_fd_sc_hd__and2b_1
X_08781_ net52 _03553_ _03586_ net355 VGND VGND VPWR VPWR _00068_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09402_ net335 _04626_ VGND VGND VPWR VPWR _00213_ sky130_fd_sc_hd__nand2_1
XFILLER_0_149_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09333_ _08695_ _08696_ VGND VGND VPWR VPWR _00144_ sky130_fd_sc_hd__and2_1
XFILLER_0_75_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09264_ net326 _04615_ VGND VGND VPWR VPWR _08628_ sky130_fd_sc_hd__and2_1
XFILLER_0_118_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09195_ _08135_ _08179_ VGND VGND VPWR VPWR _08190_ sky130_fd_sc_hd__xor2_1
XFILLER_0_105_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08979_ _05792_ _05803_ VGND VGND VPWR VPWR _05814_ sky130_fd_sc_hd__and2_1
Xhold44 i_error\[1\] VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__dlygate4sd3_1
X_11990_ net400 net174 _02748_ VGND VGND VPWR VPWR _02803_ sky130_fd_sc_hd__a21o_1
X_10941_ _01553_ _01554_ _01556_ VGND VGND VPWR VPWR _01752_ sky130_fd_sc_hd__a21oi_1
X_13660_ _04481_ _04486_ _04563_ _04567_ VGND VGND VPWR VPWR _04568_ sky130_fd_sc_hd__o31a_2
XFILLER_0_85_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10872_ _01627_ _01682_ VGND VGND VPWR VPWR _01683_ sky130_fd_sc_hd__or2_1
X_12611_ _03444_ _03449_ VGND VGND VPWR VPWR _03450_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13591_ _04487_ _04488_ _04491_ VGND VGND VPWR VPWR _04492_ sky130_fd_sc_hd__o21ai_2
X_15330_ _06366_ _06401_ VGND VGND VPWR VPWR _06405_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_109_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12542_ net210 _03321_ VGND VGND VPWR VPWR _03381_ sky130_fd_sc_hd__nand2_1
XFILLER_0_81_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15261_ _06327_ _06328_ VGND VGND VPWR VPWR _06329_ sky130_fd_sc_hd__xnor2_1
X_12473_ prev_error\[15\] _06705_ VGND VGND VPWR VPWR _03308_ sky130_fd_sc_hd__nand2_1
XFILLER_0_81_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17000_ _08240_ _08241_ VGND VGND VPWR VPWR _08242_ sky130_fd_sc_hd__nand2_1
X_14212_ _04570_ _04650_ VGND VGND VPWR VPWR _05175_ sky130_fd_sc_hd__nor2_1
X_11424_ _02190_ _02191_ VGND VGND VPWR VPWR _02235_ sky130_fd_sc_hd__nor2_1
X_15192_ net304 _05690_ VGND VGND VPWR VPWR _06253_ sky130_fd_sc_hd__nand2_1
XANTENNA_8 net520 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14143_ _05075_ _05084_ _05098_ VGND VGND VPWR VPWR _05100_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_104_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11355_ _02163_ _02165_ VGND VGND VPWR VPWR _02166_ sky130_fd_sc_hd__and2b_1
XFILLER_0_120_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10306_ net345 _00316_ VGND VGND VPWR VPWR _01117_ sky130_fd_sc_hd__nand2_1
XFILLER_0_104_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14074_ _04987_ _05023_ VGND VGND VPWR VPWR _05024_ sky130_fd_sc_hd__or2_1
X_11286_ net383 net159 _02096_ VGND VGND VPWR VPWR _02097_ sky130_fd_sc_hd__and3_1
XFILLER_0_120_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13025_ _03840_ _03868_ _03869_ VGND VGND VPWR VPWR _03870_ sky130_fd_sc_hd__o21ba_1
X_10237_ _01046_ _01042_ VGND VGND VPWR VPWR _01048_ sky130_fd_sc_hd__xor2_1
X_10168_ net354 _08681_ _08676_ net350 VGND VGND VPWR VPWR _00979_ sky130_fd_sc_hd__a22o_1
XFILLER_0_83_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10099_ net354 net523 _08681_ net350 VGND VGND VPWR VPWR _00910_ sky130_fd_sc_hd__a22o_1
X_14976_ _06015_ VGND VGND VPWR VPWR _06016_ sky130_fd_sc_hd__clkbuf_4
X_16715_ _07927_ _07928_ VGND VGND VPWR VPWR _07929_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13927_ net226 _03750_ VGND VGND VPWR VPWR _04862_ sky130_fd_sc_hd__nand2_1
XFILLER_0_107_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16646_ _07851_ _07852_ VGND VGND VPWR VPWR _07853_ sky130_fd_sc_hd__or2b_1
XFILLER_0_88_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13858_ _04762_ _04785_ VGND VGND VPWR VPWR _04786_ sky130_fd_sc_hd__or2_1
XFILLER_0_123_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12809_ _03616_ _03630_ _03652_ VGND VGND VPWR VPWR _03653_ sky130_fd_sc_hd__o21ba_1
X_16577_ _05443_ VGND VGND VPWR VPWR _07777_ sky130_fd_sc_hd__inv_2
XFILLER_0_146_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13789_ _04707_ _04709_ VGND VGND VPWR VPWR _04710_ sky130_fd_sc_hd__and2b_1
XFILLER_0_44_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15528_ _06560_ _06553_ VGND VGND VPWR VPWR _06623_ sky130_fd_sc_hd__nor2b_1
XFILLER_0_72_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15459_ net282 _05602_ VGND VGND VPWR VPWR _06547_ sky130_fd_sc_hd__nand2_1
XFILLER_0_115_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17129_ _08258_ _08277_ _08383_ VGND VGND VPWR VPWR _08384_ sky130_fd_sc_hd__a21o_1
XFILLER_0_40_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09951_ net343 _08680_ _08675_ net338 VGND VGND VPWR VPWR _00762_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_40_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08902_ net8 net63 VGND VGND VPWR VPWR _04967_ sky130_fd_sc_hd__or2b_1
X_09882_ _00629_ _00608_ _00628_ VGND VGND VPWR VPWR _00693_ sky130_fd_sc_hd__nand3_1
XFILLER_0_148_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08833_ net15 net70 VGND VGND VPWR VPWR _04208_ sky130_fd_sc_hd__nor2b_1
XFILLER_0_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08764_ net41 _03307_ _03340_ net263 VGND VGND VPWR VPWR _00039_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_146_Right_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09316_ _08679_ VGND VGND VPWR VPWR _08680_ sky130_fd_sc_hd__buf_8
XFILLER_0_48_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09247_ net332 _04769_ VGND VGND VPWR VPWR _08611_ sky130_fd_sc_hd__nand2_1
XFILLER_0_90_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09178_ _07805_ _07838_ _07860_ VGND VGND VPWR VPWR _08003_ sky130_fd_sc_hd__nor3_1
XFILLER_0_31_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11140_ _01914_ _01916_ VGND VGND VPWR VPWR _01951_ sky130_fd_sc_hd__and2_1
Xclkbuf_4_5_0_clock clknet_0_clock VGND VGND VPWR VPWR clknet_4_5_0_clock sky130_fd_sc_hd__clkbuf_8
Xoutput78 net78 VGND VGND VPWR VPWR out_clocked[11] sky130_fd_sc_hd__clkbuf_4
X_11071_ net391 net144 _01826_ _01827_ VGND VGND VPWR VPWR _01882_ sky130_fd_sc_hd__o2bb2a_1
Xoutput89 net89 VGND VGND VPWR VPWR out_clocked[5] sky130_fd_sc_hd__buf_2
X_10022_ _00830_ _00832_ VGND VGND VPWR VPWR _00833_ sky130_fd_sc_hd__nand2_1
X_14830_ _05854_ _05848_ VGND VGND VPWR VPWR _05855_ sky130_fd_sc_hd__xor2_1
XFILLER_0_98_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14761_ _05771_ _05778_ VGND VGND VPWR VPWR _05779_ sky130_fd_sc_hd__nand2_1
X_11973_ _02724_ _02781_ _02783_ VGND VGND VPWR VPWR _02785_ sky130_fd_sc_hd__a21boi_1
X_16500_ _07690_ _07691_ VGND VGND VPWR VPWR _07692_ sky130_fd_sc_hd__nand2_1
X_13712_ _04619_ _04624_ VGND VGND VPWR VPWR _04625_ sky130_fd_sc_hd__nor2_1
X_10924_ _01732_ _01734_ VGND VGND VPWR VPWR _01735_ sky130_fd_sc_hd__nor2_1
X_14692_ _05702_ VGND VGND VPWR VPWR _05703_ sky130_fd_sc_hd__clkbuf_4
X_17480_ clknet_4_3_0_clock _00059_ VGND VGND VPWR VPWR kp\[14\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_39_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_113_Right_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16431_ i_error\[3\] _07615_ VGND VGND VPWR VPWR _07616_ sky130_fd_sc_hd__or2_1
XFILLER_0_129_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13643_ _04468_ _04536_ _04547_ VGND VGND VPWR VPWR _04550_ sky130_fd_sc_hd__a21oi_1
X_10855_ _01616_ _01619_ _01621_ VGND VGND VPWR VPWR _01666_ sky130_fd_sc_hd__or3_1
XFILLER_0_67_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16362_ net254 _05801_ _07538_ VGND VGND VPWR VPWR _07540_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_66_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13574_ _04470_ _04471_ _04473_ VGND VGND VPWR VPWR _04474_ sky130_fd_sc_hd__or3_1
X_10786_ _01595_ VGND VGND VPWR VPWR _01597_ sky130_fd_sc_hd__inv_2
XFILLER_0_137_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12525_ _03357_ _03363_ VGND VGND VPWR VPWR _03364_ sky130_fd_sc_hd__xnor2_2
X_15313_ _06367_ _06381_ _06368_ VGND VGND VPWR VPWR _06387_ sky130_fd_sc_hd__and3_1
X_16293_ net302 VGND VGND VPWR VPWR _07465_ sky130_fd_sc_hd__inv_2
XFILLER_0_82_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12456_ net190 _03278_ _03286_ net195 VGND VGND VPWR VPWR _03289_ sky130_fd_sc_hd__a22oi_1
X_15244_ _06113_ _06217_ _06216_ VGND VGND VPWR VPWR _06311_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11407_ _02213_ _02216_ _02217_ VGND VGND VPWR VPWR _02218_ sky130_fd_sc_hd__o21ai_2
X_15175_ net270 _05582_ VGND VGND VPWR VPWR _06235_ sky130_fd_sc_hd__nand2_2
X_12387_ prev_error\[12\] VGND VGND VPWR VPWR _03219_ sky130_fd_sc_hd__inv_2
X_14126_ net101 _05054_ VGND VGND VPWR VPWR _05081_ sky130_fd_sc_hd__or2b_1
XFILLER_0_22_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11338_ _02049_ _02148_ VGND VGND VPWR VPWR _02149_ sky130_fd_sc_hd__xor2_1
XFILLER_0_120_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14057_ _05002_ _05004_ VGND VGND VPWR VPWR _05005_ sky130_fd_sc_hd__xor2_1
X_11269_ net391 net151 _01995_ _01996_ VGND VGND VPWR VPWR _02080_ sky130_fd_sc_hd__o2bb2a_1
X_13008_ net230 _03321_ _03422_ VGND VGND VPWR VPWR _03852_ sky130_fd_sc_hd__a21o_1
XFILLER_0_118_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14959_ _05911_ _05914_ _05912_ VGND VGND VPWR VPWR _05997_ sky130_fd_sc_hd__o21a_1
XFILLER_0_76_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16629_ _07643_ _07644_ VGND VGND VPWR VPWR _07834_ sky130_fd_sc_hd__or2_1
XFILLER_0_119_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09101_ net333 _04934_ _07145_ VGND VGND VPWR VPWR _07156_ sky130_fd_sc_hd__and3_1
XFILLER_0_128_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09032_ _06309_ _06342_ VGND VGND VPWR VPWR _06397_ sky130_fd_sc_hd__nor2_2
XFILLER_0_5_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09934_ _00730_ _00743_ VGND VGND VPWR VPWR _00745_ sky130_fd_sc_hd__xor2_4
XFILLER_0_0_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09865_ net343 net523 _08681_ net338 VGND VGND VPWR VPWR _00676_ sky130_fd_sc_hd__a22o_1
X_08816_ _03966_ _04010_ VGND VGND VPWR VPWR _04021_ sky130_fd_sc_hd__or2_1
X_09796_ _00581_ _00596_ VGND VGND VPWR VPWR _00607_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08747_ _02872_ _03296_ VGND VGND VPWR VPWR _03307_ sky130_fd_sc_hd__nor2_2
XFILLER_0_95_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10640_ _08513_ _08300_ VGND VGND VPWR VPWR _01451_ sky130_fd_sc_hd__or2b_1
XFILLER_0_63_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10571_ _01355_ _01365_ VGND VGND VPWR VPWR _01382_ sky130_fd_sc_hd__nor2_1
XFILLER_0_146_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12310_ _03134_ _03138_ _03139_ _03141_ VGND VGND VPWR VPWR _03142_ sky130_fd_sc_hd__a211o_1
X_13290_ _04151_ _04149_ VGND VGND VPWR VPWR _04161_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_134_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12241_ _03059_ _03067_ _03069_ VGND VGND VPWR VPWR _03070_ sky130_fd_sc_hd__or3_1
X_12172_ _02960_ _02973_ _02996_ VGND VGND VPWR VPWR _02997_ sky130_fd_sc_hd__and3_1
XFILLER_0_102_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11123_ _01911_ _01929_ _01933_ VGND VGND VPWR VPWR _01934_ sky130_fd_sc_hd__or3_1
X_16980_ _08165_ _08170_ VGND VGND VPWR VPWR _08220_ sky130_fd_sc_hd__or2b_1
XFILLER_0_101_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15931_ net309 _06527_ _06528_ _05665_ net292 VGND VGND VPWR VPWR _07066_ sky130_fd_sc_hd__a32o_1
X_11054_ net419 net118 net114 net423 VGND VGND VPWR VPWR _01865_ sky130_fd_sc_hd__a22oi_2
X_10005_ _00814_ _00815_ VGND VGND VPWR VPWR _00816_ sky130_fd_sc_hd__and2_1
X_15862_ _06987_ _06989_ VGND VGND VPWR VPWR _06990_ sky130_fd_sc_hd__xnor2_1
X_14813_ _05813_ _05819_ _05834_ VGND VGND VPWR VPWR _05837_ sky130_fd_sc_hd__or3_1
X_15793_ _06912_ _06913_ VGND VGND VPWR VPWR _06915_ sky130_fd_sc_hd__nand2_1
X_17532_ clknet_4_7_0_clock _00021_ VGND VGND VPWR VPWR kd_2\[12\] sky130_fd_sc_hd__dfxtp_1
X_14744_ net265 _05749_ _05758_ _05760_ VGND VGND VPWR VPWR _05761_ sky130_fd_sc_hd__a31o_1
X_11956_ _02689_ _02691_ VGND VGND VPWR VPWR _02767_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_103_Left_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17463_ clknet_4_13_0_clock _00141_ VGND VGND VPWR VPWR prev_d_error\[15\] sky130_fd_sc_hd__dfxtp_1
X_10907_ _01530_ _01717_ VGND VGND VPWR VPWR _01718_ sky130_fd_sc_hd__and2_1
X_14675_ prev_error\[16\] _05605_ _05616_ VGND VGND VPWR VPWR _05685_ sky130_fd_sc_hd__and3_1
XFILLER_0_39_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11887_ _02694_ _02687_ _02692_ VGND VGND VPWR VPWR _02698_ sky130_fd_sc_hd__nand3_1
XFILLER_0_13_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16414_ _07584_ _07595_ _07597_ VGND VGND VPWR VPWR _07598_ sky130_fd_sc_hd__or3_1
XFILLER_0_55_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13626_ _04528_ _04530_ VGND VGND VPWR VPWR _04531_ sky130_fd_sc_hd__nand2_1
X_10838_ _01635_ _01648_ VGND VGND VPWR VPWR _01649_ sky130_fd_sc_hd__xnor2_1
X_17394_ clknet_4_10_0_clock _00072_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_66_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16345_ _07515_ _07521_ VGND VGND VPWR VPWR _07522_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13557_ _04364_ _04454_ VGND VGND VPWR VPWR _04455_ sky130_fd_sc_hd__xnor2_4
X_10769_ net394 net133 net125 net399 VGND VGND VPWR VPWR _01580_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_89_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12508_ net207 _03345_ VGND VGND VPWR VPWR _03346_ sky130_fd_sc_hd__and2_1
X_16276_ net310 _04316_ _07241_ _07438_ VGND VGND VPWR VPWR _07446_ sky130_fd_sc_hd__a31o_1
X_13488_ _04243_ _04371_ _04376_ VGND VGND VPWR VPWR _04379_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_124_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15227_ _06289_ _06291_ VGND VGND VPWR VPWR _06292_ sky130_fd_sc_hd__nand2_1
X_12439_ _03264_ _03270_ VGND VGND VPWR VPWR _03271_ sky130_fd_sc_hd__or2_1
XFILLER_0_2_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_112_Left_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15158_ net283 _05630_ _05736_ net287 VGND VGND VPWR VPWR _06216_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_10_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14109_ net246 _04310_ _04311_ VGND VGND VPWR VPWR _05062_ sky130_fd_sc_hd__and3_1
X_15089_ _06136_ _06138_ _06139_ VGND VGND VPWR VPWR _06140_ sky130_fd_sc_hd__o21ai_2
Xfanout109 net111 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_129_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09650_ net352 _04428_ VGND VGND VPWR VPWR _00461_ sky130_fd_sc_hd__and2_1
Xclkbuf_0_clock clock VGND VGND VPWR VPWR clknet_0_clock sky130_fd_sc_hd__clkbuf_16
X_09581_ _00278_ _00389_ VGND VGND VPWR VPWR _00392_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_121_Left_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09015_ _06188_ _06199_ VGND VGND VPWR VPWR _06210_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_130_Left_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09917_ _00696_ _00716_ VGND VGND VPWR VPWR _00728_ sky130_fd_sc_hd__xnor2_2
X_09848_ net357 _04516_ _00461_ _00575_ VGND VGND VPWR VPWR _00659_ sky130_fd_sc_hd__a31o_1
X_09779_ _00584_ _00589_ VGND VGND VPWR VPWR _00590_ sky130_fd_sc_hd__xor2_2
X_11810_ _02501_ _02502_ VGND VGND VPWR VPWR _02621_ sky130_fd_sc_hd__nor2_1
X_12790_ _03632_ _03633_ VGND VGND VPWR VPWR _03634_ sky130_fd_sc_hd__or2_1
X_11741_ _02446_ _02551_ VGND VGND VPWR VPWR _02552_ sky130_fd_sc_hd__nor2_1
XFILLER_0_95_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14460_ _05446_ _05447_ VGND VGND VPWR VPWR _05448_ sky130_fd_sc_hd__xnor2_4
X_11672_ _02481_ _02482_ VGND VGND VPWR VPWR _02483_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10623_ _00263_ _00265_ _00256_ _00264_ VGND VGND VPWR VPWR _01434_ sky130_fd_sc_hd__o211a_1
XFILLER_0_107_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13411_ _04292_ _04293_ VGND VGND VPWR VPWR _04294_ sky130_fd_sc_hd__nor2_1
X_14391_ _05369_ _05371_ VGND VGND VPWR VPWR _05372_ sky130_fd_sc_hd__or2_1
XFILLER_0_51_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16130_ _07283_ _07284_ VGND VGND VPWR VPWR _07285_ sky130_fd_sc_hd__nand2_1
X_13342_ net212 _03260_ _04139_ VGND VGND VPWR VPWR _04218_ sky130_fd_sc_hd__a21o_1
X_10554_ _01363_ _01360_ VGND VGND VPWR VPWR _01365_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_106_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16061_ net279 _06417_ _07208_ _07206_ VGND VGND VPWR VPWR _07209_ sky130_fd_sc_hd__a31o_1
X_13273_ _04140_ _04141_ VGND VGND VPWR VPWR _04143_ sky130_fd_sc_hd__nor2_1
X_10485_ net375 _08674_ VGND VGND VPWR VPWR _01296_ sky130_fd_sc_hd__nand2_1
XFILLER_0_134_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15012_ _06053_ _06054_ VGND VGND VPWR VPWR _06055_ sky130_fd_sc_hd__xor2_4
X_12224_ _03047_ _03049_ _03051_ VGND VGND VPWR VPWR _03052_ sky130_fd_sc_hd__and3_1
XFILLER_0_20_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12155_ net436 net440 net162 net165 VGND VGND VPWR VPWR _02980_ sky130_fd_sc_hd__and4_1
X_11106_ _01914_ _01916_ VGND VGND VPWR VPWR _01917_ sky130_fd_sc_hd__nor2_1
X_16963_ _07828_ _07971_ net483 _08200_ VGND VGND VPWR VPWR _08202_ sky130_fd_sc_hd__a211o_1
X_12086_ _02904_ _02908_ VGND VGND VPWR VPWR _02909_ sky130_fd_sc_hd__xnor2_1
X_15914_ _07045_ _07047_ VGND VGND VPWR VPWR _07048_ sky130_fd_sc_hd__nand2_1
X_11037_ _01841_ _01846_ VGND VGND VPWR VPWR _01848_ sky130_fd_sc_hd__and2_1
X_16894_ _05453_ _08123_ _08125_ VGND VGND VPWR VPWR _08126_ sky130_fd_sc_hd__a21o_1
X_15845_ _06970_ _06971_ VGND VGND VPWR VPWR _06972_ sky130_fd_sc_hd__or2b_1
X_15776_ net309 _05626_ _05628_ _05589_ net292 VGND VGND VPWR VPWR _06896_ sky130_fd_sc_hd__a32o_1
XFILLER_0_87_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12988_ _03830_ _03831_ VGND VGND VPWR VPWR _03832_ sky130_fd_sc_hd__xnor2_1
X_17515_ clknet_4_5_0_clock _00004_ VGND VGND VPWR VPWR kd_1\[13\] sky130_fd_sc_hd__dfxtp_1
X_14727_ _05728_ _05732_ _05741_ VGND VGND VPWR VPWR _05742_ sky130_fd_sc_hd__o21ba_1
X_11939_ _02730_ _02737_ _02739_ VGND VGND VPWR VPWR _02750_ sky130_fd_sc_hd__and3_1
XFILLER_0_86_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17446_ clknet_4_8_0_clock _00124_ VGND VGND VPWR VPWR i_error\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_138_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14658_ _05665_ VGND VGND VPWR VPWR _05666_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_55_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13609_ net208 net202 _03792_ _03751_ VGND VGND VPWR VPWR _04512_ sky130_fd_sc_hd__nand4_1
XFILLER_0_28_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17377_ net467 net411 net456 _08593_ VGND VGND VPWR VPWR _00135_ sky130_fd_sc_hd__o211a_1
X_14589_ _05589_ VGND VGND VPWR VPWR _05590_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_27_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16328_ _06000_ _06090_ _06084_ _06088_ VGND VGND VPWR VPWR _07503_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_42_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16259_ _07382_ _07426_ VGND VGND VPWR VPWR _07427_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_880 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09702_ _00511_ _00512_ VGND VGND VPWR VPWR _00513_ sky130_fd_sc_hd__nand2_1
X_09633_ _00381_ _00416_ VGND VGND VPWR VPWR _00444_ sky130_fd_sc_hd__xnor2_1
X_09564_ net319 _00242_ _00316_ net315 VGND VGND VPWR VPWR _00375_ sky130_fd_sc_hd__a22o_1
X_09495_ _00246_ _00245_ VGND VGND VPWR VPWR _00306_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10270_ _01044_ _01080_ VGND VGND VPWR VPWR _01081_ sky130_fd_sc_hd__xor2_4
Xfanout440 net441 VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__buf_2
Xfanout451 net460 VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__buf_4
Xfanout462 net1 VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__clkbuf_4
X_13960_ _04888_ _04896_ _04897_ VGND VGND VPWR VPWR _04898_ sky130_fd_sc_hd__a21bo_1
X_12911_ _03747_ _03754_ VGND VGND VPWR VPWR _03755_ sky130_fd_sc_hd__nor2_1
X_13891_ net223 _03751_ _04814_ _04811_ VGND VGND VPWR VPWR _04822_ sky130_fd_sc_hd__a31o_1
X_15630_ _06486_ _06487_ _06488_ VGND VGND VPWR VPWR _06735_ sky130_fd_sc_hd__o21a_4
X_12842_ _03684_ _03685_ VGND VGND VPWR VPWR _03686_ sky130_fd_sc_hd__or2b_1
XFILLER_0_69_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15561_ _06657_ _06658_ VGND VGND VPWR VPWR _06659_ sky130_fd_sc_hd__nor2_1
X_12773_ net221 _03321_ VGND VGND VPWR VPWR _03617_ sky130_fd_sc_hd__nand2_1
XFILLER_0_139_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17300_ _08536_ _07420_ _08545_ net450 VGND VGND VPWR VPWR _00098_ sky130_fd_sc_hd__o211a_1
X_14512_ _06309_ _05494_ _05504_ VGND VGND VPWR VPWR _05505_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_84_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11724_ _02513_ _02516_ _02534_ VGND VGND VPWR VPWR _02535_ sky130_fd_sc_hd__a21o_1
X_15492_ net293 _06520_ _05710_ VGND VGND VPWR VPWR _06583_ sky130_fd_sc_hd__and3_1
XFILLER_0_127_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17231_ net494 _08495_ _08478_ VGND VGND VPWR VPWR _08496_ sky130_fd_sc_hd__a21oi_2
X_14443_ _01440_ VGND VGND VPWR VPWR _05430_ sky130_fd_sc_hd__inv_2
X_11655_ _02319_ _02321_ VGND VGND VPWR VPWR _02466_ sky130_fd_sc_hd__or2_1
XFILLER_0_25_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10606_ _01134_ _01160_ VGND VGND VPWR VPWR _01417_ sky130_fd_sc_hd__xor2_1
X_17162_ _03433_ _08290_ _03427_ VGND VGND VPWR VPWR _08420_ sky130_fd_sc_hd__a21o_1
X_14374_ _05351_ _05353_ VGND VGND VPWR VPWR _05354_ sky130_fd_sc_hd__nand2_1
X_11586_ _02394_ _02387_ _02396_ VGND VGND VPWR VPWR _02397_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_51_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16113_ _07263_ _07264_ _07265_ VGND VGND VPWR VPWR _07267_ sky130_fd_sc_hd__o21ai_1
X_10537_ _01324_ _01347_ VGND VGND VPWR VPWR _01348_ sky130_fd_sc_hd__xor2_2
X_13325_ _04196_ _04198_ VGND VGND VPWR VPWR _04200_ sky130_fd_sc_hd__nor2_1
X_17093_ _08332_ _08343_ VGND VGND VPWR VPWR _08345_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_150_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16044_ _07131_ _07188_ _07190_ VGND VGND VPWR VPWR _07191_ sky130_fd_sc_hd__and3_1
X_10468_ _01273_ _01277_ _01233_ _01278_ VGND VGND VPWR VPWR _01279_ sky130_fd_sc_hd__a211oi_2
X_13256_ _04117_ _04121_ _04123_ VGND VGND VPWR VPWR _04124_ sky130_fd_sc_hd__o21a_1
XFILLER_0_150_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12207_ _03032_ VGND VGND VPWR VPWR _03033_ sky130_fd_sc_hd__inv_2
X_13187_ _03925_ _04047_ VGND VGND VPWR VPWR _04048_ sky130_fd_sc_hd__nor2_1
X_10399_ _01208_ _01209_ VGND VGND VPWR VPWR _01210_ sky130_fd_sc_hd__xor2_2
X_12138_ _02956_ _02960_ _02962_ VGND VGND VPWR VPWR _02963_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_19_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16946_ _08180_ _08182_ VGND VGND VPWR VPWR _08183_ sky130_fd_sc_hd__or2_1
X_12069_ net424 net158 _02886_ _02889_ VGND VGND VPWR VPWR _02890_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_126_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16877_ _08068_ _08106_ VGND VGND VPWR VPWR _08107_ sky130_fd_sc_hd__nand2_1
X_15828_ _06950_ _06952_ VGND VGND VPWR VPWR _06953_ sky130_fd_sc_hd__and2_1
XFILLER_0_126_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15759_ _06692_ _06696_ _06699_ VGND VGND VPWR VPWR _06877_ sky130_fd_sc_hd__and3_1
XFILLER_0_129_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09280_ _08642_ _08643_ VGND VGND VPWR VPWR _08644_ sky130_fd_sc_hd__and2b_1
XFILLER_0_74_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17429_ clknet_4_2_0_clock _00107_ VGND VGND VPWR VPWR prev_error\[17\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_28_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08995_ _05968_ _05979_ VGND VGND VPWR VPWR _05990_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09616_ net356 _04923_ VGND VGND VPWR VPWR _00427_ sky130_fd_sc_hd__nand2_1
XFILLER_0_92_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09547_ _00330_ _00356_ _00357_ VGND VGND VPWR VPWR _00358_ sky130_fd_sc_hd__o21ba_1
X_09478_ net337 _04615_ _00215_ VGND VGND VPWR VPWR _00289_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_66_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11440_ _02237_ _02249_ _02199_ _02250_ VGND VGND VPWR VPWR _02251_ sky130_fd_sc_hd__a211o_1
X_11371_ prev_d_error\[17\] net436 net118 VGND VGND VPWR VPWR _02182_ sky130_fd_sc_hd__and3_1
XFILLER_0_132_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10322_ net342 net339 _00653_ _00520_ VGND VGND VPWR VPWR _01133_ sky130_fd_sc_hd__and4_2
X_13110_ net232 net501 VGND VGND VPWR VPWR _03963_ sky130_fd_sc_hd__nand2_1
X_14090_ _05036_ _05030_ _05035_ VGND VGND VPWR VPWR _05041_ sky130_fd_sc_hd__nor3_1
XFILLER_0_132_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13041_ net211 _03223_ _03814_ VGND VGND VPWR VPWR _03887_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10253_ net335 _00653_ _01063_ VGND VGND VPWR VPWR _01064_ sky130_fd_sc_hd__and3_1
X_10184_ _00990_ _00991_ _00994_ VGND VGND VPWR VPWR _00995_ sky130_fd_sc_hd__or3_1
XFILLER_0_100_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16800_ _08016_ _08018_ _08021_ VGND VGND VPWR VPWR _08022_ sky130_fd_sc_hd__a21o_1
X_14992_ net283 net490 _05722_ VGND VGND VPWR VPWR _06033_ sky130_fd_sc_hd__and3_1
Xfanout270 net272 VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__clkbuf_2
Xfanout281 net283 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__clkbuf_4
X_16731_ _07866_ _07875_ VGND VGND VPWR VPWR _07946_ sky130_fd_sc_hd__or2b_1
Xfanout292 net295 VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__buf_2
X_13943_ _04844_ _04845_ VGND VGND VPWR VPWR _04880_ sky130_fd_sc_hd__nor2_1
X_16662_ _07868_ _07869_ VGND VGND VPWR VPWR _07870_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13874_ _04773_ _04774_ VGND VGND VPWR VPWR _04804_ sky130_fd_sc_hd__xor2_1
XFILLER_0_69_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15613_ _06713_ _06715_ VGND VGND VPWR VPWR _06717_ sky130_fd_sc_hd__nand2_1
X_12825_ _03668_ VGND VGND VPWR VPWR _03669_ sky130_fd_sc_hd__buf_2
X_16593_ _05449_ _07793_ VGND VGND VPWR VPWR _07795_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15544_ _06621_ _06640_ VGND VGND VPWR VPWR _06641_ sky130_fd_sc_hd__xnor2_1
X_12756_ _03417_ _03599_ VGND VGND VPWR VPWR _03600_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_56_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11707_ _02516_ _02517_ VGND VGND VPWR VPWR _02518_ sky130_fd_sc_hd__and2_1
X_15475_ _06564_ _06473_ _06512_ _06515_ VGND VGND VPWR VPWR _06565_ sky130_fd_sc_hd__a22o_1
XFILLER_0_21_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12687_ net200 _03278_ _03525_ VGND VGND VPWR VPWR _03526_ sky130_fd_sc_hd__and3_1
XFILLER_0_127_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17214_ _07777_ _08477_ VGND VGND VPWR VPWR _08478_ sky130_fd_sc_hd__xnor2_1
X_14426_ _05409_ _05410_ VGND VGND VPWR VPWR _05411_ sky130_fd_sc_hd__nand2_1
X_11638_ _01562_ net175 VGND VGND VPWR VPWR _02449_ sky130_fd_sc_hd__nor2_2
XFILLER_0_126_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17145_ _08305_ _08306_ _08303_ VGND VGND VPWR VPWR _08402_ sky130_fd_sc_hd__o21a_1
XFILLER_0_107_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14357_ _01505_ _05333_ VGND VGND VPWR VPWR _05335_ sky130_fd_sc_hd__or2_1
XFILLER_0_80_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11569_ _02374_ _02377_ _02379_ VGND VGND VPWR VPWR _02380_ sky130_fd_sc_hd__a21o_1
XFILLER_0_123_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13308_ _04179_ _04162_ VGND VGND VPWR VPWR _04181_ sky130_fd_sc_hd__and2b_1
X_17076_ _08315_ _08325_ VGND VGND VPWR VPWR _08326_ sky130_fd_sc_hd__nand2_1
X_14288_ _05256_ _05258_ VGND VGND VPWR VPWR _05259_ sky130_fd_sc_hd__xnor2_1
X_16027_ _07166_ _07171_ VGND VGND VPWR VPWR _07172_ sky130_fd_sc_hd__xnor2_1
X_13239_ net183 _04004_ VGND VGND VPWR VPWR _04105_ sky130_fd_sc_hd__nand2_1
X_08780_ net51 _03553_ _03586_ net359 VGND VGND VPWR VPWR _00067_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_127_Right_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16929_ _08161_ _08163_ _08159_ VGND VGND VPWR VPWR _08164_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09401_ _00154_ _00211_ VGND VGND VPWR VPWR _00212_ sky130_fd_sc_hd__or2_1
XFILLER_0_1_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09332_ _05440_ _08690_ VGND VGND VPWR VPWR _08696_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09263_ _08541_ _08547_ _08626_ VGND VGND VPWR VPWR _08627_ sky130_fd_sc_hd__and3_1
XFILLER_0_62_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09194_ net332 _04780_ _08157_ _08168_ VGND VGND VPWR VPWR _08179_ sky130_fd_sc_hd__a31o_1
XFILLER_0_7_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08978_ _05704_ _05781_ VGND VGND VPWR VPWR _05803_ sky130_fd_sc_hd__nand2_1
Xhold45 net79 VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10940_ _01747_ _01748_ _01750_ VGND VGND VPWR VPWR _01751_ sky130_fd_sc_hd__or3_1
XFILLER_0_98_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10871_ _01665_ _01681_ VGND VGND VPWR VPWR _01682_ sky130_fd_sc_hd__xnor2_1
Xclkbuf_4_1_0_clock clknet_0_clock VGND VGND VPWR VPWR clknet_4_1_0_clock sky130_fd_sc_hd__clkbuf_8
X_12610_ _03445_ _03448_ VGND VGND VPWR VPWR _03449_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13590_ _04489_ _04490_ VGND VGND VPWR VPWR _04491_ sky130_fd_sc_hd__or2b_1
XFILLER_0_94_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12541_ _03370_ _03379_ VGND VGND VPWR VPWR _03380_ sky130_fd_sc_hd__and2_1
XFILLER_0_93_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15260_ _06197_ _06196_ VGND VGND VPWR VPWR _06328_ sky130_fd_sc_hd__and2b_1
X_12472_ prev_error\[14\] _03305_ VGND VGND VPWR VPWR _03306_ sky130_fd_sc_hd__nand2_2
X_14211_ _04731_ _05172_ _05173_ VGND VGND VPWR VPWR _05174_ sky130_fd_sc_hd__a21o_2
XFILLER_0_105_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11423_ _02232_ _02233_ VGND VGND VPWR VPWR _02234_ sky130_fd_sc_hd__nand2_1
X_15191_ _06214_ _06251_ VGND VGND VPWR VPWR _06252_ sky130_fd_sc_hd__xor2_2
XFILLER_0_34_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_9 _05596_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14142_ _05096_ _05097_ VGND VGND VPWR VPWR _05098_ sky130_fd_sc_hd__nand2_1
X_11354_ _02074_ _02164_ VGND VGND VPWR VPWR _02165_ sky130_fd_sc_hd__nor2_1
X_10305_ _01113_ _01114_ _01115_ VGND VGND VPWR VPWR _01116_ sky130_fd_sc_hd__o21ai_1
X_11285_ net387 net164 VGND VGND VPWR VPWR _02096_ sky130_fd_sc_hd__and2_1
X_14073_ net239 _03792_ _04986_ VGND VGND VPWR VPWR _05023_ sky130_fd_sc_hd__a21oi_1
X_10236_ _01042_ _01046_ VGND VGND VPWR VPWR _01047_ sky130_fd_sc_hd__and2b_1
X_13024_ _03842_ _03866_ VGND VGND VPWR VPWR _03869_ sky130_fd_sc_hd__nor2_1
X_10167_ _00976_ _00977_ VGND VGND VPWR VPWR _00978_ sky130_fd_sc_hd__and2_1
X_10098_ net345 _08676_ VGND VGND VPWR VPWR _00909_ sky130_fd_sc_hd__nand2_1
X_14975_ _03191_ _05569_ VGND VGND VPWR VPWR _06015_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_16_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16714_ net254 _05697_ VGND VGND VPWR VPWR _07928_ sky130_fd_sc_hd__nand2_1
X_13926_ _04853_ _04854_ VGND VGND VPWR VPWR _04861_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_88_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16645_ _07829_ _07831_ _07846_ _07850_ VGND VGND VPWR VPWR _07852_ sky130_fd_sc_hd__o22a_1
X_13857_ _04751_ _04761_ VGND VGND VPWR VPWR _04785_ sky130_fd_sc_hd__and2_1
XFILLER_0_97_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12808_ _03650_ _03651_ VGND VGND VPWR VPWR _03652_ sky130_fd_sc_hd__nor2_1
X_16576_ _07770_ _07773_ _07775_ VGND VGND VPWR VPWR _07776_ sky130_fd_sc_hd__and3_1
XFILLER_0_69_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13788_ _04616_ _04708_ VGND VGND VPWR VPWR _04709_ sky130_fd_sc_hd__xnor2_1
X_15527_ _06559_ _06554_ VGND VGND VPWR VPWR _06622_ sky130_fd_sc_hd__and2b_1
XFILLER_0_84_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12739_ _03270_ net177 _03581_ _03244_ VGND VGND VPWR VPWR _03582_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_120_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15458_ _06544_ _06524_ VGND VGND VPWR VPWR _06546_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_127_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14409_ _05390_ _05391_ VGND VGND VPWR VPWR _05392_ sky130_fd_sc_hd__nor2_1
XFILLER_0_108_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15389_ _06469_ _06382_ _06385_ VGND VGND VPWR VPWR _06470_ sky130_fd_sc_hd__and3_1
XFILLER_0_142_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17128_ _08276_ _08259_ VGND VGND VPWR VPWR _08383_ sky130_fd_sc_hd__and2b_1
XFILLER_0_13_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17059_ _08305_ _08306_ VGND VGND VPWR VPWR _08307_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_40_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09950_ net343 net338 _08680_ _08675_ VGND VGND VPWR VPWR _00761_ sky130_fd_sc_hd__and4_1
XFILLER_0_110_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08901_ net63 net8 VGND VGND VPWR VPWR _04956_ sky130_fd_sc_hd__or2b_2
X_09881_ _00658_ _00691_ VGND VGND VPWR VPWR _00692_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_148_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08832_ _04175_ _04186_ VGND VGND VPWR VPWR _04197_ sky130_fd_sc_hd__nor2_4
X_08763_ net40 _03307_ _03340_ net268 VGND VGND VPWR VPWR _00038_ sky130_fd_sc_hd__a22o_1
XFILLER_0_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09315_ _08635_ _08634_ VGND VGND VPWR VPWR _08679_ sky130_fd_sc_hd__and2_4
XFILLER_0_8_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09246_ _08608_ _08609_ VGND VGND VPWR VPWR _08610_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09177_ _07959_ _07970_ _07981_ VGND VGND VPWR VPWR _07992_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_44_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11070_ _01879_ _01877_ VGND VGND VPWR VPWR _01881_ sky130_fd_sc_hd__xnor2_1
Xoutput79 net79 VGND VGND VPWR VPWR out_clocked[12] sky130_fd_sc_hd__clkbuf_4
X_10021_ _00831_ _00747_ VGND VGND VPWR VPWR _00832_ sky130_fd_sc_hd__xnor2_1
X_14760_ _05772_ _05777_ VGND VGND VPWR VPWR _05778_ sky130_fd_sc_hd__xor2_1
X_11972_ _02752_ _02782_ VGND VGND VPWR VPWR _02783_ sky130_fd_sc_hd__or2_1
X_13711_ net242 _03233_ _04623_ _04621_ VGND VGND VPWR VPWR _04624_ sky130_fd_sc_hd__a31o_1
XFILLER_0_98_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10923_ _01732_ _01733_ net401 net126 VGND VGND VPWR VPWR _01734_ sky130_fd_sc_hd__and4bb_1
X_14691_ _05701_ VGND VGND VPWR VPWR _05702_ sky130_fd_sc_hd__buf_6
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16430_ _06975_ _07614_ VGND VGND VPWR VPWR _07615_ sky130_fd_sc_hd__xnor2_1
X_13642_ _04468_ _04536_ _04547_ VGND VGND VPWR VPWR _04548_ sky130_fd_sc_hd__and3_1
XFILLER_0_128_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10854_ _01663_ _01664_ VGND VGND VPWR VPWR _01665_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16361_ net254 _05801_ _07538_ VGND VGND VPWR VPWR _07539_ sky130_fd_sc_hd__and3_1
X_13573_ _04380_ _04459_ _04469_ VGND VGND VPWR VPWR _04473_ sky130_fd_sc_hd__a21oi_1
X_10785_ net134 _01594_ _01595_ prev_d_error\[17\] VGND VGND VPWR VPWR _01596_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_39_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15312_ _06383_ _06384_ VGND VGND VPWR VPWR _06385_ sky130_fd_sc_hd__nor2_1
X_12524_ _03358_ _03362_ VGND VGND VPWR VPWR _03363_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_82_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16292_ _07295_ _07454_ VGND VGND VPWR VPWR _07463_ sky130_fd_sc_hd__nand2_1
XFILLER_0_93_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15243_ net288 _05736_ _06307_ _06308_ VGND VGND VPWR VPWR _06310_ sky130_fd_sc_hd__nand4_2
X_12455_ _03217_ VGND VGND VPWR VPWR _03288_ sky130_fd_sc_hd__buf_2
XFILLER_0_62_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11406_ _02123_ _02122_ VGND VGND VPWR VPWR _02217_ sky130_fd_sc_hd__xnor2_1
X_15174_ net273 _05621_ VGND VGND VPWR VPWR _06234_ sky130_fd_sc_hd__nand2_1
X_12386_ prev_error\[13\] _04736_ VGND VGND VPWR VPWR _03218_ sky130_fd_sc_hd__xnor2_4
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14125_ _05049_ _05075_ VGND VGND VPWR VPWR _05080_ sky130_fd_sc_hd__or2b_1
XFILLER_0_22_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11337_ net419 net123 _02147_ _02050_ VGND VGND VPWR VPWR _02148_ sky130_fd_sc_hd__a31o_1
X_14056_ _04926_ _05003_ _04931_ VGND VGND VPWR VPWR _05004_ sky130_fd_sc_hd__a21oi_1
X_11268_ _02077_ _02078_ VGND VGND VPWR VPWR _02079_ sky130_fd_sc_hd__nor2_1
X_13007_ _03429_ _03850_ VGND VGND VPWR VPWR _03851_ sky130_fd_sc_hd__xnor2_1
X_10219_ _01027_ _01028_ _01029_ VGND VGND VPWR VPWR _01030_ sky130_fd_sc_hd__nand3_1
X_11199_ _02000_ _02007_ _02009_ VGND VGND VPWR VPWR _02010_ sky130_fd_sc_hd__a21o_1
XFILLER_0_27_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14958_ _05993_ _05994_ _05995_ VGND VGND VPWR VPWR _05996_ sky130_fd_sc_hd__or3_2
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13909_ net197 _04317_ VGND VGND VPWR VPWR _04842_ sky130_fd_sc_hd__nand2_1
X_14889_ net284 net281 _05710_ _05702_ VGND VGND VPWR VPWR _05920_ sky130_fd_sc_hd__and4_1
XFILLER_0_58_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16628_ _07818_ _07819_ VGND VGND VPWR VPWR _07833_ sky130_fd_sc_hd__nor2_1
XFILLER_0_134_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16559_ _05458_ _07756_ VGND VGND VPWR VPWR _07757_ sky130_fd_sc_hd__or2_1
X_09100_ _07123_ _07134_ VGND VGND VPWR VPWR _07145_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09031_ _06364_ _06375_ VGND VGND VPWR VPWR _06386_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09933_ _00730_ _00743_ VGND VGND VPWR VPWR _00744_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09864_ _00585_ _00587_ VGND VGND VPWR VPWR _00675_ sky130_fd_sc_hd__xor2_1
X_08815_ _03977_ _03988_ _03999_ VGND VGND VPWR VPWR _04010_ sky130_fd_sc_hd__a21o_1
X_09795_ _00482_ _00501_ VGND VGND VPWR VPWR _00606_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_99_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08746_ _03285_ VGND VGND VPWR VPWR _03296_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_48_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10570_ _01357_ _01358_ VGND VGND VPWR VPWR _01381_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09229_ _08245_ _08399_ _08421_ VGND VGND VPWR VPWR _08541_ sky130_fd_sc_hd__or3_1
XFILLER_0_106_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12240_ _03057_ _03068_ VGND VGND VPWR VPWR _03069_ sky130_fd_sc_hd__or2_1
XFILLER_0_121_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12171_ _02953_ _02974_ _02988_ _02992_ _02995_ VGND VGND VPWR VPWR _02996_ sky130_fd_sc_hd__a32o_1
XFILLER_0_114_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11122_ _01929_ _01931_ _01932_ VGND VGND VPWR VPWR _01933_ sky130_fd_sc_hd__nor3_1
X_15930_ _05618_ _05619_ _07064_ net292 VGND VGND VPWR VPWR _07065_ sky130_fd_sc_hd__o211a_1
X_11053_ prev_d_error\[8\] net123 VGND VGND VPWR VPWR _01864_ sky130_fd_sc_hd__nand2_1
X_10004_ _00813_ _00808_ _00812_ VGND VGND VPWR VPWR _00815_ sky130_fd_sc_hd__or3_1
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15861_ _06520_ _06988_ VGND VGND VPWR VPWR _06989_ sky130_fd_sc_hd__xnor2_2
X_14812_ _05813_ _05819_ _05834_ VGND VGND VPWR VPWR _05835_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_99_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15792_ _06843_ _06853_ VGND VGND VPWR VPWR _06913_ sky130_fd_sc_hd__xor2_1
XFILLER_0_59_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17531_ clknet_4_7_0_clock _00020_ VGND VGND VPWR VPWR kd_2\[11\] sky130_fd_sc_hd__dfxtp_1
X_14743_ net273 net269 _05738_ _05724_ VGND VGND VPWR VPWR _05760_ sky130_fd_sc_hd__and4_1
XFILLER_0_59_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11955_ _02763_ _02765_ VGND VGND VPWR VPWR _02766_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17462_ clknet_4_13_0_clock _00140_ VGND VGND VPWR VPWR prev_d_error\[14\] sky130_fd_sc_hd__dfxtp_1
X_10906_ _01524_ _01529_ VGND VGND VPWR VPWR _01717_ sky130_fd_sc_hd__nand2_1
X_14674_ _05674_ net102 _05680_ _05683_ VGND VGND VPWR VPWR _05684_ sky130_fd_sc_hd__a211o_4
X_11886_ _02659_ _02657_ VGND VGND VPWR VPWR _02697_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_129_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16413_ i_error\[11\] _07578_ VGND VGND VPWR VPWR _07597_ sky130_fd_sc_hd__xnor2_1
X_13625_ _04446_ _04529_ VGND VGND VPWR VPWR _04530_ sky130_fd_sc_hd__nor2_1
X_17393_ prev_d_error\[17\] net469 net458 _08602_ VGND VGND VPWR VPWR _00143_ sky130_fd_sc_hd__o211a_1
X_10837_ _01505_ _01647_ VGND VGND VPWR VPWR _01648_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_104_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16344_ _07516_ _07520_ VGND VGND VPWR VPWR _07521_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_125_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13556_ _04366_ _04390_ VGND VGND VPWR VPWR _04454_ sky130_fd_sc_hd__xnor2_2
X_10768_ net394 net397 net129 net128 VGND VGND VPWR VPWR _01579_ sky130_fd_sc_hd__and4_1
XFILLER_0_27_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12507_ _03344_ VGND VGND VPWR VPWR _03345_ sky130_fd_sc_hd__clkbuf_4
X_16275_ _07444_ _07440_ VGND VGND VPWR VPWR _07445_ sky130_fd_sc_hd__xnor2_1
X_13487_ _04326_ _04327_ _03365_ _04029_ VGND VGND VPWR VPWR _04378_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_81_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10699_ _01507_ _01509_ VGND VGND VPWR VPWR _01510_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_35_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15226_ _06182_ _06290_ VGND VGND VPWR VPWR _06291_ sky130_fd_sc_hd__and2_1
XFILLER_0_125_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12438_ _03269_ VGND VGND VPWR VPWR _03270_ sky130_fd_sc_hd__buf_2
XFILLER_0_23_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15157_ net280 _05746_ VGND VGND VPWR VPWR _06215_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12369_ prev_error\[2\] _00557_ VGND VGND VPWR VPWR _03201_ sky130_fd_sc_hd__nor2_1
X_14108_ net240 _04002_ _05058_ _05060_ VGND VGND VPWR VPWR _05061_ sky130_fd_sc_hd__a31o_1
XFILLER_0_129_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15088_ _06130_ _06135_ VGND VGND VPWR VPWR _06139_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14039_ net238 _03934_ _04002_ net230 VGND VGND VPWR VPWR _04985_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_38_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09580_ _00278_ _00389_ _00390_ VGND VGND VPWR VPWR _00391_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_145_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09014_ _05825_ _06023_ _06177_ VGND VGND VPWR VPWR _06199_ sky130_fd_sc_hd__and3_1
XFILLER_0_116_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09916_ _00640_ _00723_ _00726_ VGND VGND VPWR VPWR _00727_ sky130_fd_sc_hd__nand3_2
XFILLER_0_95_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09847_ _00641_ _00649_ _00657_ VGND VGND VPWR VPWR _00658_ sky130_fd_sc_hd__and3_1
X_09778_ net347 _07409_ _00401_ _00588_ VGND VGND VPWR VPWR _00589_ sky130_fd_sc_hd__a31o_1
XFILLER_0_68_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08729_ net48 _03061_ _03094_ net238 VGND VGND VPWR VPWR _00010_ sky130_fd_sc_hd__a22o_1
XFILLER_0_96_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11740_ _02443_ _02445_ VGND VGND VPWR VPWR _02551_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11671_ _02391_ _02452_ _02480_ VGND VGND VPWR VPWR _02482_ sky130_fd_sc_hd__o21bai_1
X_13410_ _04291_ _04283_ _04290_ VGND VGND VPWR VPWR _04293_ sky130_fd_sc_hd__and3_1
X_10622_ _00639_ _00727_ _01430_ _01432_ VGND VGND VPWR VPWR _01433_ sky130_fd_sc_hd__a31o_4
X_14390_ _03481_ _03486_ _05370_ VGND VGND VPWR VPWR _05371_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_64_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13341_ net202 _03576_ VGND VGND VPWR VPWR _04217_ sky130_fd_sc_hd__and2_1
X_10553_ _01360_ _01363_ VGND VGND VPWR VPWR _01364_ sky130_fd_sc_hd__and2b_1
XFILLER_0_107_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16060_ _07206_ _07207_ VGND VGND VPWR VPWR _07208_ sky130_fd_sc_hd__nor2_1
X_13272_ net209 _03260_ _03269_ net203 VGND VGND VPWR VPWR _04141_ sky130_fd_sc_hd__a22oi_1
X_10484_ _01293_ _01294_ VGND VGND VPWR VPWR _01295_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_122_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15011_ _05965_ _05964_ VGND VGND VPWR VPWR _06054_ sky130_fd_sc_hd__or2b_2
XFILLER_0_20_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12223_ _03043_ _03046_ VGND VGND VPWR VPWR _03051_ sky130_fd_sc_hd__xor2_1
XFILLER_0_102_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12154_ _02977_ _02978_ VGND VGND VPWR VPWR _02979_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_20_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11105_ _01860_ _01915_ VGND VGND VPWR VPWR _01916_ sky130_fd_sc_hd__or2_1
X_16962_ net475 _07971_ VGND VGND VPWR VPWR _08200_ sky130_fd_sc_hd__nor2_1
X_12085_ _02906_ _02907_ VGND VGND VPWR VPWR _02908_ sky130_fd_sc_hd__nor2_1
X_15913_ _07042_ _07043_ VGND VGND VPWR VPWR _07047_ sky130_fd_sc_hd__xnor2_2
X_11036_ _01841_ _01846_ VGND VGND VPWR VPWR _01847_ sky130_fd_sc_hd__nor2_1
X_16893_ _08118_ _08122_ VGND VGND VPWR VPWR _08125_ sky130_fd_sc_hd__nor2b_1
X_15844_ _06891_ _06889_ VGND VGND VPWR VPWR _06971_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_91_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15775_ _06888_ _06893_ _06765_ _06894_ VGND VGND VPWR VPWR _06895_ sky130_fd_sc_hd__a211o_1
XFILLER_0_87_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12987_ _03743_ _03742_ VGND VGND VPWR VPWR _03831_ sky130_fd_sc_hd__and2b_1
XFILLER_0_24_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14726_ net265 _05739_ _05740_ VGND VGND VPWR VPWR _05741_ sky130_fd_sc_hd__and3_1
X_17514_ clknet_4_5_0_clock _00003_ VGND VGND VPWR VPWR kd_1\[12\] sky130_fd_sc_hd__dfxtp_1
X_11938_ net400 net174 _02748_ VGND VGND VPWR VPWR _02749_ sky130_fd_sc_hd__nand3_1
XFILLER_0_115_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17445_ clknet_4_8_0_clock _00123_ VGND VGND VPWR VPWR i_error\[15\] sky130_fd_sc_hd__dfxtp_1
X_14657_ _05664_ VGND VGND VPWR VPWR _05665_ sky130_fd_sc_hd__clkbuf_4
X_11869_ _02550_ _02679_ VGND VGND VPWR VPWR _02680_ sky130_fd_sc_hd__or2_1
XFILLER_0_129_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13608_ net197 _03936_ VGND VGND VPWR VPWR _04511_ sky130_fd_sc_hd__nand2_1
X_17376_ net467 _08165_ VGND VGND VPWR VPWR _08593_ sky130_fd_sc_hd__nand2_1
XFILLER_0_54_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14588_ _05588_ VGND VGND VPWR VPWR _05589_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_144_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16327_ _06299_ _06404_ _07499_ _07500_ _07501_ VGND VGND VPWR VPWR _07502_ sky130_fd_sc_hd__a311o_2
XFILLER_0_43_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13539_ _04299_ _04323_ VGND VGND VPWR VPWR _04435_ sky130_fd_sc_hd__and2_1
XFILLER_0_70_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16258_ net307 _06205_ _07381_ VGND VGND VPWR VPWR _07426_ sky130_fd_sc_hd__a21oi_1
X_15209_ _06268_ _06271_ VGND VGND VPWR VPWR _06272_ sky130_fd_sc_hd__xor2_2
XFILLER_0_23_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16189_ net291 _06415_ _07347_ _07348_ VGND VGND VPWR VPWR _07350_ sky130_fd_sc_hd__a22o_1
XFILLER_0_11_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09701_ _00508_ _00510_ VGND VGND VPWR VPWR _00512_ sky130_fd_sc_hd__or2_1
X_09632_ _00421_ _00441_ _00442_ VGND VGND VPWR VPWR _00443_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_78_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09563_ _04549_ _00373_ VGND VGND VPWR VPWR _00374_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09494_ net323 _08682_ _00303_ _00304_ VGND VGND VPWR VPWR _00305_ sky130_fd_sc_hd__a31o_1
XFILLER_0_148_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_880 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout430 net431 VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__buf_2
Xfanout441 prev_d_error\[2\] VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__buf_2
Xfanout452 net459 VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__clkbuf_4
Xfanout463 net464 VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__buf_2
X_12910_ net181 _03578_ _03669_ net176 VGND VGND VPWR VPWR _03754_ sky130_fd_sc_hd__a22oi_1
X_13890_ _04804_ _04820_ VGND VGND VPWR VPWR _04821_ sky130_fd_sc_hd__and2_1
X_12841_ _03675_ _03679_ _03677_ VGND VGND VPWR VPWR _03685_ sky130_fd_sc_hd__a21o_1
X_15560_ _06653_ _06656_ VGND VGND VPWR VPWR _06658_ sky130_fd_sc_hd__nor2_1
XFILLER_0_69_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12772_ _03557_ _03615_ VGND VGND VPWR VPWR _03616_ sky130_fd_sc_hd__or2_1
X_14511_ _06364_ _05503_ VGND VGND VPWR VPWR _05504_ sky130_fd_sc_hd__xnor2_1
X_11723_ _02430_ _02533_ VGND VGND VPWR VPWR _02534_ sky130_fd_sc_hd__or2_1
X_15491_ _06548_ _06556_ _06555_ _06558_ VGND VGND VPWR VPWR _06582_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_83_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17230_ _08494_ VGND VGND VPWR VPWR _08495_ sky130_fd_sc_hd__buf_4
X_14442_ _00270_ _01442_ VGND VGND VPWR VPWR _05428_ sky130_fd_sc_hd__xor2_4
X_11654_ _02463_ _02406_ _02464_ VGND VGND VPWR VPWR _02465_ sky130_fd_sc_hd__or3_1
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17161_ _08257_ _08299_ _08297_ VGND VGND VPWR VPWR _08419_ sky130_fd_sc_hd__a21oi_1
X_10605_ _01203_ _01242_ _01409_ _01414_ _01415_ VGND VGND VPWR VPWR _01416_ sky130_fd_sc_hd__a221o_1
X_14373_ _01709_ _05306_ _05350_ VGND VGND VPWR VPWR _05353_ sky130_fd_sc_hd__or3_1
XFILLER_0_4_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11585_ _02393_ _02395_ VGND VGND VPWR VPWR _02396_ sky130_fd_sc_hd__or2_1
XFILLER_0_141_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16112_ net301 _06160_ _07184_ VGND VGND VPWR VPWR _07265_ sky130_fd_sc_hd__nand3_1
X_13324_ _04196_ _04198_ VGND VGND VPWR VPWR _04199_ sky130_fd_sc_hd__xor2_4
X_10536_ _01345_ _01346_ VGND VGND VPWR VPWR _01347_ sky130_fd_sc_hd__or2b_1
X_17092_ _08341_ _08342_ VGND VGND VPWR VPWR _08343_ sky130_fd_sc_hd__nor2_1
XFILLER_0_107_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16043_ net306 _05602_ _07129_ _07130_ VGND VGND VPWR VPWR _07190_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_108_Right_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13255_ _04030_ _04122_ VGND VGND VPWR VPWR _04123_ sky130_fd_sc_hd__xor2_1
X_10467_ _01221_ _01232_ _01231_ VGND VGND VPWR VPWR _01278_ sky130_fd_sc_hd__o21a_1
X_12206_ _03011_ _03031_ VGND VGND VPWR VPWR _03032_ sky130_fd_sc_hd__xnor2_2
X_13186_ net186 _03669_ _03924_ VGND VGND VPWR VPWR _04047_ sky130_fd_sc_hd__a21oi_1
X_10398_ net358 _00315_ VGND VGND VPWR VPWR _01209_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12137_ _02915_ _02961_ VGND VGND VPWR VPWR _02962_ sky130_fd_sc_hd__nand2_1
X_16945_ _05463_ _08181_ VGND VGND VPWR VPWR _08182_ sky130_fd_sc_hd__and2b_1
X_12068_ _02887_ VGND VGND VPWR VPWR _02889_ sky130_fd_sc_hd__inv_2
X_11019_ _01764_ _01829_ VGND VGND VPWR VPWR _01830_ sky130_fd_sc_hd__nor2_1
X_16876_ _08071_ _08072_ VGND VGND VPWR VPWR _08106_ sky130_fd_sc_hd__and2_1
XFILLER_0_126_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15827_ _06911_ _06951_ VGND VGND VPWR VPWR _06952_ sky130_fd_sc_hd__and2_1
XFILLER_0_150_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15758_ _06869_ _06875_ VGND VGND VPWR VPWR _06876_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14709_ _03331_ _05719_ _05720_ VGND VGND VPWR VPWR _05722_ sky130_fd_sc_hd__nand3_4
X_15689_ _06468_ _06503_ VGND VGND VPWR VPWR _06800_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_28_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17428_ clknet_4_2_0_clock _00106_ VGND VGND VPWR VPWR prev_error\[16\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17359_ net465 net446 net458 _08582_ VGND VGND VPWR VPWR _00126_ sky130_fd_sc_hd__o211a_1
XFILLER_0_27_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08994_ _05055_ _05044_ VGND VGND VPWR VPWR _05979_ sky130_fd_sc_hd__and2b_1
X_09615_ _06705_ _05429_ _00383_ VGND VGND VPWR VPWR _00426_ sky130_fd_sc_hd__o21a_1
XFILLER_0_92_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09546_ _00331_ _00355_ VGND VGND VPWR VPWR _00357_ sky130_fd_sc_hd__and2b_1
XFILLER_0_78_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09477_ net337 _04615_ _00215_ VGND VGND VPWR VPWR _00288_ sky130_fd_sc_hd__and3_1
XFILLER_0_38_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_124_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11370_ _02059_ _02060_ VGND VGND VPWR VPWR _02181_ sky130_fd_sc_hd__and2_1
XFILLER_0_61_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10321_ _01064_ _01131_ VGND VGND VPWR VPWR _01132_ sky130_fd_sc_hd__nor2_1
X_13040_ _03884_ _03885_ _03367_ _03328_ VGND VGND VPWR VPWR _03886_ sky130_fd_sc_hd__a2bb2o_1
X_10252_ _01061_ _01062_ VGND VGND VPWR VPWR _01063_ sky130_fd_sc_hd__nor2_1
X_10183_ net334 _00519_ _00993_ VGND VGND VPWR VPWR _00994_ sky130_fd_sc_hd__and3_1
X_14991_ _06030_ _06029_ VGND VGND VPWR VPWR _06032_ sky130_fd_sc_hd__xor2_2
Xfanout260 ki\[13\] VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__clkbuf_4
Xfanout271 net272 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__clkbuf_4
Xfanout282 net283 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__clkbuf_4
X_16730_ _07864_ _07877_ _07944_ VGND VGND VPWR VPWR _07945_ sky130_fd_sc_hd__a21o_1
X_13942_ _04871_ _04877_ VGND VGND VPWR VPWR _04878_ sky130_fd_sc_hd__or2_1
Xfanout293 net295 VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__buf_2
X_16661_ net251 _05711_ VGND VGND VPWR VPWR _07869_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13873_ _04786_ _04787_ VGND VGND VPWR VPWR _04803_ sky130_fd_sc_hd__xnor2_1
X_15612_ _06418_ _06714_ VGND VGND VPWR VPWR _06715_ sky130_fd_sc_hd__xnor2_1
X_12824_ _03667_ VGND VGND VPWR VPWR _03668_ sky130_fd_sc_hd__clkbuf_4
X_16592_ _05438_ _05439_ _07785_ VGND VGND VPWR VPWR _07793_ sky130_fd_sc_hd__or3_1
XFILLER_0_57_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15543_ _06624_ _06638_ VGND VGND VPWR VPWR _06640_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12755_ _03475_ _03474_ VGND VGND VPWR VPWR _03599_ sky130_fd_sc_hd__and2b_1
X_11706_ _02507_ _02509_ _02515_ VGND VGND VPWR VPWR _02517_ sky130_fd_sc_hd__or3_1
XFILLER_0_127_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15474_ net300 _05626_ _05628_ VGND VGND VPWR VPWR _06564_ sky130_fd_sc_hd__and3_1
XFILLER_0_139_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12686_ _03523_ _03524_ VGND VGND VPWR VPWR _03525_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14425_ _05406_ _05408_ VGND VGND VPWR VPWR _05410_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17213_ _08100_ _08099_ VGND VGND VPWR VPWR _08477_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11637_ _02438_ _02447_ VGND VGND VPWR VPWR _02448_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_112_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17144_ _08381_ _08400_ VGND VGND VPWR VPWR _08401_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_141_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14356_ _01505_ _05333_ VGND VGND VPWR VPWR _05334_ sky130_fd_sc_hd__nand2_1
X_11568_ _02378_ _02375_ VGND VGND VPWR VPWR _02379_ sky130_fd_sc_hd__nor2_1
XFILLER_0_52_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13307_ _04162_ _04179_ VGND VGND VPWR VPWR _04180_ sky130_fd_sc_hd__xnor2_1
X_10519_ net371 VGND VGND VPWR VPWR _01330_ sky130_fd_sc_hd__inv_2
X_17075_ _08316_ _08324_ VGND VGND VPWR VPWR _08325_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_150_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14287_ _03150_ _05257_ VGND VGND VPWR VPWR _05258_ sky130_fd_sc_hd__xor2_2
XFILLER_0_0_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11499_ net435 net525 net124 net439 VGND VGND VPWR VPWR _02310_ sky130_fd_sc_hd__a22oi_1
X_16026_ _07169_ _07170_ VGND VGND VPWR VPWR _07171_ sky130_fd_sc_hd__xor2_1
X_13238_ _04006_ _04103_ VGND VGND VPWR VPWR _04104_ sky130_fd_sc_hd__and2_1
XFILLER_0_21_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13169_ _04024_ _04027_ VGND VGND VPWR VPWR _04028_ sky130_fd_sc_hd__nand2_1
XFILLER_0_137_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16928_ _08156_ _08162_ VGND VGND VPWR VPWR _08163_ sky130_fd_sc_hd__or2_1
XFILLER_0_79_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16859_ _08084_ _08085_ _08081_ VGND VGND VPWR VPWR _08087_ sky130_fd_sc_hd__a21oi_1
X_09400_ net332 _04527_ _00153_ VGND VGND VPWR VPWR _00211_ sky130_fd_sc_hd__a21oi_1
X_09331_ net344 _04934_ _08694_ _08692_ VGND VGND VPWR VPWR _08695_ sky130_fd_sc_hd__a31o_1
XFILLER_0_48_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09262_ _08554_ _08604_ _08625_ VGND VGND VPWR VPWR _08626_ sky130_fd_sc_hd__a21o_1
XFILLER_0_35_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09193_ net340 _05011_ _08146_ VGND VGND VPWR VPWR _08168_ sky130_fd_sc_hd__and3_1
XFILLER_0_16_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08977_ _05704_ _05781_ VGND VGND VPWR VPWR _05792_ sky130_fd_sc_hd__or2_1
Xhold46 i_error\[3\] VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10870_ _01679_ _01680_ VGND VGND VPWR VPWR _01681_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09529_ _05649_ _00339_ VGND VGND VPWR VPWR _00340_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12540_ _03377_ _03378_ VGND VGND VPWR VPWR _03379_ sky130_fd_sc_hd__and2_1
XFILLER_0_66_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12471_ _04879_ _04890_ VGND VGND VPWR VPWR _03305_ sky130_fd_sc_hd__nand2_2
XFILLER_0_136_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14210_ _04652_ _04730_ VGND VGND VPWR VPWR _05173_ sky130_fd_sc_hd__and2b_1
XFILLER_0_123_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11422_ _02221_ _02225_ VGND VGND VPWR VPWR _02233_ sky130_fd_sc_hd__xor2_1
X_15190_ _06249_ _06250_ VGND VGND VPWR VPWR _06251_ sky130_fd_sc_hd__nor2_1
XFILLER_0_123_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14141_ _05063_ _05072_ VGND VGND VPWR VPWR _05097_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_89_Left_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11353_ net403 net144 _02072_ _02073_ VGND VGND VPWR VPWR _02164_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_105_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10304_ _00827_ _01111_ VGND VGND VPWR VPWR _01115_ sky130_fd_sc_hd__nand2_1
X_14072_ net218 net521 _05020_ VGND VGND VPWR VPWR _05021_ sky130_fd_sc_hd__and3_2
XFILLER_0_132_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11284_ _02090_ _02092_ _02094_ VGND VGND VPWR VPWR _02095_ sky130_fd_sc_hd__o21ai_1
X_13023_ _03842_ _03866_ VGND VGND VPWR VPWR _03868_ sky130_fd_sc_hd__and2_1
X_10235_ net358 _01044_ _08681_ _01045_ VGND VGND VPWR VPWR _01046_ sky130_fd_sc_hd__a31o_1
X_10166_ _00971_ _00974_ _00975_ VGND VGND VPWR VPWR _00977_ sky130_fd_sc_hd__or3_1
X_14974_ net249 _05975_ VGND VGND VPWR VPWR _06014_ sky130_fd_sc_hd__nand2_1
X_10097_ net350 net523 VGND VGND VPWR VPWR _00908_ sky130_fd_sc_hd__nand2_1
X_16713_ _07546_ _07885_ _07683_ VGND VGND VPWR VPWR _07927_ sky130_fd_sc_hd__a21bo_1
X_13925_ _04796_ _04856_ _04852_ _04855_ VGND VGND VPWR VPWR _04860_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_16_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16644_ _07835_ _07840_ _07846_ _07850_ VGND VGND VPWR VPWR _07851_ sky130_fd_sc_hd__a22o_1
X_13856_ _04782_ _04783_ VGND VGND VPWR VPWR _04784_ sky130_fd_sc_hd__and2b_1
XFILLER_0_76_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12807_ _03616_ _03630_ VGND VGND VPWR VPWR _03651_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16575_ _05445_ _07774_ VGND VGND VPWR VPWR _07775_ sky130_fd_sc_hd__and2_1
X_13787_ _04619_ _04624_ VGND VGND VPWR VPWR _04708_ sky130_fd_sc_hd__xor2_1
XFILLER_0_32_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10999_ net391 net138 _01755_ _01756_ VGND VGND VPWR VPWR _01810_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_123_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15526_ _06611_ _06620_ VGND VGND VPWR VPWR _06621_ sky130_fd_sc_hd__or2_1
XFILLER_0_123_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12738_ net180 VGND VGND VPWR VPWR _03581_ sky130_fd_sc_hd__inv_2
XFILLER_0_139_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15457_ _06524_ _06544_ VGND VGND VPWR VPWR _06545_ sky130_fd_sc_hd__or2b_1
X_12669_ _03452_ _03506_ VGND VGND VPWR VPWR _03508_ sky130_fd_sc_hd__or2_1
XFILLER_0_25_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14408_ _03452_ _05389_ VGND VGND VPWR VPWR _05391_ sky130_fd_sc_hd__nor2_1
X_15388_ _06367_ _06381_ _06368_ VGND VGND VPWR VPWR _06469_ sky130_fd_sc_hd__nand3_1
XFILLER_0_40_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14339_ _05313_ _05314_ VGND VGND VPWR VPWR _05315_ sky130_fd_sc_hd__nor2_1
X_17127_ _03499_ _08284_ _05381_ VGND VGND VPWR VPWR _08382_ sky130_fd_sc_hd__o21ba_1
X_17058_ _05411_ _05412_ _05409_ VGND VGND VPWR VPWR _08306_ sky130_fd_sc_hd__o21a_2
XFILLER_0_150_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08900_ _04857_ _04703_ _04868_ _04835_ VGND VGND VPWR VPWR _04945_ sky130_fd_sc_hd__o31a_1
X_16009_ net278 _06206_ VGND VGND VPWR VPWR _07152_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09880_ _00689_ _00690_ VGND VGND VPWR VPWR _00691_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08831_ net69 net14 VGND VGND VPWR VPWR _04186_ sky130_fd_sc_hd__nor2b_1
X_08762_ net39 _03307_ _03340_ net272 VGND VGND VPWR VPWR _00037_ sky130_fd_sc_hd__a22o_1
XFILLER_0_79_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_843 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09314_ _04560_ _08677_ VGND VGND VPWR VPWR _08678_ sky130_fd_sc_hd__nor2_1
XFILLER_0_75_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09245_ _08605_ _08606_ _08607_ VGND VGND VPWR VPWR _08609_ sky130_fd_sc_hd__or3_1
XFILLER_0_8_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09176_ net318 net314 _07409_ _07332_ VGND VGND VPWR VPWR _07981_ sky130_fd_sc_hd__and4_1
XFILLER_0_71_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10020_ _00748_ _00746_ VGND VGND VPWR VPWR _00831_ sky130_fd_sc_hd__nor2_1
X_11971_ _02724_ _02781_ VGND VGND VPWR VPWR _02782_ sky130_fd_sc_hd__xnor2_1
X_13710_ _04621_ _04622_ VGND VGND VPWR VPWR _04623_ sky130_fd_sc_hd__and2b_1
X_10922_ net406 net121 net117 net413 VGND VGND VPWR VPWR _01733_ sky130_fd_sc_hd__a22oi_1
X_14690_ _03316_ _05686_ VGND VGND VPWR VPWR _05701_ sky130_fd_sc_hd__xor2_4
X_13641_ _04537_ _04539_ _04546_ _04545_ _04542_ VGND VGND VPWR VPWR _04547_ sky130_fd_sc_hd__a32o_1
X_10853_ _01635_ _01648_ VGND VGND VPWR VPWR _01664_ sky130_fd_sc_hd__and2b_1
X_16360_ _07536_ _07537_ VGND VGND VPWR VPWR _07538_ sky130_fd_sc_hd__nor2_1
XFILLER_0_66_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13572_ _04414_ _04413_ VGND VGND VPWR VPWR _04471_ sky130_fd_sc_hd__xor2_1
XFILLER_0_67_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10784_ net381 net129 net125 net385 VGND VGND VPWR VPWR _01595_ sky130_fd_sc_hd__a22o_1
XFILLER_0_93_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15311_ _06314_ _06313_ _06306_ VGND VGND VPWR VPWR _06384_ sky130_fd_sc_hd__a21oi_1
X_12523_ _03360_ _03361_ VGND VGND VPWR VPWR _03362_ sky130_fd_sc_hd__nor2_1
XFILLER_0_81_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16291_ _07450_ _07461_ net310 _06349_ VGND VGND VPWR VPWR _07462_ sky130_fd_sc_hd__and4b_1
X_15242_ net293 _05723_ _06103_ VGND VGND VPWR VPWR _06308_ sky130_fd_sc_hd__a21o_1
X_12454_ net195 net190 _03278_ _03286_ VGND VGND VPWR VPWR _03287_ sky130_fd_sc_hd__and4_1
XFILLER_0_81_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_124_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11405_ _02214_ _02215_ VGND VGND VPWR VPWR _02216_ sky130_fd_sc_hd__and2b_1
X_15173_ net266 _05590_ VGND VGND VPWR VPWR _06233_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12385_ _03216_ VGND VGND VPWR VPWR _03217_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_34_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14124_ _05015_ _05078_ VGND VGND VPWR VPWR _05079_ sky130_fd_sc_hd__nand2_1
X_11336_ net423 net128 VGND VGND VPWR VPWR _02147_ sky130_fd_sc_hd__and2_1
XFILLER_0_104_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14055_ net215 net521 VGND VGND VPWR VPWR _05003_ sky130_fd_sc_hd__nand2_1
XFILLER_0_120_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11267_ _02076_ _02072_ _02074_ VGND VGND VPWR VPWR _02078_ sky130_fd_sc_hd__nor3_1
XFILLER_0_120_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13006_ net230 _03422_ _03430_ VGND VGND VPWR VPWR _03850_ sky130_fd_sc_hd__a21o_1
X_10218_ _00950_ _01026_ _01020_ _01025_ VGND VGND VPWR VPWR _01029_ sky130_fd_sc_hd__a211o_1
X_11198_ _01903_ _02008_ VGND VGND VPWR VPWR _02009_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10149_ _00930_ _00959_ VGND VGND VPWR VPWR _00960_ sky130_fd_sc_hd__nor2_2
XFILLER_0_89_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14957_ _05919_ _05960_ VGND VGND VPWR VPWR _05995_ sky130_fd_sc_hd__xnor2_2
X_13908_ _04838_ _04840_ VGND VGND VPWR VPWR _04841_ sky130_fd_sc_hd__xor2_1
X_14888_ _05907_ _05908_ VGND VGND VPWR VPWR _05919_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_134_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16627_ _07823_ _07828_ _07829_ _07831_ VGND VGND VPWR VPWR _07832_ sky130_fd_sc_hd__a2bb2o_2
XFILLER_0_43_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13839_ _03573_ _03574_ _03961_ VGND VGND VPWR VPWR _04765_ sky130_fd_sc_hd__a21o_1
XFILLER_0_147_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16558_ _07755_ _05457_ VGND VGND VPWR VPWR _07756_ sky130_fd_sc_hd__and2b_1
XFILLER_0_57_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15509_ _06598_ _06599_ _06601_ VGND VGND VPWR VPWR _06602_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_73_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16489_ _07678_ _07679_ VGND VGND VPWR VPWR _07680_ sky130_fd_sc_hd__and2_1
X_09030_ _06001_ _06012_ VGND VGND VPWR VPWR _06375_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_26_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09932_ _00735_ _00742_ VGND VGND VPWR VPWR _00743_ sky130_fd_sc_hd__or2b_4
XFILLER_0_110_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09863_ _00672_ _00673_ VGND VGND VPWR VPWR _00674_ sky130_fd_sc_hd__or2b_1
X_08814_ net74 net19 VGND VGND VPWR VPWR _03999_ sky130_fd_sc_hd__and2b_1
X_09794_ _00566_ _00604_ VGND VGND VPWR VPWR _00605_ sky130_fd_sc_hd__xnor2_1
X_08745_ net29 _02795_ _02828_ VGND VGND VPWR VPWR _03285_ sky130_fd_sc_hd__or3_2
XFILLER_0_49_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09228_ _08529_ VGND VGND VPWR VPWR _08535_ sky130_fd_sc_hd__inv_2
XFILLER_0_134_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09159_ net330 _04516_ VGND VGND VPWR VPWR _07794_ sky130_fd_sc_hd__and2_1
XFILLER_0_32_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12170_ _02994_ VGND VGND VPWR VPWR _02995_ sky130_fd_sc_hd__inv_2
XFILLER_0_31_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11121_ _01822_ _01928_ _01923_ _01927_ VGND VGND VPWR VPWR _01932_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_101_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11052_ _01460_ _01860_ _01862_ VGND VGND VPWR VPWR _01863_ sky130_fd_sc_hd__o21ai_2
X_10003_ _00808_ _00812_ _00813_ VGND VGND VPWR VPWR _00814_ sky130_fd_sc_hd__o21ai_2
X_15860_ net294 _05602_ VGND VGND VPWR VPWR _06988_ sky130_fd_sc_hd__nand2_1
X_14811_ _05832_ _05833_ VGND VGND VPWR VPWR _05834_ sky130_fd_sc_hd__xnor2_1
X_15791_ _06899_ _06902_ _06911_ VGND VGND VPWR VPWR _06912_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_98_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17530_ clknet_4_6_0_clock _00019_ VGND VGND VPWR VPWR kd_2\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_98_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14742_ net269 _05738_ _05724_ net273 VGND VGND VPWR VPWR _05758_ sky130_fd_sc_hd__a22o_1
X_11954_ _02761_ _02764_ VGND VGND VPWR VPWR _02765_ sky130_fd_sc_hd__and2_1
XFILLER_0_58_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10905_ _01659_ _01658_ VGND VGND VPWR VPWR _01716_ sky130_fd_sc_hd__xnor2_1
X_14673_ prev_error\[14\] _04912_ _05674_ _05681_ VGND VGND VPWR VPWR _05683_ sky130_fd_sc_hd__a31o_1
X_17461_ clknet_4_13_0_clock _00139_ VGND VGND VPWR VPWR prev_d_error\[13\] sky130_fd_sc_hd__dfxtp_1
X_11885_ _02695_ VGND VGND VPWR VPWR _02696_ sky130_fd_sc_hd__inv_2
X_16412_ i_error\[9\] _07588_ _07594_ VGND VGND VPWR VPWR _07595_ sky130_fd_sc_hd__o21ai_1
X_13624_ _04440_ _04443_ _04445_ VGND VGND VPWR VPWR _04529_ sky130_fd_sc_hd__and3_1
X_10836_ _01645_ _01646_ VGND VGND VPWR VPWR _01647_ sky130_fd_sc_hd__or2_1
XFILLER_0_67_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17392_ net469 _08447_ VGND VGND VPWR VPWR _08602_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_17_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16343_ _07517_ _07518_ VGND VGND VPWR VPWR _07520_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13555_ _04434_ _04436_ _04452_ VGND VGND VPWR VPWR _04453_ sky130_fd_sc_hd__a21o_2
XFILLER_0_54_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10767_ _01576_ _01577_ VGND VGND VPWR VPWR _01578_ sky130_fd_sc_hd__nand2_1
XFILLER_0_137_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_879 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12506_ _03315_ _03304_ _03313_ _03314_ VGND VGND VPWR VPWR _03344_ sky130_fd_sc_hd__a31oi_4
X_16274_ _07405_ _07421_ VGND VGND VPWR VPWR _07444_ sky130_fd_sc_hd__nand2_1
X_13486_ _04243_ _04371_ _04376_ VGND VGND VPWR VPWR _04377_ sky130_fd_sc_hd__and3_1
X_10698_ _01489_ _01508_ VGND VGND VPWR VPWR _01509_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15225_ _06150_ _06181_ _06180_ VGND VGND VPWR VPWR _06290_ sky130_fd_sc_hd__a21o_1
X_12437_ _03268_ VGND VGND VPWR VPWR _03269_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_124_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15156_ _06193_ _06213_ VGND VGND VPWR VPWR _06214_ sky130_fd_sc_hd__and2b_1
X_12368_ _03197_ _03198_ _03199_ VGND VGND VPWR VPWR _03200_ sky130_fd_sc_hd__a21o_1
X_14107_ _05026_ _05059_ VGND VGND VPWR VPWR _05060_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11319_ prev_d_error\[13\] net157 _02089_ VGND VGND VPWR VPWR _02130_ sky130_fd_sc_hd__a21oi_1
X_15087_ _06010_ _06137_ VGND VGND VPWR VPWR _06138_ sky130_fd_sc_hd__or2_1
X_12299_ _03111_ _03130_ VGND VGND VPWR VPWR _03131_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_26_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14038_ net238 net231 _03932_ _04001_ VGND VGND VPWR VPWR _04984_ sky130_fd_sc_hd__and4_1
XFILLER_0_129_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15989_ net301 _05664_ _05973_ net297 VGND VGND VPWR VPWR _07130_ sky130_fd_sc_hd__a22o_1
XFILLER_0_148_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_35_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09013_ _05825_ _06023_ _06177_ VGND VGND VPWR VPWR _06188_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_54_890 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_44_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09915_ _00724_ _00725_ VGND VGND VPWR VPWR _00726_ sky130_fd_sc_hd__or2b_1
XFILLER_0_95_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09846_ _00650_ _00656_ VGND VGND VPWR VPWR _00657_ sky130_fd_sc_hd__or2_1
X_09777_ _00585_ _00587_ VGND VGND VPWR VPWR _00588_ sky130_fd_sc_hd__nor2_1
X_08728_ net47 _03061_ _03094_ net243 VGND VGND VPWR VPWR _00009_ sky130_fd_sc_hd__a22o_1
XFILLER_0_139_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11670_ _02391_ _02452_ _02480_ VGND VGND VPWR VPWR _02481_ sky130_fd_sc_hd__or3b_1
XFILLER_0_49_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10621_ _00637_ _01431_ VGND VGND VPWR VPWR _01432_ sky130_fd_sc_hd__nand2_1
XFILLER_0_138_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13340_ _04214_ _04215_ VGND VGND VPWR VPWR _04216_ sky130_fd_sc_hd__nand2_1
XFILLER_0_134_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10552_ _01361_ _01362_ VGND VGND VPWR VPWR _01363_ sky130_fd_sc_hd__nor2_1
XFILLER_0_36_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13271_ net203 _03260_ _04139_ VGND VGND VPWR VPWR _04140_ sky130_fd_sc_hd__and3_1
X_10483_ net358 _00519_ VGND VGND VPWR VPWR _01294_ sky130_fd_sc_hd__nand2_1
XFILLER_0_106_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15010_ net255 _05590_ VGND VGND VPWR VPWR _06053_ sky130_fd_sc_hd__nand2_2
X_12222_ _03048_ VGND VGND VPWR VPWR _03049_ sky130_fd_sc_hd__inv_2
XFILLER_0_121_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12153_ net424 net169 VGND VGND VPWR VPWR _02978_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11104_ net425 net110 _01462_ VGND VGND VPWR VPWR _01915_ sky130_fd_sc_hd__a21oi_1
X_16961_ _08197_ _08198_ VGND VGND VPWR VPWR _08199_ sky130_fd_sc_hd__nor2_2
X_12084_ net420 net162 net165 net416 VGND VGND VPWR VPWR _02907_ sky130_fd_sc_hd__a22oi_2
X_15912_ _07037_ _07038_ VGND VGND VPWR VPWR _07045_ sky130_fd_sc_hd__nor2_1
X_11035_ _01843_ _01845_ VGND VGND VPWR VPWR _01846_ sky130_fd_sc_hd__xnor2_1
X_16892_ _08118_ _08122_ VGND VGND VPWR VPWR _08123_ sky130_fd_sc_hd__xnor2_2
X_15843_ _06932_ _06967_ _06968_ VGND VGND VPWR VPWR _06970_ sky130_fd_sc_hd__a21boi_2
X_15774_ _06762_ _06764_ _06725_ _06763_ VGND VGND VPWR VPWR _06894_ sky130_fd_sc_hd__o211a_1
XFILLER_0_87_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12986_ net187 _03270_ VGND VGND VPWR VPWR _03830_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17513_ clknet_4_5_0_clock _00002_ VGND VGND VPWR VPWR kd_1\[11\] sky130_fd_sc_hd__dfxtp_1
X_14725_ _05728_ _05732_ VGND VGND VPWR VPWR _05740_ sky130_fd_sc_hd__xor2_1
X_11937_ _02746_ _02747_ VGND VGND VPWR VPWR _02748_ sky130_fd_sc_hd__and2_1
XFILLER_0_24_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17444_ clknet_4_8_0_clock _00122_ VGND VGND VPWR VPWR i_error\[14\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_28_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14656_ net103 _05663_ VGND VGND VPWR VPWR _05664_ sky130_fd_sc_hd__xnor2_4
X_11868_ _02549_ _02378_ VGND VGND VPWR VPWR _02679_ sky130_fd_sc_hd__and2b_1
XFILLER_0_74_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13607_ _04509_ _04424_ VGND VGND VPWR VPWR _04510_ sky130_fd_sc_hd__xor2_1
X_10819_ _01518_ _01614_ _01629_ VGND VGND VPWR VPWR _01630_ sky130_fd_sc_hd__a21o_1
XFILLER_0_7_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17375_ net468 net414 net457 _08592_ VGND VGND VPWR VPWR _00134_ sky130_fd_sc_hd__o211a_1
XFILLER_0_27_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14587_ _05586_ _05587_ VGND VGND VPWR VPWR _05588_ sky130_fd_sc_hd__xnor2_4
X_11799_ net434 net139 net135 net438 VGND VGND VPWR VPWR _02610_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_131_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16326_ _06092_ _06190_ VGND VGND VPWR VPWR _07501_ sky130_fd_sc_hd__xnor2_2
X_13538_ _04416_ _04418_ _04433_ VGND VGND VPWR VPWR _04434_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_131_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16257_ _07422_ _07423_ _07424_ VGND VGND VPWR VPWR _07425_ sky130_fd_sc_hd__o21ba_1
X_13469_ _04354_ _04357_ _04352_ VGND VGND VPWR VPWR _04358_ sky130_fd_sc_hd__o21a_1
XFILLER_0_112_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15208_ _06269_ _06270_ VGND VGND VPWR VPWR _06271_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_11_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16188_ net291 _06416_ _07347_ _07348_ VGND VGND VPWR VPWR _07349_ sky130_fd_sc_hd__nand4_1
XFILLER_0_112_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15139_ net259 _05666_ VGND VGND VPWR VPWR _06195_ sky130_fd_sc_hd__nand2_1
XFILLER_0_140_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09700_ _00508_ _00510_ VGND VGND VPWR VPWR _00511_ sky130_fd_sc_hd__nand2_1
X_09631_ _00422_ _00440_ VGND VGND VPWR VPWR _00442_ sky130_fd_sc_hd__and2b_1
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09562_ _00372_ VGND VGND VPWR VPWR _00373_ sky130_fd_sc_hd__clkbuf_4
X_09493_ net327 _07948_ _00231_ VGND VGND VPWR VPWR _00304_ sky130_fd_sc_hd__and3_1
XFILLER_0_78_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_52_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout420 prev_d_error\[6\] VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__clkbuf_4
Xfanout431 net432 VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__clkbuf_4
Xfanout442 net443 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__clkbuf_2
Xfanout453 net454 VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__clkbuf_4
Xfanout464 net470 VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__clkbuf_4
X_09829_ _00602_ _00634_ VGND VGND VPWR VPWR _00640_ sky130_fd_sc_hd__xnor2_1
X_12840_ _03612_ _03683_ VGND VGND VPWR VPWR _03684_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_61_Left_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12771_ _03462_ _03556_ VGND VGND VPWR VPWR _03615_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14510_ _05501_ _05502_ VGND VGND VPWR VPWR _05503_ sky130_fd_sc_hd__nand2_1
X_11722_ _02426_ _02429_ VGND VGND VPWR VPWR _02533_ sky130_fd_sc_hd__nor2_1
X_15490_ _06576_ _06579_ _06578_ VGND VGND VPWR VPWR _06581_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_49_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14441_ _05425_ _05426_ VGND VGND VPWR VPWR _05427_ sky130_fd_sc_hd__nor2_4
X_11653_ _02404_ _02405_ VGND VGND VPWR VPWR _02464_ sky130_fd_sc_hd__and2_1
X_10604_ _01243_ _01244_ VGND VGND VPWR VPWR _01415_ sky130_fd_sc_hd__nor2_1
X_14372_ _01709_ _05306_ _05350_ VGND VGND VPWR VPWR _05351_ sky130_fd_sc_hd__o21ai_2
X_17160_ _08411_ _08417_ VGND VGND VPWR VPWR _08418_ sky130_fd_sc_hd__xnor2_1
X_11584_ _02308_ _02392_ VGND VGND VPWR VPWR _02395_ sky130_fd_sc_hd__and2_1
XFILLER_0_36_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16111_ net297 _06160_ _06015_ net301 VGND VGND VPWR VPWR _07264_ sky130_fd_sc_hd__a22oi_2
X_13323_ net241 _03327_ VGND VGND VPWR VPWR _04198_ sky130_fd_sc_hd__nand2_2
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_70_Left_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10535_ _01314_ _01344_ _01343_ _01339_ VGND VGND VPWR VPWR _01346_ sky130_fd_sc_hd__a211o_1
XFILLER_0_101_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17091_ _01480_ _05338_ _08340_ VGND VGND VPWR VPWR _08342_ sky130_fd_sc_hd__nor3_1
XFILLER_0_150_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16042_ _07185_ _07187_ VGND VGND VPWR VPWR _07188_ sky130_fd_sc_hd__or2b_1
X_13254_ _03892_ _04033_ _04031_ VGND VGND VPWR VPWR _04122_ sky130_fd_sc_hd__o21a_1
X_10466_ _01275_ _01276_ VGND VGND VPWR VPWR _01277_ sky130_fd_sc_hd__or2_1
XFILLER_0_150_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12205_ _03012_ _03030_ _03027_ VGND VGND VPWR VPWR _03031_ sky130_fd_sc_hd__o21ai_2
X_13185_ _04040_ _04045_ VGND VGND VPWR VPWR _04046_ sky130_fd_sc_hd__xor2_1
X_10397_ _00970_ _01206_ _01207_ VGND VGND VPWR VPWR _01208_ sky130_fd_sc_hd__a21o_1
X_12136_ _02901_ _02914_ _02913_ VGND VGND VPWR VPWR _02961_ sky130_fd_sc_hd__a21o_1
X_16944_ _08175_ _08178_ VGND VGND VPWR VPWR _08181_ sky130_fd_sc_hd__xnor2_1
X_12067_ _02886_ _02887_ net424 net158 VGND VGND VPWR VPWR _02888_ sky130_fd_sc_hd__and4b_1
X_11018_ _01562_ net151 _01763_ VGND VGND VPWR VPWR _01829_ sky130_fd_sc_hd__o21a_1
X_16875_ _08089_ _08103_ _08104_ VGND VGND VPWR VPWR _08105_ sky130_fd_sc_hd__a21o_1
XFILLER_0_35_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15826_ _06905_ _06909_ _06910_ VGND VGND VPWR VPWR _06951_ sky130_fd_sc_hd__nand3_1
X_15757_ _06871_ _06872_ _06874_ VGND VGND VPWR VPWR _06875_ sky130_fd_sc_hd__o21ba_1
X_12969_ net214 _03284_ _03336_ net220 VGND VGND VPWR VPWR _03813_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_75_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14708_ _05719_ _05720_ _03331_ VGND VGND VPWR VPWR _05721_ sky130_fd_sc_hd__a21o_1
X_15688_ _06405_ _06505_ VGND VGND VPWR VPWR _06799_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_87_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17427_ clknet_4_2_0_clock _00105_ VGND VGND VPWR VPWR prev_error\[15\] sky130_fd_sc_hd__dfxtp_2
X_14639_ _05642_ _05644_ VGND VGND VPWR VPWR _05645_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_109_Left_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17358_ net465 _08097_ VGND VGND VPWR VPWR _08582_ sky130_fd_sc_hd__nand2_1
XFILLER_0_126_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16309_ _07234_ _07339_ _07338_ VGND VGND VPWR VPWR _07482_ sky130_fd_sc_hd__a21o_1
XFILLER_0_15_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17289_ net462 prev_error\[3\] VGND VGND VPWR VPWR _08539_ sky130_fd_sc_hd__or2_1
XFILLER_0_3_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08993_ net321 _04780_ VGND VGND VPWR VPWR _05968_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09614_ _00338_ _00348_ VGND VGND VPWR VPWR _00425_ sky130_fd_sc_hd__xnor2_1
X_09545_ _00331_ _00355_ VGND VGND VPWR VPWR _00356_ sky130_fd_sc_hd__xor2_1
X_09476_ _00213_ _00286_ VGND VGND VPWR VPWR _00287_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_19_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10320_ net335 _00653_ _01063_ VGND VGND VPWR VPWR _01131_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_131_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10251_ net339 _00519_ _00372_ net342 VGND VGND VPWR VPWR _01062_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_30_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10182_ _00991_ _00992_ VGND VGND VPWR VPWR _00993_ sky130_fd_sc_hd__nor2_1
X_14990_ _06029_ _06030_ VGND VGND VPWR VPWR _06031_ sky130_fd_sc_hd__and2b_1
Xfanout250 ki\[16\] VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__clkbuf_4
Xfanout261 net264 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__buf_2
Xfanout272 ki\[10\] VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__buf_2
Xfanout283 ki\[7\] VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__clkbuf_4
X_13941_ _04872_ _04876_ VGND VGND VPWR VPWR _04877_ sky130_fd_sc_hd__and2b_1
Xfanout294 net295 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__clkbuf_4
X_16660_ net248 _05801_ VGND VGND VPWR VPWR _07868_ sky130_fd_sc_hd__nand2_1
X_13872_ _04763_ _04800_ VGND VGND VPWR VPWR _04801_ sky130_fd_sc_hd__xnor2_4
X_15611_ _06421_ _06420_ VGND VGND VPWR VPWR _06714_ sky130_fd_sc_hd__or2b_1
X_12823_ _03666_ VGND VGND VPWR VPWR _03667_ sky130_fd_sc_hd__clkbuf_4
X_16591_ _07791_ _07633_ VGND VGND VPWR VPWR _07792_ sky130_fd_sc_hd__xnor2_2
X_15542_ _06636_ _06637_ VGND VGND VPWR VPWR _06638_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_141_Right_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12754_ _03595_ _03597_ VGND VGND VPWR VPWR _03598_ sky130_fd_sc_hd__and2b_1
XFILLER_0_139_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11705_ _02507_ _02509_ _02515_ VGND VGND VPWR VPWR _02516_ sky130_fd_sc_hd__o21ai_1
X_15473_ _06546_ _06561_ VGND VGND VPWR VPWR _06563_ sky130_fd_sc_hd__nand2_1
X_12685_ net204 _03284_ _03337_ net209 VGND VGND VPWR VPWR _03524_ sky130_fd_sc_hd__a22oi_1
X_17212_ _08109_ _08131_ VGND VGND VPWR VPWR _08475_ sky130_fd_sc_hd__xnor2_1
X_14424_ _05406_ _05408_ VGND VGND VPWR VPWR _05409_ sky130_fd_sc_hd__or2_1
X_11636_ _02379_ _02446_ VGND VGND VPWR VPWR _02447_ sky130_fd_sc_hd__or2_1
XFILLER_0_108_840 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17143_ _08393_ _08398_ VGND VGND VPWR VPWR _08400_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_52_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11567_ net388 net174 VGND VGND VPWR VPWR _02378_ sky130_fd_sc_hd__nand2_1
X_14355_ _01687_ _05332_ VGND VGND VPWR VPWR _05333_ sky130_fd_sc_hd__xor2_1
XFILLER_0_21_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10518_ net375 _00241_ _01298_ _01299_ VGND VGND VPWR VPWR _01329_ sky130_fd_sc_hd__a22oi_1
X_13306_ _04163_ _04177_ _04178_ VGND VGND VPWR VPWR _04179_ sky130_fd_sc_hd__o21a_1
XFILLER_0_24_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14286_ _02569_ _02568_ VGND VGND VPWR VPWR _05257_ sky130_fd_sc_hd__and2b_1
X_17074_ _08317_ _08323_ VGND VGND VPWR VPWR _08324_ sky130_fd_sc_hd__xor2_1
XFILLER_0_123_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11498_ net435 net439 net525 net124 VGND VGND VPWR VPWR _02309_ sky130_fd_sc_hd__and4_1
XFILLER_0_150_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16025_ _07020_ _07098_ VGND VGND VPWR VPWR _07170_ sky130_fd_sc_hd__xnor2_1
X_13237_ _03263_ _04004_ _04005_ VGND VGND VPWR VPWR _04103_ sky130_fd_sc_hd__o21ai_1
X_10449_ _01241_ _01259_ VGND VGND VPWR VPWR _01260_ sky130_fd_sc_hd__and2_1
XFILLER_0_110_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13168_ _04025_ _04026_ VGND VGND VPWR VPWR _04027_ sky130_fd_sc_hd__xnor2_2
X_12119_ _02942_ _02943_ net442 net154 VGND VGND VPWR VPWR _02944_ sky130_fd_sc_hd__and4bb_1
X_13099_ _03847_ _03861_ VGND VGND VPWR VPWR _03951_ sky130_fd_sc_hd__xnor2_1
X_16927_ _08153_ _08155_ VGND VGND VPWR VPWR _08162_ sky130_fd_sc_hd__and2_1
XFILLER_0_137_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16858_ _08081_ _08084_ _08085_ VGND VGND VPWR VPWR _08086_ sky130_fd_sc_hd__and3_1
X_15809_ _06915_ _06929_ _06931_ VGND VGND VPWR VPWR _06932_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_149_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16789_ _07835_ _07980_ VGND VGND VPWR VPWR _08010_ sky130_fd_sc_hd__nor2_1
X_09330_ _08692_ _08693_ VGND VGND VPWR VPWR _08694_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09261_ _08623_ _08624_ VGND VGND VPWR VPWR _08625_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09192_ net340 _05011_ _08146_ VGND VGND VPWR VPWR _08157_ sky130_fd_sc_hd__a21o_1
XFILLER_0_145_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08976_ net332 _05715_ _05748_ _05770_ VGND VGND VPWR VPWR _05781_ sky130_fd_sc_hd__a31o_1
Xhold47 i_error\[0\] VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__dlygate4sd3_1
X_09528_ net369 net364 net520 VGND VGND VPWR VPWR _00339_ sky130_fd_sc_hd__and3_1
X_09459_ _00268_ _00269_ VGND VGND VPWR VPWR _00270_ sky130_fd_sc_hd__nor2_2
X_12470_ _05660_ prev_error\[16\] VGND VGND VPWR VPWR _03304_ sky130_fd_sc_hd__or2b_2
XFILLER_0_136_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11421_ _02230_ _02231_ VGND VGND VPWR VPWR _02232_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14140_ _05093_ _05095_ VGND VGND VPWR VPWR _05096_ sky130_fd_sc_hd__and2b_1
X_11352_ _02160_ _02162_ VGND VGND VPWR VPWR _02163_ sky130_fd_sc_hd__nor2_1
XFILLER_0_132_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10303_ net358 _08676_ VGND VGND VPWR VPWR _01114_ sky130_fd_sc_hd__nand2_1
XFILLER_0_120_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14071_ _05016_ _05019_ VGND VGND VPWR VPWR _05020_ sky130_fd_sc_hd__nand2_1
XFILLER_0_104_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11283_ _02004_ _02093_ VGND VGND VPWR VPWR _02094_ sky130_fd_sc_hd__nor2_1
X_13022_ _03844_ _03865_ _03863_ VGND VGND VPWR VPWR _03866_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_131_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10234_ net363 _07937_ _00736_ VGND VGND VPWR VPWR _01045_ sky130_fd_sc_hd__and3_1
X_10165_ _00971_ _00974_ _00975_ VGND VGND VPWR VPWR _00976_ sky130_fd_sc_hd__o21ai_2
X_14973_ _06007_ _06010_ _06011_ VGND VGND VPWR VPWR _06013_ sky130_fd_sc_hd__o21ai_1
X_10096_ net354 _08681_ VGND VGND VPWR VPWR _00907_ sky130_fd_sc_hd__nand2_1
X_16712_ i_error\[17\] _07924_ VGND VGND VPWR VPWR _07925_ sky130_fd_sc_hd__xnor2_1
X_13924_ _04801_ _04858_ VGND VGND VPWR VPWR _04859_ sky130_fd_sc_hd__nand2_2
XFILLER_0_89_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16643_ _07726_ _07848_ VGND VGND VPWR VPWR _07850_ sky130_fd_sc_hd__or2_1
X_13855_ _04712_ _04713_ VGND VGND VPWR VPWR _04783_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_57_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12806_ _03648_ _03649_ VGND VGND VPWR VPWR _03650_ sky130_fd_sc_hd__or2_1
X_16574_ _05443_ _05444_ VGND VGND VPWR VPWR _07774_ sky130_fd_sc_hd__or2_1
X_13786_ _04696_ _04705_ _04706_ VGND VGND VPWR VPWR _04707_ sky130_fd_sc_hd__o21a_1
X_10998_ _01807_ _01805_ VGND VGND VPWR VPWR _01809_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15525_ _06612_ _06619_ VGND VGND VPWR VPWR _06620_ sky130_fd_sc_hd__and2_1
XFILLER_0_96_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12737_ net180 net176 _03261_ _03270_ VGND VGND VPWR VPWR _03580_ sky130_fd_sc_hd__and4_1
X_15456_ _06534_ _06543_ VGND VGND VPWR VPWR _06544_ sky130_fd_sc_hd__nand2_1
X_12668_ _03452_ _03506_ VGND VGND VPWR VPWR _03507_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14407_ _03452_ _05389_ VGND VGND VPWR VPWR _05390_ sky130_fd_sc_hd__and2_1
X_11619_ _02426_ _02429_ VGND VGND VPWR VPWR _02430_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15387_ _06426_ _06467_ _06465_ VGND VGND VPWR VPWR _06468_ sky130_fd_sc_hd__a21o_1
XFILLER_0_142_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12599_ net198 _03322_ _03437_ VGND VGND VPWR VPWR _03438_ sky130_fd_sc_hd__a21o_1
XFILLER_0_53_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17126_ _08308_ _08351_ _08350_ VGND VGND VPWR VPWR _08381_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_106_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14338_ net381 net385 net116 net113 VGND VGND VPWR VPWR _05314_ sky130_fd_sc_hd__and4_1
XFILLER_0_12_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17057_ _08303_ _08304_ VGND VGND VPWR VPWR _08305_ sky130_fd_sc_hd__nand2_2
XFILLER_0_40_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14269_ _04402_ _05186_ VGND VGND VPWR VPWR _05238_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16008_ net290 _06017_ _07138_ _07150_ VGND VGND VPWR VPWR _07151_ sky130_fd_sc_hd__a31o_1
X_08830_ net14 net69 VGND VGND VPWR VPWR _04175_ sky130_fd_sc_hd__nor2b_1
XFILLER_0_148_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08761_ net55 _03318_ _03351_ net275 VGND VGND VPWR VPWR _00053_ sky130_fd_sc_hd__a22o_1
XFILLER_0_73_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09313_ _08676_ VGND VGND VPWR VPWR _08677_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_137_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09244_ _08605_ _08606_ _08607_ VGND VGND VPWR VPWR _08608_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_146_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09175_ net314 _07420_ _07343_ net318 VGND VGND VPWR VPWR _07970_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_31_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08959_ _05341_ _05319_ VGND VGND VPWR VPWR _05594_ sky130_fd_sc_hd__or2b_1
XFILLER_0_98_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11970_ _02754_ _02779_ _02780_ VGND VGND VPWR VPWR _02781_ sky130_fd_sc_hd__a21bo_1
X_10921_ net408 net412 net122 net117 VGND VGND VPWR VPWR _01732_ sky130_fd_sc_hd__and4_1
XFILLER_0_39_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13640_ _04542_ _04545_ VGND VGND VPWR VPWR _04546_ sky130_fd_sc_hd__xor2_1
X_10852_ _01647_ _01505_ VGND VGND VPWR VPWR _01663_ sky130_fd_sc_hd__and2b_1
XFILLER_0_79_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13571_ _04380_ _04459_ _04469_ VGND VGND VPWR VPWR _04470_ sky130_fd_sc_hd__and3_1
X_10783_ net381 net385 net129 net125 VGND VGND VPWR VPWR _01594_ sky130_fd_sc_hd__and4_1
XFILLER_0_66_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15310_ _06306_ _06314_ _06313_ VGND VGND VPWR VPWR _06383_ sky130_fd_sc_hd__and3_1
X_12522_ net191 _03286_ _03337_ net193 VGND VGND VPWR VPWR _03361_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_137_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16290_ net302 _04314_ _06417_ net307 VGND VGND VPWR VPWR _07461_ sky130_fd_sc_hd__a22o_1
XFILLER_0_136_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15241_ _05724_ _05688_ VGND VGND VPWR VPWR _06307_ sky130_fd_sc_hd__nand2_1
XFILLER_0_109_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12453_ _03284_ VGND VGND VPWR VPWR _03286_ sky130_fd_sc_hd__buf_2
X_11404_ _02143_ _02178_ _02176_ VGND VGND VPWR VPWR _02215_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_22_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15172_ _06230_ _06132_ VGND VGND VPWR VPWR _06231_ sky130_fd_sc_hd__xnor2_1
X_12384_ _03215_ VGND VGND VPWR VPWR _03216_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14123_ _05076_ VGND VGND VPWR VPWR _05078_ sky130_fd_sc_hd__inv_2
X_11335_ _02144_ _02145_ net425 net123 VGND VGND VPWR VPWR _02146_ sky130_fd_sc_hd__and4bb_1
X_14054_ _04991_ _04992_ _05001_ VGND VGND VPWR VPWR _05002_ sky130_fd_sc_hd__o21ai_1
X_11266_ _02072_ _02074_ _02076_ VGND VGND VPWR VPWR _02077_ sky130_fd_sc_hd__o21a_1
X_10217_ _00987_ _01000_ VGND VGND VPWR VPWR _01028_ sky130_fd_sc_hd__xor2_1
X_13005_ _03848_ _03807_ VGND VGND VPWR VPWR _03849_ sky130_fd_sc_hd__xnor2_1
X_11197_ _01897_ _01900_ _01902_ VGND VGND VPWR VPWR _02008_ sky130_fd_sc_hd__or3_1
X_10148_ _00915_ _00927_ _00929_ VGND VGND VPWR VPWR _00959_ sky130_fd_sc_hd__and3_1
X_14956_ _05985_ _05992_ VGND VGND VPWR VPWR _05994_ sky130_fd_sc_hd__nor2_1
X_10079_ _00784_ _00804_ VGND VGND VPWR VPWR _00890_ sky130_fd_sc_hd__xor2_2
XFILLER_0_89_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13907_ _04760_ _04839_ VGND VGND VPWR VPWR _04840_ sky130_fd_sc_hd__nor2_1
X_14887_ _05789_ _05917_ VGND VGND VPWR VPWR _05918_ sky130_fd_sc_hd__xor2_1
XFILLER_0_43_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16626_ _07726_ _07830_ VGND VGND VPWR VPWR _07831_ sky130_fd_sc_hd__or2_1
X_13838_ _04699_ _04701_ VGND VGND VPWR VPWR _04764_ sky130_fd_sc_hd__xor2_1
X_16557_ _05437_ _07754_ VGND VGND VPWR VPWR _07755_ sky130_fd_sc_hd__and2b_1
X_13769_ _04683_ _04686_ _04687_ VGND VGND VPWR VPWR _04688_ sky130_fd_sc_hd__a21oi_1
X_15508_ net268 _06161_ _06600_ VGND VGND VPWR VPWR _06601_ sky130_fd_sc_hd__and3_1
XFILLER_0_85_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16488_ _07661_ _07550_ _07677_ VGND VGND VPWR VPWR _07679_ sky130_fd_sc_hd__or3_1
XFILLER_0_128_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15439_ net305 _05736_ _06508_ _06509_ VGND VGND VPWR VPWR _06525_ sky130_fd_sc_hd__a22o_1
XFILLER_0_5_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17109_ _08358_ _08361_ VGND VGND VPWR VPWR _08362_ sky130_fd_sc_hd__xor2_1
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09931_ _00739_ _00740_ _00735_ _00741_ VGND VGND VPWR VPWR _00742_ sky130_fd_sc_hd__or4_4
XFILLER_0_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09862_ _00665_ _00670_ _00671_ VGND VGND VPWR VPWR _00673_ sky130_fd_sc_hd__or3b_1
XFILLER_0_110_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08813_ net18 net73 VGND VGND VPWR VPWR _03988_ sky130_fd_sc_hd__or2b_2
X_09793_ _00601_ _00600_ VGND VGND VPWR VPWR _00604_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08744_ net46 _03050_ _03083_ kd_1\[17\] VGND VGND VPWR VPWR _00008_ sky130_fd_sc_hd__a22o_1
XFILLER_0_49_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09227_ _08322_ _08476_ VGND VGND VPWR VPWR _08529_ sky130_fd_sc_hd__xor2_2
XFILLER_0_106_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09158_ _07453_ _07552_ VGND VGND VPWR VPWR _07783_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_44_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09089_ _07002_ _07013_ VGND VGND VPWR VPWR _07024_ sky130_fd_sc_hd__nor2_1
XFILLER_0_102_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11120_ _01908_ _01930_ VGND VGND VPWR VPWR _01931_ sky130_fd_sc_hd__or2_1
XFILLER_0_101_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11051_ _01793_ _01861_ VGND VGND VPWR VPWR _01862_ sky130_fd_sc_hd__nor2_1
X_10002_ _00725_ _00724_ VGND VGND VPWR VPWR _00813_ sky130_fd_sc_hd__xnor2_1
X_14810_ _05772_ _05777_ _05779_ VGND VGND VPWR VPWR _05833_ sky130_fd_sc_hd__a21bo_1
X_15790_ _06905_ _06909_ _06910_ VGND VGND VPWR VPWR _06911_ sky130_fd_sc_hd__a21o_1
X_14741_ _05756_ _05740_ VGND VGND VPWR VPWR _05757_ sky130_fd_sc_hd__xor2_1
X_11953_ _02760_ _02756_ _02758_ VGND VGND VPWR VPWR _02764_ sky130_fd_sc_hd__or3_1
XFILLER_0_86_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10904_ _01713_ _01714_ VGND VGND VPWR VPWR _01715_ sky130_fd_sc_hd__nor2_1
XFILLER_0_98_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17460_ clknet_4_13_0_clock _00138_ VGND VGND VPWR VPWR prev_d_error\[12\] sky130_fd_sc_hd__dfxtp_1
X_14672_ prev_error\[15\] net529 VGND VGND VPWR VPWR _05681_ sky130_fd_sc_hd__and2_1
X_11884_ _02687_ _02692_ _02694_ VGND VGND VPWR VPWR _02695_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16411_ i_error\[8\] _07592_ _07593_ _07588_ i_error\[9\] VGND VGND VPWR VPWR _07594_
+ sky130_fd_sc_hd__a32o_1
XFILLER_0_67_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13623_ net183 _04319_ _04526_ VGND VGND VPWR VPWR _04528_ sky130_fd_sc_hd__and3_1
X_17391_ _03878_ _08358_ _08601_ net458 VGND VGND VPWR VPWR _00142_ sky130_fd_sc_hd__o211a_1
X_10835_ _01642_ _01644_ _01640_ VGND VGND VPWR VPWR _01646_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_109_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16342_ net248 _05749_ _05739_ net251 VGND VGND VPWR VPWR _07518_ sky130_fd_sc_hd__a22o_1
XFILLER_0_27_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13554_ _04437_ _04451_ VGND VGND VPWR VPWR _04452_ sky130_fd_sc_hd__nor2_1
X_10766_ _01560_ _01566_ _01575_ VGND VGND VPWR VPWR _01577_ sky130_fd_sc_hd__or3_1
X_12505_ _03317_ _03319_ VGND VGND VPWR VPWR _03343_ sky130_fd_sc_hd__or2_4
X_16273_ _07416_ _07441_ VGND VGND VPWR VPWR _07443_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_109_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13485_ _04372_ _04375_ VGND VGND VPWR VPWR _04376_ sky130_fd_sc_hd__or2b_1
XFILLER_0_124_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10697_ net406 net412 net105 VGND VGND VPWR VPWR _01508_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_23_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15224_ _06252_ _06286_ _06288_ VGND VGND VPWR VPWR _06289_ sky130_fd_sc_hd__a21o_1
XFILLER_0_125_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12436_ _03265_ _03267_ VGND VGND VPWR VPWR _03268_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_120_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15155_ _06198_ _06201_ _06212_ VGND VGND VPWR VPWR _06213_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_23_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12367_ prev_error\[1\] _00518_ VGND VGND VPWR VPWR _03199_ sky130_fd_sc_hd__and2b_1
XFILLER_0_1_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14106_ net235 _04315_ VGND VGND VPWR VPWR _05059_ sky130_fd_sc_hd__nand2_1
X_11318_ net395 net157 _02089_ VGND VGND VPWR VPWR _02129_ sky130_fd_sc_hd__and3_1
X_15086_ net255 _05604_ _06009_ VGND VGND VPWR VPWR _06137_ sky130_fd_sc_hd__a21oi_1
X_12298_ _03128_ _03129_ VGND VGND VPWR VPWR _03130_ sky130_fd_sc_hd__or2_1
XFILLER_0_38_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14037_ _04982_ _04969_ VGND VGND VPWR VPWR _04983_ sky130_fd_sc_hd__xnor2_1
X_11249_ _02032_ _02047_ VGND VGND VPWR VPWR _02060_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_129_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15988_ net301 net297 _05664_ _05973_ VGND VGND VPWR VPWR _07129_ sky130_fd_sc_hd__nand4_2
X_14939_ _05974_ VGND VGND VPWR VPWR _05975_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_145_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16609_ _07605_ _07608_ _07638_ _07811_ VGND VGND VPWR VPWR _07812_ sky130_fd_sc_hd__o31a_2
XFILLER_0_147_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09012_ _06155_ _06166_ VGND VGND VPWR VPWR _06177_ sky130_fd_sc_hd__nand2_1
XFILLER_0_116_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09914_ _00658_ _00691_ _00689_ VGND VGND VPWR VPWR _00725_ sky130_fd_sc_hd__a21o_1
XFILLER_0_95_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09845_ _00655_ _00559_ VGND VGND VPWR VPWR _00656_ sky130_fd_sc_hd__nor2_1
X_09776_ net345 _07409_ _00401_ _00586_ VGND VGND VPWR VPWR _00587_ sky130_fd_sc_hd__a31o_1
X_08727_ net38 _03061_ _03094_ net246 VGND VGND VPWR VPWR _00000_ sky130_fd_sc_hd__a22o_1
XFILLER_0_68_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10620_ _00539_ _00543_ _00452_ VGND VGND VPWR VPWR _01431_ sky130_fd_sc_hd__a21o_1
XFILLER_0_9_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10551_ _01323_ _01327_ _01336_ _01337_ VGND VGND VPWR VPWR _01362_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_52_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10482_ _01111_ _01292_ VGND VGND VPWR VPWR _01293_ sky130_fd_sc_hd__xnor2_1
X_13270_ net207 _03269_ VGND VGND VPWR VPWR _04139_ sky130_fd_sc_hd__and2_1
XFILLER_0_32_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12221_ net429 net449 net161 net173 VGND VGND VPWR VPWR _03048_ sky130_fd_sc_hd__and4_1
XFILLER_0_32_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12152_ _02975_ _02976_ VGND VGND VPWR VPWR _02977_ sky130_fd_sc_hd__nor2_1
X_11103_ _01459_ _01483_ VGND VGND VPWR VPWR _01914_ sky130_fd_sc_hd__or2_1
X_16960_ _05221_ net503 _08196_ VGND VGND VPWR VPWR _08198_ sky130_fd_sc_hd__a21oi_1
X_12083_ net416 net420 net162 net165 VGND VGND VPWR VPWR _02906_ sky130_fd_sc_hd__and4_1
X_15911_ _07042_ _07043_ VGND VGND VPWR VPWR _07044_ sky130_fd_sc_hd__or2b_1
X_11034_ _01770_ _01844_ VGND VGND VPWR VPWR _01845_ sky130_fd_sc_hd__nand2_1
X_16891_ _08119_ _08121_ _08032_ VGND VGND VPWR VPWR _08122_ sky130_fd_sc_hd__mux2_2
X_15842_ _06966_ _06965_ _06933_ _06885_ VGND VGND VPWR VPWR _06968_ sky130_fd_sc_hd__a211o_1
XFILLER_0_99_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15773_ _06889_ _06891_ VGND VGND VPWR VPWR _06893_ sky130_fd_sc_hd__or2b_1
X_12985_ _03827_ _03828_ VGND VGND VPWR VPWR _03829_ sky130_fd_sc_hd__nor2_1
X_17512_ clknet_4_5_0_clock _00001_ VGND VGND VPWR VPWR kd_1\[10\] sky130_fd_sc_hd__dfxtp_1
X_14724_ _05738_ VGND VGND VPWR VPWR _05739_ sky130_fd_sc_hd__buf_2
X_11936_ _02667_ _02741_ _02745_ VGND VGND VPWR VPWR _02747_ sky130_fd_sc_hd__o21ai_1
X_17443_ clknet_4_8_0_clock _00121_ VGND VGND VPWR VPWR i_error\[13\] sky130_fd_sc_hd__dfxtp_1
X_14655_ net522 _05571_ _05573_ VGND VGND VPWR VPWR _05663_ sky130_fd_sc_hd__a21oi_4
X_11867_ _02669_ _02676_ _02677_ VGND VGND VPWR VPWR _02678_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_27_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13606_ _04425_ _04423_ VGND VGND VPWR VPWR _04509_ sky130_fd_sc_hd__nor2_1
X_17374_ net468 _08175_ VGND VGND VPWR VPWR _08592_ sky130_fd_sc_hd__nand2_1
X_10818_ _01627_ _01628_ VGND VGND VPWR VPWR _01629_ sky130_fd_sc_hd__nand2_1
X_14586_ _05558_ _05559_ _05575_ _05577_ VGND VGND VPWR VPWR _05587_ sky130_fd_sc_hd__o31a_2
X_11798_ net434 net438 net139 net135 VGND VGND VPWR VPWR _02609_ sky130_fd_sc_hd__and4_1
XFILLER_0_28_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16325_ _06189_ _06296_ _06292_ _06295_ VGND VGND VPWR VPWR _07500_ sky130_fd_sc_hd__o211a_1
XFILLER_0_27_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13537_ _04419_ _04432_ VGND VGND VPWR VPWR _04433_ sky130_fd_sc_hd__or2_1
X_10749_ net382 net386 net138 net134 VGND VGND VPWR VPWR _01560_ sky130_fd_sc_hd__and4_1
X_16256_ net302 net298 _04312_ _06415_ VGND VGND VPWR VPWR _07424_ sky130_fd_sc_hd__and4_1
X_13468_ _04355_ _04356_ VGND VGND VPWR VPWR _04357_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_140_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15207_ _06106_ _06107_ VGND VGND VPWR VPWR _06270_ sky130_fd_sc_hd__and2_1
X_12419_ net180 net176 _03234_ _03250_ VGND VGND VPWR VPWR _03251_ sky130_fd_sc_hd__and4_1
XFILLER_0_51_872 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16187_ net310 _05974_ _06347_ net294 VGND VGND VPWR VPWR _07348_ sky130_fd_sc_hd__a22o_1
X_13399_ _04184_ _04183_ VGND VGND VPWR VPWR _04281_ sky130_fd_sc_hd__nor2_1
XFILLER_0_23_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15138_ net263 _05604_ VGND VGND VPWR VPWR _06194_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15069_ _06105_ _06106_ VGND VGND VPWR VPWR _06118_ sky130_fd_sc_hd__nand2_2
XFILLER_0_4_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09630_ _00422_ _00440_ VGND VGND VPWR VPWR _00441_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_65_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09561_ _00371_ VGND VGND VPWR VPWR _00372_ sky130_fd_sc_hd__buf_2
XFILLER_0_78_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09492_ net327 _07948_ _00231_ VGND VGND VPWR VPWR _00303_ sky130_fd_sc_hd__a21o_1
XFILLER_0_148_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout410 prev_d_error\[9\] VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__clkbuf_4
Xfanout421 prev_d_error\[6\] VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__buf_2
Xfanout432 prev_d_error\[4\] VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__buf_2
Xfanout443 prev_d_error\[1\] VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__clkbuf_2
Xfanout454 net455 VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__buf_2
Xfanout465 net469 VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__clkbuf_4
X_09828_ _00637_ _00638_ VGND VGND VPWR VPWR _00639_ sky130_fd_sc_hd__and2_2
XPHY_EDGE_ROW_122_Right_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09759_ _00463_ _00462_ VGND VGND VPWR VPWR _00570_ sky130_fd_sc_hd__or2_1
X_12770_ _03613_ VGND VGND VPWR VPWR _03614_ sky130_fd_sc_hd__inv_2
XFILLER_0_138_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11721_ _02530_ _02531_ VGND VGND VPWR VPWR _02532_ sky130_fd_sc_hd__and2_1
XFILLER_0_84_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14440_ _00544_ _01433_ _00451_ VGND VGND VPWR VPWR _05426_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_127_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11652_ _02461_ _02462_ VGND VGND VPWR VPWR _02463_ sky130_fd_sc_hd__nand2_1
XFILLER_0_64_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10603_ _01181_ _01413_ VGND VGND VPWR VPWR _01414_ sky130_fd_sc_hd__xor2_1
X_14371_ _05307_ _05349_ VGND VGND VPWR VPWR _05350_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11583_ _02383_ _02385_ VGND VGND VPWR VPWR _02394_ sky130_fd_sc_hd__nor2_1
X_16110_ net306 _05973_ VGND VGND VPWR VPWR _07263_ sky130_fd_sc_hd__nand2_1
XFILLER_0_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13322_ _04195_ _03317_ _03319_ VGND VGND VPWR VPWR _04196_ sky130_fd_sc_hd__or3_4
XFILLER_0_134_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10534_ _01339_ _01343_ _01344_ _01314_ VGND VGND VPWR VPWR _01345_ sky130_fd_sc_hd__o211a_1
X_17090_ _01480_ _05338_ _08340_ VGND VGND VPWR VPWR _08341_ sky130_fd_sc_hd__o21a_1
XFILLER_0_40_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16041_ _06093_ _05967_ _07185_ _07186_ VGND VGND VPWR VPWR _07187_ sky130_fd_sc_hd__or4_4
XFILLER_0_134_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10465_ _01262_ _01272_ VGND VGND VPWR VPWR _01276_ sky130_fd_sc_hd__xnor2_1
X_13253_ net224 _03223_ _04119_ VGND VGND VPWR VPWR _04121_ sky130_fd_sc_hd__and3_1
XFILLER_0_32_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12204_ _03027_ _03029_ VGND VGND VPWR VPWR _03030_ sky130_fd_sc_hd__nand2_1
XFILLER_0_110_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10396_ net362 _00241_ _07387_ net380 VGND VGND VPWR VPWR _01207_ sky130_fd_sc_hd__a22oi_1
X_13184_ net199 _03270_ _04042_ _04044_ VGND VGND VPWR VPWR _04045_ sky130_fd_sc_hd__a31o_1
XFILLER_0_102_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12135_ _02956_ _02958_ _02959_ VGND VGND VPWR VPWR _02960_ sky130_fd_sc_hd__nand3_1
XFILLER_0_102_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16943_ _08175_ _08178_ VGND VGND VPWR VPWR _08180_ sky130_fd_sc_hd__and2b_1
X_12066_ net446 net138 net154 net428 VGND VGND VPWR VPWR _02887_ sky130_fd_sc_hd__a22o_1
X_11017_ _01826_ _01827_ net391 net142 VGND VGND VPWR VPWR _01828_ sky130_fd_sc_hd__and4bb_1
X_16874_ _08076_ _08078_ _08088_ VGND VGND VPWR VPWR _08104_ sky130_fd_sc_hd__and3_1
X_15825_ _06948_ _06934_ VGND VGND VPWR VPWR _06950_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_126_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15756_ net256 _04314_ _06873_ VGND VGND VPWR VPWR _06874_ sky130_fd_sc_hd__and3_1
XFILLER_0_99_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12968_ net220 net217 _03283_ _03335_ VGND VGND VPWR VPWR _03812_ sky130_fd_sc_hd__and4_1
X_14707_ prev_error\[14\] _04912_ VGND VGND VPWR VPWR _05720_ sky130_fd_sc_hd__nand2_2
XFILLER_0_87_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11919_ _02725_ _02727_ _02729_ VGND VGND VPWR VPWR _02730_ sky130_fd_sc_hd__o21ai_2
X_15687_ _06788_ _06796_ _06797_ VGND VGND VPWR VPWR _06798_ sky130_fd_sc_hd__a21o_1
X_12899_ net193 net190 _03249_ _03261_ VGND VGND VPWR VPWR _03743_ sky130_fd_sc_hd__and4_1
X_17426_ clknet_4_2_0_clock _00104_ VGND VGND VPWR VPWR prev_error\[14\] sky130_fd_sc_hd__dfxtp_4
XFILLER_0_74_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14638_ _05643_ _05585_ VGND VGND VPWR VPWR _05644_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_136_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17357_ _03878_ _08378_ _08581_ net452 VGND VGND VPWR VPWR _00125_ sky130_fd_sc_hd__o211a_1
XFILLER_0_138_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14569_ prev_error\[4\] _00238_ _00239_ VGND VGND VPWR VPWR _05568_ sky130_fd_sc_hd__and3_1
XFILLER_0_43_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16308_ _07235_ _07237_ VGND VGND VPWR VPWR _07481_ sky130_fd_sc_hd__xnor2_1
X_17288_ _08536_ _00373_ _08538_ net451 VGND VGND VPWR VPWR _00092_ sky130_fd_sc_hd__o211a_1
XFILLER_0_126_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16239_ _07397_ _07403_ _07404_ VGND VGND VPWR VPWR _07405_ sky130_fd_sc_hd__or3_2
XFILLER_0_2_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08992_ _05935_ _05946_ VGND VGND VPWR VPWR _05957_ sky130_fd_sc_hd__and2_1
XFILLER_0_76_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09613_ _00423_ _00393_ VGND VGND VPWR VPWR _00424_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_97_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09544_ _00332_ _00353_ _00354_ VGND VGND VPWR VPWR _00355_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_116_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09475_ _00216_ _00214_ VGND VGND VPWR VPWR _00286_ sky130_fd_sc_hd__or2_1
XFILLER_0_78_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10250_ net342 net339 _00519_ _00372_ VGND VGND VPWR VPWR _01061_ sky130_fd_sc_hd__and4_1
XFILLER_0_30_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10181_ net342 _00315_ _00372_ net339 VGND VGND VPWR VPWR _00992_ sky130_fd_sc_hd__a22oi_1
Xfanout240 kd_1\[1\] VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__buf_2
Xfanout251 net253 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__clkbuf_4
Xfanout262 net264 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout273 net276 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__clkbuf_4
X_13940_ _04872_ _04873_ _04875_ VGND VGND VPWR VPWR _04876_ sky130_fd_sc_hd__or3_1
Xfanout284 net287 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__clkbuf_4
Xfanout295 ki\[4\] VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__clkbuf_4
X_13871_ _04798_ _04799_ VGND VGND VPWR VPWR _04800_ sky130_fd_sc_hd__or2_2
X_15610_ _06712_ _06633_ VGND VGND VPWR VPWR _06713_ sky130_fd_sc_hd__or2_1
X_12822_ _03664_ _03665_ VGND VGND VPWR VPWR _03666_ sky130_fd_sc_hd__xnor2_4
X_16590_ _07634_ _07616_ VGND VGND VPWR VPWR _07791_ sky130_fd_sc_hd__or2b_1
XFILLER_0_69_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15541_ _06630_ _06635_ VGND VGND VPWR VPWR _06637_ sky130_fd_sc_hd__nor2_1
X_12753_ _03566_ _03596_ VGND VGND VPWR VPWR _03597_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11704_ _02513_ _02514_ VGND VGND VPWR VPWR _02515_ sky130_fd_sc_hd__and2_1
X_15472_ _06553_ _06560_ VGND VGND VPWR VPWR _06561_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_84_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12684_ net209 net204 _03284_ _03336_ VGND VGND VPWR VPWR _03523_ sky130_fd_sc_hd__and4_1
X_17211_ _08127_ _08473_ VGND VGND VPWR VPWR _08474_ sky130_fd_sc_hd__xnor2_1
X_14423_ _03416_ _03521_ _03519_ VGND VGND VPWR VPWR _05408_ sky130_fd_sc_hd__a21oi_2
X_11635_ _02443_ _02445_ VGND VGND VPWR VPWR _02446_ sky130_fd_sc_hd__and2_1
X_17142_ _08396_ _08397_ VGND VGND VPWR VPWR _08398_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14354_ _05329_ _05331_ VGND VGND VPWR VPWR _05332_ sky130_fd_sc_hd__xor2_1
X_11566_ _02375_ _02376_ VGND VGND VPWR VPWR _02377_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_107_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13305_ _04165_ _04176_ VGND VGND VPWR VPWR _04178_ sky130_fd_sc_hd__or2b_1
XFILLER_0_135_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10517_ _01323_ _01327_ VGND VGND VPWR VPWR _01328_ sky130_fd_sc_hd__and2_1
X_17073_ _08320_ _08321_ VGND VGND VPWR VPWR _08323_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_134_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14285_ _04569_ _05177_ VGND VGND VPWR VPWR _05256_ sky130_fd_sc_hd__xnor2_4
X_11497_ _02298_ _02307_ VGND VGND VPWR VPWR _02308_ sky130_fd_sc_hd__or2_1
X_16024_ _07149_ _07155_ _07168_ VGND VGND VPWR VPWR _07169_ sky130_fd_sc_hd__a21o_1
X_13236_ net184 _03793_ _04100_ _04101_ VGND VGND VPWR VPWR _04102_ sky130_fd_sc_hd__a31o_1
X_10448_ _01235_ _01240_ _01239_ VGND VGND VPWR VPWR _01259_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13167_ _03894_ _03893_ VGND VGND VPWR VPWR _04026_ sky130_fd_sc_hd__and2b_1
X_10379_ net366 _08674_ VGND VGND VPWR VPWR _01190_ sky130_fd_sc_hd__nand2_1
X_12118_ net437 net161 kd_2\[3\] net433 VGND VGND VPWR VPWR _02943_ sky130_fd_sc_hd__a22oi_1
X_13098_ _03840_ _03949_ VGND VGND VPWR VPWR _03950_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_137_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16926_ _08158_ _08152_ VGND VGND VPWR VPWR _08161_ sky130_fd_sc_hd__nand2_1
X_12049_ net437 net154 net158 net433 VGND VGND VPWR VPWR _02868_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_137_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16857_ _08000_ _08041_ VGND VGND VPWR VPWR _08085_ sky130_fd_sc_hd__nand2_1
X_15808_ _06879_ _06930_ VGND VGND VPWR VPWR _06931_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16788_ _07846_ _07978_ _07980_ _07835_ VGND VGND VPWR VPWR _08009_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15739_ _06843_ _06853_ _06854_ VGND VGND VPWR VPWR _06855_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_47_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09260_ _08554_ _08604_ VGND VGND VPWR VPWR _08624_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_117_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09191_ net337 _04879_ _04890_ VGND VGND VPWR VPWR _08146_ sky130_fd_sc_hd__and3_2
X_17409_ clknet_4_14_0_clock _00087_ VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_117_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08975_ net332 _05715_ _05759_ VGND VGND VPWR VPWR _05770_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_39_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09527_ _00273_ _00337_ VGND VGND VPWR VPWR _00338_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_79_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09458_ _00267_ _00185_ VGND VGND VPWR VPWR _00269_ sky130_fd_sc_hd__and2b_1
XFILLER_0_54_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09389_ _00198_ _00199_ VGND VGND VPWR VPWR _00200_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11420_ net430 net124 _02229_ VGND VGND VPWR VPWR _02231_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_62_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11351_ _02160_ _02161_ net403 net148 VGND VGND VPWR VPWR _02162_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_21_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10302_ _00827_ _01111_ _01112_ VGND VGND VPWR VPWR _01113_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_21_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14070_ net223 _04315_ _05018_ VGND VGND VPWR VPWR _05019_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_128_Left_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11282_ _01561_ net164 _02003_ VGND VGND VPWR VPWR _02093_ sky130_fd_sc_hd__o21a_1
X_13021_ _03863_ _03864_ VGND VGND VPWR VPWR _03865_ sky130_fd_sc_hd__nor2_1
X_10233_ _00736_ _01043_ VGND VGND VPWR VPWR _01044_ sky130_fd_sc_hd__xnor2_4
X_10164_ _00909_ _00911_ VGND VGND VPWR VPWR _00975_ sky130_fd_sc_hd__xor2_1
X_14972_ _05976_ _05978_ VGND VGND VPWR VPWR _06011_ sky130_fd_sc_hd__xor2_1
X_10095_ _00904_ _00900_ VGND VGND VPWR VPWR _00906_ sky130_fd_sc_hd__xor2_1
X_16711_ _07923_ _07897_ _07899_ VGND VGND VPWR VPWR _07924_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13923_ _04852_ _04855_ _04796_ _04856_ VGND VGND VPWR VPWR _04858_ sky130_fd_sc_hd__a211o_2
XFILLER_0_107_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16642_ _07824_ _07847_ VGND VGND VPWR VPWR _07848_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_137_Left_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13854_ _04777_ _04781_ VGND VGND VPWR VPWR _04782_ sky130_fd_sc_hd__and2_1
X_12805_ _03634_ _03647_ VGND VGND VPWR VPWR _03649_ sky130_fd_sc_hd__and2_1
X_16573_ _07626_ _07771_ VGND VGND VPWR VPWR _07773_ sky130_fd_sc_hd__xor2_2
X_13785_ _04698_ _04704_ VGND VGND VPWR VPWR _04706_ sky130_fd_sc_hd__nand2_1
X_10997_ _01805_ _01807_ VGND VGND VPWR VPWR _01808_ sky130_fd_sc_hd__and2b_1
X_15524_ _06616_ _06618_ VGND VGND VPWR VPWR _06619_ sky130_fd_sc_hd__nor2_1
X_12736_ _03264_ _03578_ VGND VGND VPWR VPWR _03579_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15455_ _06538_ _06541_ _06534_ _06542_ VGND VGND VPWR VPWR _06543_ sky130_fd_sc_hd__nand4bb_4
X_12667_ _03500_ _03505_ VGND VGND VPWR VPWR _03506_ sky130_fd_sc_hd__xor2_1
XFILLER_0_127_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14406_ _05382_ _05388_ VGND VGND VPWR VPWR _05389_ sky130_fd_sc_hd__xnor2_1
X_11618_ _02427_ _02428_ VGND VGND VPWR VPWR _02429_ sky130_fd_sc_hd__xnor2_1
X_15386_ _06465_ _06466_ VGND VGND VPWR VPWR _06467_ sky130_fd_sc_hd__nor2_1
XFILLER_0_108_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12598_ _03372_ _03347_ _03436_ VGND VGND VPWR VPWR _03437_ sky130_fd_sc_hd__and3_1
XFILLER_0_52_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17125_ _08307_ _08353_ _08379_ VGND VGND VPWR VPWR _08380_ sky130_fd_sc_hd__o21a_2
XFILLER_0_25_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_146_Left_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14337_ net381 net120 _05312_ VGND VGND VPWR VPWR _05313_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_80_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11549_ _02358_ _02359_ VGND VGND VPWR VPWR _02360_ sky130_fd_sc_hd__nor2_1
X_17056_ _08301_ _08302_ VGND VGND VPWR VPWR _08304_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14268_ _03160_ _05236_ VGND VGND VPWR VPWR _05237_ sky130_fd_sc_hd__or2_1
XFILLER_0_111_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16007_ net292 _05975_ _06819_ VGND VGND VPWR VPWR _07150_ sky130_fd_sc_hd__and3_1
X_13219_ _04068_ _04081_ VGND VGND VPWR VPWR _04083_ sky130_fd_sc_hd__or2_1
X_14199_ _05153_ _05156_ _05160_ VGND VGND VPWR VPWR _05161_ sky130_fd_sc_hd__a21o_1
XFILLER_0_148_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08760_ net54 _03318_ _03351_ net279 VGND VGND VPWR VPWR _00052_ sky130_fd_sc_hd__a22o_1
X_16909_ _07985_ _08033_ _08140_ _08141_ VGND VGND VPWR VPWR _08142_ sky130_fd_sc_hd__o22a_1
X_09312_ _08675_ VGND VGND VPWR VPWR _08676_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_75_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09243_ _08190_ _08212_ VGND VGND VPWR VPWR _08607_ sky130_fd_sc_hd__xor2_1
XFILLER_0_75_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09174_ _04549_ _07948_ VGND VGND VPWR VPWR _07959_ sky130_fd_sc_hd__or2_1
XFILLER_0_133_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08958_ net321 _04934_ VGND VGND VPWR VPWR _05583_ sky130_fd_sc_hd__nand2_1
X_08889_ _04681_ _04813_ VGND VGND VPWR VPWR _04824_ sky130_fd_sc_hd__xnor2_1
X_10920_ _01718_ _01730_ VGND VGND VPWR VPWR _01731_ sky130_fd_sc_hd__nand2_1
X_10851_ _01650_ _01651_ VGND VGND VPWR VPWR _01662_ sky130_fd_sc_hd__or2b_1
X_13570_ _04465_ _04468_ VGND VGND VPWR VPWR _04469_ sky130_fd_sc_hd__or2b_1
XFILLER_0_94_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10782_ _01497_ _01499_ _01498_ VGND VGND VPWR VPWR _01593_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_137_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12521_ net193 _03286_ _03359_ VGND VGND VPWR VPWR _03360_ sky130_fd_sc_hd__and3_1
XFILLER_0_93_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15240_ net281 _05631_ _06301_ _06305_ VGND VGND VPWR VPWR _06306_ sky130_fd_sc_hd__a31o_1
X_12452_ _03283_ VGND VGND VPWR VPWR _03284_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11403_ _02128_ _02212_ VGND VGND VPWR VPWR _02214_ sky130_fd_sc_hd__xnor2_2
X_15171_ net266 _05584_ VGND VGND VPWR VPWR _06230_ sky130_fd_sc_hd__nand2_1
XFILLER_0_62_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12383_ _03180_ _03214_ VGND VGND VPWR VPWR _03215_ sky130_fd_sc_hd__xnor2_4
X_14122_ _05049_ _05053_ _05054_ _05075_ VGND VGND VPWR VPWR _05076_ sky130_fd_sc_hd__or4bb_1
XFILLER_0_22_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11334_ net430 net119 _01939_ VGND VGND VPWR VPWR _02145_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_50_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14053_ net222 _04107_ _04993_ VGND VGND VPWR VPWR _05001_ sky130_fd_sc_hd__nand3_1
X_11265_ _01978_ _02075_ VGND VGND VPWR VPWR _02076_ sky130_fd_sc_hd__nor2_1
X_13004_ _03367_ _03321_ _03806_ VGND VGND VPWR VPWR _03848_ sky130_fd_sc_hd__a21oi_1
X_10216_ _01020_ _01025_ _00950_ _01026_ VGND VGND VPWR VPWR _01027_ sky130_fd_sc_hd__o211ai_4
X_11196_ _02001_ _02004_ _02006_ VGND VGND VPWR VPWR _02007_ sky130_fd_sc_hd__o21ai_1
X_10147_ _00956_ _00957_ VGND VGND VPWR VPWR _00958_ sky130_fd_sc_hd__or2b_1
XFILLER_0_118_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14955_ _05985_ _05992_ VGND VGND VPWR VPWR _05993_ sky130_fd_sc_hd__and2_1
X_10078_ _00858_ _00887_ _00888_ VGND VGND VPWR VPWR _00889_ sky130_fd_sc_hd__a21boi_2
X_13906_ net192 net518 _04759_ VGND VGND VPWR VPWR _04839_ sky130_fd_sc_hd__a21oi_1
X_14886_ _05900_ _05916_ VGND VGND VPWR VPWR _05917_ sky130_fd_sc_hd__xor2_1
XFILLER_0_58_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16625_ _07824_ _05432_ VGND VGND VPWR VPWR _07830_ sky130_fd_sc_hd__xnor2_1
X_13837_ _04750_ _04762_ _04684_ VGND VGND VPWR VPWR _04763_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_9_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16556_ _05449_ _05453_ VGND VGND VPWR VPWR _07754_ sky130_fd_sc_hd__nor2_1
X_13768_ _04678_ _04682_ _04675_ VGND VGND VPWR VPWR _04687_ sky130_fd_sc_hd__o21a_1
XFILLER_0_18_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15507_ _06598_ _06599_ VGND VGND VPWR VPWR _06600_ sky130_fd_sc_hd__xor2_1
X_12719_ _03554_ _03558_ VGND VGND VPWR VPWR _03560_ sky130_fd_sc_hd__nand2_1
X_16487_ _07661_ _07550_ _07677_ VGND VGND VPWR VPWR _07678_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_73_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13699_ _04554_ _04557_ _04556_ VGND VGND VPWR VPWR _04611_ sky130_fd_sc_hd__o21ai_1
X_15438_ _06517_ _06523_ VGND VGND VPWR VPWR _06524_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_150_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15369_ net271 _05603_ _06446_ VGND VGND VPWR VPWR _06448_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_4_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17108_ _08026_ _08360_ _08033_ VGND VGND VPWR VPWR _08361_ sky130_fd_sc_hd__mux2_1
XFILLER_0_123_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09930_ _00701_ _00731_ _00734_ VGND VGND VPWR VPWR _00741_ sky130_fd_sc_hd__a21oi_1
X_17039_ _05382_ _08284_ VGND VGND VPWR VPWR _08285_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09861_ _00665_ _00670_ _00671_ VGND VGND VPWR VPWR _00672_ sky130_fd_sc_hd__o21ba_1
X_08812_ net19 net74 VGND VGND VPWR VPWR _03977_ sky130_fd_sc_hd__or2b_1
X_09792_ _00535_ _00536_ VGND VGND VPWR VPWR _00603_ sky130_fd_sc_hd__xor2_1
X_08743_ net45 _03050_ _03083_ net179 VGND VGND VPWR VPWR _00007_ sky130_fd_sc_hd__a22o_1
XFILLER_0_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09226_ _08300_ _08513_ VGND VGND VPWR VPWR _08521_ sky130_fd_sc_hd__xor2_1
XFILLER_0_63_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09157_ _07750_ _07761_ VGND VGND VPWR VPWR _07772_ sky130_fd_sc_hd__nor2_2
XFILLER_0_31_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09088_ _06837_ _06991_ VGND VGND VPWR VPWR _07013_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11050_ net415 net118 _01791_ _01792_ VGND VGND VPWR VPWR _01861_ sky130_fd_sc_hd__o2bb2a_1
X_10001_ _00809_ _00810_ _00808_ _00811_ VGND VGND VPWR VPWR _00812_ sky130_fd_sc_hd__a211oi_4
X_14740_ net266 _05738_ VGND VGND VPWR VPWR _05756_ sky130_fd_sc_hd__nand2_1
X_11952_ _02727_ _02762_ VGND VGND VPWR VPWR _02763_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10903_ _01712_ _01656_ _01660_ VGND VGND VPWR VPWR _01714_ sky130_fd_sc_hd__nor3_1
X_14671_ _03281_ _03331_ _05679_ VGND VGND VPWR VPWR _05680_ sky130_fd_sc_hd__nor3_1
X_11883_ _02620_ _02693_ VGND VGND VPWR VPWR _02694_ sky130_fd_sc_hd__nand2_1
X_16410_ _06799_ _06806_ _07591_ VGND VGND VPWR VPWR _07593_ sky130_fd_sc_hd__nand3_2
X_13622_ net184 net518 _04524_ _04525_ VGND VGND VPWR VPWR _04526_ sky130_fd_sc_hd__a31o_1
XFILLER_0_129_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17390_ net469 net382 VGND VGND VPWR VPWR _08601_ sky130_fd_sc_hd__or2_1
X_10834_ _01640_ _01642_ _01644_ VGND VGND VPWR VPWR _01645_ sky130_fd_sc_hd__and3_1
XFILLER_0_66_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16341_ net251 net248 _05749_ _05739_ VGND VGND VPWR VPWR _07517_ sky130_fd_sc_hd__nand4_1
X_13553_ _04438_ _04446_ _04448_ _04449_ VGND VGND VPWR VPWR _04451_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_27_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10765_ _01560_ _01566_ _01575_ VGND VGND VPWR VPWR _01576_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_82_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12504_ _03328_ VGND VGND VPWR VPWR _03342_ sky130_fd_sc_hd__buf_2
XFILLER_0_82_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16272_ _07419_ _07421_ _07440_ _07405_ VGND VGND VPWR VPWR _07441_ sky130_fd_sc_hd__and4b_1
XFILLER_0_137_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13484_ _04372_ _04374_ _03282_ net241 VGND VGND VPWR VPWR _04375_ sky130_fd_sc_hd__or4bb_1
XFILLER_0_82_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10696_ net401 net108 VGND VGND VPWR VPWR _01507_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15223_ _06284_ _06285_ VGND VGND VPWR VPWR _06288_ sky130_fd_sc_hd__nor2_1
XFILLER_0_35_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12435_ _03186_ _03266_ VGND VGND VPWR VPWR _03267_ sky130_fd_sc_hd__nand2_2
XFILLER_0_35_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15154_ _06203_ _06209_ _06211_ VGND VGND VPWR VPWR _06212_ sky130_fd_sc_hd__a21o_1
X_12366_ prev_error\[1\] _00517_ VGND VGND VPWR VPWR _03198_ sky130_fd_sc_hd__xnor2_4
XPHY_EDGE_ROW_136_Right_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14105_ net231 _04315_ _04106_ net235 VGND VGND VPWR VPWR _05058_ sky130_fd_sc_hd__a22o_1
X_11317_ _02117_ _02127_ VGND VGND VPWR VPWR _02128_ sky130_fd_sc_hd__nor2_1
X_15085_ _06130_ _06135_ VGND VGND VPWR VPWR _06136_ sky130_fd_sc_hd__xor2_2
X_12297_ _02840_ _03126_ _03127_ VGND VGND VPWR VPWR _03129_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_120_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14036_ net239 _03750_ VGND VGND VPWR VPWR _04982_ sky130_fd_sc_hd__nand2_1
X_11248_ _02057_ _02058_ VGND VGND VPWR VPWR _02059_ sky130_fd_sc_hd__nand2_1
X_11179_ _01969_ _01989_ VGND VGND VPWR VPWR _01990_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15987_ _07070_ _07062_ _07069_ VGND VGND VPWR VPWR _07128_ sky130_fd_sc_hd__nand3_1
XFILLER_0_145_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14938_ _05973_ VGND VGND VPWR VPWR _05974_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_54_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14869_ _05896_ _05856_ _05862_ VGND VGND VPWR VPWR _05898_ sky130_fd_sc_hd__or3_1
X_16608_ i_error\[6\] _07604_ VGND VGND VPWR VPWR _07811_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16539_ _07655_ _07654_ VGND VGND VPWR VPWR _07735_ sky130_fd_sc_hd__or2b_1
XFILLER_0_46_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09011_ _06133_ _06144_ VGND VGND VPWR VPWR _06166_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_103_Right_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09913_ _00721_ _00722_ VGND VGND VPWR VPWR _00724_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09844_ net320 _00654_ VGND VGND VPWR VPWR _00655_ sky130_fd_sc_hd__nand2_1
X_09775_ net341 _07398_ _07321_ net345 VGND VGND VPWR VPWR _00586_ sky130_fd_sc_hd__a22oi_1
X_08726_ _03083_ VGND VGND VPWR VPWR _03094_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_96_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10550_ _01323_ _01337_ _01327_ _01336_ VGND VGND VPWR VPWR _01361_ sky130_fd_sc_hd__and4_1
XFILLER_0_119_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09209_ _06331_ _08333_ _06287_ VGND VGND VPWR VPWR _08344_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_106_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10481_ net362 _00371_ VGND VGND VPWR VPWR _01292_ sky130_fd_sc_hd__nand2_1
X_12220_ net449 net159 net175 net429 VGND VGND VPWR VPWR _03047_ sky130_fd_sc_hd__a22o_1
XFILLER_0_122_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12151_ net429 net449 net150 net168 VGND VGND VPWR VPWR _02976_ sky130_fd_sc_hd__and4_1
XFILLER_0_114_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11102_ _01869_ _01867_ VGND VGND VPWR VPWR _01913_ sky130_fd_sc_hd__xnor2_1
X_12082_ net415 net169 VGND VGND VPWR VPWR _02904_ sky130_fd_sc_hd__nand2_1
X_15910_ _06962_ _06964_ VGND VGND VPWR VPWR _07043_ sky130_fd_sc_hd__xnor2_2
X_11033_ _01769_ _01760_ _01767_ VGND VGND VPWR VPWR _01844_ sky130_fd_sc_hd__nand3_1
X_16890_ _07798_ _08120_ _07968_ VGND VGND VPWR VPWR _08121_ sky130_fd_sc_hd__mux2_1
X_15841_ _06885_ _06933_ _06965_ _06966_ VGND VGND VPWR VPWR _06967_ sky130_fd_sc_hd__o211ai_2
X_15772_ _06880_ _06882_ _06890_ VGND VGND VPWR VPWR _06891_ sky130_fd_sc_hd__a21bo_1
X_12984_ _03821_ _03826_ VGND VGND VPWR VPWR _03828_ sky130_fd_sc_hd__and2_1
XFILLER_0_99_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17511_ clknet_4_5_0_clock _00017_ VGND VGND VPWR VPWR kd_1\[9\] sky130_fd_sc_hd__dfxtp_1
X_14723_ _05736_ VGND VGND VPWR VPWR _05738_ sky130_fd_sc_hd__clkbuf_4
X_11935_ _02667_ _02741_ _02745_ VGND VGND VPWR VPWR _02746_ sky130_fd_sc_hd__or3_1
XFILLER_0_115_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14654_ net249 _05604_ VGND VGND VPWR VPWR _05662_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17442_ clknet_4_8_0_clock _00120_ VGND VGND VPWR VPWR i_error\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_129_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11866_ _02661_ _02647_ VGND VGND VPWR VPWR _02677_ sky130_fd_sc_hd__xnor2_1
X_13605_ _04443_ _04507_ VGND VGND VPWR VPWR _04508_ sky130_fd_sc_hd__nand2_1
XFILLER_0_129_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10817_ _01626_ _01615_ _01601_ VGND VGND VPWR VPWR _01628_ sky130_fd_sc_hd__nand3_1
X_14585_ _03185_ _03239_ VGND VGND VPWR VPWR _05586_ sky130_fd_sc_hd__nand2_2
X_17373_ net467 net417 net456 _08590_ VGND VGND VPWR VPWR _00133_ sky130_fd_sc_hd__o211a_1
XFILLER_0_95_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11797_ _02541_ _02607_ VGND VGND VPWR VPWR _02608_ sky130_fd_sc_hd__or2_1
XFILLER_0_54_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16324_ _06808_ _07496_ _07498_ VGND VGND VPWR VPWR _07499_ sky130_fd_sc_hd__a21o_1
X_13536_ _04427_ _04430_ _04431_ VGND VGND VPWR VPWR _04432_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_137_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10748_ _01522_ _01558_ VGND VGND VPWR VPWR _01559_ sky130_fd_sc_hd__and2b_1
XFILLER_0_82_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16255_ net298 _04312_ _06415_ net302 VGND VGND VPWR VPWR _07423_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_82_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13467_ _04261_ _04260_ VGND VGND VPWR VPWR _04356_ sky130_fd_sc_hd__or2b_2
X_10679_ net406 net109 net105 net412 VGND VGND VPWR VPWR _01490_ sky130_fd_sc_hd__a22o_1
XFILLER_0_125_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15206_ _06096_ _06101_ _06065_ VGND VGND VPWR VPWR _06269_ sky130_fd_sc_hd__o21a_1
X_12418_ _03249_ VGND VGND VPWR VPWR _03250_ sky130_fd_sc_hd__buf_2
XFILLER_0_23_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16186_ net310 net294 _05974_ _06347_ VGND VGND VPWR VPWR _07347_ sky130_fd_sc_hd__nand4_2
X_13398_ _04278_ _04279_ VGND VGND VPWR VPWR _04280_ sky130_fd_sc_hd__and2b_1
XFILLER_0_50_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15137_ _06169_ _06192_ VGND VGND VPWR VPWR _06193_ sky130_fd_sc_hd__or2_1
XFILLER_0_50_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12349_ _04505_ VGND VGND VPWR VPWR _03181_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15068_ _06112_ _06113_ _06116_ VGND VGND VPWR VPWR _06117_ sky130_fd_sc_hd__a21o_2
XFILLER_0_121_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14019_ _04921_ _04922_ VGND VGND VPWR VPWR _04963_ sky130_fd_sc_hd__xor2_1
X_09560_ _00370_ VGND VGND VPWR VPWR _00371_ sky130_fd_sc_hd__clkbuf_4
X_09491_ _00247_ _00248_ VGND VGND VPWR VPWR _00302_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_18_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_872 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout400 prev_d_error\[12\] VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__clkbuf_4
Xfanout411 prev_d_error\[9\] VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__clkbuf_2
Xfanout422 prev_d_error\[6\] VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout433 net434 VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__buf_2
Xfanout444 prev_d_error\[1\] VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__buf_2
Xfanout455 net459 VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__clkbuf_2
Xfanout466 net468 VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__buf_2
X_09827_ _00545_ _00636_ VGND VGND VPWR VPWR _00638_ sky130_fd_sc_hd__nand2_1
X_09758_ net361 _04769_ _00568_ _00567_ VGND VGND VPWR VPWR _00569_ sky130_fd_sc_hd__nand4_2
XFILLER_0_69_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08709_ _02905_ VGND VGND VPWR VPWR _02916_ sky130_fd_sc_hd__buf_2
X_09689_ _00424_ _00438_ VGND VGND VPWR VPWR _00500_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_68_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11720_ _02527_ _02525_ VGND VGND VPWR VPWR _02531_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_37_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11651_ _02456_ _02458_ _02460_ VGND VGND VPWR VPWR _02462_ sky130_fd_sc_hd__or3_1
XFILLER_0_139_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10602_ _01411_ _01412_ VGND VGND VPWR VPWR _01413_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_119_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14370_ _05347_ _05348_ VGND VGND VPWR VPWR _05349_ sky130_fd_sc_hd__or2_1
X_11582_ _02308_ _02392_ VGND VGND VPWR VPWR _02393_ sky130_fd_sc_hd__nor2_1
X_13321_ net245 VGND VGND VPWR VPWR _04195_ sky130_fd_sc_hd__inv_2
XFILLER_0_51_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10533_ _01305_ _01313_ _01312_ VGND VGND VPWR VPWR _01344_ sky130_fd_sc_hd__a21o_1
XFILLER_0_150_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16040_ net301 _05973_ _07184_ VGND VGND VPWR VPWR _07186_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_107_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13252_ _03283_ _03366_ _04118_ VGND VGND VPWR VPWR _04119_ sky130_fd_sc_hd__a21oi_1
X_10464_ _01254_ _01274_ VGND VGND VPWR VPWR _01275_ sky130_fd_sc_hd__xor2_1
XFILLER_0_33_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12203_ _03026_ _03020_ _03025_ VGND VGND VPWR VPWR _03029_ sky130_fd_sc_hd__nand3_1
X_13183_ net208 net203 _03249_ _03260_ VGND VGND VPWR VPWR _04044_ sky130_fd_sc_hd__and4_1
X_10395_ net379 _00238_ _00239_ VGND VGND VPWR VPWR _01206_ sky130_fd_sc_hd__and3_1
X_12134_ _02955_ _02947_ _02953_ VGND VGND VPWR VPWR _02959_ sky130_fd_sc_hd__nand3_1
X_16942_ _08176_ _08177_ _08033_ VGND VGND VPWR VPWR _08178_ sky130_fd_sc_hd__mux2_1
X_12065_ net428 net446 net138 net154 VGND VGND VPWR VPWR _02886_ sky130_fd_sc_hd__and4_1
X_11016_ net395 net140 net136 net399 VGND VGND VPWR VPWR _01827_ sky130_fd_sc_hd__a22oi_1
X_16873_ _08090_ _08092_ _08101_ VGND VGND VPWR VPWR _08103_ sky130_fd_sc_hd__and3_1
X_15824_ _06934_ _06948_ VGND VGND VPWR VPWR _06949_ sky130_fd_sc_hd__and2b_1
XFILLER_0_126_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15755_ _06871_ _06872_ VGND VGND VPWR VPWR _06873_ sky130_fd_sc_hd__xor2_1
X_12967_ _03808_ _03810_ VGND VGND VPWR VPWR _03811_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_35_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14706_ _03177_ _05678_ _05625_ _03281_ _05718_ VGND VGND VPWR VPWR _05719_ sky130_fd_sc_hd__a311o_4
X_11918_ _02654_ _02728_ VGND VGND VPWR VPWR _02729_ sky130_fd_sc_hd__xnor2_1
X_15686_ _06795_ _06781_ _06786_ VGND VGND VPWR VPWR _06797_ sky130_fd_sc_hd__and3_1
X_12898_ net193 _03249_ _03261_ net190 VGND VGND VPWR VPWR _03742_ sky130_fd_sc_hd__a22o_1
XFILLER_0_75_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17425_ clknet_4_2_0_clock _00103_ VGND VGND VPWR VPWR prev_error\[13\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_68_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14637_ net252 _05622_ VGND VGND VPWR VPWR _05643_ sky130_fd_sc_hd__nand2_1
X_11849_ _02657_ _02659_ VGND VGND VPWR VPWR _02660_ sky130_fd_sc_hd__or2b_1
XFILLER_0_117_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17356_ net463 i_error\[17\] VGND VGND VPWR VPWR _08581_ sky130_fd_sc_hd__or2_1
X_14568_ _03931_ _05565_ _05566_ VGND VGND VPWR VPWR _05567_ sky130_fd_sc_hd__a21o_2
XFILLER_0_129_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16307_ _07335_ _07340_ _07292_ VGND VGND VPWR VPWR _07480_ sky130_fd_sc_hd__or3b_1
X_13519_ net212 _03578_ _04411_ _04412_ VGND VGND VPWR VPWR _04413_ sky130_fd_sc_hd__a31oi_2
X_14499_ _05472_ _05474_ _05489_ VGND VGND VPWR VPWR _05491_ sky130_fd_sc_hd__and3_1
XFILLER_0_70_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17287_ net462 prev_error\[2\] VGND VGND VPWR VPWR _08538_ sky130_fd_sc_hd__or2_1
X_16238_ _07396_ _07385_ _07394_ VGND VGND VPWR VPWR _07404_ sky130_fd_sc_hd__nor3_1
XFILLER_0_3_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16169_ _07278_ _07324_ _07323_ _07319_ VGND VGND VPWR VPWR _07328_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_11_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08991_ _05858_ _05891_ _05924_ VGND VGND VPWR VPWR _05946_ sky130_fd_sc_hd__nand3_1
XFILLER_0_76_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09612_ _00394_ _00387_ VGND VGND VPWR VPWR _00423_ sky130_fd_sc_hd__nor2_1
X_09543_ _00333_ _00352_ VGND VGND VPWR VPWR _00354_ sky130_fd_sc_hd__or2b_1
X_09474_ _00221_ _00284_ VGND VGND VPWR VPWR _00285_ sky130_fd_sc_hd__and2_1
XFILLER_0_148_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10180_ net342 net339 _00315_ _00372_ VGND VGND VPWR VPWR _00991_ sky130_fd_sc_hd__and4_1
Xfanout230 net231 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__clkbuf_4
Xfanout241 net243 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_100_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout252 net253 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__clkbuf_2
Xfanout263 net264 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__clkbuf_4
Xfanout274 net276 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__clkbuf_4
Xfanout285 net287 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__clkbuf_4
Xfanout296 net299 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__clkbuf_4
X_13870_ _04726_ _04797_ _04792_ _04796_ VGND VGND VPWR VPWR _04799_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_97_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12821_ _03190_ _08680_ VGND VGND VPWR VPWR _03665_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_139_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12752_ _03565_ _03562_ VGND VGND VPWR VPWR _03596_ sky130_fd_sc_hd__and2b_1
X_15540_ _06630_ _06635_ VGND VGND VPWR VPWR _06636_ sky130_fd_sc_hd__and2_1
XFILLER_0_69_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11703_ _02510_ _02512_ VGND VGND VPWR VPWR _02514_ sky130_fd_sc_hd__or2_1
X_15471_ _06554_ _06559_ VGND VGND VPWR VPWR _06560_ sky130_fd_sc_hd__xor2_2
X_12683_ _03416_ _03521_ VGND VGND VPWR VPWR _03522_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_127_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14422_ _05357_ _05405_ VGND VGND VPWR VPWR _05406_ sky130_fd_sc_hd__xnor2_1
X_17210_ _08109_ _08131_ _08134_ VGND VGND VPWR VPWR _08473_ sky130_fd_sc_hd__a21oi_1
X_11634_ _02378_ _02375_ _02444_ VGND VGND VPWR VPWR _02445_ sky130_fd_sc_hd__o21a_1
XFILLER_0_37_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17141_ _08279_ _08293_ _08292_ VGND VGND VPWR VPWR _08397_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_92_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14353_ net389 net108 VGND VGND VPWR VPWR _05331_ sky130_fd_sc_hd__nand2_1
X_11565_ _02284_ _02283_ VGND VGND VPWR VPWR _02376_ sky130_fd_sc_hd__and2b_1
XFILLER_0_25_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13304_ _04165_ _04176_ VGND VGND VPWR VPWR _04177_ sky130_fd_sc_hd__xor2_1
X_10516_ net358 _00652_ _01321_ _01322_ VGND VGND VPWR VPWR _01327_ sky130_fd_sc_hd__a22o_1
X_17072_ _01563_ net120 VGND VGND VPWR VPWR _08321_ sky130_fd_sc_hd__nor2_1
X_14284_ _05252_ _05254_ VGND VGND VPWR VPWR _05255_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11496_ _02295_ _02297_ VGND VGND VPWR VPWR _02307_ sky130_fd_sc_hd__and2_1
XFILLER_0_80_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16023_ _07151_ _07154_ VGND VGND VPWR VPWR _07168_ sky130_fd_sc_hd__and2_1
X_13235_ net192 net188 _03668_ net519 VGND VGND VPWR VPWR _04101_ sky130_fd_sc_hd__and4_1
X_10447_ net342 _00654_ _01257_ VGND VGND VPWR VPWR _01258_ sky130_fd_sc_hd__and3_1
XFILLER_0_123_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13166_ net213 _03217_ VGND VGND VPWR VPWR _04025_ sky130_fd_sc_hd__nand2_1
X_10378_ _01142_ _01140_ _01139_ VGND VGND VPWR VPWR _01189_ sky130_fd_sc_hd__a21o_1
XFILLER_0_20_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12117_ net433 net437 net161 net162 VGND VGND VPWR VPWR _02942_ sky130_fd_sc_hd__and4_1
X_13097_ _03869_ _03868_ VGND VGND VPWR VPWR _03949_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16925_ _08109_ _08132_ _08137_ _08159_ VGND VGND VPWR VPWR _08160_ sky130_fd_sc_hd__a211oi_4
X_12048_ net433 net437 net154 net158 VGND VGND VPWR VPWR _02867_ sky130_fd_sc_hd__and4_1
XFILLER_0_46_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16856_ _08082_ _07969_ _08041_ _08083_ VGND VGND VPWR VPWR _08084_ sky130_fd_sc_hd__a211o_1
X_15807_ _06876_ _06878_ VGND VGND VPWR VPWR _06930_ sky130_fd_sc_hd__or2_1
X_16787_ _07999_ _08004_ _07989_ _08005_ _08007_ VGND VGND VPWR VPWR _08008_ sky130_fd_sc_hd__a2111o_1
X_13999_ _04872_ _04875_ _04873_ VGND VGND VPWR VPWR _04941_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_48_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15738_ _06845_ _06852_ VGND VGND VPWR VPWR _06854_ sky130_fd_sc_hd__or2b_1
XFILLER_0_62_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15669_ _06754_ _06777_ VGND VGND VPWR VPWR _06778_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_145_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17408_ clknet_4_10_0_clock _00086_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_117_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09190_ _08124_ _07145_ VGND VGND VPWR VPWR _08135_ sky130_fd_sc_hd__xor2_1
XFILLER_0_16_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17339_ _08564_ _08178_ _08570_ net452 VGND VGND VPWR VPWR _00116_ sky130_fd_sc_hd__o211a_1
XFILLER_0_126_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08974_ _05418_ VGND VGND VPWR VPWR _05759_ sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09526_ net356 _05022_ VGND VGND VPWR VPWR _00337_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09457_ _00185_ _00267_ VGND VGND VPWR VPWR _00268_ sky130_fd_sc_hd__and2b_1
XFILLER_0_109_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_49_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09388_ net348 _04923_ _05011_ net352 VGND VGND VPWR VPWR _00199_ sky130_fd_sc_hd__a22o_1
XFILLER_0_19_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11350_ net408 net144 _02071_ VGND VGND VPWR VPWR _02161_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_104_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10301_ net363 _08680_ _04593_ net379 VGND VGND VPWR VPWR _01112_ sky130_fd_sc_hd__a22o_1
XFILLER_0_120_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11281_ _02090_ _02091_ net391 net155 VGND VGND VPWR VPWR _02092_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_132_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13020_ _03846_ _03862_ VGND VGND VPWR VPWR _03864_ sky130_fd_sc_hd__and2_1
X_10232_ net363 net523 VGND VGND VPWR VPWR _01043_ sky130_fd_sc_hd__nand2_2
X_10163_ _00971_ _00972_ _00973_ VGND VGND VPWR VPWR _00974_ sky130_fd_sc_hd__nor3_1
X_14971_ net255 _05604_ _06009_ VGND VGND VPWR VPWR _06010_ sky130_fd_sc_hd__and3_1
X_10094_ _00900_ _00904_ VGND VGND VPWR VPWR _00905_ sky130_fd_sc_hd__and2b_1
X_16710_ _07896_ VGND VGND VPWR VPWR _07923_ sky130_fd_sc_hd__inv_2
XFILLER_0_89_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13922_ _04790_ _04795_ _04794_ VGND VGND VPWR VPWR _04856_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_16_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16641_ _05464_ _05427_ VGND VGND VPWR VPWR _07847_ sky130_fd_sc_hd__and2b_1
X_13853_ _04777_ _04778_ _04779_ VGND VGND VPWR VPWR _04781_ sky130_fd_sc_hd__nand3_2
X_12804_ _03634_ _03647_ VGND VGND VPWR VPWR _03648_ sky130_fd_sc_hd__nor2_1
X_16572_ _07630_ _07628_ VGND VGND VPWR VPWR _07771_ sky130_fd_sc_hd__or2b_1
X_13784_ _04698_ _04704_ VGND VGND VPWR VPWR _04705_ sky130_fd_sc_hd__xnor2_1
X_10996_ _01734_ _01806_ VGND VGND VPWR VPWR _01807_ sky130_fd_sc_hd__nor2_1
XFILLER_0_69_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15523_ _06614_ _06615_ _06613_ VGND VGND VPWR VPWR _06618_ sky130_fd_sc_hd__o21a_1
XFILLER_0_139_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12735_ _03577_ VGND VGND VPWR VPWR _03578_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_139_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15454_ _06510_ _06525_ _06533_ VGND VGND VPWR VPWR _06542_ sky130_fd_sc_hd__a21o_1
X_12666_ _03501_ _03504_ VGND VGND VPWR VPWR _03505_ sky130_fd_sc_hd__xor2_1
XFILLER_0_72_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11617_ _02372_ _02350_ _02371_ VGND VGND VPWR VPWR _02428_ sky130_fd_sc_hd__o21a_1
X_14405_ _05386_ _05387_ VGND VGND VPWR VPWR _05388_ sky130_fd_sc_hd__xnor2_1
X_15385_ _06443_ _06461_ _06464_ VGND VGND VPWR VPWR _06466_ sky130_fd_sc_hd__nor3_1
XFILLER_0_108_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12597_ net207 net203 VGND VGND VPWR VPWR _03436_ sky130_fd_sc_hd__or2_1
X_17124_ _05415_ _08356_ _08354_ VGND VGND VPWR VPWR _08379_ sky130_fd_sc_hd__a21o_1
X_11548_ _02354_ _02355_ _02357_ VGND VGND VPWR VPWR _02359_ sky130_fd_sc_hd__and3_1
X_14336_ net385 net113 VGND VGND VPWR VPWR _05312_ sky130_fd_sc_hd__nand2_1
X_17055_ _08301_ _08302_ VGND VGND VPWR VPWR _08303_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14267_ _03159_ _02399_ _03157_ VGND VGND VPWR VPWR _05236_ sky130_fd_sc_hd__and3_1
X_11479_ _02266_ _02268_ VGND VGND VPWR VPWR _02290_ sky130_fd_sc_hd__nor2_2
XFILLER_0_21_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16006_ net278 _06349_ _07147_ _07148_ VGND VGND VPWR VPWR _07149_ sky130_fd_sc_hd__a31o_1
X_13218_ _04068_ _04081_ VGND VGND VPWR VPWR _04082_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_21_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14198_ _05128_ _05130_ _05148_ _05147_ _05159_ VGND VGND VPWR VPWR _05160_ sky130_fd_sc_hd__a32o_1
X_13149_ _03263_ _04004_ _04005_ VGND VGND VPWR VPWR _04006_ sky130_fd_sc_hd__or3_1
XFILLER_0_0_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16908_ _07810_ net504 net483 VGND VGND VPWR VPWR _08141_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16839_ _07996_ _08064_ _08032_ VGND VGND VPWR VPWR _08065_ sky130_fd_sc_hd__mux2_4
XFILLER_0_48_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09311_ _08674_ VGND VGND VPWR VPWR _08675_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_146_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09242_ _08597_ _08579_ VGND VGND VPWR VPWR _08606_ sky130_fd_sc_hd__and2b_1
XFILLER_0_8_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09173_ _07937_ VGND VGND VPWR VPWR _07948_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_145_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08957_ _05561_ VGND VGND VPWR VPWR _05572_ sky130_fd_sc_hd__clkbuf_4
X_08888_ _04791_ _04461_ _04802_ VGND VGND VPWR VPWR _04813_ sky130_fd_sc_hd__o21a_1
X_10850_ _01604_ _01632_ _01630_ VGND VGND VPWR VPWR _01661_ sky130_fd_sc_hd__o21ai_1
X_09509_ _00317_ _00319_ VGND VGND VPWR VPWR _00320_ sky130_fd_sc_hd__or2b_1
XFILLER_0_149_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10781_ _01578_ _01591_ VGND VGND VPWR VPWR _01592_ sky130_fd_sc_hd__or2b_1
XFILLER_0_93_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12520_ net188 _03332_ _03333_ VGND VGND VPWR VPWR _03359_ sky130_fd_sc_hd__and3_1
XFILLER_0_54_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_117_Right_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12451_ _03282_ VGND VGND VPWR VPWR _03283_ sky130_fd_sc_hd__buf_2
XFILLER_0_136_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11402_ _02128_ _02212_ VGND VGND VPWR VPWR _02213_ sky130_fd_sc_hd__and2_1
X_15170_ _06227_ _06228_ VGND VGND VPWR VPWR _06229_ sky130_fd_sc_hd__nand2_1
X_12382_ _03182_ _03183_ _03212_ _03213_ VGND VGND VPWR VPWR _03214_ sky130_fd_sc_hd__a31o_2
XFILLER_0_34_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14121_ _05071_ _05073_ _05042_ _05074_ VGND VGND VPWR VPWR _05075_ sky130_fd_sc_hd__o211a_1
X_11333_ net430 net119 _01939_ VGND VGND VPWR VPWR _02144_ sky130_fd_sc_hd__and3_1
XFILLER_0_132_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14052_ _04990_ _04997_ _04998_ VGND VGND VPWR VPWR _04999_ sky130_fd_sc_hd__o21ai_2
X_11264_ net403 net141 _01976_ _01977_ VGND VGND VPWR VPWR _02075_ sky130_fd_sc_hd__o2bb2a_1
X_13003_ _03811_ _03816_ VGND VGND VPWR VPWR _03847_ sky130_fd_sc_hd__xor2_1
X_10215_ _00946_ _00949_ _00948_ VGND VGND VPWR VPWR _01026_ sky130_fd_sc_hd__a21o_1
X_11195_ _02000_ _02005_ VGND VGND VPWR VPWR _02006_ sky130_fd_sc_hd__and2_1
X_10146_ _00884_ _00885_ VGND VGND VPWR VPWR _00957_ sky130_fd_sc_hd__xor2_4
X_14954_ _05989_ _05991_ VGND VGND VPWR VPWR _05992_ sky130_fd_sc_hd__nor2_1
X_10077_ _00882_ _00886_ _00781_ _00859_ VGND VGND VPWR VPWR _00888_ sky130_fd_sc_hd__o211ai_2
X_13905_ _04822_ _04825_ _04830_ VGND VGND VPWR VPWR _04838_ sky130_fd_sc_hd__a21o_1
X_14885_ _05911_ _05915_ VGND VGND VPWR VPWR _05916_ sky130_fd_sc_hd__nor2_1
X_16624_ _07584_ net480 VGND VGND VPWR VPWR _07829_ sky130_fd_sc_hd__xor2_2
XFILLER_0_58_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13836_ _04751_ _04761_ VGND VGND VPWR VPWR _04762_ sky130_fd_sc_hd__nor2_1
XFILLER_0_134_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16555_ _07751_ _07752_ VGND VGND VPWR VPWR _07753_ sky130_fd_sc_hd__nand2_2
XFILLER_0_84_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13767_ _04684_ _04685_ VGND VGND VPWR VPWR _04686_ sky130_fd_sc_hd__nor2_1
X_10979_ _01524_ _01729_ VGND VGND VPWR VPWR _01790_ sky130_fd_sc_hd__xor2_1
XFILLER_0_57_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15506_ net274 _05974_ VGND VGND VPWR VPWR _06599_ sky130_fd_sc_hd__nand2_1
XFILLER_0_127_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12718_ _03554_ _03558_ VGND VGND VPWR VPWR _03559_ sky130_fd_sc_hd__or2_1
X_16486_ _07675_ _07676_ VGND VGND VPWR VPWR _07677_ sky130_fd_sc_hd__and2_1
XFILLER_0_45_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13698_ _04534_ _04561_ VGND VGND VPWR VPWR _04610_ sky130_fd_sc_hd__xor2_4
XFILLER_0_73_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15437_ _06519_ _06522_ VGND VGND VPWR VPWR _06523_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_127_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12649_ _03480_ _03487_ VGND VGND VPWR VPWR _03488_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_26_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15368_ net271 _05603_ _06446_ VGND VGND VPWR VPWR _06447_ sky130_fd_sc_hd__and3_1
XFILLER_0_81_882 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17107_ _08359_ _07918_ _07971_ VGND VGND VPWR VPWR _08360_ sky130_fd_sc_hd__mux2_1
XFILLER_0_130_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14319_ _05240_ _05291_ _05292_ VGND VGND VPWR VPWR _05293_ sky130_fd_sc_hd__a21bo_4
XFILLER_0_7_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15299_ net300 _05721_ _05722_ VGND VGND VPWR VPWR _06371_ sky130_fd_sc_hd__and3_1
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17038_ _08282_ _08283_ VGND VGND VPWR VPWR _08284_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09860_ _00590_ _00594_ VGND VGND VPWR VPWR _00671_ sky130_fd_sc_hd__xor2_1
X_08811_ _03944_ _03955_ VGND VGND VPWR VPWR _03966_ sky130_fd_sc_hd__nand2_1
X_09791_ _00566_ _00600_ _00601_ VGND VGND VPWR VPWR _00602_ sky130_fd_sc_hd__o21bai_2
X_08742_ net44 _03050_ _03083_ net183 VGND VGND VPWR VPWR _00006_ sky130_fd_sc_hd__a22o_1
XFILLER_0_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_879 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09225_ _08497_ _08505_ VGND VGND VPWR VPWR _08513_ sky130_fd_sc_hd__nand2_1
XFILLER_0_17_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09156_ _07068_ _07739_ VGND VGND VPWR VPWR _07761_ sky130_fd_sc_hd__and2_1
XFILLER_0_90_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09087_ _06837_ _06991_ VGND VGND VPWR VPWR _07002_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10000_ _00806_ _00807_ _00783_ _00805_ VGND VGND VPWR VPWR _00811_ sky130_fd_sc_hd__a211oi_4
X_09989_ _00656_ _00798_ VGND VGND VPWR VPWR _00800_ sky130_fd_sc_hd__nor2_1
X_11951_ net424 net152 _02725_ _02726_ VGND VGND VPWR VPWR _02762_ sky130_fd_sc_hd__o2bb2a_1
X_10902_ _01656_ _01660_ _01712_ VGND VGND VPWR VPWR _01713_ sky130_fd_sc_hd__o21a_1
XFILLER_0_98_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14670_ _03219_ _05677_ _05678_ VGND VGND VPWR VPWR _05679_ sky130_fd_sc_hd__o21a_1
XFILLER_0_58_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11882_ _02617_ _02619_ VGND VGND VPWR VPWR _02693_ sky130_fd_sc_hd__or2_1
X_13621_ net192 net188 _04107_ _04003_ VGND VGND VPWR VPWR _04525_ sky130_fd_sc_hd__and4_1
X_10833_ _01508_ _01641_ _01643_ VGND VGND VPWR VPWR _01644_ sky130_fd_sc_hd__or3_1
XFILLER_0_104_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16340_ net524 _05746_ VGND VGND VPWR VPWR _07516_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13552_ _03263_ _04319_ VGND VGND VPWR VPWR _04449_ sky130_fd_sc_hd__or2_1
X_10764_ _01573_ _01574_ VGND VGND VPWR VPWR _01575_ sky130_fd_sc_hd__and2_1
XFILLER_0_137_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12503_ net198 _03337_ _03339_ VGND VGND VPWR VPWR _03341_ sky130_fd_sc_hd__and3_1
X_16271_ _07437_ _07439_ VGND VGND VPWR VPWR _07440_ sky130_fd_sc_hd__or2_1
X_13483_ net233 _03215_ _03221_ net236 VGND VGND VPWR VPWR _04374_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_81_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10695_ net401 net112 _01490_ _01489_ net108 VGND VGND VPWR VPWR _01506_ sky130_fd_sc_hd__a32o_1
XFILLER_0_125_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15222_ _06284_ _06285_ VGND VGND VPWR VPWR _06286_ sky130_fd_sc_hd__xor2_2
X_12434_ prev_error\[8\] _07387_ VGND VGND VPWR VPWR _03266_ sky130_fd_sc_hd__or2b_1
X_15153_ _06198_ _06201_ VGND VGND VPWR VPWR _06211_ sky130_fd_sc_hd__xnor2_1
X_12365_ prev_error\[0\] _00799_ VGND VGND VPWR VPWR _03197_ sky130_fd_sc_hd__nand2_2
XFILLER_0_133_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14104_ _05028_ _05056_ VGND VGND VPWR VPWR _05057_ sky130_fd_sc_hd__nor2_1
X_11316_ _02114_ _02116_ VGND VGND VPWR VPWR _02127_ sky130_fd_sc_hd__and2_1
X_15084_ net269 _05621_ _06047_ _06134_ VGND VGND VPWR VPWR _06135_ sky130_fd_sc_hd__a31o_1
XFILLER_0_120_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12296_ _02840_ _03126_ _03127_ VGND VGND VPWR VPWR _03128_ sky130_fd_sc_hd__and3_1
X_14035_ _04935_ _04980_ VGND VGND VPWR VPWR _04981_ sky130_fd_sc_hd__xor2_2
X_11247_ _02056_ _02051_ VGND VGND VPWR VPWR _02058_ sky130_fd_sc_hd__or2b_1
XFILLER_0_120_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11178_ _01968_ _01953_ _01967_ VGND VGND VPWR VPWR _01989_ sky130_fd_sc_hd__nor3_1
X_10129_ _00903_ _00901_ VGND VGND VPWR VPWR _00940_ sky130_fd_sc_hd__or2b_1
X_15986_ _07121_ _07122_ _07115_ VGND VGND VPWR VPWR _07127_ sky130_fd_sc_hd__o21ai_1
X_14937_ net522 _05571_ VGND VGND VPWR VPWR _05973_ sky130_fd_sc_hd__xor2_4
X_14868_ _05856_ _05862_ _05896_ VGND VGND VPWR VPWR _05897_ sky130_fd_sc_hd__o21a_1
XFILLER_0_148_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16607_ _07726_ _07809_ VGND VGND VPWR VPWR _07810_ sky130_fd_sc_hd__nor2_1
X_13819_ _04665_ _04742_ VGND VGND VPWR VPWR _04743_ sky130_fd_sc_hd__xor2_1
X_14799_ net251 net248 _05746_ _05749_ VGND VGND VPWR VPWR _05821_ sky130_fd_sc_hd__and4_1
X_16538_ _07576_ _07649_ VGND VGND VPWR VPWR _07734_ sky130_fd_sc_hd__nand2_1
XFILLER_0_73_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16469_ _07570_ _07657_ VGND VGND VPWR VPWR _07658_ sky130_fd_sc_hd__nand2_1
X_09010_ _06133_ _06144_ VGND VGND VPWR VPWR _06155_ sky130_fd_sc_hd__or2_1
XFILLER_0_128_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_882 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09912_ _00721_ _00722_ VGND VGND VPWR VPWR _00723_ sky130_fd_sc_hd__or2_1
X_09843_ _00653_ VGND VGND VPWR VPWR _00654_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_13_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09774_ net338 _07937_ VGND VGND VPWR VPWR _00585_ sky130_fd_sc_hd__nand2_1
X_08725_ _03072_ VGND VGND VPWR VPWR _03083_ sky130_fd_sc_hd__buf_2
XFILLER_0_95_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_22_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09208_ _05539_ _08058_ VGND VGND VPWR VPWR _08333_ sky130_fd_sc_hd__xor2_1
XFILLER_0_63_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10480_ _01250_ _01269_ _01270_ _01268_ VGND VGND VPWR VPWR _01291_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_106_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09139_ _07299_ _07563_ VGND VGND VPWR VPWR _07574_ sky130_fd_sc_hd__and2b_1
X_12150_ net449 net153 net168 net429 VGND VGND VPWR VPWR _02975_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_20_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11101_ _01524_ _01799_ VGND VGND VPWR VPWR _01912_ sky130_fd_sc_hd__xor2_1
X_12081_ _02878_ _02880_ _02877_ VGND VGND VPWR VPWR _02903_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11032_ _01842_ _01818_ VGND VGND VPWR VPWR _01843_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_31_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15840_ _06960_ _06961_ VGND VGND VPWR VPWR _06966_ sky130_fd_sc_hd__nand2_1
X_15771_ _06879_ _06883_ VGND VGND VPWR VPWR _06890_ sky130_fd_sc_hd__or2_1
X_12983_ _03821_ _03826_ VGND VGND VPWR VPWR _03827_ sky130_fd_sc_hd__nor2_1
X_17510_ clknet_4_1_0_clock _00016_ VGND VGND VPWR VPWR kd_1\[8\] sky130_fd_sc_hd__dfxtp_1
X_14722_ _05735_ VGND VGND VPWR VPWR _05736_ sky130_fd_sc_hd__buf_6
X_11934_ _02742_ _02744_ VGND VGND VPWR VPWR _02745_ sky130_fd_sc_hd__nor2_1
XFILLER_0_24_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17441_ clknet_4_8_0_clock _00119_ VGND VGND VPWR VPWR i_error\[11\] sky130_fd_sc_hd__dfxtp_1
X_14653_ _05658_ _05659_ VGND VGND VPWR VPWR _05661_ sky130_fd_sc_hd__xnor2_1
X_11865_ _02671_ _02675_ VGND VGND VPWR VPWR _02676_ sky130_fd_sc_hd__and2_1
XFILLER_0_67_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_40_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13604_ net184 _04108_ _04442_ VGND VGND VPWR VPWR _04507_ sky130_fd_sc_hd__a21o_1
X_17372_ net467 _08139_ VGND VGND VPWR VPWR _08590_ sky130_fd_sc_hd__nand2_1
X_10816_ _01615_ _01601_ _01626_ VGND VGND VPWR VPWR _01627_ sky130_fd_sc_hd__a21o_1
X_14584_ net249 _05584_ VGND VGND VPWR VPWR _05585_ sky130_fd_sc_hd__nand2_1
X_11796_ _02537_ _02538_ _02540_ VGND VGND VPWR VPWR _02607_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_138_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16323_ _06300_ _06403_ VGND VGND VPWR VPWR _07498_ sky130_fd_sc_hd__xnor2_1
X_13535_ _04426_ _04422_ VGND VGND VPWR VPWR _04431_ sky130_fd_sc_hd__and2b_1
XFILLER_0_131_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10747_ _01532_ _01557_ VGND VGND VPWR VPWR _01558_ sky130_fd_sc_hd__or2_1
XFILLER_0_70_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16254_ net307 _06348_ VGND VGND VPWR VPWR _07422_ sky130_fd_sc_hd__nand2_1
X_13466_ net191 _03793_ VGND VGND VPWR VPWR _04355_ sky130_fd_sc_hd__nand2_2
X_10678_ net406 net412 net105 VGND VGND VPWR VPWR _01489_ sky130_fd_sc_hd__and3_1
XFILLER_0_23_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15205_ _06262_ _06266_ _06267_ VGND VGND VPWR VPWR _06268_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_51_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12417_ _03248_ VGND VGND VPWR VPWR _03249_ sky130_fd_sc_hd__buf_2
X_16185_ _07307_ _07308_ _07317_ VGND VGND VPWR VPWR _07346_ sky130_fd_sc_hd__a21o_1
XFILLER_0_140_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13397_ _04194_ _04256_ VGND VGND VPWR VPWR _04279_ sky130_fd_sc_hd__xor2_1
XFILLER_0_11_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15136_ _06167_ _06168_ VGND VGND VPWR VPWR _06192_ sky130_fd_sc_hd__nor2_1
X_12348_ _03179_ VGND VGND VPWR VPWR _03180_ sky130_fd_sc_hd__inv_2
X_15067_ _06114_ _06115_ VGND VGND VPWR VPWR _06116_ sky130_fd_sc_hd__nor2_1
X_12279_ _02922_ _03108_ _03110_ VGND VGND VPWR VPWR _03111_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_120_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14018_ _04939_ _04955_ _04957_ _04954_ VGND VGND VPWR VPWR _04962_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_4_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15969_ _07088_ _07089_ _07107_ VGND VGND VPWR VPWR _07108_ sky130_fd_sc_hd__nand3_1
X_09490_ _00251_ _00250_ VGND VGND VPWR VPWR _00301_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_81_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout401 net402 VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__buf_2
Xfanout412 net413 VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__buf_2
Xfanout423 prev_d_error\[6\] VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__buf_2
Xfanout434 prev_d_error\[3\] VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__buf_2
Xfanout445 prev_d_error\[1\] VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__buf_2
Xfanout456 net457 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__clkbuf_4
X_09826_ _00545_ _00636_ VGND VGND VPWR VPWR _00637_ sky130_fd_sc_hd__or2_1
Xfanout467 net468 VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__clkbuf_2
X_09757_ net378 net520 _05638_ net373 VGND VGND VPWR VPWR _00568_ sky130_fd_sc_hd__a22o_1
X_08708_ _02850_ _02872_ net451 VGND VGND VPWR VPWR _02905_ sky130_fd_sc_hd__o21a_1
X_09688_ _00483_ _00497_ _00498_ VGND VGND VPWR VPWR _00499_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_68_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11650_ _02456_ _02458_ _02460_ VGND VGND VPWR VPWR _02461_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_36_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10601_ _01181_ _01182_ _01202_ _01184_ _01201_ VGND VGND VPWR VPWR _01412_ sky130_fd_sc_hd__o32ai_4
X_11581_ _02367_ _02391_ VGND VGND VPWR VPWR _02392_ sky130_fd_sc_hd__nor2_1
XFILLER_0_147_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10532_ _01341_ _01342_ VGND VGND VPWR VPWR _01343_ sky130_fd_sc_hd__nor2_1
X_13320_ _04161_ _04180_ VGND VGND VPWR VPWR _04194_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_135_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10463_ _01225_ _01255_ VGND VGND VPWR VPWR _01274_ sky130_fd_sc_hd__nor2_1
X_13251_ net227 _03283_ _03345_ net245 VGND VGND VPWR VPWR _04118_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_150_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12202_ _03020_ _03025_ _03026_ VGND VGND VPWR VPWR _03027_ sky130_fd_sc_hd__a21o_1
X_13182_ net208 _03249_ _03260_ net203 VGND VGND VPWR VPWR _04042_ sky130_fd_sc_hd__a22o_1
X_10394_ _01195_ _01194_ _01187_ VGND VGND VPWR VPWR _01205_ sky130_fd_sc_hd__a21o_1
X_12133_ _02865_ _02957_ VGND VGND VPWR VPWR _02958_ sky130_fd_sc_hd__nor2_1
XFILLER_0_130_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16941_ _07835_ _07839_ _07969_ VGND VGND VPWR VPWR _08177_ sky130_fd_sc_hd__mux2_1
X_12064_ _02881_ _02884_ VGND VGND VPWR VPWR _02885_ sky130_fd_sc_hd__nand2_1
X_11015_ net395 net398 net140 net136 VGND VGND VPWR VPWR _01826_ sky130_fd_sc_hd__and4_1
X_16872_ _05443_ _08099_ _08100_ VGND VGND VPWR VPWR _08101_ sky130_fd_sc_hd__o21bai_1
X_15823_ _06941_ _06946_ VGND VGND VPWR VPWR _06948_ sky130_fd_sc_hd__nand2_1
X_15754_ net263 _06348_ VGND VGND VPWR VPWR _06872_ sky130_fd_sc_hd__nand2_1
X_12966_ _03708_ _03809_ VGND VGND VPWR VPWR _03810_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_99_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14705_ prev_error\[13\] _04747_ VGND VGND VPWR VPWR _05718_ sky130_fd_sc_hd__nor2_1
X_11917_ _02656_ _02655_ VGND VGND VPWR VPWR _02728_ sky130_fd_sc_hd__nor2_1
XFILLER_0_87_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15685_ _06781_ _06786_ _06795_ VGND VGND VPWR VPWR _06796_ sky130_fd_sc_hd__a21o_1
X_12897_ _03672_ _03661_ VGND VGND VPWR VPWR _03741_ sky130_fd_sc_hd__xor2_1
X_17424_ clknet_4_2_0_clock _00102_ VGND VGND VPWR VPWR prev_error\[12\] sky130_fd_sc_hd__dfxtp_1
X_14636_ _05595_ _05590_ VGND VGND VPWR VPWR _05642_ sky130_fd_sc_hd__or2_1
XFILLER_0_142_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11848_ _02653_ _02658_ VGND VGND VPWR VPWR _02659_ sky130_fd_sc_hd__and2_1
XFILLER_0_67_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17355_ _03878_ _08361_ _08580_ net452 VGND VGND VPWR VPWR _00124_ sky130_fd_sc_hd__o211a_1
X_14567_ prev_error\[3\] _00313_ VGND VGND VPWR VPWR _05566_ sky130_fd_sc_hd__and2_1
X_11779_ net405 net410 net160 net163 VGND VGND VPWR VPWR _02590_ sky130_fd_sc_hd__and4_1
XFILLER_0_55_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16306_ _07340_ _07476_ _07478_ VGND VGND VPWR VPWR _07479_ sky130_fd_sc_hd__or3_1
XFILLER_0_42_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13518_ net219 net216 _03243_ _03269_ VGND VGND VPWR VPWR _04412_ sky130_fd_sc_hd__and4_1
XFILLER_0_125_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17286_ _08536_ _00520_ _08537_ net451 VGND VGND VPWR VPWR _00091_ sky130_fd_sc_hd__o211a_1
X_14498_ _05472_ _05474_ _05489_ VGND VGND VPWR VPWR _05490_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_3_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16237_ _07401_ _07402_ VGND VGND VPWR VPWR _07403_ sky130_fd_sc_hd__or2_1
XFILLER_0_113_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13449_ _04332_ _04205_ _04333_ _04335_ VGND VGND VPWR VPWR _04336_ sky130_fd_sc_hd__o22a_2
XFILLER_0_141_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16168_ _07326_ _07304_ VGND VGND VPWR VPWR _07327_ sky130_fd_sc_hd__xor2_1
XFILLER_0_23_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15119_ _06145_ _06140_ VGND VGND VPWR VPWR _06173_ sky130_fd_sc_hd__or2b_1
X_08990_ _05858_ _05891_ _05924_ VGND VGND VPWR VPWR _05935_ sky130_fd_sc_hd__a21o_1
X_16099_ _07247_ _07249_ VGND VGND VPWR VPWR _07251_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09611_ _00334_ _00350_ VGND VGND VPWR VPWR _00422_ sky130_fd_sc_hd__xnor2_2
X_09542_ _00333_ _00352_ VGND VGND VPWR VPWR _00353_ sky130_fd_sc_hd__xnor2_2
X_09473_ _00218_ _00220_ VGND VGND VPWR VPWR _00284_ sky130_fd_sc_hd__nand2_1
XFILLER_0_116_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout220 net221 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__clkbuf_2
Xfanout231 kd_1\[3\] VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__buf_2
Xfanout242 net243 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout253 ki\[15\] VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__clkbuf_4
Xfanout264 ki\[12\] VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__clkbuf_4
Xfanout275 net276 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__clkbuf_2
Xfanout286 net287 VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__clkbuf_2
X_09809_ _00612_ _00616_ _00619_ VGND VGND VPWR VPWR _00620_ sky130_fd_sc_hd__a21boi_2
Xfanout297 net298 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__clkbuf_4
X_12820_ _03191_ _03204_ _03205_ VGND VGND VPWR VPWR _03664_ sky130_fd_sc_hd__a21o_1
X_12751_ _03589_ _03594_ VGND VGND VPWR VPWR _03595_ sky130_fd_sc_hd__xor2_1
XFILLER_0_69_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11702_ _02510_ _02512_ VGND VGND VPWR VPWR _02513_ sky130_fd_sc_hd__nand2_1
X_15470_ _06555_ _06558_ VGND VGND VPWR VPWR _06559_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_139_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12682_ _03519_ _03520_ VGND VGND VPWR VPWR _03521_ sky130_fd_sc_hd__nor2_1
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14421_ _05403_ _05404_ VGND VGND VPWR VPWR _05405_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11633_ net388 net171 net175 net384 VGND VGND VPWR VPWR _02444_ sky130_fd_sc_hd__a22o_1
XFILLER_0_108_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17140_ _08265_ _08395_ VGND VGND VPWR VPWR _08396_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_108_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14352_ _01688_ _05328_ VGND VGND VPWR VPWR _05329_ sky130_fd_sc_hd__nor2_2
X_11564_ net384 net171 VGND VGND VPWR VPWR _02375_ sky130_fd_sc_hd__nand2_2
XFILLER_0_92_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13303_ _04170_ _04174_ VGND VGND VPWR VPWR _04176_ sky130_fd_sc_hd__nand2_1
X_10515_ _01295_ _01325_ VGND VGND VPWR VPWR _01326_ sky130_fd_sc_hd__xnor2_1
X_17071_ _05312_ _08318_ _08319_ VGND VGND VPWR VPWR _08320_ sky130_fd_sc_hd__o21ai_1
X_14283_ _05250_ _05251_ VGND VGND VPWR VPWR _05254_ sky130_fd_sc_hd__or2_1
XFILLER_0_107_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11495_ _02300_ _02304_ _02305_ VGND VGND VPWR VPWR _02306_ sky130_fd_sc_hd__o21a_1
XFILLER_0_122_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16022_ _07164_ _07165_ VGND VGND VPWR VPWR _07166_ sky130_fd_sc_hd__and2_1
X_10446_ _01251_ _01253_ _01256_ VGND VGND VPWR VPWR _01257_ sky130_fd_sc_hd__a21bo_1
X_13234_ net194 _03669_ net519 net191 VGND VGND VPWR VPWR _04100_ sky130_fd_sc_hd__a22o_1
XFILLER_0_21_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10377_ _01142_ _01139_ _01140_ VGND VGND VPWR VPWR _01188_ sky130_fd_sc_hd__nand3_1
X_13165_ _03336_ _03367_ _04022_ _04023_ VGND VGND VPWR VPWR _04024_ sky130_fd_sc_hd__a22o_1
X_12116_ _02939_ _02940_ VGND VGND VPWR VPWR _02941_ sky130_fd_sc_hd__nor2_1
X_13096_ _03918_ _03947_ VGND VGND VPWR VPWR _03948_ sky130_fd_sc_hd__or2_1
X_16924_ _08152_ _08156_ _08158_ VGND VGND VPWR VPWR _08159_ sky130_fd_sc_hd__a21bo_1
X_12047_ _02860_ _02865_ net410 kd_2\[0\] VGND VGND VPWR VPWR _02866_ sky130_fd_sc_hd__o211a_1
X_16855_ net478 _07966_ _07967_ _07773_ VGND VGND VPWR VPWR _08083_ sky130_fd_sc_hd__o211a_1
X_15806_ _06927_ _06928_ VGND VGND VPWR VPWR _06929_ sky130_fd_sc_hd__nand2_1
X_16786_ _07813_ _07985_ _07996_ _07995_ _08006_ VGND VGND VPWR VPWR _08007_ sky130_fd_sc_hd__a221o_1
X_13998_ net247 _03269_ _04936_ _04939_ VGND VGND VPWR VPWR _04940_ sky130_fd_sc_hd__a31o_1
X_15737_ _06845_ _06852_ VGND VGND VPWR VPWR _06853_ sky130_fd_sc_hd__xor2_2
X_12949_ _03792_ VGND VGND VPWR VPWR _03793_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_888 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15668_ _06774_ _06776_ VGND VGND VPWR VPWR _06777_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_28_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17407_ clknet_4_14_0_clock _00085_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dfxtp_1
X_14619_ net257 _05622_ VGND VGND VPWR VPWR _05623_ sky130_fd_sc_hd__nand2_1
X_15599_ _05596_ _04317_ VGND VGND VPWR VPWR _06701_ sky130_fd_sc_hd__or2_1
XFILLER_0_7_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17338_ net464 i_error\[8\] VGND VGND VPWR VPWR _08570_ sky130_fd_sc_hd__or2_1
XFILLER_0_43_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17269_ _08459_ _08524_ _08525_ VGND VGND VPWR VPWR _00084_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_70_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08973_ _05726_ _05737_ VGND VGND VPWR VPWR _05748_ sky130_fd_sc_hd__nand2_1
Xhold39 net80 VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09525_ _00189_ _00335_ VGND VGND VPWR VPWR _00336_ sky130_fd_sc_hd__or2_2
XFILLER_0_149_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09456_ _00263_ _00266_ VGND VGND VPWR VPWR _00267_ sky130_fd_sc_hd__or2_1
XFILLER_0_148_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09387_ net352 net348 _04923_ _05022_ VGND VGND VPWR VPWR _00198_ sky130_fd_sc_hd__nand4_1
XFILLER_0_47_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10300_ net379 _08634_ _08635_ VGND VGND VPWR VPWR _01111_ sky130_fd_sc_hd__and3_2
X_11280_ net398 net148 net153 net395 VGND VGND VPWR VPWR _02091_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_104_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10231_ _01040_ _01041_ VGND VGND VPWR VPWR _01042_ sky130_fd_sc_hd__xor2_1
XFILLER_0_113_890 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_5_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10162_ net358 _07937_ VGND VGND VPWR VPWR _00973_ sky130_fd_sc_hd__nand2_1
XFILLER_0_100_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14970_ _05963_ _06006_ _06008_ VGND VGND VPWR VPWR _06009_ sky130_fd_sc_hd__o21a_1
X_10093_ net358 _07409_ _00901_ _00903_ VGND VGND VPWR VPWR _00904_ sky130_fd_sc_hd__a31o_1
X_13921_ _04853_ _04854_ VGND VGND VPWR VPWR _04855_ sky130_fd_sc_hd__nand2_1
X_16640_ _07645_ _07845_ VGND VGND VPWR VPWR _07846_ sky130_fd_sc_hd__xor2_4
X_13852_ _04776_ _04771_ _04775_ VGND VGND VPWR VPWR _04779_ sky130_fd_sc_hd__or3_1
X_12803_ _03526_ _03635_ _03640_ _03646_ VGND VGND VPWR VPWR _03647_ sky130_fd_sc_hd__o31a_1
X_16571_ _05553_ _05554_ _07768_ _07769_ VGND VGND VPWR VPWR _07770_ sky130_fd_sc_hd__a2bb2o_4
X_13783_ net232 _03269_ _04620_ _04702_ VGND VGND VPWR VPWR _04704_ sky130_fd_sc_hd__a31o_1
XFILLER_0_57_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10995_ net402 net125 _01732_ _01733_ VGND VGND VPWR VPWR _01806_ sky130_fd_sc_hd__o2bb2a_1
X_15522_ _06613_ _06614_ _06615_ VGND VGND VPWR VPWR _06616_ sky130_fd_sc_hd__nor3_1
X_12734_ _03576_ VGND VGND VPWR VPWR _03577_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_57_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15453_ net289 _05582_ _06539_ _06536_ VGND VGND VPWR VPWR _06541_ sky130_fd_sc_hd__o2bb2a_2
XFILLER_0_127_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12665_ _03502_ _03503_ VGND VGND VPWR VPWR _03504_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14404_ net187 _03342_ VGND VGND VPWR VPWR _05387_ sky130_fd_sc_hd__nand2_1
X_11616_ net392 net166 VGND VGND VPWR VPWR _02427_ sky130_fd_sc_hd__nand2_1
X_15384_ _06443_ _06461_ _06464_ VGND VGND VPWR VPWR _06465_ sky130_fd_sc_hd__o21a_1
X_12596_ _03357_ _03363_ _03355_ VGND VGND VPWR VPWR _03435_ sky130_fd_sc_hd__a21o_1
XFILLER_0_142_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17123_ _07963_ _07770_ _07964_ _08376_ VGND VGND VPWR VPWR _08378_ sky130_fd_sc_hd__a31o_1
XFILLER_0_53_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14335_ _01563_ net121 VGND VGND VPWR VPWR _05311_ sky130_fd_sc_hd__or2_1
XFILLER_0_123_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11547_ _02354_ _02355_ _02357_ VGND VGND VPWR VPWR _02358_ sky130_fd_sc_hd__a21oi_1
X_17054_ _05357_ _05405_ _05403_ VGND VGND VPWR VPWR _08302_ sky130_fd_sc_hd__a21oi_1
X_14266_ _05232_ _05234_ VGND VGND VPWR VPWR _05235_ sky130_fd_sc_hd__xnor2_4
X_11478_ _02277_ _02288_ VGND VGND VPWR VPWR _02289_ sky130_fd_sc_hd__or2_1
XFILLER_0_150_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16005_ _07076_ _07146_ VGND VGND VPWR VPWR _07148_ sky130_fd_sc_hd__nor2_1
X_13217_ _04070_ _04079_ _04080_ VGND VGND VPWR VPWR _04081_ sky130_fd_sc_hd__o21a_1
X_10429_ _01200_ _01234_ _01221_ _01233_ VGND VGND VPWR VPWR _01240_ sky130_fd_sc_hd__a211o_1
X_14197_ _04910_ _05158_ VGND VGND VPWR VPWR _05159_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13148_ _03997_ _03998_ VGND VGND VPWR VPWR _04005_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_148_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13079_ _03927_ _03928_ VGND VGND VPWR VPWR _03929_ sky130_fd_sc_hd__nand2_1
X_16907_ _07813_ _07971_ VGND VGND VPWR VPWR _08140_ sky130_fd_sc_hd__nor2_1
X_16838_ _07792_ _08063_ _07968_ VGND VGND VPWR VPWR _08064_ sky130_fd_sc_hd__mux2_1
X_16769_ _07766_ _07974_ VGND VGND VPWR VPWR _07988_ sky130_fd_sc_hd__nor2_1
X_09310_ _08673_ VGND VGND VPWR VPWR _08674_ sky130_fd_sc_hd__buf_4
XFILLER_0_76_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09241_ _05440_ _08591_ VGND VGND VPWR VPWR _08605_ sky130_fd_sc_hd__nor2_1
XFILLER_0_63_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09172_ net523 VGND VGND VPWR VPWR _07937_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_7_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08956_ _05506_ _05550_ VGND VGND VPWR VPWR _05561_ sky130_fd_sc_hd__and2_1
X_08887_ net313 _04450_ _04780_ net317 VGND VGND VPWR VPWR _04802_ sky130_fd_sc_hd__a22o_1
XFILLER_0_79_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09508_ _00309_ _00318_ VGND VGND VPWR VPWR _00319_ sky130_fd_sc_hd__and2_1
XFILLER_0_149_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10780_ _01566_ _01582_ _01583_ _01590_ VGND VGND VPWR VPWR _01591_ sky130_fd_sc_hd__o31ai_2
X_09439_ _00235_ _00237_ _00249_ VGND VGND VPWR VPWR _00250_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_137_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12450_ _03280_ _03281_ VGND VGND VPWR VPWR _03282_ sky130_fd_sc_hd__xnor2_4
X_11401_ _02180_ _02211_ _02209_ VGND VGND VPWR VPWR _02212_ sky130_fd_sc_hd__o21ai_2
X_12381_ prev_error\[11\] _03181_ VGND VGND VPWR VPWR _03213_ sky130_fd_sc_hd__nor2_1
XFILLER_0_117_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14120_ _05037_ _05041_ _05040_ VGND VGND VPWR VPWR _05074_ sky130_fd_sc_hd__o21ai_1
X_11332_ _02134_ _02140_ _02142_ VGND VGND VPWR VPWR _02143_ sky130_fd_sc_hd__a21o_2
X_14051_ _04963_ _04971_ VGND VGND VPWR VPWR _04998_ sky130_fd_sc_hd__xor2_1
X_11263_ _02072_ _02073_ net403 net143 VGND VGND VPWR VPWR _02074_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_104_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13002_ _03715_ _03845_ VGND VGND VPWR VPWR _03846_ sky130_fd_sc_hd__nand2_1
X_10214_ _01021_ _01023_ _01024_ VGND VGND VPWR VPWR _01025_ sky130_fd_sc_hd__and3_2
X_11194_ _01995_ _01997_ _01999_ VGND VGND VPWR VPWR _02005_ sky130_fd_sc_hd__or3_1
X_10145_ _00952_ _00955_ VGND VGND VPWR VPWR _00956_ sky130_fd_sc_hd__nor2_2
XFILLER_0_100_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14953_ _05938_ _05986_ _05988_ VGND VGND VPWR VPWR _05991_ sky130_fd_sc_hd__and3_1
X_10076_ _00781_ _00859_ _00882_ _00886_ VGND VGND VPWR VPWR _00887_ sky130_fd_sc_hd__a211o_4
X_13904_ _04821_ _04834_ _04781_ _04836_ VGND VGND VPWR VPWR _04837_ sky130_fd_sc_hd__o211ai_2
X_14884_ _05911_ _05912_ _05914_ VGND VGND VPWR VPWR _05915_ sky130_fd_sc_hd__nor3_1
XFILLER_0_89_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16623_ _07726_ _07826_ VGND VGND VPWR VPWR _07828_ sky130_fd_sc_hd__nor2_1
X_13835_ _04753_ _04757_ _04760_ VGND VGND VPWR VPWR _04761_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_69_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16554_ _07608_ _07638_ _07605_ VGND VGND VPWR VPWR _07752_ sky130_fd_sc_hd__o21ai_1
X_13766_ net188 _04317_ _04108_ net192 VGND VGND VPWR VPWR _04685_ sky130_fd_sc_hd__a22oi_1
X_10978_ _01783_ _01784_ _01773_ _01776_ VGND VGND VPWR VPWR _01789_ sky130_fd_sc_hd__o211a_1
X_15505_ net271 _06016_ VGND VGND VPWR VPWR _06598_ sky130_fd_sc_hd__nand2_1
X_12717_ _03426_ _03557_ VGND VGND VPWR VPWR _03558_ sky130_fd_sc_hd__nor2_1
X_16485_ _07674_ _07663_ _07523_ VGND VGND VPWR VPWR _07676_ sky130_fd_sc_hd__nand3_1
X_13697_ _04608_ VGND VGND VPWR VPWR _04609_ sky130_fd_sc_hd__inv_2
XFILLER_0_128_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15436_ _06520_ _06219_ _06521_ VGND VGND VPWR VPWR _06522_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_72_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12648_ _03481_ _03486_ VGND VGND VPWR VPWR _03487_ sky130_fd_sc_hd__xor2_1
XFILLER_0_81_850 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15367_ net274 _05588_ VGND VGND VPWR VPWR _06446_ sky130_fd_sc_hd__and2_1
XFILLER_0_136_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12579_ _03417_ VGND VGND VPWR VPWR _03418_ sky130_fd_sc_hd__inv_2
X_17106_ _07913_ VGND VGND VPWR VPWR _08359_ sky130_fd_sc_hd__inv_2
XFILLER_0_25_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14318_ _05237_ _05239_ VGND VGND VPWR VPWR _05292_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_68_Left_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15298_ _06260_ _06259_ _06253_ VGND VGND VPWR VPWR _06370_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_41_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17037_ net186 _03322_ VGND VGND VPWR VPWR _08283_ sky130_fd_sc_hd__nand2_1
XFILLER_0_150_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14249_ _05214_ _05215_ VGND VGND VPWR VPWR _05216_ sky130_fd_sc_hd__nand2_1
XFILLER_0_111_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08810_ net58 net3 VGND VGND VPWR VPWR _03955_ sky130_fd_sc_hd__or2b_1
X_09790_ _00580_ _00597_ _00599_ VGND VGND VPWR VPWR _00601_ sky130_fd_sc_hd__a21oi_1
X_08741_ net43 _03050_ _03083_ net184 VGND VGND VPWR VPWR _00005_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_77_Left_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09224_ _08311_ _08487_ VGND VGND VPWR VPWR _08505_ sky130_fd_sc_hd__nand2_1
XFILLER_0_118_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09155_ _07068_ _07739_ VGND VGND VPWR VPWR _07750_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_86_Left_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09086_ _06969_ _06980_ VGND VGND VPWR VPWR _06991_ sky130_fd_sc_hd__or2_1
XFILLER_0_102_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09988_ _04076_ _00651_ VGND VGND VPWR VPWR _00799_ sky130_fd_sc_hd__and2_2
X_08939_ _05352_ _05363_ VGND VGND VPWR VPWR _05374_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_95_Left_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_150_Right_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11950_ _02756_ _02758_ _02760_ VGND VGND VPWR VPWR _02761_ sky130_fd_sc_hd__o21ai_1
X_10901_ _01661_ _01711_ VGND VGND VPWR VPWR _01712_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_86_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11881_ _02689_ _02691_ VGND VGND VPWR VPWR _02692_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13620_ net188 _04107_ _04003_ net192 VGND VGND VPWR VPWR _04524_ sky130_fd_sc_hd__a22o_1
X_10832_ _01489_ _01507_ VGND VGND VPWR VPWR _01643_ sky130_fd_sc_hd__nor2_1
XFILLER_0_104_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13551_ _04438_ _04447_ VGND VGND VPWR VPWR _04448_ sky130_fd_sc_hd__xnor2_1
X_10763_ _01569_ _01572_ _01570_ VGND VGND VPWR VPWR _01574_ sky130_fd_sc_hd__o21ai_1
X_12502_ _03330_ _03338_ VGND VGND VPWR VPWR _03339_ sky130_fd_sc_hd__nor2_1
X_16270_ net310 net521 _07241_ _07438_ VGND VGND VPWR VPWR _07439_ sky130_fd_sc_hd__and4_1
X_13482_ net236 net233 _03215_ _03221_ VGND VGND VPWR VPWR _04372_ sky130_fd_sc_hd__and4_1
X_10694_ _01504_ VGND VGND VPWR VPWR _01505_ sky130_fd_sc_hd__clkbuf_4
X_15221_ _06146_ _06147_ VGND VGND VPWR VPWR _06285_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_124_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12433_ _03188_ _03189_ _03206_ _03207_ VGND VGND VPWR VPWR _03265_ sky130_fd_sc_hd__a31o_2
XFILLER_0_23_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15152_ _05595_ _06206_ _06208_ VGND VGND VPWR VPWR _06209_ sky130_fd_sc_hd__or3_1
XFILLER_0_2_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12364_ prev_error\[2\] _00557_ VGND VGND VPWR VPWR _03196_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14103_ net240 _03935_ _05027_ VGND VGND VPWR VPWR _05056_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_1_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11315_ _02120_ _02124_ _02125_ VGND VGND VPWR VPWR _02126_ sky130_fd_sc_hd__o21ai_1
X_15083_ net266 _05584_ _06132_ VGND VGND VPWR VPWR _06134_ sky130_fd_sc_hd__and3_1
X_12295_ _03107_ _03115_ VGND VGND VPWR VPWR _03127_ sky130_fd_sc_hd__nand2_1
XFILLER_0_132_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14034_ _04961_ _04979_ VGND VGND VPWR VPWR _04980_ sky130_fd_sc_hd__xor2_2
X_11246_ _02051_ _02056_ VGND VGND VPWR VPWR _02057_ sky130_fd_sc_hd__or2b_1
XFILLER_0_129_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11177_ _01975_ _01987_ VGND VGND VPWR VPWR _01988_ sky130_fd_sc_hd__xnor2_1
X_10128_ _00934_ _00938_ VGND VGND VPWR VPWR _00939_ sky130_fd_sc_hd__and2_1
X_15985_ _07050_ _07125_ VGND VGND VPWR VPWR _07126_ sky130_fd_sc_hd__xnor2_4
X_14936_ _05662_ _05971_ VGND VGND VPWR VPWR _05972_ sky130_fd_sc_hd__nor2_1
X_10059_ net370 _04593_ VGND VGND VPWR VPWR _00870_ sky130_fd_sc_hd__and2_1
X_14867_ _05894_ _05895_ VGND VGND VPWR VPWR _05896_ sky130_fd_sc_hd__and2_1
X_16606_ _07807_ _07808_ VGND VGND VPWR VPWR _07809_ sky130_fd_sc_hd__or2_1
X_13818_ net214 _03792_ VGND VGND VPWR VPWR _04742_ sky130_fd_sc_hd__nand2_1
X_14798_ _05773_ _05775_ VGND VGND VPWR VPWR _05820_ sky130_fd_sc_hd__or2_1
X_16537_ _07726_ _07732_ VGND VGND VPWR VPWR _07733_ sky130_fd_sc_hd__nor2_1
X_13749_ _04663_ _04664_ _04581_ _04665_ VGND VGND VPWR VPWR _04666_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_85_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16468_ _07576_ _07649_ _07654_ _07655_ _07656_ VGND VGND VPWR VPWR _07657_ sky130_fd_sc_hd__a311o_1
XFILLER_0_73_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15419_ _06501_ _06502_ VGND VGND VPWR VPWR _06503_ sky130_fd_sc_hd__xor2_1
XFILLER_0_143_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16399_ _07579_ _07580_ VGND VGND VPWR VPWR _07581_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_115_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09911_ _00605_ _00631_ VGND VGND VPWR VPWR _00722_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_95_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09842_ _00652_ VGND VGND VPWR VPWR _00653_ sky130_fd_sc_hd__buf_2
X_09773_ _00582_ _00583_ VGND VGND VPWR VPWR _00584_ sky130_fd_sc_hd__xor2_2
X_08724_ _02850_ _03039_ net451 VGND VGND VPWR VPWR _03072_ sky130_fd_sc_hd__o21a_1
Xclkbuf_4_14_0_clock clknet_0_clock VGND VGND VPWR VPWR clknet_4_14_0_clock sky130_fd_sc_hd__clkbuf_8
XFILLER_0_96_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09207_ _08047_ _08289_ VGND VGND VPWR VPWR _08322_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_134_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09138_ _07453_ _07552_ _07530_ VGND VGND VPWR VPWR _07563_ sky130_fd_sc_hd__a21o_1
XFILLER_0_134_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09069_ _06782_ _06639_ _06111_ VGND VGND VPWR VPWR _06804_ sky130_fd_sc_hd__and3_1
X_11100_ _01851_ _01910_ VGND VGND VPWR VPWR _01911_ sky130_fd_sc_hd__nor2_1
X_12080_ _02855_ _02857_ _02856_ VGND VGND VPWR VPWR _02902_ sky130_fd_sc_hd__o21ba_1
X_11031_ _01813_ _01797_ _01815_ VGND VGND VPWR VPWR _01842_ sky130_fd_sc_hd__a21oi_1
X_15770_ _06886_ _06887_ VGND VGND VPWR VPWR _06889_ sky130_fd_sc_hd__xnor2_2
X_12982_ _03822_ _03823_ _03825_ VGND VGND VPWR VPWR _03826_ sky130_fd_sc_hd__o21ba_1
X_14721_ _05719_ _05734_ VGND VGND VPWR VPWR _05735_ sky130_fd_sc_hd__and2_1
X_11933_ _02742_ _02743_ net402 net174 VGND VGND VPWR VPWR _02744_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_99_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17440_ clknet_4_8_0_clock _00118_ VGND VGND VPWR VPWR i_error\[10\] sky130_fd_sc_hd__dfxtp_1
X_14652_ _05606_ _05608_ VGND VGND VPWR VPWR _05659_ sky130_fd_sc_hd__xnor2_1
X_11864_ _02674_ VGND VGND VPWR VPWR _02675_ sky130_fd_sc_hd__inv_2
XFILLER_0_39_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13603_ _04503_ _04504_ VGND VGND VPWR VPWR _04506_ sky130_fd_sc_hd__xnor2_1
X_17371_ net468 net422 net456 _08589_ VGND VGND VPWR VPWR _00132_ sky130_fd_sc_hd__o211a_1
X_10815_ _01624_ _01625_ VGND VGND VPWR VPWR _01626_ sky130_fd_sc_hd__nand2_1
X_14583_ _05582_ VGND VGND VPWR VPWR _05584_ sky130_fd_sc_hd__clkbuf_4
X_11795_ _02558_ _02605_ VGND VGND VPWR VPWR _02606_ sky130_fd_sc_hd__nand2_1
X_16322_ _06974_ _07492_ _07493_ _06805_ _07495_ VGND VGND VPWR VPWR _07496_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_67_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13534_ _04304_ _04429_ VGND VGND VPWR VPWR _04430_ sky130_fd_sc_hd__nor2_1
XFILLER_0_82_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10746_ _01553_ _01554_ _01556_ VGND VGND VPWR VPWR _01557_ sky130_fd_sc_hd__and3_1
XFILLER_0_138_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16253_ _07397_ _07404_ _07403_ VGND VGND VPWR VPWR _07421_ sky130_fd_sc_hd__o21ai_1
X_13465_ _04352_ _04353_ VGND VGND VPWR VPWR _04354_ sky130_fd_sc_hd__nand2_2
X_10677_ net401 net112 VGND VGND VPWR VPWR _01488_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15204_ _06255_ _06261_ _06257_ VGND VGND VPWR VPWR _06267_ sky130_fd_sc_hd__nand3_1
X_12416_ _03247_ VGND VGND VPWR VPWR _03248_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_35_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16184_ _07307_ _07308_ _07317_ VGND VGND VPWR VPWR _07345_ sky130_fd_sc_hd__nand3_1
X_13396_ _04273_ _04277_ VGND VGND VPWR VPWR _04278_ sky130_fd_sc_hd__xor2_1
XFILLER_0_51_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15135_ _06092_ _06190_ VGND VGND VPWR VPWR _06191_ sky130_fd_sc_hd__or2_1
XFILLER_0_23_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12347_ _03177_ _03178_ VGND VGND VPWR VPWR _03179_ sky130_fd_sc_hd__nand2_2
XFILLER_0_23_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15066_ _06112_ _06113_ VGND VGND VPWR VPWR _06115_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_121_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12278_ _02810_ _03109_ VGND VGND VPWR VPWR _03110_ sky130_fd_sc_hd__or2_1
X_14017_ _04947_ _04960_ VGND VGND VPWR VPWR _04961_ sky130_fd_sc_hd__xor2_2
X_11229_ net432 net115 _01939_ VGND VGND VPWR VPWR _02040_ sky130_fd_sc_hd__and3_1
XFILLER_0_4_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15968_ _07100_ _07106_ VGND VGND VPWR VPWR _07107_ sky130_fd_sc_hd__xor2_1
XFILLER_0_78_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14919_ _05943_ _05948_ VGND VGND VPWR VPWR _05953_ sky130_fd_sc_hd__and2b_1
X_15899_ _07023_ _07030_ VGND VGND VPWR VPWR _07031_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_19_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout402 prev_d_error\[11\] VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__clkbuf_2
Xfanout413 prev_d_error\[9\] VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__buf_2
Xfanout424 net427 VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__buf_2
Xfanout435 net436 VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__buf_2
Xfanout446 prev_d_error\[0\] VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__clkbuf_4
X_09825_ _00602_ _00634_ _00635_ VGND VGND VPWR VPWR _00636_ sky130_fd_sc_hd__a21boi_1
Xfanout457 net458 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__buf_2
Xfanout468 net469 VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__buf_2
X_09756_ net377 net373 _05385_ _05638_ VGND VGND VPWR VPWR _00567_ sky130_fd_sc_hd__nand4_4
X_08707_ _02883_ VGND VGND VPWR VPWR _02894_ sky130_fd_sc_hd__clkbuf_4
X_09687_ _00484_ _00496_ _00485_ VGND VGND VPWR VPWR _00498_ sky130_fd_sc_hd__nand3_1
XFILLER_0_84_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10600_ _01158_ _01410_ VGND VGND VPWR VPWR _01411_ sky130_fd_sc_hd__nand2_1
X_11580_ _02368_ _02389_ _02390_ VGND VGND VPWR VPWR _02391_ sky130_fd_sc_hd__and3_1
XFILLER_0_25_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10531_ _01326_ _01338_ VGND VGND VPWR VPWR _01342_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_134_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13250_ _03284_ _03367_ VGND VGND VPWR VPWR _04117_ sky130_fd_sc_hd__and2_1
XFILLER_0_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10462_ _01262_ _01272_ VGND VGND VPWR VPWR _01273_ sky130_fd_sc_hd__nand2_1
XFILLER_0_134_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12201_ _02979_ _02987_ VGND VGND VPWR VPWR _03026_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_32_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13181_ _04040_ VGND VGND VPWR VPWR _04041_ sky130_fd_sc_hd__inv_2
X_10393_ _01195_ _01187_ _01194_ VGND VGND VPWR VPWR _01204_ sky130_fd_sc_hd__nand3_1
XFILLER_0_103_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12132_ _02863_ _02864_ VGND VGND VPWR VPWR _02957_ sky130_fd_sc_hd__nor2_1
XFILLER_0_103_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16940_ _07980_ VGND VGND VPWR VPWR _08176_ sky130_fd_sc_hd__inv_2
X_12063_ _02876_ _02882_ VGND VGND VPWR VPWR _02884_ sky130_fd_sc_hd__and2_1
X_11014_ _01801_ _01822_ _01824_ VGND VGND VPWR VPWR _01825_ sky130_fd_sc_hd__a21oi_2
X_16871_ _08098_ _08094_ _08095_ VGND VGND VPWR VPWR _08100_ sky130_fd_sc_hd__and3_1
X_15822_ _06943_ _06941_ _06944_ _06945_ VGND VGND VPWR VPWR _06946_ sky130_fd_sc_hd__nand4_2
XFILLER_0_99_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15753_ net259 _06416_ VGND VGND VPWR VPWR _06871_ sky130_fd_sc_hd__nand2_2
X_12965_ _03710_ _03709_ VGND VGND VPWR VPWR _03809_ sky130_fd_sc_hd__nor2_1
X_14704_ _05714_ _05716_ VGND VGND VPWR VPWR _05717_ sky130_fd_sc_hd__and2_1
X_11916_ _02725_ _02726_ net424 net152 VGND VGND VPWR VPWR _02727_ sky130_fd_sc_hd__and4bb_1
X_15684_ _06790_ _06794_ VGND VGND VPWR VPWR _06795_ sky130_fd_sc_hd__xnor2_1
X_12896_ _03718_ _03739_ VGND VGND VPWR VPWR _03740_ sky130_fd_sc_hd__nor2_1
XFILLER_0_87_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14635_ _05623_ _05637_ _05640_ VGND VGND VPWR VPWR _05641_ sky130_fd_sc_hd__o21bai_1
X_17423_ clknet_4_2_0_clock _00101_ VGND VGND VPWR VPWR prev_error\[11\] sky130_fd_sc_hd__dfxtp_1
X_11847_ _02648_ _02650_ _02652_ VGND VGND VPWR VPWR _02658_ sky130_fd_sc_hd__or3_1
XFILLER_0_74_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17354_ net463 i_error\[16\] VGND VGND VPWR VPWR _08580_ sky130_fd_sc_hd__or2_1
X_14566_ _04000_ _05563_ _05564_ VGND VGND VPWR VPWR _05565_ sky130_fd_sc_hd__a21o_1
X_11778_ net410 net160 net163 net405 VGND VGND VPWR VPWR _02589_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_138_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16305_ _07341_ _07477_ VGND VGND VPWR VPWR _07478_ sky130_fd_sc_hd__nor2_1
X_13517_ net219 _03243_ _03269_ net216 VGND VGND VPWR VPWR _04411_ sky130_fd_sc_hd__a22o_1
XFILLER_0_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17285_ net462 prev_error\[1\] VGND VGND VPWR VPWR _08537_ sky130_fd_sc_hd__or2_1
X_10729_ _01536_ _01539_ VGND VGND VPWR VPWR _01540_ sky130_fd_sc_hd__and2b_1
X_14497_ _05487_ _05488_ VGND VGND VPWR VPWR _05489_ sky130_fd_sc_hd__or2_1
XFILLER_0_126_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16236_ net286 _04314_ _07400_ VGND VGND VPWR VPWR _07402_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_141_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13448_ _04332_ _04205_ _04334_ VGND VGND VPWR VPWR _04335_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_24_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16167_ net275 net521 VGND VGND VPWR VPWR _07326_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13379_ _04114_ _04258_ VGND VGND VPWR VPWR _04259_ sky130_fd_sc_hd__nand2_1
X_15118_ _06142_ _06143_ VGND VGND VPWR VPWR _06172_ sky130_fd_sc_hd__nand2_1
X_16098_ _07247_ _07249_ VGND VGND VPWR VPWR _07250_ sky130_fd_sc_hd__nand2_1
XFILLER_0_121_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15049_ _06093_ _05840_ _06094_ _06095_ _05691_ VGND VGND VPWR VPWR _06096_ sky130_fd_sc_hd__o311a_1
X_09610_ _00412_ _00420_ VGND VGND VPWR VPWR _00421_ sky130_fd_sc_hd__and2_1
X_09541_ _00334_ _00350_ _00351_ VGND VGND VPWR VPWR _00352_ sky130_fd_sc_hd__a21o_1
XFILLER_0_92_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09472_ _00276_ _00281_ _00282_ VGND VGND VPWR VPWR _00283_ sky130_fd_sc_hd__a21o_1
XFILLER_0_116_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout210 net213 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__clkbuf_4
Xfanout221 kd_1\[6\] VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__clkbuf_4
Xfanout232 net234 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__clkbuf_4
Xfanout243 kd_1\[1\] VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__clkbuf_2
Xfanout254 net255 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__buf_2
Xfanout265 net266 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__buf_2
Xfanout276 ki\[9\] VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__buf_2
X_09808_ _00569_ _00617_ _00618_ VGND VGND VPWR VPWR _00619_ sky130_fd_sc_hd__nand3_2
Xfanout287 ki\[6\] VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__buf_2
Xfanout298 net299 VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__clkbuf_4
X_09739_ _00546_ _00549_ VGND VGND VPWR VPWR _00550_ sky130_fd_sc_hd__or2_1
XFILLER_0_69_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12750_ _03592_ _03593_ VGND VGND VPWR VPWR _03594_ sky130_fd_sc_hd__nor2_1
XFILLER_0_97_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11701_ _02511_ _02410_ VGND VGND VPWR VPWR _02512_ sky130_fd_sc_hd__xnor2_1
X_12681_ _03518_ _03476_ VGND VGND VPWR VPWR _03520_ sky130_fd_sc_hd__and2b_1
X_14420_ _05401_ _05402_ VGND VGND VPWR VPWR _05404_ sky130_fd_sc_hd__and2_1
XFILLER_0_37_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11632_ net392 net170 _02442_ _02441_ VGND VGND VPWR VPWR _02443_ sky130_fd_sc_hd__a31o_1
XFILLER_0_112_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14351_ net393 net397 net105 VGND VGND VPWR VPWR _05328_ sky130_fd_sc_hd__o21ai_1
X_11563_ net392 net166 _02371_ _02373_ VGND VGND VPWR VPWR _02374_ sky130_fd_sc_hd__a31o_1
XFILLER_0_24_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13302_ _04172_ _04173_ _04170_ VGND VGND VPWR VPWR _04174_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_135_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10514_ _01297_ _01301_ VGND VGND VPWR VPWR _01325_ sky130_fd_sc_hd__xnor2_1
X_17070_ net381 net113 net109 net385 VGND VGND VPWR VPWR _08319_ sky130_fd_sc_hd__a22o_1
X_14282_ _05250_ _05251_ VGND VGND VPWR VPWR _05252_ sky130_fd_sc_hd__nand2_1
XFILLER_0_122_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11494_ _02215_ _02214_ VGND VGND VPWR VPWR _02305_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_134_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16021_ net275 net272 _04314_ _06417_ VGND VGND VPWR VPWR _07165_ sky130_fd_sc_hd__and4_1
XFILLER_0_122_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13233_ _04007_ _04018_ VGND VGND VPWR VPWR _04099_ sky130_fd_sc_hd__xnor2_1
X_10445_ _01225_ _01254_ _01255_ VGND VGND VPWR VPWR _01256_ sky130_fd_sc_hd__or3_1
XFILLER_0_33_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13164_ net224 _03284_ VGND VGND VPWR VPWR _04023_ sky130_fd_sc_hd__and2_1
X_10376_ _01165_ _01186_ VGND VGND VPWR VPWR _01187_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_131_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12115_ _02932_ _02938_ _02937_ VGND VGND VPWR VPWR _02940_ sky130_fd_sc_hd__a21oi_1
X_13095_ _03943_ _03946_ VGND VGND VPWR VPWR _03947_ sky130_fd_sc_hd__and2b_1
X_16923_ _08144_ _08151_ VGND VGND VPWR VPWR _08158_ sky130_fd_sc_hd__or2_1
X_12046_ _02863_ _02864_ VGND VGND VPWR VPWR _02865_ sky130_fd_sc_hd__and2_1
XFILLER_0_137_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16854_ _07770_ _07775_ VGND VGND VPWR VPWR _08082_ sky130_fd_sc_hd__nand2_1
X_15805_ _06912_ _06913_ VGND VGND VPWR VPWR _06928_ sky130_fd_sc_hd__xor2_1
X_16785_ _07798_ _07990_ VGND VGND VPWR VPWR _08006_ sky130_fd_sc_hd__nor2_1
X_13997_ net222 _03935_ _04937_ _04938_ VGND VGND VPWR VPWR _04939_ sky130_fd_sc_hd__and4_1
XFILLER_0_1_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15736_ _06846_ _06847_ _06851_ VGND VGND VPWR VPWR _06852_ sky130_fd_sc_hd__o21ai_2
X_12948_ _03791_ VGND VGND VPWR VPWR _03792_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_48_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15667_ _06498_ _06775_ VGND VGND VPWR VPWR _06776_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12879_ net200 _03233_ VGND VGND VPWR VPWR _03723_ sky130_fd_sc_hd__nand2_1
X_17406_ clknet_4_10_0_clock _00084_ VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_134_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14618_ _05621_ VGND VGND VPWR VPWR _05622_ sky130_fd_sc_hd__clkbuf_4
X_15598_ _06692_ _06696_ _06699_ VGND VGND VPWR VPWR _06700_ sky130_fd_sc_hd__a21oi_2
X_14549_ _05531_ _05545_ VGND VGND VPWR VPWR _05546_ sky130_fd_sc_hd__xnor2_1
X_17337_ _08564_ _08142_ _08569_ net459 VGND VGND VPWR VPWR _00115_ sky130_fd_sc_hd__o211a_1
XFILLER_0_126_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17268_ net464 net515 net453 VGND VGND VPWR VPWR _08525_ sky130_fd_sc_hd__o21ai_1
X_16219_ _07357_ _07355_ VGND VGND VPWR VPWR _07383_ sky130_fd_sc_hd__nor2_1
XFILLER_0_140_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17199_ _08255_ _08453_ _08455_ _08460_ VGND VGND VPWR VPWR _08461_ sky130_fd_sc_hd__or4_4
XFILLER_0_23_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08972_ net341 net336 VGND VGND VPWR VPWR _05737_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09524_ _00187_ _00188_ _00186_ VGND VGND VPWR VPWR _00335_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_79_878 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09455_ _00256_ _00264_ _00263_ _00265_ VGND VGND VPWR VPWR _00266_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_94_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09386_ net344 _04769_ VGND VGND VPWR VPWR _00197_ sky130_fd_sc_hd__nand2_1
XFILLER_0_52_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10230_ _00980_ _00979_ VGND VGND VPWR VPWR _01041_ sky130_fd_sc_hd__and2b_1
X_10161_ net379 _04428_ _00970_ VGND VGND VPWR VPWR _00972_ sky130_fd_sc_hd__a21oi_1
X_10092_ net360 _04747_ _00902_ VGND VGND VPWR VPWR _00903_ sky130_fd_sc_hd__and3_1
X_13920_ _04803_ _04851_ VGND VGND VPWR VPWR _04854_ sky130_fd_sc_hd__xor2_1
XFILLER_0_107_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13851_ _04741_ _04745_ VGND VGND VPWR VPWR _04778_ sky130_fd_sc_hd__xor2_1
XFILLER_0_69_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12802_ _03642_ _03645_ VGND VGND VPWR VPWR _03646_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16570_ _01457_ _05420_ _05422_ _05466_ VGND VGND VPWR VPWR _07769_ sky130_fd_sc_hd__and4_1
X_13782_ _04699_ _04701_ VGND VGND VPWR VPWR _04702_ sky130_fd_sc_hd__nor2_1
X_10994_ _01802_ _01804_ VGND VGND VPWR VPWR _01805_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15521_ net264 _06162_ _06206_ net260 VGND VGND VPWR VPWR _06615_ sky130_fd_sc_hd__a22oi_2
X_12733_ _03573_ _03574_ VGND VGND VPWR VPWR _03576_ sky130_fd_sc_hd__nand2_2
XFILLER_0_139_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_106_Left_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15452_ net309 net490 _05722_ net292 _05620_ VGND VGND VPWR VPWR _06539_ sky130_fd_sc_hd__a32oi_1
X_12664_ net193 net189 _03322_ _03342_ VGND VGND VPWR VPWR _03503_ sky130_fd_sc_hd__and4_1
X_14403_ _03322_ _05383_ _05384_ VGND VGND VPWR VPWR _05386_ sky130_fd_sc_hd__a21boi_1
X_11615_ _02424_ _02422_ VGND VGND VPWR VPWR _02426_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_127_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15383_ _06361_ _06462_ VGND VGND VPWR VPWR _06464_ sky130_fd_sc_hd__and2_1
X_12595_ _03427_ _03433_ VGND VGND VPWR VPWR _03434_ sky130_fd_sc_hd__nand2b_2
XFILLER_0_80_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17122_ _08028_ _08030_ _08029_ VGND VGND VPWR VPWR _08376_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_107_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14334_ net108 _01688_ _01691_ VGND VGND VPWR VPWR _05310_ sky130_fd_sc_hd__a21o_1
X_11546_ _02262_ _02356_ VGND VGND VPWR VPWR _02357_ sky130_fd_sc_hd__nand2_1
XFILLER_0_52_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17053_ _08257_ _08299_ VGND VGND VPWR VPWR _08301_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_52_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14265_ _05188_ _05233_ VGND VGND VPWR VPWR _05234_ sky130_fd_sc_hd__xnor2_4
X_11477_ _02280_ _02282_ _02287_ VGND VGND VPWR VPWR _02288_ sky130_fd_sc_hd__a21oi_2
X_16004_ _07076_ _07146_ VGND VGND VPWR VPWR _07147_ sky130_fd_sc_hd__xor2_1
XFILLER_0_110_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13216_ _04071_ _04078_ VGND VGND VPWR VPWR _04080_ sky130_fd_sc_hd__nand2_1
XFILLER_0_150_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10428_ _01236_ _01238_ VGND VGND VPWR VPWR _01239_ sky130_fd_sc_hd__xor2_1
XFILLER_0_122_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14196_ _04908_ _04909_ VGND VGND VPWR VPWR _05158_ sky130_fd_sc_hd__and2_1
XFILLER_0_122_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_115_Left_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13147_ _04003_ VGND VGND VPWR VPWR _04004_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_148_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10359_ _01168_ _01169_ VGND VGND VPWR VPWR _01170_ sky130_fd_sc_hd__xnor2_1
X_13078_ _03926_ _03921_ VGND VGND VPWR VPWR _03928_ sky130_fd_sc_hd__or2b_1
X_12029_ _02812_ _02845_ _02843_ VGND VGND VPWR VPWR _02846_ sky130_fd_sc_hd__a21o_1
X_16906_ _05291_ _08138_ VGND VGND VPWR VPWR _08139_ sky130_fd_sc_hd__xor2_4
X_16837_ _07796_ VGND VGND VPWR VPWR _08063_ sky130_fd_sc_hd__inv_2
X_16768_ _07753_ _07986_ _07985_ _07813_ VGND VGND VPWR VPWR _07987_ sky130_fd_sc_hd__o22a_1
XFILLER_0_73_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_124_Left_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15719_ _06549_ _06550_ VGND VGND VPWR VPWR _06833_ sky130_fd_sc_hd__xor2_1
X_16699_ i_error\[15\] _07718_ VGND VGND VPWR VPWR _07911_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09240_ _08366_ _08603_ _08355_ VGND VGND VPWR VPWR _08604_ sky130_fd_sc_hd__a21o_1
XFILLER_0_146_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09171_ _07915_ VGND VGND VPWR VPWR _07926_ sky130_fd_sc_hd__buf_1
XFILLER_0_8_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_133_Left_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_131_Right_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08955_ _05517_ _05539_ VGND VGND VPWR VPWR _05550_ sky130_fd_sc_hd__or2b_1
X_08886_ net313 _04780_ VGND VGND VPWR VPWR _04791_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_142_Left_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09507_ net315 _00243_ _08676_ net319 VGND VGND VPWR VPWR _00318_ sky130_fd_sc_hd__a22o_1
XFILLER_0_66_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09438_ _00247_ _00248_ VGND VGND VPWR VPWR _00249_ sky130_fd_sc_hd__and2_1
XFILLER_0_149_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09369_ _00177_ _00178_ _00179_ VGND VGND VPWR VPWR _00180_ sky130_fd_sc_hd__nor3_1
X_11400_ _02209_ _02210_ VGND VGND VPWR VPWR _02211_ sky130_fd_sc_hd__nand2_1
X_12380_ _03185_ _03186_ _03209_ _03210_ _03211_ VGND VGND VPWR VPWR _03212_ sky130_fd_sc_hd__a311o_1
XFILLER_0_90_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11331_ _02103_ _02141_ VGND VGND VPWR VPWR _02142_ sky130_fd_sc_hd__nand2_1
X_14050_ _04995_ _04996_ VGND VGND VPWR VPWR _04997_ sky130_fd_sc_hd__and2b_1
X_11262_ net408 net140 net136 net413 VGND VGND VPWR VPWR _02073_ sky130_fd_sc_hd__a22oi_1
X_13001_ _03712_ _03714_ VGND VGND VPWR VPWR _03845_ sky130_fd_sc_hd__or2_1
X_10213_ _01019_ _01014_ _01018_ VGND VGND VPWR VPWR _01024_ sky130_fd_sc_hd__or3_1
X_11193_ _01561_ net164 _02003_ VGND VGND VPWR VPWR _02004_ sky130_fd_sc_hd__nor3_1
X_10144_ _00952_ _00953_ _00954_ VGND VGND VPWR VPWR _00955_ sky130_fd_sc_hd__nor3_2
XFILLER_0_118_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14952_ _05938_ _05986_ _05988_ VGND VGND VPWR VPWR _05989_ sky130_fd_sc_hd__a21oi_2
X_10075_ _00884_ _00885_ VGND VGND VPWR VPWR _00886_ sky130_fd_sc_hd__nor2_1
X_13903_ _04777_ _04779_ _04778_ VGND VGND VPWR VPWR _04836_ sky130_fd_sc_hd__a21o_1
X_14883_ _05862_ _05910_ _05905_ _05909_ VGND VGND VPWR VPWR _05914_ sky130_fd_sc_hd__o211a_1
X_16622_ _05465_ _07825_ VGND VGND VPWR VPWR _07826_ sky130_fd_sc_hd__nand2_1
X_13834_ net192 net518 _04759_ VGND VGND VPWR VPWR _04760_ sky130_fd_sc_hd__and3_1
X_16553_ _07605_ _07608_ _07638_ VGND VGND VPWR VPWR _07751_ sky130_fd_sc_hd__or3_1
X_13765_ net192 net188 _04317_ _04108_ VGND VGND VPWR VPWR _04684_ sky130_fd_sc_hd__and4_1
X_10977_ _01787_ VGND VGND VPWR VPWR _01788_ sky130_fd_sc_hd__inv_2
Xmax_cap94 _05521_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_58_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15504_ net98 _06593_ _06563_ _06545_ VGND VGND VPWR VPWR _06597_ sky130_fd_sc_hd__o211a_1
X_12716_ _03462_ _03556_ VGND VGND VPWR VPWR _03557_ sky130_fd_sc_hd__and2_1
X_16484_ _07663_ _07523_ _07674_ VGND VGND VPWR VPWR _07675_ sky130_fd_sc_hd__a21o_1
X_13696_ _04588_ _04605_ _04607_ VGND VGND VPWR VPWR _04608_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_38_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12647_ _03482_ _03485_ VGND VGND VPWR VPWR _03486_ sky130_fd_sc_hd__xor2_1
X_15435_ net293 _05745_ _05709_ net308 VGND VGND VPWR VPWR _06521_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15366_ _06322_ _06444_ VGND VGND VPWR VPWR _06445_ sky130_fd_sc_hd__or2_1
X_12578_ _03303_ _03415_ VGND VGND VPWR VPWR _03417_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_53_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17105_ _08354_ _08357_ VGND VGND VPWR VPWR _08358_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_4_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14317_ _05248_ _05289_ _05290_ VGND VGND VPWR VPWR _05291_ sky130_fd_sc_hd__o21ai_4
X_11529_ _02325_ _02337_ _02338_ _02339_ VGND VGND VPWR VPWR _02340_ sky130_fd_sc_hd__a211oi_2
X_15297_ _06253_ _06260_ _06259_ VGND VGND VPWR VPWR _06369_ sky130_fd_sc_hd__or3_1
XFILLER_0_1_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14248_ _03882_ _05193_ VGND VGND VPWR VPWR _05215_ sky130_fd_sc_hd__xor2_4
XFILLER_0_0_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17036_ _05383_ _08281_ VGND VGND VPWR VPWR _08282_ sky130_fd_sc_hd__or2_2
XFILLER_0_40_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14179_ _05014_ _04981_ VGND VGND VPWR VPWR _05139_ sky130_fd_sc_hd__and2b_1
XFILLER_0_1_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08740_ net42 _03050_ _03083_ net191 VGND VGND VPWR VPWR _00004_ sky130_fd_sc_hd__a22o_1
XFILLER_0_76_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09223_ _08311_ _08487_ VGND VGND VPWR VPWR _08497_ sky130_fd_sc_hd__or2_1
XFILLER_0_57_870 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_840 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09154_ _07090_ _07695_ _07728_ VGND VGND VPWR VPWR _07739_ sky130_fd_sc_hd__o21a_1
XFILLER_0_16_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_10_0_clock clknet_0_clock VGND VGND VPWR VPWR clknet_4_10_0_clock sky130_fd_sc_hd__clkbuf_8
XFILLER_0_31_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09085_ _06309_ _06958_ _06848_ VGND VGND VPWR VPWR _06980_ sky130_fd_sc_hd__nor3_1
XFILLER_0_44_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09987_ _00792_ _00795_ _00797_ VGND VGND VPWR VPWR _00798_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_110_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08938_ net65 net10 VGND VGND VPWR VPWR _05363_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_150_Left_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08869_ _04593_ VGND VGND VPWR VPWR _04604_ sky130_fd_sc_hd__buf_2
X_10900_ _01709_ _01710_ VGND VGND VPWR VPWR _01711_ sky130_fd_sc_hd__or2_1
X_11880_ _02687_ _02690_ VGND VGND VPWR VPWR _02691_ sky130_fd_sc_hd__and2_1
X_10831_ _01508_ _01641_ VGND VGND VPWR VPWR _01642_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13550_ _04321_ _04446_ VGND VGND VPWR VPWR _04447_ sky130_fd_sc_hd__or2_1
X_10762_ _01569_ _01570_ _01572_ VGND VGND VPWR VPWR _01573_ sky130_fd_sc_hd__or3_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12501_ net207 _03322_ _03328_ net203 VGND VGND VPWR VPWR _03338_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_81_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13481_ net242 _03335_ _04240_ _04242_ VGND VGND VPWR VPWR _04371_ sky130_fd_sc_hd__a22o_1
X_10693_ _01473_ _01477_ VGND VGND VPWR VPWR _01504_ sky130_fd_sc_hd__or2_1
XFILLER_0_137_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15220_ _06280_ _06282_ _06283_ VGND VGND VPWR VPWR _06284_ sky130_fd_sc_hd__a21oi_2
X_12432_ _03263_ VGND VGND VPWR VPWR _03264_ sky130_fd_sc_hd__buf_2
XFILLER_0_81_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15151_ _06203_ _06207_ VGND VGND VPWR VPWR _06208_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12363_ _03194_ _00314_ VGND VGND VPWR VPWR _03195_ sky130_fd_sc_hd__or2_1
XFILLER_0_50_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14102_ _05013_ _05050_ _05052_ VGND VGND VPWR VPWR _05054_ sky130_fd_sc_hd__o21ai_1
X_11314_ _02026_ _02025_ VGND VGND VPWR VPWR _02125_ sky130_fd_sc_hd__xnor2_1
X_15082_ _06047_ _06131_ VGND VGND VPWR VPWR _06132_ sky130_fd_sc_hd__xnor2_1
X_12294_ _02835_ _02838_ _02837_ VGND VGND VPWR VPWR _03126_ sky130_fd_sc_hd__a21o_1
XFILLER_0_50_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14033_ _04974_ _04977_ VGND VGND VPWR VPWR _04979_ sky130_fd_sc_hd__nor2_1
XFILLER_0_120_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11245_ _02054_ _02055_ VGND VGND VPWR VPWR _02056_ sky130_fd_sc_hd__and2_1
XFILLER_0_31_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11176_ _01982_ _01986_ VGND VGND VPWR VPWR _01987_ sky130_fd_sc_hd__nor2_1
X_10127_ net374 _04505_ _00935_ _00937_ VGND VGND VPWR VPWR _00938_ sky130_fd_sc_hd__a31o_1
X_15984_ _07121_ _07124_ VGND VGND VPWR VPWR _07125_ sky130_fd_sc_hd__nand2b_4
XFILLER_0_145_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14935_ net252 _05666_ VGND VGND VPWR VPWR _05971_ sky130_fd_sc_hd__nand2_1
X_10058_ net370 _04505_ _04604_ net365 VGND VGND VPWR VPWR _00869_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_89_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14866_ _05866_ _05893_ VGND VGND VPWR VPWR _05895_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16605_ net96 _05434_ VGND VGND VPWR VPWR _07808_ sky130_fd_sc_hd__and2b_1
X_13817_ _04739_ _04740_ VGND VGND VPWR VPWR _04741_ sky130_fd_sc_hd__or2_1
X_14797_ _05815_ _05816_ _05818_ VGND VGND VPWR VPWR _05819_ sky130_fd_sc_hd__o21a_1
XFILLER_0_85_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16536_ _05421_ _07731_ VGND VGND VPWR VPWR _07732_ sky130_fd_sc_hd__xnor2_1
X_13748_ net219 _03750_ VGND VGND VPWR VPWR _04665_ sky130_fd_sc_hd__nand2_1
XFILLER_0_128_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16467_ i_error\[14\] _07569_ VGND VGND VPWR VPWR _07656_ sky130_fd_sc_hd__xnor2_4
X_13679_ net206 net202 _03791_ _03934_ VGND VGND VPWR VPWR _04589_ sky130_fd_sc_hd__and4_1
XFILLER_0_72_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15418_ _06395_ _06396_ VGND VGND VPWR VPWR _06502_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16398_ _06297_ _07500_ VGND VGND VPWR VPWR _07580_ sky130_fd_sc_hd__nor2_1
XFILLER_0_115_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15349_ _06407_ _06425_ VGND VGND VPWR VPWR _06426_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09910_ _00692_ _00719_ _00720_ VGND VGND VPWR VPWR _00721_ sky130_fd_sc_hd__o21ba_1
X_17019_ net187 _03342_ _05384_ _05383_ _03322_ VGND VGND VPWR VPWR _08263_ sky130_fd_sc_hd__a32o_1
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09841_ _04076_ _00651_ VGND VGND VPWR VPWR _00652_ sky130_fd_sc_hd__nand2_4
XFILLER_0_0_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09772_ _00473_ _00472_ VGND VGND VPWR VPWR _00583_ sky130_fd_sc_hd__or2b_1
X_08723_ _03050_ VGND VGND VPWR VPWR _03061_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09206_ _07662_ _07673_ VGND VGND VPWR VPWR _08311_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_106_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09137_ _07530_ _07541_ VGND VGND VPWR VPWR _07552_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09068_ _06639_ _06111_ _06782_ VGND VGND VPWR VPWR _06793_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_102_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11030_ _01831_ _01838_ _01840_ VGND VGND VPWR VPWR _01841_ sky130_fd_sc_hd__a21o_1
X_12981_ net198 _03249_ _03824_ VGND VGND VPWR VPWR _03825_ sky130_fd_sc_hd__and3_1
X_14720_ _05733_ _05675_ _05679_ _03281_ VGND VGND VPWR VPWR _05734_ sky130_fd_sc_hd__o211ai_4
X_11932_ net410 net167 net170 net405 VGND VGND VPWR VPWR _02743_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_59_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14651_ _05655_ _05656_ _05657_ VGND VGND VPWR VPWR _05658_ sky130_fd_sc_hd__o21bai_2
X_11863_ _02672_ _02673_ VGND VGND VPWR VPWR _02674_ sky130_fd_sc_hd__or2_1
XFILLER_0_129_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13602_ _04427_ _04430_ VGND VGND VPWR VPWR _04504_ sky130_fd_sc_hd__xnor2_1
X_10814_ _01594_ _01596_ _01623_ VGND VGND VPWR VPWR _01625_ sky130_fd_sc_hd__or3_1
X_17370_ net467 _08145_ VGND VGND VPWR VPWR _08589_ sky130_fd_sc_hd__nand2_1
X_14582_ _05581_ VGND VGND VPWR VPWR _05582_ sky130_fd_sc_hd__clkbuf_4
X_11794_ _02543_ _02557_ _02556_ VGND VGND VPWR VPWR _02605_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16321_ _06788_ _07494_ VGND VGND VPWR VPWR _07495_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13533_ net184 _04004_ _04303_ VGND VGND VPWR VPWR _04429_ sky130_fd_sc_hd__a21oi_1
X_10745_ _01532_ _01555_ VGND VGND VPWR VPWR _01556_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16252_ _07401_ _07418_ VGND VGND VPWR VPWR _07419_ sky130_fd_sc_hd__xnor2_1
X_13464_ _04347_ _04350_ VGND VGND VPWR VPWR _04353_ sky130_fd_sc_hd__or2_1
XFILLER_0_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10676_ _01486_ VGND VGND VPWR VPWR _01487_ sky130_fd_sc_hd__inv_2
XFILLER_0_82_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15203_ _06263_ _06264_ VGND VGND VPWR VPWR _06266_ sky130_fd_sc_hd__xor2_1
XFILLER_0_63_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12415_ _03245_ _03246_ VGND VGND VPWR VPWR _03247_ sky130_fd_sc_hd__xor2_4
XFILLER_0_125_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16183_ _07329_ _07342_ VGND VGND VPWR VPWR _07344_ sky130_fd_sc_hd__nand2_1
X_13395_ _04275_ _04276_ VGND VGND VPWR VPWR _04277_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15134_ _06185_ _06189_ VGND VGND VPWR VPWR _06190_ sky130_fd_sc_hd__nor2_1
X_12346_ prev_error\[12\] _04417_ VGND VGND VPWR VPWR _03178_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15065_ net277 _05631_ VGND VGND VPWR VPWR _06114_ sky130_fd_sc_hd__nand2_1
X_12277_ _02808_ _02809_ VGND VGND VPWR VPWR _03109_ sky130_fd_sc_hd__nor2_1
X_14016_ _04948_ _04959_ VGND VGND VPWR VPWR _04960_ sky130_fd_sc_hd__xnor2_2
X_11228_ _01481_ _02038_ VGND VGND VPWR VPWR _02039_ sky130_fd_sc_hd__xnor2_1
X_11159_ _01963_ _01958_ VGND VGND VPWR VPWR _01970_ sky130_fd_sc_hd__or2b_1
XFILLER_0_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15967_ _07104_ _07105_ VGND VGND VPWR VPWR _07106_ sky130_fd_sc_hd__nor2_1
X_14918_ _05655_ _05951_ VGND VGND VPWR VPWR _05952_ sky130_fd_sc_hd__xor2_1
X_15898_ _07028_ _07029_ VGND VGND VPWR VPWR _07030_ sky130_fd_sc_hd__nor2_1
X_14849_ _05874_ _05875_ VGND VGND VPWR VPWR _05876_ sky130_fd_sc_hd__nor2_1
XFILLER_0_86_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16519_ _07709_ _07711_ VGND VGND VPWR VPWR _07713_ sky130_fd_sc_hd__and2_1
XFILLER_0_6_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17499_ clknet_4_12_0_clock _00042_ VGND VGND VPWR VPWR ki\[15\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_143_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout403 net404 VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__buf_2
XFILLER_0_10_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout414 prev_d_error\[8\] VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__clkbuf_4
Xfanout425 net426 VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__buf_2
Xfanout436 prev_d_error\[3\] VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__clkbuf_4
X_09824_ _00603_ _00633_ VGND VGND VPWR VPWR _00635_ sky130_fd_sc_hd__nand2_1
Xfanout447 prev_d_error\[0\] VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout458 net459 VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__clkbuf_4
Xfanout469 net470 VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__clkbuf_4
X_09755_ _00553_ _00564_ _00565_ VGND VGND VPWR VPWR _00566_ sky130_fd_sc_hd__a21o_1
XFILLER_0_69_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08706_ _02850_ _02872_ VGND VGND VPWR VPWR _02883_ sky130_fd_sc_hd__nor2_2
X_09686_ _00484_ _00485_ _00496_ VGND VGND VPWR VPWR _00497_ sky130_fd_sc_hd__a21o_1
XFILLER_0_69_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10530_ _01324_ _01340_ VGND VGND VPWR VPWR _01341_ sky130_fd_sc_hd__or2_1
XFILLER_0_92_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_878 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10461_ _01268_ _01271_ VGND VGND VPWR VPWR _01272_ sky130_fd_sc_hd__nand2b_1
XFILLER_0_150_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12200_ _03022_ _03024_ VGND VGND VPWR VPWR _03025_ sky130_fd_sc_hd__or2b_1
XFILLER_0_33_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13180_ _03903_ _04039_ VGND VGND VPWR VPWR _04040_ sky130_fd_sc_hd__or2_1
X_10392_ _01183_ _01202_ VGND VGND VPWR VPWR _01203_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_32_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12131_ _02947_ _02953_ _02955_ VGND VGND VPWR VPWR _02956_ sky130_fd_sc_hd__a21o_1
X_12062_ _02875_ _02867_ _02869_ VGND VGND VPWR VPWR _02882_ sky130_fd_sc_hd__or3_1
X_11013_ _01751_ _01823_ VGND VGND VPWR VPWR _01824_ sky130_fd_sc_hd__nand2_1
X_16870_ _08094_ _08095_ _08098_ VGND VGND VPWR VPWR _08099_ sky130_fd_sc_hd__a21oi_1
X_15821_ net291 _05603_ _06942_ _06896_ VGND VGND VPWR VPWR _06945_ sky130_fd_sc_hd__a22o_1
XFILLER_0_126_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15752_ net253 net521 VGND VGND VPWR VPWR _06869_ sky130_fd_sc_hd__nand2_1
X_12964_ _03367_ _03321_ _03806_ _03807_ VGND VGND VPWR VPWR _03808_ sky130_fd_sc_hd__o2bb2a_1
X_14703_ _05696_ _05707_ VGND VGND VPWR VPWR _05716_ sky130_fd_sc_hd__xor2_1
X_11915_ net447 net131 net147 net428 VGND VGND VPWR VPWR _02726_ sky130_fd_sc_hd__a22oi_1
X_15683_ _06791_ _06792_ VGND VGND VPWR VPWR _06794_ sky130_fd_sc_hd__xor2_1
X_12895_ _03736_ _03738_ VGND VGND VPWR VPWR _03739_ sky130_fd_sc_hd__nor2_1
X_17422_ clknet_4_2_0_clock _00100_ VGND VGND VPWR VPWR prev_error\[10\] sky130_fd_sc_hd__dfxtp_1
X_14634_ net258 _05631_ _05639_ VGND VGND VPWR VPWR _05640_ sky130_fd_sc_hd__and3_1
XFILLER_0_68_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11846_ _02654_ _02655_ _02656_ VGND VGND VPWR VPWR _02657_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_129_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17353_ _03878_ _08034_ _08578_ net452 VGND VGND VPWR VPWR _00123_ sky130_fd_sc_hd__o211a_1
XFILLER_0_28_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11777_ net404 net167 VGND VGND VPWR VPWR _02588_ sky130_fd_sc_hd__nand2_1
X_14565_ prev_error\[2\] _00370_ VGND VGND VPWR VPWR _05564_ sky130_fd_sc_hd__and2_1
XFILLER_0_55_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16304_ _07413_ _07414_ _07378_ VGND VGND VPWR VPWR _07477_ sky130_fd_sc_hd__o21a_1
XFILLER_0_27_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13516_ _04333_ _04335_ VGND VGND VPWR VPWR _04410_ sky130_fd_sc_hd__xor2_1
X_10728_ _01537_ _01538_ VGND VGND VPWR VPWR _01539_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17284_ _03878_ VGND VGND VPWR VPWR _08536_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_82_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14496_ _05475_ _05486_ VGND VGND VPWR VPWR _05488_ sky130_fd_sc_hd__nor2_1
XFILLER_0_83_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16235_ net286 _04313_ _07400_ VGND VGND VPWR VPWR _07401_ sky130_fd_sc_hd__and3_1
X_13447_ net220 _03248_ _03260_ net217 VGND VGND VPWR VPWR _04334_ sky130_fd_sc_hd__a22o_1
X_10659_ _01468_ _01469_ VGND VGND VPWR VPWR _01470_ sky130_fd_sc_hd__nor2_1
XFILLER_0_113_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16166_ _07319_ _07323_ _07324_ _07278_ VGND VGND VPWR VPWR _07325_ sky130_fd_sc_hd__o211a_1
X_13378_ _04112_ _04113_ VGND VGND VPWR VPWR _04258_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15117_ _06151_ _06170_ VGND VGND VPWR VPWR _06171_ sky130_fd_sc_hd__or2_1
X_12329_ _02306_ _03160_ VGND VGND VPWR VPWR _03161_ sky130_fd_sc_hd__or2_4
X_16097_ _07248_ _07208_ VGND VGND VPWR VPWR _07249_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_121_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15048_ _05840_ _06094_ _06093_ VGND VGND VPWR VPWR _06095_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_76_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16999_ _08230_ _08239_ VGND VGND VPWR VPWR _08241_ sky130_fd_sc_hd__nand2_1
X_09540_ _00336_ _00349_ VGND VGND VPWR VPWR _00351_ sky130_fd_sc_hd__nor2_1
X_09471_ _00274_ _00275_ VGND VGND VPWR VPWR _00282_ sky130_fd_sc_hd__and2_1
XFILLER_0_148_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout200 net201 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__buf_2
Xfanout211 net213 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout222 net223 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__clkbuf_4
Xfanout233 net234 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__clkbuf_2
Xfanout244 net247 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__clkbuf_4
Xfanout255 net257 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout266 ki\[11\] VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__clkbuf_4
X_09807_ _00612_ _00616_ VGND VGND VPWR VPWR _00618_ sky130_fd_sc_hd__xor2_1
Xfanout277 net280 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__clkbuf_4
Xfanout288 ki\[5\] VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__clkbuf_4
Xfanout299 ki\[3\] VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__buf_2
X_09738_ net328 _00243_ _00548_ VGND VGND VPWR VPWR _00549_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_19_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09669_ _00479_ _00365_ VGND VGND VPWR VPWR _00480_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_96_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11700_ _02411_ _02409_ VGND VGND VPWR VPWR _02511_ sky130_fd_sc_hd__nor2_1
X_12680_ _03476_ _03518_ VGND VGND VPWR VPWR _03519_ sky130_fd_sc_hd__and2b_1
XFILLER_0_65_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11631_ _02440_ _02372_ _02441_ VGND VGND VPWR VPWR _02442_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_64_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_145_Right_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11562_ _02372_ _02350_ VGND VGND VPWR VPWR _02373_ sky130_fd_sc_hd__nor2_1
X_14350_ _01642_ _01693_ _01686_ VGND VGND VPWR VPWR _05327_ sky130_fd_sc_hd__a21o_1
XFILLER_0_52_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10513_ _01321_ _01323_ _01255_ VGND VGND VPWR VPWR _01324_ sky130_fd_sc_hd__a21oi_2
X_13301_ _04077_ _04166_ _04169_ VGND VGND VPWR VPWR _04173_ sky130_fd_sc_hd__a21o_1
X_14281_ _05179_ _05183_ VGND VGND VPWR VPWR _05251_ sky130_fd_sc_hd__xor2_2
X_11493_ _02302_ _02303_ VGND VGND VPWR VPWR _02304_ sky130_fd_sc_hd__and2b_1
XFILLER_0_134_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16020_ _07162_ _07163_ VGND VGND VPWR VPWR _07164_ sky130_fd_sc_hd__xnor2_1
X_13232_ _04093_ _04092_ VGND VGND VPWR VPWR _04097_ sky130_fd_sc_hd__xor2_1
X_10444_ net355 _00653_ VGND VGND VPWR VPWR _01255_ sky130_fd_sc_hd__nand2_2
XFILLER_0_150_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13163_ net228 _03335_ _03345_ net245 VGND VGND VPWR VPWR _04022_ sky130_fd_sc_hd__a22o_1
XFILLER_0_150_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10375_ net359 _00241_ VGND VGND VPWR VPWR _01186_ sky130_fd_sc_hd__nand2_1
X_12114_ _02932_ _02937_ _02938_ VGND VGND VPWR VPWR _02939_ sky130_fd_sc_hd__and3_1
X_13094_ _03918_ _03945_ VGND VGND VPWR VPWR _03946_ sky130_fd_sc_hd__nor2_1
X_16922_ _08153_ _08155_ VGND VGND VPWR VPWR _08156_ sky130_fd_sc_hd__nor2_1
X_12045_ net416 net420 net169 net173 VGND VGND VPWR VPWR _02864_ sky130_fd_sc_hd__and4_1
X_16853_ _05272_ _08079_ VGND VGND VPWR VPWR _08081_ sky130_fd_sc_hd__xnor2_1
X_15804_ _06922_ _06924_ _06926_ VGND VGND VPWR VPWR _06927_ sky130_fd_sc_hd__a21o_1
X_16784_ _07753_ _07986_ _07985_ _07813_ _07991_ VGND VGND VPWR VPWR _08005_ sky130_fd_sc_hd__o221ai_1
X_13996_ net247 _03268_ _04936_ VGND VGND VPWR VPWR _04938_ sky130_fd_sc_hd__a21o_1
XFILLER_0_99_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15735_ _06849_ _06850_ VGND VGND VPWR VPWR _06851_ sky130_fd_sc_hd__or2b_1
X_12947_ _03790_ VGND VGND VPWR VPWR _03791_ sky130_fd_sc_hd__buf_2
XFILLER_0_62_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15666_ _06407_ _06425_ VGND VGND VPWR VPWR _06775_ sky130_fd_sc_hd__nand2_1
X_12878_ net200 _03288_ _03638_ VGND VGND VPWR VPWR _03722_ sky130_fd_sc_hd__a21oi_1
X_17405_ clknet_4_10_0_clock _00083_ VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_118_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14617_ _05620_ VGND VGND VPWR VPWR _05621_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_8_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11829_ _02606_ _02635_ _02639_ VGND VGND VPWR VPWR _02640_ sky130_fd_sc_hd__nand3_1
X_15597_ _06697_ _06698_ VGND VGND VPWR VPWR _06699_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_28_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17336_ net464 i_error\[7\] VGND VGND VPWR VPWR _08569_ sky130_fd_sc_hd__or2_1
XFILLER_0_55_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14548_ _05532_ _05544_ VGND VGND VPWR VPWR _05545_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_28_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_112_Right_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17267_ net494 _08494_ VGND VGND VPWR VPWR _08524_ sky130_fd_sc_hd__nand2_1
XFILLER_0_141_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14479_ _07772_ _01456_ _07750_ VGND VGND VPWR VPWR _05469_ sky130_fd_sc_hd__a21o_4
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16218_ net307 _06204_ _07381_ VGND VGND VPWR VPWR _07382_ sky130_fd_sc_hd__and3_1
XFILLER_0_141_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17198_ _03867_ _08457_ _08458_ _08459_ VGND VGND VPWR VPWR _08460_ sky130_fd_sc_hd__or4_4
XFILLER_0_3_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16149_ _07268_ _07269_ _07270_ _07246_ VGND VGND VPWR VPWR _07306_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_87_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08971_ _05660_ VGND VGND VPWR VPWR _05726_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09523_ _00276_ _00281_ VGND VGND VPWR VPWR _00334_ sky130_fd_sc_hd__xor2_2
X_09454_ _00180_ _00262_ _00230_ _00261_ VGND VGND VPWR VPWR _00265_ sky130_fd_sc_hd__o211a_1
XFILLER_0_149_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09385_ _00193_ _00195_ VGND VGND VPWR VPWR _00196_ sky130_fd_sc_hd__xor2_2
XFILLER_0_136_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10160_ net379 _04428_ _00970_ VGND VGND VPWR VPWR _00971_ sky130_fd_sc_hd__and3_1
XFILLER_0_100_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10091_ net379 _05143_ _05154_ VGND VGND VPWR VPWR _00902_ sky130_fd_sc_hd__and3_1
XFILLER_0_100_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13850_ _04771_ _04775_ _04776_ VGND VGND VPWR VPWR _04777_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12801_ _03643_ _03644_ VGND VGND VPWR VPWR _03645_ sky130_fd_sc_hd__xnor2_1
X_13781_ _04620_ _04700_ VGND VGND VPWR VPWR _04701_ sky130_fd_sc_hd__xor2_1
X_10993_ _01802_ _01803_ net402 net130 VGND VGND VPWR VPWR _01804_ sky130_fd_sc_hd__and4bb_1
X_15520_ net263 net259 _06161_ _06206_ VGND VGND VPWR VPWR _06614_ sky130_fd_sc_hd__and4_1
X_12732_ _03189_ _03206_ _03572_ VGND VGND VPWR VPWR _03574_ sky130_fd_sc_hd__a21o_1
XFILLER_0_123_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15451_ _06536_ _05582_ net289 _06537_ VGND VGND VPWR VPWR _06538_ sky130_fd_sc_hd__and4b_1
XFILLER_0_96_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12663_ net193 _03322_ _03342_ net189 VGND VGND VPWR VPWR _03502_ sky130_fd_sc_hd__a22oi_1
X_14402_ net193 _03372_ _03322_ net189 VGND VGND VPWR VPWR _05384_ sky130_fd_sc_hd__a22o_1
X_11614_ _02422_ _02424_ VGND VGND VPWR VPWR _02425_ sky130_fd_sc_hd__and2b_1
XFILLER_0_108_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15382_ _06360_ _06345_ _06358_ VGND VGND VPWR VPWR _06462_ sky130_fd_sc_hd__nand3_1
XFILLER_0_53_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12594_ _03421_ _03432_ VGND VGND VPWR VPWR _03433_ sky130_fd_sc_hd__nand2_2
XFILLER_0_53_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17121_ _08369_ _08374_ _08367_ VGND VGND VPWR VPWR _08375_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14333_ _01668_ _01670_ VGND VGND VPWR VPWR _05309_ sky130_fd_sc_hd__or2_1
X_11545_ _02259_ _02261_ VGND VGND VPWR VPWR _02356_ sky130_fd_sc_hd__or2_1
XFILLER_0_53_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17052_ _08297_ _08298_ VGND VGND VPWR VPWR _08299_ sky130_fd_sc_hd__nor2_1
X_11476_ _02285_ _02286_ VGND VGND VPWR VPWR _02287_ sky130_fd_sc_hd__and2_1
X_14264_ _05189_ _04193_ VGND VGND VPWR VPWR _05233_ sky130_fd_sc_hd__and2b_1
XFILLER_0_40_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16003_ net282 _06205_ VGND VGND VPWR VPWR _07146_ sky130_fd_sc_hd__nand2_1
X_10427_ _01133_ _01237_ VGND VGND VPWR VPWR _01238_ sky130_fd_sc_hd__and2b_1
X_13215_ _04071_ _04078_ VGND VGND VPWR VPWR _04079_ sky130_fd_sc_hd__xnor2_1
X_14195_ _05153_ _05156_ VGND VGND VPWR VPWR _05157_ sky130_fd_sc_hd__or2_1
X_10358_ _01125_ _01124_ VGND VGND VPWR VPWR _01169_ sky130_fd_sc_hd__and2b_1
X_13146_ _04002_ VGND VGND VPWR VPWR _04003_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_20_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13077_ _03921_ _03926_ VGND VGND VPWR VPWR _03927_ sky130_fd_sc_hd__or2b_1
X_10289_ _01097_ _01098_ _01099_ VGND VGND VPWR VPWR _01100_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12028_ _02843_ _02844_ VGND VGND VPWR VPWR _02845_ sky130_fd_sc_hd__nor2_1
X_16905_ _05240_ _05292_ VGND VGND VPWR VPWR _08138_ sky130_fd_sc_hd__nand2_2
X_16836_ _05263_ _05283_ VGND VGND VPWR VPWR _08062_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_73_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16767_ _07757_ _07975_ VGND VGND VPWR VPWR _07986_ sky130_fd_sc_hd__nor2_1
XFILLER_0_87_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13979_ _03573_ _03574_ _04195_ VGND VGND VPWR VPWR _04919_ sky130_fd_sc_hd__a21o_1
X_15718_ net289 _05590_ _06821_ _06820_ VGND VGND VPWR VPWR _06832_ sky130_fd_sc_hd__a31oi_2
X_16698_ _07908_ _07909_ VGND VGND VPWR VPWR _07910_ sky130_fd_sc_hd__nand2_2
XFILLER_0_29_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15649_ _06754_ _06755_ VGND VGND VPWR VPWR _06756_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09170_ _07904_ VGND VGND VPWR VPWR _07915_ sky130_fd_sc_hd__buf_6
XFILLER_0_56_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17319_ _08549_ _05759_ _08557_ net450 VGND VGND VPWR VPWR _00107_ sky130_fd_sc_hd__o211a_1
XFILLER_0_28_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08954_ _05506_ _05528_ VGND VGND VPWR VPWR _05539_ sky130_fd_sc_hd__and2_2
X_08885_ _04769_ VGND VGND VPWR VPWR _04780_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_138_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09506_ _04549_ _00316_ VGND VGND VPWR VPWR _00317_ sky130_fd_sc_hd__or2_1
XFILLER_0_79_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09437_ _00235_ _00237_ VGND VGND VPWR VPWR _00248_ sky130_fd_sc_hd__xor2_1
XFILLER_0_93_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09368_ _08625_ _00176_ _00171_ _00175_ VGND VGND VPWR VPWR _00179_ sky130_fd_sc_hd__o211a_1
XFILLER_0_81_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09299_ net330 _04615_ _07332_ net326 VGND VGND VPWR VPWR _08663_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_62_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11330_ _02100_ _02102_ VGND VGND VPWR VPWR _02141_ sky130_fd_sc_hd__or2_1
XFILLER_0_34_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11261_ net407 net136 _02071_ VGND VGND VPWR VPWR _02072_ sky130_fd_sc_hd__and3_1
XFILLER_0_104_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10212_ _00982_ _01022_ VGND VGND VPWR VPWR _01023_ sky130_fd_sc_hd__and2_1
X_13000_ _03835_ _03843_ VGND VGND VPWR VPWR _03844_ sky130_fd_sc_hd__nor2_1
X_11192_ _02001_ _02002_ VGND VGND VPWR VPWR _02003_ sky130_fd_sc_hd__or2_1
XFILLER_0_101_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10143_ _00924_ _00926_ VGND VGND VPWR VPWR _00954_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_118_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14951_ _05673_ _05987_ VGND VGND VPWR VPWR _05988_ sky130_fd_sc_hd__or2_1
X_10074_ _00860_ _00881_ VGND VGND VPWR VPWR _00885_ sky130_fd_sc_hd__xnor2_4
X_13902_ _04832_ _04833_ VGND VGND VPWR VPWR _04834_ sky130_fd_sc_hd__nor2_1
X_14882_ _05673_ _05788_ VGND VGND VPWR VPWR _05912_ sky130_fd_sc_hd__xnor2_1
X_16621_ _07824_ _05432_ _05428_ VGND VGND VPWR VPWR _07825_ sky130_fd_sc_hd__a21bo_1
X_13833_ _04753_ _04757_ VGND VGND VPWR VPWR _04759_ sky130_fd_sc_hd__xor2_1
XFILLER_0_134_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16552_ _07722_ _07748_ _07730_ _07733_ VGND VGND VPWR VPWR _07749_ sky130_fd_sc_hd__o22a_1
X_13764_ _04675_ _04678_ _04682_ VGND VGND VPWR VPWR _04683_ sky130_fd_sc_hd__or3_1
X_10976_ _01716_ _01786_ VGND VGND VPWR VPWR _01787_ sky130_fd_sc_hd__xnor2_1
Xmax_cap95 _05915_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__buf_1
X_15503_ _06545_ _06563_ _06593_ net98 VGND VGND VPWR VPWR _06596_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_84_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12715_ _03543_ _03555_ VGND VGND VPWR VPWR _03556_ sky130_fd_sc_hd__nor2_1
X_16483_ _07664_ _07672_ VGND VGND VPWR VPWR _07674_ sky130_fd_sc_hd__xnor2_1
X_13695_ _04531_ _04606_ VGND VGND VPWR VPWR _04607_ sky130_fd_sc_hd__nand2_1
X_15434_ net308 _05625_ _05635_ VGND VGND VPWR VPWR _06520_ sky130_fd_sc_hd__and3_4
XFILLER_0_84_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12646_ _03483_ _03484_ VGND VGND VPWR VPWR _03485_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15365_ net267 _05604_ _06321_ VGND VGND VPWR VPWR _06444_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_108_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12577_ _03303_ _03415_ _03413_ VGND VGND VPWR VPWR _03416_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17104_ _05415_ _08356_ VGND VGND VPWR VPWR _08357_ sky130_fd_sc_hd__nand2_2
XFILLER_0_81_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14316_ _05244_ _05247_ VGND VGND VPWR VPWR _05290_ sky130_fd_sc_hd__nand2_1
X_11528_ _02237_ _02248_ _02247_ VGND VGND VPWR VPWR _02339_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_25_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15296_ _06267_ _06262_ _06266_ VGND VGND VPWR VPWR _06368_ sky130_fd_sc_hd__a21o_1
XFILLER_0_40_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17035_ net194 net189 _03372_ VGND VGND VPWR VPWR _08281_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_150_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14247_ _03170_ _05213_ VGND VGND VPWR VPWR _05214_ sky130_fd_sc_hd__and2_1
X_11459_ _02268_ _02269_ VGND VGND VPWR VPWR _02270_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14178_ _05135_ _05136_ _05118_ VGND VGND VPWR VPWR _05138_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13129_ _03981_ _03983_ VGND VGND VPWR VPWR _03984_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16819_ _08020_ _08033_ _08040_ _08042_ VGND VGND VPWR VPWR _08043_ sky130_fd_sc_hd__o22a_1
XFILLER_0_76_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09222_ _08322_ _08476_ _08454_ VGND VGND VPWR VPWR _08487_ sky130_fd_sc_hd__o21a_1
XFILLER_0_17_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09153_ _07706_ _07717_ VGND VGND VPWR VPWR _07728_ sky130_fd_sc_hd__or2b_1
XFILLER_0_99_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09084_ _06309_ _06848_ _06958_ VGND VGND VPWR VPWR _06969_ sky130_fd_sc_hd__o21a_1
XFILLER_0_4_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09986_ _00655_ _00559_ _00796_ VGND VGND VPWR VPWR _00797_ sky130_fd_sc_hd__o21ai_1
X_08937_ _04956_ _05319_ _05330_ _05341_ VGND VGND VPWR VPWR _05352_ sky130_fd_sc_hd__a31o_1
X_08868_ _04571_ _04582_ _04384_ _04021_ VGND VGND VPWR VPWR _04593_ sky130_fd_sc_hd__o211a_2
XFILLER_0_98_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08799_ net52 _02883_ _02916_ net150 VGND VGND VPWR VPWR _00032_ sky130_fd_sc_hd__a22o_1
X_10830_ net401 net105 VGND VGND VPWR VPWR _01641_ sky130_fd_sc_hd__nand2_1
XFILLER_0_94_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10761_ _01563_ net138 _01567_ _01571_ VGND VGND VPWR VPWR _01572_ sky130_fd_sc_hd__o22a_1
XFILLER_0_67_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12500_ _03336_ VGND VGND VPWR VPWR _03337_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_137_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13480_ _04236_ _04369_ VGND VGND VPWR VPWR _04370_ sky130_fd_sc_hd__xor2_4
X_10692_ _01492_ _01495_ _01502_ VGND VGND VPWR VPWR _01503_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_81_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12431_ kd_1\[17\] VGND VGND VPWR VPWR _03263_ sky130_fd_sc_hd__inv_2
XFILLER_0_90_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15150_ _06159_ _06202_ VGND VGND VPWR VPWR _06207_ sky130_fd_sc_hd__nand2_1
X_12362_ prev_error\[3\] VGND VGND VPWR VPWR _03194_ sky130_fd_sc_hd__inv_2
X_14101_ _05013_ _05050_ _05052_ VGND VGND VPWR VPWR _05053_ sky130_fd_sc_hd__nor3_1
X_11313_ _02122_ _02123_ VGND VGND VPWR VPWR _02124_ sky130_fd_sc_hd__and2b_1
X_15081_ net270 _05621_ VGND VGND VPWR VPWR _06131_ sky130_fd_sc_hd__nand2_1
X_12293_ _03121_ _03124_ _02970_ _03036_ VGND VGND VPWR VPWR _03125_ sky130_fd_sc_hd__o22a_1
XFILLER_0_120_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14032_ _04974_ _04975_ _04976_ VGND VGND VPWR VPWR _04977_ sky130_fd_sc_hd__nor3_1
X_11244_ _02040_ _02042_ _02053_ VGND VGND VPWR VPWR _02055_ sky130_fd_sc_hd__or3_1
XFILLER_0_120_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11175_ _01983_ _01985_ VGND VGND VPWR VPWR _01986_ sky130_fd_sc_hd__and2_1
X_10126_ net367 _04604_ _00936_ VGND VGND VPWR VPWR _00937_ sky130_fd_sc_hd__and3_1
X_15983_ _07115_ _07121_ _07122_ VGND VGND VPWR VPWR _07124_ sky130_fd_sc_hd__or3_4
X_14934_ _05668_ _05969_ VGND VGND VPWR VPWR _05970_ sky130_fd_sc_hd__and2_1
X_10057_ net374 _04428_ VGND VGND VPWR VPWR _00868_ sky130_fd_sc_hd__nand2_1
X_14865_ _05866_ _05893_ VGND VGND VPWR VPWR _05894_ sky130_fd_sc_hd__or2_1
X_16604_ _05434_ net96 VGND VGND VPWR VPWR _07807_ sky130_fd_sc_hd__and2b_1
X_13816_ _04738_ _04733_ VGND VGND VPWR VPWR _04740_ sky130_fd_sc_hd__and2b_1
XFILLER_0_98_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14796_ _05813_ _05817_ VGND VGND VPWR VPWR _05818_ sky130_fd_sc_hd__nor2_1
XFILLER_0_85_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16535_ _05422_ _05466_ VGND VGND VPWR VPWR _07731_ sky130_fd_sc_hd__nand2_1
X_13747_ net219 _03667_ _03750_ net216 VGND VGND VPWR VPWR _04664_ sky130_fd_sc_hd__a22o_1
X_10959_ _01760_ _01767_ _01769_ VGND VGND VPWR VPWR _01770_ sky130_fd_sc_hd__a21o_1
X_16466_ i_error\[13\] _07653_ VGND VGND VPWR VPWR _07655_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13678_ _04579_ _04586_ _04587_ VGND VGND VPWR VPWR _04588_ sky130_fd_sc_hd__a21o_1
XFILLER_0_128_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15417_ _06497_ _06499_ _06500_ VGND VGND VPWR VPWR _06501_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_128_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12629_ _03426_ _03466_ _03467_ VGND VGND VPWR VPWR _03468_ sky130_fd_sc_hd__o21a_1
X_16397_ _06404_ _07499_ VGND VGND VPWR VPWR _07579_ sky130_fd_sc_hd__and2_1
XFILLER_0_115_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15348_ _06413_ _06414_ _06424_ VGND VGND VPWR VPWR _06425_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15279_ _06348_ VGND VGND VPWR VPWR _06349_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_79_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17018_ _05360_ _05364_ _05365_ VGND VGND VPWR VPWR _08262_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_1_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09840_ net2 net57 VGND VGND VPWR VPWR _00651_ sky130_fd_sc_hd__or2b_1
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09771_ net333 _07937_ VGND VGND VPWR VPWR _00582_ sky130_fd_sc_hd__nand2_1
X_08722_ _02850_ _03039_ VGND VGND VPWR VPWR _03050_ sky130_fd_sc_hd__nor2_2
XFILLER_0_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09205_ _08047_ _08289_ _08267_ VGND VGND VPWR VPWR _08300_ sky130_fd_sc_hd__a21o_1
XFILLER_0_45_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09136_ _07464_ _07497_ _07519_ VGND VGND VPWR VPWR _07541_ sky130_fd_sc_hd__nor3_1
XFILLER_0_115_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09067_ _06661_ _06771_ VGND VGND VPWR VPWR _06782_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_8_0_clock clknet_0_clock VGND VGND VPWR VPWR clknet_4_8_0_clock sky130_fd_sc_hd__clkbuf_8
X_09969_ _00773_ _00779_ VGND VGND VPWR VPWR _00780_ sky130_fd_sc_hd__xnor2_1
X_12980_ _03822_ _03823_ VGND VGND VPWR VPWR _03824_ sky130_fd_sc_hd__xor2_1
X_11931_ net405 net410 net167 net170 VGND VGND VPWR VPWR _02742_ sky130_fd_sc_hd__and4_1
XFILLER_0_99_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14650_ net262 _05622_ _05636_ VGND VGND VPWR VPWR _05657_ sky130_fd_sc_hd__and3_1
XFILLER_0_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11862_ net400 net170 net174 net396 VGND VGND VPWR VPWR _02673_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_86_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13601_ _04492_ _04501_ _04502_ VGND VGND VPWR VPWR _04503_ sky130_fd_sc_hd__a21oi_2
X_10813_ _01594_ _01596_ _01623_ VGND VGND VPWR VPWR _01624_ sky130_fd_sc_hd__o21ai_1
X_14581_ _03246_ _05580_ VGND VGND VPWR VPWR _05581_ sky130_fd_sc_hd__xor2_4
XFILLER_0_95_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11793_ _02587_ _02601_ _02603_ VGND VGND VPWR VPWR _02604_ sky130_fd_sc_hd__a21oi_2
X_16320_ _06786_ _06787_ _06762_ _06765_ VGND VGND VPWR VPWR _07494_ sky130_fd_sc_hd__a211o_1
XFILLER_0_67_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_843 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13532_ _04422_ _04426_ VGND VGND VPWR VPWR _04427_ sky130_fd_sc_hd__xnor2_1
X_10744_ _01466_ _01530_ _01531_ VGND VGND VPWR VPWR _01555_ sky130_fd_sc_hd__and3_1
XFILLER_0_131_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16251_ _07407_ _07417_ VGND VGND VPWR VPWR _07418_ sky130_fd_sc_hd__and2_1
X_13463_ _04347_ _04350_ VGND VGND VPWR VPWR _04352_ sky130_fd_sc_hd__nand2_1
X_10675_ _01485_ VGND VGND VPWR VPWR _01486_ sky130_fd_sc_hd__buf_2
X_15202_ _06222_ _06220_ VGND VGND VPWR VPWR _06264_ sky130_fd_sc_hd__or2b_1
XFILLER_0_36_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12414_ _03228_ _03211_ VGND VGND VPWR VPWR _03246_ sky130_fd_sc_hd__nor2_8
X_16182_ _07325_ _07328_ _07327_ VGND VGND VPWR VPWR _07342_ sky130_fd_sc_hd__o21ai_1
X_13394_ _04099_ _04115_ VGND VGND VPWR VPWR _04276_ sky130_fd_sc_hd__xor2_1
XFILLER_0_140_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15133_ _06176_ _06186_ _06185_ _06187_ VGND VGND VPWR VPWR _06189_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_2_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12345_ prev_error\[12\] _04417_ VGND VGND VPWR VPWR _03177_ sky130_fd_sc_hd__nand2_2
XFILLER_0_51_888 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15064_ net281 net491 _05734_ VGND VGND VPWR VPWR _06113_ sky130_fd_sc_hd__and3_2
X_12276_ _02925_ _02924_ VGND VGND VPWR VPWR _03108_ sky130_fd_sc_hd__or2b_1
XFILLER_0_120_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14015_ _04954_ _04958_ VGND VGND VPWR VPWR _04959_ sky130_fd_sc_hd__or2b_1
X_11227_ _01946_ _01947_ VGND VGND VPWR VPWR _02038_ sky130_fd_sc_hd__nor2_1
X_11158_ _01953_ _01967_ _01968_ VGND VGND VPWR VPWR _01969_ sky130_fd_sc_hd__o21a_1
X_10109_ _00916_ _00919_ VGND VGND VPWR VPWR _00920_ sky130_fd_sc_hd__xor2_1
X_15966_ _07102_ _07083_ _07103_ VGND VGND VPWR VPWR _07105_ sky130_fd_sc_hd__and3_1
X_11089_ _01562_ net159 _01899_ VGND VGND VPWR VPWR _01900_ sky130_fd_sc_hd__nor3_1
X_14917_ _05657_ _05656_ VGND VGND VPWR VPWR _05951_ sky130_fd_sc_hd__or2_1
X_15897_ _07025_ _07026_ _07027_ VGND VGND VPWR VPWR _07029_ sky130_fd_sc_hd__and3_1
X_14848_ net273 net269 _05697_ VGND VGND VPWR VPWR _05875_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_58_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14779_ _05798_ _05727_ VGND VGND VPWR VPWR _05799_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_147_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16518_ _07709_ _07711_ VGND VGND VPWR VPWR _07712_ sky130_fd_sc_hd__nor2_1
XFILLER_0_18_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17498_ clknet_4_12_0_clock _00041_ VGND VGND VPWR VPWR ki\[14\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_144_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16449_ i_error\[5\] _07589_ _07606_ VGND VGND VPWR VPWR _07636_ sky130_fd_sc_hd__and3_1
XFILLER_0_73_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout404 prev_d_error\[11\] VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__buf_2
Xfanout415 prev_d_error\[8\] VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__clkbuf_4
Xfanout426 net427 VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__clkbuf_4
X_09823_ _00603_ _00633_ VGND VGND VPWR VPWR _00634_ sky130_fd_sc_hd__xor2_1
Xfanout437 net438 VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__buf_2
Xfanout448 net449 VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__buf_2
Xfanout459 net460 VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__buf_2
X_09754_ _00523_ _00513_ VGND VGND VPWR VPWR _00565_ sky130_fd_sc_hd__xor2_1
X_08705_ _02861_ VGND VGND VPWR VPWR _02872_ sky130_fd_sc_hd__clkbuf_2
X_09685_ _00488_ _00494_ _00495_ VGND VGND VPWR VPWR _00496_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_146_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_126_Right_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10460_ _01268_ _01250_ _01269_ _01270_ VGND VGND VPWR VPWR _01271_ sky130_fd_sc_hd__or4_4
XFILLER_0_51_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09119_ net317 net313 _04626_ _07343_ VGND VGND VPWR VPWR _07354_ sky130_fd_sc_hd__and4_1
XFILLER_0_150_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10391_ _01184_ _01201_ VGND VGND VPWR VPWR _01202_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_20_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12130_ _02885_ _02954_ VGND VGND VPWR VPWR _02955_ sky130_fd_sc_hd__nand2_1
X_12061_ _02879_ _02880_ VGND VGND VPWR VPWR _02881_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11012_ _01747_ _01748_ _01750_ VGND VGND VPWR VPWR _01823_ sky130_fd_sc_hd__o21ai_1
X_15820_ _06813_ _06940_ _06939_ VGND VGND VPWR VPWR _06944_ sky130_fd_sc_hd__a21o_1
XFILLER_0_126_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15751_ _06642_ _06866_ _06865_ _06840_ VGND VGND VPWR VPWR _06868_ sky130_fd_sc_hd__o211a_1
X_12963_ net223 net501 VGND VGND VPWR VPWR _03807_ sky130_fd_sc_hd__nand2_1
X_14702_ _05712_ _05713_ _05698_ _05705_ VGND VGND VPWR VPWR _05714_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_99_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11914_ net428 net447 net131 net147 VGND VGND VPWR VPWR _02725_ sky130_fd_sc_hd__and4_1
X_15682_ _06497_ _06499_ VGND VGND VPWR VPWR _06792_ sky130_fd_sc_hd__xor2_1
X_12894_ _03718_ _03737_ VGND VGND VPWR VPWR _03738_ sky130_fd_sc_hd__or2_1
XFILLER_0_87_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17421_ clknet_4_2_0_clock _00099_ VGND VGND VPWR VPWR prev_error\[9\] sky130_fd_sc_hd__dfxtp_1
X_14633_ net263 net479 _05635_ VGND VGND VPWR VPWR _05639_ sky130_fd_sc_hd__and3_1
XFILLER_0_68_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11845_ net417 net422 net152 net156 VGND VGND VPWR VPWR _02656_ sky130_fd_sc_hd__and4_1
XFILLER_0_129_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17352_ net463 i_error\[15\] VGND VGND VPWR VPWR _08578_ sky130_fd_sc_hd__or2_1
X_14564_ _04310_ _03198_ _05562_ VGND VGND VPWR VPWR _05563_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_83_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11776_ _02577_ _02584_ _02586_ VGND VGND VPWR VPWR _02587_ sky130_fd_sc_hd__a21o_2
XFILLER_0_144_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16303_ _07341_ _07378_ _07473_ _07474_ VGND VGND VPWR VPWR _07476_ sky130_fd_sc_hd__a22oi_1
X_13515_ net227 _04403_ _03335_ _04408_ VGND VGND VPWR VPWR _04409_ sky130_fd_sc_hd__a31o_1
X_17283_ net462 prev_error\[0\] net451 _08534_ VGND VGND VPWR VPWR _00090_ sky130_fd_sc_hd__o211a_1
X_10727_ _01494_ _01493_ VGND VGND VPWR VPWR _01538_ sky130_fd_sc_hd__and2b_1
X_14495_ _05475_ _05486_ VGND VGND VPWR VPWR _05487_ sky130_fd_sc_hd__and2_1
XFILLER_0_125_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16234_ _07386_ _07391_ VGND VGND VPWR VPWR _07400_ sky130_fd_sc_hd__nand2_1
XFILLER_0_125_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13446_ net213 _03269_ VGND VGND VPWR VPWR _04333_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10658_ net418 net421 net105 VGND VGND VPWR VPWR _01469_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_63_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16165_ _07274_ _07275_ _07276_ VGND VGND VPWR VPWR _07324_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_141_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13377_ _04194_ _04256_ VGND VGND VPWR VPWR _04257_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10589_ _01348_ _01386_ _01399_ VGND VGND VPWR VPWR _01400_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_23_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15116_ _06156_ _06158_ _06169_ VGND VGND VPWR VPWR _06170_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_50_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12328_ _02399_ _03157_ _03159_ VGND VGND VPWR VPWR _03160_ sky130_fd_sc_hd__a21oi_1
X_16096_ net279 _06416_ VGND VGND VPWR VPWR _07248_ sky130_fd_sc_hd__nand2_1
X_15047_ net300 net296 VGND VGND VPWR VPWR _06094_ sky130_fd_sc_hd__nor2_1
X_12259_ net448 net164 _03079_ VGND VGND VPWR VPWR _03090_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_76_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16998_ _08230_ _08239_ VGND VGND VPWR VPWR _08240_ sky130_fd_sc_hd__or2_1
X_15949_ _07073_ _07074_ _07085_ VGND VGND VPWR VPWR _07086_ sky130_fd_sc_hd__nand3_2
X_09470_ net344 _04450_ _00280_ _00277_ VGND VGND VPWR VPWR _00281_ sky130_fd_sc_hd__a31o_1
XFILLER_0_116_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_890 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout201 kd_1\[11\] VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_100_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout212 net213 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__clkbuf_4
Xfanout223 kd_1\[5\] VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__buf_2
Xfanout234 kd_1\[3\] VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout245 net246 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__clkbuf_4
Xfanout256 net257 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__clkbuf_4
X_09806_ net361 _04769_ _00568_ _00567_ VGND VGND VPWR VPWR _00617_ sky130_fd_sc_hd__a22o_1
Xfanout267 ki\[11\] VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__clkbuf_4
Xfanout278 net280 VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__clkbuf_4
Xfanout289 ki\[5\] VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__buf_2
X_09737_ _00546_ _00547_ VGND VGND VPWR VPWR _00548_ sky130_fd_sc_hd__and2b_1
X_09668_ net323 _08677_ VGND VGND VPWR VPWR _00479_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09599_ _00291_ _00399_ _00405_ VGND VGND VPWR VPWR _00410_ sky130_fd_sc_hd__or3b_1
X_11630_ net396 net400 net163 net167 VGND VGND VPWR VPWR _02441_ sky130_fd_sc_hd__and4_1
XFILLER_0_77_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11561_ net400 net164 VGND VGND VPWR VPWR _02372_ sky130_fd_sc_hd__nand2_1
XFILLER_0_107_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13300_ _04119_ _04171_ VGND VGND VPWR VPWR _04172_ sky130_fd_sc_hd__xor2_1
X_10512_ net359 _00652_ _01321_ _01322_ VGND VGND VPWR VPWR _01323_ sky130_fd_sc_hd__nand4_2
XFILLER_0_107_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14280_ _03154_ _05249_ VGND VGND VPWR VPWR _05250_ sky130_fd_sc_hd__and2_1
X_11492_ _02277_ _02288_ _02293_ _02292_ _02290_ VGND VGND VPWR VPWR _02303_ sky130_fd_sc_hd__o32ai_4
XFILLER_0_107_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13231_ _03994_ _04095_ VGND VGND VPWR VPWR _04096_ sky130_fd_sc_hd__nand2_1
X_10443_ _01251_ _01253_ VGND VGND VPWR VPWR _01254_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_123_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13162_ _03996_ _04019_ VGND VGND VPWR VPWR _04020_ sky130_fd_sc_hd__nor2_1
X_10374_ _01144_ _01146_ _01145_ VGND VGND VPWR VPWR _01185_ sky130_fd_sc_hd__a21o_1
X_12113_ _02931_ _02901_ _02915_ VGND VGND VPWR VPWR _02938_ sky130_fd_sc_hd__nand3_1
XFILLER_0_20_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13093_ _03898_ _03915_ _03917_ VGND VGND VPWR VPWR _03945_ sky130_fd_sc_hd__and3_1
X_16921_ _05437_ _08115_ _08154_ VGND VGND VPWR VPWR _08155_ sky130_fd_sc_hd__a21oi_1
X_12044_ _02860_ _02862_ VGND VGND VPWR VPWR _02863_ sky130_fd_sc_hd__nor2_1
X_16852_ _05280_ _05279_ VGND VGND VPWR VPWR _08079_ sky130_fd_sc_hd__and2b_1
X_15803_ _06921_ _06916_ VGND VGND VPWR VPWR _06926_ sky130_fd_sc_hd__and2b_1
X_16783_ _07784_ _07998_ _08000_ _07773_ _08002_ VGND VGND VPWR VPWR _08004_ sky130_fd_sc_hd__a221o_1
X_13995_ net244 _03268_ _04936_ VGND VGND VPWR VPWR _04937_ sky130_fd_sc_hd__nand3_1
X_15734_ _06846_ _06847_ VGND VGND VPWR VPWR _06850_ sky130_fd_sc_hd__xor2_1
X_12946_ _03788_ _03789_ VGND VGND VPWR VPWR _03790_ sky130_fd_sc_hd__xnor2_2
X_15665_ _06740_ _06743_ _06773_ VGND VGND VPWR VPWR _06774_ sky130_fd_sc_hd__a21bo_1
X_12877_ _03719_ _03720_ VGND VGND VPWR VPWR _03721_ sky130_fd_sc_hd__xnor2_1
X_17404_ clknet_4_10_0_clock _00082_ VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dfxtp_1
X_14616_ _05618_ _05619_ VGND VGND VPWR VPWR _05620_ sky130_fd_sc_hd__or2_2
XFILLER_0_28_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11828_ _02604_ _02636_ _02638_ VGND VGND VPWR VPWR _02639_ sky130_fd_sc_hd__or3_1
X_15596_ net250 _04315_ VGND VGND VPWR VPWR _06698_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17335_ _08564_ _08148_ _08568_ net454 VGND VGND VPWR VPWR _00114_ sky130_fd_sc_hd__o211a_1
X_14547_ _05540_ _05543_ VGND VGND VPWR VPWR _05544_ sky130_fd_sc_hd__xnor2_1
X_11759_ _02563_ _02565_ VGND VGND VPWR VPWR _02570_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_43_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17266_ _08522_ _08523_ net455 VGND VGND VPWR VPWR _00083_ sky130_fd_sc_hd__o21a_1
XFILLER_0_114_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14478_ _01457_ _05421_ _05467_ VGND VGND VPWR VPWR _05468_ sky130_fd_sc_hd__or3_1
XFILLER_0_43_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16217_ _07356_ _07379_ VGND VGND VPWR VPWR _07381_ sky130_fd_sc_hd__xor2_1
XFILLER_0_125_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13429_ _04313_ VGND VGND VPWR VPWR _04314_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_140_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17197_ _08229_ _08249_ VGND VGND VPWR VPWR _08459_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_11_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16148_ net275 _04319_ _07304_ VGND VGND VPWR VPWR _07305_ sky130_fd_sc_hd__and3_1
XFILLER_0_23_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08970_ net341 net336 VGND VGND VPWR VPWR _05715_ sky130_fd_sc_hd__or2_1
X_16079_ _07160_ _07161_ _07172_ VGND VGND VPWR VPWR _07229_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_87_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput1 iterate_enable VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_2
XFILLER_0_127_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09522_ _00202_ _00203_ VGND VGND VPWR VPWR _00333_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_36_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09453_ _00252_ _00258_ VGND VGND VPWR VPWR _00264_ sky130_fd_sc_hd__nand2_1
X_09384_ _00194_ _08694_ VGND VGND VPWR VPWR _00195_ sky130_fd_sc_hd__xor2_2
XFILLER_0_59_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10090_ net360 _07321_ _04747_ net378 VGND VGND VPWR VPWR _00901_ sky130_fd_sc_hd__a22o_1
XFILLER_0_100_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12800_ _03569_ _03568_ VGND VGND VPWR VPWR _03644_ sky130_fd_sc_hd__and2b_1
X_13780_ net232 _03268_ VGND VGND VPWR VPWR _04700_ sky130_fd_sc_hd__nand2_1
X_10992_ net406 net126 net123 net412 VGND VGND VPWR VPWR _01803_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_97_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12731_ _03189_ _03206_ _03572_ VGND VGND VPWR VPWR _03573_ sky130_fd_sc_hd__nand3_2
XFILLER_0_96_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15450_ net309 net490 _05722_ net292 _05620_ VGND VGND VPWR VPWR _06537_ sky130_fd_sc_hd__a32o_1
XFILLER_0_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12662_ net186 _03337_ VGND VGND VPWR VPWR _03501_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14401_ net193 net189 _03372_ VGND VGND VPWR VPWR _05383_ sky130_fd_sc_hd__and3_1
X_11613_ _02344_ _02423_ VGND VGND VPWR VPWR _02424_ sky130_fd_sc_hd__nor2_1
X_15381_ _06459_ _06460_ VGND VGND VPWR VPWR _06461_ sky130_fd_sc_hd__and2b_1
X_12593_ _03431_ _03425_ VGND VGND VPWR VPWR _03432_ sky130_fd_sc_hd__and2b_1
XFILLER_0_37_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17120_ _08229_ _08250_ _08370_ _08373_ VGND VGND VPWR VPWR _08374_ sky130_fd_sc_hd__a31o_1
XFILLER_0_38_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14332_ _01665_ _01681_ _01683_ VGND VGND VPWR VPWR _05307_ sky130_fd_sc_hd__o21ai_1
X_11544_ _02334_ _02329_ VGND VGND VPWR VPWR _02355_ sky130_fd_sc_hd__or2b_1
XFILLER_0_80_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17051_ _08295_ _08296_ VGND VGND VPWR VPWR _08298_ sky130_fd_sc_hd__and2_1
XFILLER_0_122_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14263_ _03161_ _05230_ VGND VGND VPWR VPWR _05232_ sky130_fd_sc_hd__xor2_4
X_11475_ _02280_ _02282_ VGND VGND VPWR VPWR _02286_ sky130_fd_sc_hd__xor2_1
X_16002_ _07128_ _07142_ _07141_ VGND VGND VPWR VPWR _07144_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_122_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13214_ _04074_ _04077_ VGND VGND VPWR VPWR _04078_ sky130_fd_sc_hd__nand2_1
XFILLER_0_150_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10426_ net339 _00653_ _00520_ net342 VGND VGND VPWR VPWR _01237_ sky130_fd_sc_hd__a22o_1
XFILLER_0_104_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14194_ _04882_ _05155_ VGND VGND VPWR VPWR _05156_ sky130_fd_sc_hd__xor2_1
X_13145_ _04001_ VGND VGND VPWR VPWR _04002_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_0_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10357_ net346 _00372_ VGND VGND VPWR VPWR _01168_ sky130_fd_sc_hd__nand2_1
X_13076_ _03781_ _03923_ _03925_ VGND VGND VPWR VPWR _03926_ sky130_fd_sc_hd__o21bai_1
X_10288_ _01025_ _01096_ _01091_ _01095_ VGND VGND VPWR VPWR _01099_ sky130_fd_sc_hd__o211ai_1
X_16904_ _08133_ _08134_ _08136_ VGND VGND VPWR VPWR _08137_ sky130_fd_sc_hd__a21o_1
X_12027_ _02842_ _02835_ _02840_ VGND VGND VPWR VPWR _02844_ sky130_fd_sc_hd__and3_1
X_16835_ _08059_ _08060_ VGND VGND VPWR VPWR _08061_ sky130_fd_sc_hd__nor2_1
X_16766_ _07809_ _07975_ VGND VGND VPWR VPWR _07985_ sky130_fd_sc_hd__nor2_2
X_13978_ net244 _03935_ VGND VGND VPWR VPWR _04918_ sky130_fd_sc_hd__nand2_2
X_15717_ net278 _05975_ _06829_ _06830_ VGND VGND VPWR VPWR _06831_ sky130_fd_sc_hd__a31o_1
X_12929_ _03760_ _03766_ _03764_ VGND VGND VPWR VPWR _03773_ sky130_fd_sc_hd__a21o_1
X_16697_ i_error\[16\] _07907_ VGND VGND VPWR VPWR _07909_ sky130_fd_sc_hd__or2_1
XFILLER_0_87_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15648_ _06753_ _06717_ _06751_ VGND VGND VPWR VPWR _06755_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_1_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_38_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15579_ _06665_ _06678_ VGND VGND VPWR VPWR _06679_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_7_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17318_ net461 prev_error\[17\] VGND VGND VPWR VPWR _08557_ sky130_fd_sc_hd__or2_1
XFILLER_0_16_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17249_ _08498_ net90 VGND VGND VPWR VPWR _08510_ sky130_fd_sc_hd__and2_1
XFILLER_0_98_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08953_ _05484_ _05495_ _05440_ VGND VGND VPWR VPWR _05528_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_47_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08884_ _04758_ VGND VGND VPWR VPWR _04769_ sky130_fd_sc_hd__buf_4
XFILLER_0_2_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09505_ _00315_ VGND VGND VPWR VPWR _00316_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_149_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09436_ _00244_ _00245_ _00246_ VGND VGND VPWR VPWR _00247_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_93_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09367_ _08689_ _00166_ VGND VGND VPWR VPWR _00178_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_74_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09298_ net330 _07332_ _08628_ VGND VGND VPWR VPWR _08662_ sky130_fd_sc_hd__and3_1
XFILLER_0_105_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11260_ net413 net140 VGND VGND VPWR VPWR _02071_ sky130_fd_sc_hd__and2_1
XFILLER_0_120_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10211_ _00978_ _00981_ VGND VGND VPWR VPWR _01022_ sky130_fd_sc_hd__or2_1
X_11191_ net387 net155 net159 net383 VGND VGND VPWR VPWR _02002_ sky130_fd_sc_hd__a22oi_1
X_10142_ _00880_ _00951_ _00946_ _00950_ VGND VGND VPWR VPWR _00953_ sky130_fd_sc_hd__o211a_1
XFILLER_0_100_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14950_ _05654_ _05672_ VGND VGND VPWR VPWR _05987_ sky130_fd_sc_hd__and2_1
X_10073_ _00883_ _00852_ VGND VGND VPWR VPWR _00884_ sky130_fd_sc_hd__xnor2_4
X_13901_ _04804_ _04820_ VGND VGND VPWR VPWR _04833_ sky130_fd_sc_hd__xnor2_1
X_14881_ _05905_ _05909_ _05862_ _05910_ VGND VGND VPWR VPWR _05911_ sky130_fd_sc_hd__a211oi_2
X_16620_ _05427_ _05464_ VGND VGND VPWR VPWR _07824_ sky130_fd_sc_hd__and2b_1
X_13832_ net197 _04317_ _04754_ _04756_ VGND VGND VPWR VPWR _04757_ sky130_fd_sc_hd__a31o_1
XFILLER_0_134_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16551_ _07727_ VGND VGND VPWR VPWR _07748_ sky130_fd_sc_hd__inv_2
XFILLER_0_69_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13763_ net197 _04107_ _04680_ VGND VGND VPWR VPWR _04682_ sky130_fd_sc_hd__and3_1
X_10975_ _01783_ _01785_ VGND VGND VPWR VPWR _01786_ sky130_fd_sc_hd__nor2_1
XFILLER_0_58_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15502_ _06580_ _06581_ _06592_ VGND VGND VPWR VPWR _06594_ sky130_fd_sc_hd__nor3_4
X_12714_ _03539_ _03541_ VGND VGND VPWR VPWR _03555_ sky130_fd_sc_hd__and2_1
X_16482_ _07670_ _07671_ VGND VGND VPWR VPWR _07672_ sky130_fd_sc_hd__nor2_1
X_13694_ _04528_ _04530_ VGND VGND VPWR VPWR _04606_ sky130_fd_sc_hd__or2_1
X_15433_ net289 _05621_ VGND VGND VPWR VPWR _06519_ sky130_fd_sc_hd__nand2_1
X_12645_ net177 _03278_ _03286_ net180 VGND VGND VPWR VPWR _03484_ sky130_fd_sc_hd__a22o_1
XFILLER_0_150_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15364_ _06439_ _06442_ VGND VGND VPWR VPWR _06443_ sky130_fd_sc_hd__nor2_1
X_12576_ _03413_ _03414_ VGND VGND VPWR VPWR _03415_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17103_ _05305_ _05414_ VGND VGND VPWR VPWR _08356_ sky130_fd_sc_hd__nand2_1
X_14315_ _05255_ _05288_ _05252_ VGND VGND VPWR VPWR _05289_ sky130_fd_sc_hd__o21a_4
X_11527_ _02237_ _02247_ _02248_ VGND VGND VPWR VPWR _02338_ sky130_fd_sc_hd__and3_1
X_15295_ _06267_ _06262_ _06266_ VGND VGND VPWR VPWR _06367_ sky130_fd_sc_hd__nand3_1
XFILLER_0_135_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17034_ _05382_ _05388_ VGND VGND VPWR VPWR _08280_ sky130_fd_sc_hd__and2b_1
X_14246_ _03169_ _02030_ _03168_ VGND VGND VPWR VPWR _05213_ sky130_fd_sc_hd__or3_1
X_11458_ _02266_ _02267_ _02257_ _02262_ VGND VGND VPWR VPWR _02269_ sky130_fd_sc_hd__o211a_1
XFILLER_0_1_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10409_ _01210_ _01218_ _01219_ VGND VGND VPWR VPWR _01220_ sky130_fd_sc_hd__a21o_1
X_14177_ _05118_ _05135_ _05136_ VGND VGND VPWR VPWR _05137_ sky130_fd_sc_hd__and3_1
X_11389_ _02195_ _02199_ VGND VGND VPWR VPWR _02200_ sky130_fd_sc_hd__nor2_1
XFILLER_0_110_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13128_ _03980_ _03979_ VGND VGND VPWR VPWR _03983_ sky130_fd_sc_hd__and2b_1
X_13059_ _03905_ _03899_ _03903_ VGND VGND VPWR VPWR _03907_ sky130_fd_sc_hd__nor3_1
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16818_ _07733_ _07971_ net483 VGND VGND VPWR VPWR _08042_ sky130_fd_sc_hd__a21o_1
XFILLER_0_17_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16749_ _07963_ _07965_ net481 _07918_ VGND VGND VPWR VPWR _07966_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_75_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09221_ _08454_ _08465_ VGND VGND VPWR VPWR _08476_ sky130_fd_sc_hd__nand2_1
XFILLER_0_124_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09152_ _07574_ _07651_ _07629_ VGND VGND VPWR VPWR _07717_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_90_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09083_ _06397_ _06947_ VGND VGND VPWR VPWR _06958_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_114_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput70 target[5] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_55_Left_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09985_ net316 _00654_ _00520_ net320 VGND VGND VPWR VPWR _00796_ sky130_fd_sc_hd__a22o_1
X_08936_ net9 net64 VGND VGND VPWR VPWR _05341_ sky130_fd_sc_hd__and2b_1
XFILLER_0_99_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08867_ _03966_ _04010_ VGND VGND VPWR VPWR _04582_ sky130_fd_sc_hd__nand2_1
XFILLER_0_98_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08798_ net51 _02883_ _02916_ net154 VGND VGND VPWR VPWR _00031_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_64_Left_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10760_ _01568_ VGND VGND VPWR VPWR _01571_ sky130_fd_sc_hd__inv_2
X_09419_ _00206_ _00228_ _00175_ _00229_ VGND VGND VPWR VPWR _00230_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_66_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_4_0_clock clknet_0_clock VGND VGND VPWR VPWR clknet_4_4_0_clock sky130_fd_sc_hd__clkbuf_8
X_10691_ _01496_ _01501_ VGND VGND VPWR VPWR _01502_ sky130_fd_sc_hd__and2_1
XFILLER_0_137_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12430_ net180 net176 _03250_ _03261_ VGND VGND VPWR VPWR _03262_ sky130_fd_sc_hd__nand4_1
XFILLER_0_47_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12361_ _00238_ _00239_ _03192_ VGND VGND VPWR VPWR _03193_ sky130_fd_sc_hd__a21o_1
XFILLER_0_22_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14100_ _05051_ _05047_ _05046_ VGND VGND VPWR VPWR _05052_ sky130_fd_sc_hd__o21ba_1
X_11312_ _02106_ _02112_ _02111_ VGND VGND VPWR VPWR _02123_ sky130_fd_sc_hd__o21ai_1
X_15080_ _06128_ _06129_ VGND VGND VPWR VPWR _06130_ sky130_fd_sc_hd__xor2_2
XFILLER_0_50_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_73_Left_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12292_ _02866_ _03122_ _03123_ VGND VGND VPWR VPWR _03124_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_133_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14031_ _04958_ _04962_ _04973_ VGND VGND VPWR VPWR _04976_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_132_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11243_ _02040_ _02042_ _02053_ VGND VGND VPWR VPWR _02054_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_129_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11174_ _01893_ _01984_ VGND VGND VPWR VPWR _01985_ sky130_fd_sc_hd__nor2_1
XFILLER_0_100_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10125_ net372 _05143_ _05154_ VGND VGND VPWR VPWR _00936_ sky130_fd_sc_hd__and3_1
X_15982_ _07041_ _07051_ _07120_ VGND VGND VPWR VPWR _07122_ sky130_fd_sc_hd__o21ba_4
X_14933_ ki\[17\] _05967_ _05667_ VGND VGND VPWR VPWR _05969_ sky130_fd_sc_hd__a21o_1
X_10056_ _00865_ _00866_ VGND VGND VPWR VPWR _00867_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_82_Left_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14864_ _05868_ _05892_ VGND VGND VPWR VPWR _05893_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16603_ _07764_ _07767_ _07803_ _07804_ VGND VGND VPWR VPWR _07806_ sky130_fd_sc_hd__a2bb2o_1
X_13815_ _04733_ _04738_ VGND VGND VPWR VPWR _04739_ sky130_fd_sc_hd__and2b_1
X_14795_ _05793_ _05796_ _05812_ VGND VGND VPWR VPWR _05817_ sky130_fd_sc_hd__and3_1
X_16534_ _07656_ _07729_ VGND VGND VPWR VPWR _07730_ sky130_fd_sc_hd__xnor2_4
X_13746_ net212 _03792_ VGND VGND VPWR VPWR _04663_ sky130_fd_sc_hd__and2_1
X_10958_ _01590_ _01768_ VGND VGND VPWR VPWR _01769_ sky130_fd_sc_hd__nand2_1
XFILLER_0_46_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16465_ i_error\[13\] _07653_ VGND VGND VPWR VPWR _07654_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13677_ _04508_ _04517_ VGND VGND VPWR VPWR _04587_ sky130_fd_sc_hd__xnor2_1
X_10889_ _01698_ _01699_ VGND VGND VPWR VPWR _01700_ sky130_fd_sc_hd__nand2_1
X_15416_ _06494_ _06495_ VGND VGND VPWR VPWR _06500_ sky130_fd_sc_hd__and2_1
XFILLER_0_128_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12628_ _03421_ _03462_ VGND VGND VPWR VPWR _03467_ sky130_fd_sc_hd__xnor2_1
X_16396_ _07501_ _07577_ VGND VGND VPWR VPWR _07578_ sky130_fd_sc_hd__xor2_2
XFILLER_0_143_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15347_ _06422_ _06423_ VGND VGND VPWR VPWR _06424_ sky130_fd_sc_hd__and2_1
X_12559_ net185 _03288_ _03290_ VGND VGND VPWR VPWR _03398_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_91_Left_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15278_ _06347_ VGND VGND VPWR VPWR _06348_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_13_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17017_ _05368_ _05358_ VGND VGND VPWR VPWR _08261_ sky130_fd_sc_hd__or2b_1
X_14229_ _03882_ _05193_ _03880_ VGND VGND VPWR VPWR _05194_ sky130_fd_sc_hd__o21a_2
XFILLER_0_1_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_107_Right_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09770_ _00578_ _00579_ VGND VGND VPWR VPWR _00581_ sky130_fd_sc_hd__xor2_1
X_08721_ _03028_ VGND VGND VPWR VPWR _03039_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_135_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09204_ _08267_ _08278_ VGND VGND VPWR VPWR _08289_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09135_ _07464_ _07497_ _07519_ VGND VGND VPWR VPWR _07530_ sky130_fd_sc_hd__o21a_1
XFILLER_0_134_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09066_ _06749_ _06760_ VGND VGND VPWR VPWR _06771_ sky130_fd_sc_hd__nor2_1
XFILLER_0_130_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_139_Left_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09968_ _00777_ _00778_ VGND VGND VPWR VPWR _00779_ sky130_fd_sc_hd__nor2_1
X_08919_ _03988_ _04351_ _05132_ VGND VGND VPWR VPWR _05154_ sky130_fd_sc_hd__nand3_4
X_09899_ _00669_ _00668_ VGND VGND VPWR VPWR _00710_ sky130_fd_sc_hd__and2b_1
X_11930_ net404 net170 _02665_ _02666_ VGND VGND VPWR VPWR _02741_ sky130_fd_sc_hd__o2bb2a_1
X_11861_ net396 net400 net170 net174 VGND VGND VPWR VPWR _02672_ sky130_fd_sc_hd__and4_1
XFILLER_0_24_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13600_ _04497_ _04500_ VGND VGND VPWR VPWR _04502_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10812_ _01616_ _01622_ VGND VGND VPWR VPWR _01623_ sky130_fd_sc_hd__xnor2_1
X_14580_ _05558_ _03240_ _05559_ _05575_ _05579_ VGND VGND VPWR VPWR _05580_ sky130_fd_sc_hd__o41a_2
XFILLER_0_95_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11792_ _02553_ _02602_ VGND VGND VPWR VPWR _02603_ sky130_fd_sc_hd__nand2_1
X_13531_ _04423_ _04424_ _04425_ VGND VGND VPWR VPWR _04426_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_137_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10743_ _01552_ _01540_ _01547_ VGND VGND VPWR VPWR _01554_ sky130_fd_sc_hd__or3_1
XFILLER_0_138_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16250_ _07369_ _07406_ _07399_ _07405_ VGND VGND VPWR VPWR _07417_ sky130_fd_sc_hd__o211ai_1
X_13462_ net201 net519 _04348_ _04349_ VGND VGND VPWR VPWR _04350_ sky130_fd_sc_hd__a31o_1
XFILLER_0_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10674_ _01480_ _01484_ VGND VGND VPWR VPWR _01485_ sky130_fd_sc_hd__or2_1
X_15201_ net288 _05724_ VGND VGND VPWR VPWR _06263_ sky130_fd_sc_hd__nand2_1
X_12413_ _03185_ _03186_ _03209_ _03210_ VGND VGND VPWR VPWR _03245_ sky130_fd_sc_hd__a31o_2
X_16181_ _07305_ _07333_ VGND VGND VPWR VPWR _07341_ sky130_fd_sc_hd__xnor2_1
X_13393_ _04216_ _04231_ _04214_ VGND VGND VPWR VPWR _04275_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_51_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15132_ _06183_ _06184_ _06150_ _06182_ VGND VGND VPWR VPWR _06187_ sky130_fd_sc_hd__o211a_1
X_12344_ _01715_ _03175_ VGND VGND VPWR VPWR _03176_ sky130_fd_sc_hd__xor2_1
XFILLER_0_23_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15063_ net287 net490 _05722_ VGND VGND VPWR VPWR _06112_ sky130_fd_sc_hd__and3_1
X_12275_ _02919_ _02929_ _03106_ VGND VGND VPWR VPWR _03107_ sky130_fd_sc_hd__a21o_1
XFILLER_0_50_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14014_ _04939_ _04954_ _04955_ _04957_ VGND VGND VPWR VPWR _04958_ sky130_fd_sc_hd__or4_1
X_11226_ _02033_ _02036_ VGND VGND VPWR VPWR _02037_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11157_ _01913_ _01921_ VGND VGND VPWR VPWR _01968_ sky130_fd_sc_hd__xor2_1
XFILLER_0_65_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10108_ net335 _00373_ _00917_ _00918_ VGND VGND VPWR VPWR _00919_ sky130_fd_sc_hd__a31o_1
X_15965_ _07102_ _07083_ _07103_ VGND VGND VPWR VPWR _07104_ sky130_fd_sc_hd__a21oi_2
X_11088_ _01897_ _01898_ VGND VGND VPWR VPWR _01899_ sky130_fd_sc_hd__or2_1
X_14916_ _05949_ VGND VGND VPWR VPWR _05950_ sky130_fd_sc_hd__inv_2
X_10039_ _00844_ _00849_ VGND VGND VPWR VPWR _00850_ sky130_fd_sc_hd__xor2_1
X_15896_ _07025_ _07026_ _07027_ VGND VGND VPWR VPWR _07028_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_78_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14847_ net273 net269 _05691_ VGND VGND VPWR VPWR _05874_ sky130_fd_sc_hd__and3_1
XFILLER_0_19_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14778_ net273 _05691_ VGND VGND VPWR VPWR _05798_ sky130_fd_sc_hd__and2_1
XFILLER_0_58_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16517_ _07509_ _07560_ _07710_ VGND VGND VPWR VPWR _07711_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_58_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13729_ _04558_ _04611_ _04640_ VGND VGND VPWR VPWR _04644_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_45_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17497_ clknet_4_6_0_clock _00040_ VGND VGND VPWR VPWR ki\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_105_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_144_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_888 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16448_ _07616_ _07633_ _07634_ VGND VGND VPWR VPWR _07635_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16379_ _05839_ _05898_ _05897_ VGND VGND VPWR VPWR _07559_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_60_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout405 net409 VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__clkbuf_4
Xfanout416 prev_d_error\[7\] VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__clkbuf_4
X_09822_ _00605_ _00631_ _00632_ VGND VGND VPWR VPWR _00633_ sky130_fd_sc_hd__a21o_1
Xfanout427 prev_d_error\[5\] VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__buf_4
XFILLER_0_10_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout438 net441 VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__buf_2
Xfanout449 prev_d_error\[0\] VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__clkbuf_4
X_09753_ _00555_ _00563_ VGND VGND VPWR VPWR _00564_ sky130_fd_sc_hd__or2b_1
X_08704_ net28 net27 net75 net20 VGND VGND VPWR VPWR _02861_ sky130_fd_sc_hd__or4b_2
XFILLER_0_146_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09684_ _00492_ _00493_ VGND VGND VPWR VPWR _00495_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09118_ _07332_ VGND VGND VPWR VPWR _07343_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_103_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10390_ _01197_ _01200_ VGND VGND VPWR VPWR _01201_ sky130_fd_sc_hd__and2_1
XFILLER_0_33_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09049_ _06551_ _06573_ VGND VGND VPWR VPWR _06584_ sky130_fd_sc_hd__or2_1
XFILLER_0_32_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12060_ net424 net162 VGND VGND VPWR VPWR _02880_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11011_ _01818_ _01819_ _01821_ VGND VGND VPWR VPWR _01822_ sky130_fd_sc_hd__or3_2
X_15750_ _06840_ _06865_ _06866_ net500 VGND VGND VPWR VPWR _06867_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_99_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12962_ net244 _03345_ _03343_ _03805_ VGND VGND VPWR VPWR _03806_ sky130_fd_sc_hd__o2bb2a_1
X_14701_ net284 _05691_ _05703_ net281 VGND VGND VPWR VPWR _05713_ sky130_fd_sc_hd__a22oi_1
X_11913_ _02710_ _02712_ VGND VGND VPWR VPWR _02724_ sky130_fd_sc_hd__xnor2_1
X_15681_ _06772_ _06778_ _06770_ VGND VGND VPWR VPWR _06791_ sky130_fd_sc_hd__o21bai_1
X_12893_ _03717_ _03701_ _03715_ VGND VGND VPWR VPWR _03737_ sky130_fd_sc_hd__and3_1
X_17420_ clknet_4_2_0_clock _00098_ VGND VGND VPWR VPWR prev_error\[8\] sky130_fd_sc_hd__dfxtp_1
X_14632_ net262 _05631_ _05636_ VGND VGND VPWR VPWR _05637_ sky130_fd_sc_hd__a21oi_1
X_11844_ net422 net152 net156 net417 VGND VGND VPWR VPWR _02655_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_142_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17351_ _08564_ _08043_ _08577_ net455 VGND VGND VPWR VPWR _00122_ sky130_fd_sc_hd__o211a_1
X_14563_ prev_error\[1\] _00517_ VGND VGND VPWR VPWR _05562_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11775_ _02532_ _02585_ VGND VGND VPWR VPWR _02586_ sky130_fd_sc_hd__or2_1
XFILLER_0_138_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16302_ _07412_ _07414_ _07415_ _07441_ VGND VGND VPWR VPWR _07474_ sky130_fd_sc_hd__or4b_1
X_13514_ _04404_ _04405_ _04407_ VGND VGND VPWR VPWR _04408_ sky130_fd_sc_hd__and3_1
X_10726_ net401 net116 VGND VGND VPWR VPWR _01537_ sky130_fd_sc_hd__nand2_1
XFILLER_0_137_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14494_ _05476_ _05485_ VGND VGND VPWR VPWR _05486_ sky130_fd_sc_hd__xor2_1
X_17282_ net462 _00799_ VGND VGND VPWR VPWR _08534_ sky130_fd_sc_hd__nand2_1
XFILLER_0_126_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16233_ _07397_ VGND VGND VPWR VPWR _07399_ sky130_fd_sc_hd__inv_2
X_13445_ net220 _03260_ VGND VGND VPWR VPWR _04332_ sky130_fd_sc_hd__nand2_1
XFILLER_0_126_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10657_ net418 net421 net106 VGND VGND VPWR VPWR _01468_ sky130_fd_sc_hd__and3_1
XFILLER_0_141_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16164_ _07319_ _07320_ _07322_ VGND VGND VPWR VPWR _07323_ sky130_fd_sc_hd__nor3_1
XFILLER_0_106_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13376_ _04232_ _04254_ _04255_ VGND VGND VPWR VPWR _04256_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_134_880 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10588_ _01385_ _01387_ _01398_ VGND VGND VPWR VPWR _01399_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_51_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15115_ _06167_ _06168_ VGND VGND VPWR VPWR _06169_ sky130_fd_sc_hd__and2_1
X_12327_ _02306_ _03158_ VGND VGND VPWR VPWR _03159_ sky130_fd_sc_hd__or2_1
X_16095_ net311 _05603_ _07241_ _07246_ VGND VGND VPWR VPWR _07247_ sky130_fd_sc_hd__a31o_1
X_15046_ net306 VGND VGND VPWR VPWR _06093_ sky130_fd_sc_hd__inv_2
X_12258_ _03084_ _03088_ VGND VGND VPWR VPWR _03089_ sky130_fd_sc_hd__nand2_1
X_11209_ _02017_ _02019_ VGND VGND VPWR VPWR _02020_ sky130_fd_sc_hd__and2_1
X_12189_ net444 net162 VGND VGND VPWR VPWR _03014_ sky130_fd_sc_hd__nand2_1
X_16997_ _08236_ _08238_ VGND VGND VPWR VPWR _08239_ sky130_fd_sc_hd__or2_1
XFILLER_0_92_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15948_ _07083_ _07084_ VGND VGND VPWR VPWR _07085_ sky130_fd_sc_hd__and2_1
XFILLER_0_92_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15879_ _06946_ _06993_ _06994_ _07008_ VGND VGND VPWR VPWR _07009_ sky130_fd_sc_hd__a31o_1
XFILLER_0_116_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout202 net205 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__clkbuf_4
Xfanout213 kd_1\[8\] VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__buf_2
Xfanout224 kd_1\[5\] VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__clkbuf_4
Xfanout235 net238 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__clkbuf_4
Xfanout246 net247 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__clkbuf_4
X_09805_ net373 net529 _00614_ _00615_ VGND VGND VPWR VPWR _00616_ sky130_fd_sc_hd__a31o_1
Xfanout257 ki\[14\] VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__buf_2
Xfanout268 ki\[11\] VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__clkbuf_2
Xfanout279 net280 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__buf_2
XFILLER_0_66_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09736_ net334 _08681_ _08676_ net331 VGND VGND VPWR VPWR _00547_ sky130_fd_sc_hd__a22o_1
X_09667_ _00477_ VGND VGND VPWR VPWR _00478_ sky130_fd_sc_hd__inv_2
XFILLER_0_97_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09598_ _00407_ _00408_ VGND VGND VPWR VPWR _00409_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11560_ net400 net159 net164 net396 VGND VGND VPWR VPWR _02371_ sky130_fd_sc_hd__a22o_1
X_10511_ net362 _00518_ _08674_ net380 VGND VGND VPWR VPWR _01322_ sky130_fd_sc_hd__a22o_1
XFILLER_0_24_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11491_ _02300_ _02301_ VGND VGND VPWR VPWR _02302_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13230_ _03995_ _04091_ _04094_ VGND VGND VPWR VPWR _04095_ sky130_fd_sc_hd__o21a_1
XFILLER_0_134_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10442_ _01252_ _01226_ VGND VGND VPWR VPWR _01253_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_150_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13161_ _04007_ _04018_ _04016_ VGND VGND VPWR VPWR _04019_ sky130_fd_sc_hd__o21a_1
XFILLER_0_0_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10373_ _01150_ _01151_ VGND VGND VPWR VPWR _01184_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_103_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12112_ _02934_ _02936_ VGND VGND VPWR VPWR _02937_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_131_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13092_ _03919_ _03942_ VGND VGND VPWR VPWR _03943_ sky130_fd_sc_hd__or2b_2
XFILLER_0_130_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16920_ _08110_ _08114_ VGND VGND VPWR VPWR _08154_ sky130_fd_sc_hd__and2b_1
X_12043_ _02854_ _02859_ VGND VGND VPWR VPWR _02862_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16851_ _08073_ _08075_ _08074_ VGND VGND VPWR VPWR _08078_ sky130_fd_sc_hd__o21ai_1
X_15802_ _06874_ _06923_ VGND VGND VPWR VPWR _06924_ sky130_fd_sc_hd__nor2_1
X_16782_ _07773_ _08000_ _08001_ _07780_ VGND VGND VPWR VPWR _08002_ sky130_fd_sc_hd__o22a_1
XFILLER_0_88_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13994_ net225 _03791_ VGND VGND VPWR VPWR _04936_ sky130_fd_sc_hd__and2_2
XFILLER_0_1_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15733_ net268 _06206_ VGND VGND VPWR VPWR _06849_ sky130_fd_sc_hd__nand2_1
X_12945_ _03195_ _03202_ VGND VGND VPWR VPWR _03789_ sky130_fd_sc_hd__nand2_1
XFILLER_0_88_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15664_ _06741_ _06742_ VGND VGND VPWR VPWR _06773_ sky130_fd_sc_hd__nand2_1
X_12876_ _03642_ _03645_ VGND VGND VPWR VPWR _03720_ sky130_fd_sc_hd__xnor2_1
X_17403_ clknet_4_10_0_clock _00081_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_56_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14615_ _05612_ net488 _03230_ VGND VGND VPWR VPWR _05619_ sky130_fd_sc_hd__a21oi_1
X_11827_ _02635_ _02637_ VGND VGND VPWR VPWR _02638_ sky130_fd_sc_hd__nand2_1
X_15595_ net253 _06417_ VGND VGND VPWR VPWR _06697_ sky130_fd_sc_hd__nand2_1
X_17334_ net470 i_error\[6\] VGND VGND VPWR VPWR _08568_ sky130_fd_sc_hd__or2_1
X_14546_ _05541_ _05542_ VGND VGND VPWR VPWR _05543_ sky130_fd_sc_hd__xnor2_1
X_11758_ _02567_ _02562_ _02566_ VGND VGND VPWR VPWR _02569_ sky130_fd_sc_hd__and3_1
XFILLER_0_126_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10709_ _01518_ _01519_ VGND VGND VPWR VPWR _01520_ sky130_fd_sc_hd__and2_1
X_17265_ _08461_ _08494_ _08466_ VGND VGND VPWR VPWR _08523_ sky130_fd_sc_hd__a21oi_1
X_14477_ _05422_ _05466_ VGND VGND VPWR VPWR _05467_ sky130_fd_sc_hd__or2_1
X_11689_ net426 net139 _02499_ _02496_ VGND VGND VPWR VPWR _02500_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_24_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16216_ _07356_ _07379_ VGND VGND VPWR VPWR _07380_ sky130_fd_sc_hd__nor2_1
X_13428_ _04312_ VGND VGND VPWR VPWR _04313_ sky130_fd_sc_hd__clkbuf_4
X_17196_ _08369_ _08374_ VGND VGND VPWR VPWR _08458_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16147_ _07301_ _07302_ _07303_ VGND VGND VPWR VPWR _07304_ sky130_fd_sc_hd__a21bo_1
X_13359_ net237 _03335_ VGND VGND VPWR VPWR _04237_ sky130_fd_sc_hd__nand2_1
X_16078_ _07218_ _07219_ _07227_ VGND VGND VPWR VPWR _07228_ sky130_fd_sc_hd__nor3_2
XFILLER_0_121_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15029_ _06072_ _06073_ VGND VGND VPWR VPWR _06074_ sky130_fd_sc_hd__or2_1
Xinput2 measurement[0] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_2
X_09521_ _00298_ _00297_ VGND VGND VPWR VPWR _00332_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_79_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09452_ _00230_ _00261_ _00180_ _00262_ VGND VGND VPWR VPWR _00263_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_94_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09383_ net344 _04923_ VGND VGND VPWR VPWR _00194_ sky130_fd_sc_hd__nand2_1
XFILLER_0_143_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_144_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09719_ _00361_ _00380_ VGND VGND VPWR VPWR _00530_ sky130_fd_sc_hd__and2_1
X_10991_ net406 net412 net126 net123 VGND VGND VPWR VPWR _01802_ sky130_fd_sc_hd__and4_1
X_12730_ _03187_ _07904_ VGND VGND VPWR VPWR _03572_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_139_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12661_ _03347_ _03440_ _03498_ _03499_ VGND VGND VPWR VPWR _03500_ sky130_fd_sc_hd__a31o_1
XFILLER_0_32_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11612_ net404 net155 _02342_ _02343_ VGND VGND VPWR VPWR _02423_ sky130_fd_sc_hd__o2bb2a_1
X_14400_ _03499_ _05381_ VGND VGND VPWR VPWR _05382_ sky130_fd_sc_hd__or2_1
XFILLER_0_37_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15380_ _06439_ _06442_ VGND VGND VPWR VPWR _06460_ sky130_fd_sc_hd__xor2_1
XFILLER_0_65_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12592_ _03429_ _03430_ VGND VGND VPWR VPWR _03431_ sky130_fd_sc_hd__or2b_1
X_14331_ _01711_ _01661_ VGND VGND VPWR VPWR _05306_ sky130_fd_sc_hd__and2b_1
XFILLER_0_80_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11543_ _02326_ _02328_ VGND VGND VPWR VPWR _02354_ sky130_fd_sc_hd__or2b_1
XFILLER_0_65_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17050_ _08295_ _08296_ VGND VGND VPWR VPWR _08297_ sky130_fd_sc_hd__nor2_1
X_14262_ _02219_ _02218_ VGND VGND VPWR VPWR _05230_ sky130_fd_sc_hd__nand2_2
X_11474_ net384 net171 _02283_ _02284_ VGND VGND VPWR VPWR _02285_ sky130_fd_sc_hd__a31o_1
XFILLER_0_80_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16001_ _07128_ _07141_ _07142_ VGND VGND VPWR VPWR _07143_ sky130_fd_sc_hd__and3_2
X_13213_ net241 _03321_ _04074_ _04075_ VGND VGND VPWR VPWR _04077_ sky130_fd_sc_hd__nand4_2
X_10425_ _01222_ _01223_ _01229_ VGND VGND VPWR VPWR _01236_ sky130_fd_sc_hd__a21bo_1
X_14193_ _04913_ _04911_ VGND VGND VPWR VPWR _05155_ sky130_fd_sc_hd__and2b_1
XFILLER_0_21_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_872 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13144_ _03200_ _04000_ VGND VGND VPWR VPWR _04001_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_150_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10356_ net359 _00242_ _01165_ _01166_ VGND VGND VPWR VPWR _01167_ sky130_fd_sc_hd__a31o_1
XFILLER_0_148_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13075_ net186 _03669_ _03924_ VGND VGND VPWR VPWR _03925_ sky130_fd_sc_hd__and3_1
X_10287_ _01058_ _01067_ VGND VGND VPWR VPWR _01098_ sky130_fd_sc_hd__xor2_1
X_16903_ _08116_ _08126_ VGND VGND VPWR VPWR _08136_ sky130_fd_sc_hd__and2_1
X_12026_ _02835_ _02840_ _02842_ VGND VGND VPWR VPWR _02843_ sky130_fd_sc_hd__a21oi_1
X_16834_ _08049_ _08057_ VGND VGND VPWR VPWR _08060_ sky130_fd_sc_hd__and2_1
X_16765_ _07979_ _07982_ _07976_ net473 _07983_ VGND VGND VPWR VPWR _07984_ sky130_fd_sc_hd__o221a_1
X_13977_ net206 net518 VGND VGND VPWR VPWR _04917_ sky130_fd_sc_hd__nand2_1
X_15716_ net285 net282 _05664_ _05602_ VGND VGND VPWR VPWR _06830_ sky130_fd_sc_hd__and4_1
X_12928_ _03693_ _03771_ VGND VGND VPWR VPWR _03772_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16696_ i_error\[16\] _07907_ VGND VGND VPWR VPWR _07908_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15647_ _06717_ _06751_ _06753_ VGND VGND VPWR VPWR _06754_ sky130_fd_sc_hd__a21oi_2
X_12859_ net211 _03337_ _03620_ VGND VGND VPWR VPWR _03703_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_146_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15578_ _06676_ _06677_ VGND VGND VPWR VPWR _06678_ sky130_fd_sc_hd__nor2_1
XFILLER_0_113_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17317_ _08549_ _05726_ _08556_ net450 VGND VGND VPWR VPWR _00106_ sky130_fd_sc_hd__o211a_1
XFILLER_0_71_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14529_ _05493_ VGND VGND VPWR VPWR _05524_ sky130_fd_sc_hd__inv_2
XFILLER_0_114_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17248_ _08508_ _08509_ net453 VGND VGND VPWR VPWR _00077_ sky130_fd_sc_hd__o21a_1
XFILLER_0_126_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17179_ _03452_ _08438_ VGND VGND VPWR VPWR _08439_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08952_ _05451_ _05484_ VGND VGND VPWR VPWR _05517_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_102_Left_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08883_ _04747_ VGND VGND VPWR VPWR _04758_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09504_ _00314_ VGND VGND VPWR VPWR _00315_ sky130_fd_sc_hd__clkbuf_4
X_09435_ net318 net314 _08682_ _08677_ VGND VGND VPWR VPWR _00246_ sky130_fd_sc_hd__and4_1
XFILLER_0_149_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_111_Left_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09366_ _00171_ _00175_ _08625_ _00176_ VGND VGND VPWR VPWR _00177_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_19_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09297_ _08659_ _08660_ VGND VGND VPWR VPWR _08661_ sky130_fd_sc_hd__and2_2
XFILLER_0_47_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10210_ _01014_ _01018_ _01019_ VGND VGND VPWR VPWR _01021_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_101_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11190_ net383 net387 net155 net159 VGND VGND VPWR VPWR _02001_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_120_Left_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10141_ _00946_ _00950_ _00880_ _00951_ VGND VGND VPWR VPWR _00952_ sky130_fd_sc_hd__a211oi_2
Xclkbuf_4_0_0_clock clknet_0_clock VGND VGND VPWR VPWR clknet_4_0_0_clock sky130_fd_sc_hd__clkbuf_8
X_10072_ _00853_ _00840_ VGND VGND VPWR VPWR _00883_ sky130_fd_sc_hd__or2_2
XFILLER_0_27_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13900_ _04830_ _04831_ VGND VGND VPWR VPWR _04832_ sky130_fd_sc_hd__or2_1
X_14880_ _05857_ _05859_ _05861_ VGND VGND VPWR VPWR _05910_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_89_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13831_ _04677_ _04755_ VGND VGND VPWR VPWR _04756_ sky130_fd_sc_hd__nor2_1
X_16550_ _07740_ _07746_ VGND VGND VPWR VPWR _07747_ sky130_fd_sc_hd__nand2_1
X_10974_ _01773_ _01776_ _01783_ _01784_ VGND VGND VPWR VPWR _01785_ sky130_fd_sc_hd__a211oi_2
X_13762_ _04678_ _04679_ VGND VGND VPWR VPWR _04680_ sky130_fd_sc_hd__nor2_1
X_15501_ _06580_ _06581_ _06592_ VGND VGND VPWR VPWR _06593_ sky130_fd_sc_hd__o21a_1
Xmax_cap97 _00180_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_84_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12713_ _03466_ _03552_ VGND VGND VPWR VPWR _03554_ sky130_fd_sc_hd__or2_1
X_16481_ _07537_ _07539_ _07669_ VGND VGND VPWR VPWR _07671_ sky130_fd_sc_hd__nor3_1
X_13693_ _04601_ _04603_ VGND VGND VPWR VPWR _04605_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15432_ _06511_ _06516_ VGND VGND VPWR VPWR _06517_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_84_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12644_ net180 net176 _03278_ _03286_ VGND VGND VPWR VPWR _03483_ sky130_fd_sc_hd__nand4_1
XFILLER_0_38_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12575_ _03387_ _03401_ _03412_ VGND VGND VPWR VPWR _03414_ sky130_fd_sc_hd__nor3_1
X_15363_ _06330_ _06440_ VGND VGND VPWR VPWR _06442_ sky130_fd_sc_hd__or2_1
XFILLER_0_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17102_ _08307_ _08353_ VGND VGND VPWR VPWR _08354_ sky130_fd_sc_hd__xnor2_4
X_14314_ _05256_ _05258_ _05287_ VGND VGND VPWR VPWR _05288_ sky130_fd_sc_hd__o21ba_1
X_11526_ _02325_ _02335_ _02336_ VGND VGND VPWR VPWR _02337_ sky130_fd_sc_hd__nand3_2
XFILLER_0_108_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15294_ _06337_ _06365_ VGND VGND VPWR VPWR _06366_ sky130_fd_sc_hd__nand2_1
X_17033_ _08258_ _08277_ VGND VGND VPWR VPWR _08279_ sky130_fd_sc_hd__xnor2_1
X_14245_ _05210_ _05211_ VGND VGND VPWR VPWR _05212_ sky130_fd_sc_hd__nor2_4
X_11457_ _02257_ _02262_ _02266_ _02267_ VGND VGND VPWR VPWR _02268_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_40_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10408_ _01212_ _01217_ VGND VGND VPWR VPWR _01219_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14176_ _05134_ _05133_ _05120_ _05119_ VGND VGND VPWR VPWR _05136_ sky130_fd_sc_hd__a211o_1
X_11388_ _02196_ _02198_ VGND VGND VPWR VPWR _02199_ sky130_fd_sc_hd__and2_1
X_10339_ _01122_ _01126_ VGND VGND VPWR VPWR _01150_ sky130_fd_sc_hd__xor2_4
X_13127_ _03943_ _03946_ VGND VGND VPWR VPWR _03982_ sky130_fd_sc_hd__xor2_2
X_13058_ _03899_ _03903_ _03905_ VGND VGND VPWR VPWR _03906_ sky130_fd_sc_hd__o21a_1
X_12009_ _02821_ _02823_ VGND VGND VPWR VPWR _02824_ sky130_fd_sc_hd__nand2_1
X_16817_ _08028_ _08030_ _08031_ VGND VGND VPWR VPWR _08041_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_108_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16748_ _07770_ _07964_ VGND VGND VPWR VPWR _07965_ sky130_fd_sc_hd__nand2_2
XFILLER_0_48_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16679_ _07685_ _07692_ _07546_ VGND VGND VPWR VPWR _07889_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_76_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09220_ _08443_ _08388_ _08432_ VGND VGND VPWR VPWR _08465_ sky130_fd_sc_hd__or3_1
XFILLER_0_75_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09151_ _07090_ _07695_ VGND VGND VPWR VPWR _07706_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_134_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09082_ _06859_ _06936_ VGND VGND VPWR VPWR _06947_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_32_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput60 target[12] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_1
Xinput71 target[6] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_12_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09984_ net324 _00520_ _00794_ VGND VGND VPWR VPWR _00795_ sky130_fd_sc_hd__nand3_1
XFILLER_0_110_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08935_ _04857_ _04703_ _04868_ _04967_ _04835_ VGND VGND VPWR VPWR _05330_ sky130_fd_sc_hd__o311ai_4
X_08866_ net496 _04318_ _04329_ _04362_ VGND VGND VPWR VPWR _04571_ sky130_fd_sc_hd__o211a_1
XFILLER_0_98_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08797_ net50 _02883_ _02916_ net158 VGND VGND VPWR VPWR _00030_ sky130_fd_sc_hd__a22o_1
XFILLER_0_66_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09418_ _00172_ _00174_ VGND VGND VPWR VPWR _00229_ sky130_fd_sc_hd__nand2_1
X_10690_ _01497_ _01500_ VGND VGND VPWR VPWR _01501_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_35_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09349_ _00155_ _00150_ VGND VGND VPWR VPWR _00160_ sky130_fd_sc_hd__and2b_1
XFILLER_0_90_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12360_ prev_error\[4\] VGND VGND VPWR VPWR _03192_ sky130_fd_sc_hd__inv_2
XFILLER_0_35_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11311_ _02120_ _02121_ VGND VGND VPWR VPWR _02122_ sky130_fd_sc_hd__or2_1
XFILLER_0_16_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12291_ _02941_ _02968_ VGND VGND VPWR VPWR _03123_ sky130_fd_sc_hd__and2_1
XFILLER_0_105_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14030_ _04930_ _04931_ VGND VGND VPWR VPWR _04975_ sky130_fd_sc_hd__xnor2_1
X_11242_ _01959_ _02052_ VGND VGND VPWR VPWR _02053_ sky130_fd_sc_hd__xnor2_1
X_11173_ net392 net149 _01891_ _01892_ VGND VGND VPWR VPWR _01984_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10124_ net365 _07321_ _00870_ VGND VGND VPWR VPWR _00935_ sky130_fd_sc_hd__a21o_1
X_15981_ _07041_ _07051_ _07120_ VGND VGND VPWR VPWR _07121_ sky130_fd_sc_hd__nor3b_2
X_10055_ _00733_ _00732_ VGND VGND VPWR VPWR _00866_ sky130_fd_sc_hd__and2b_1
X_14932_ net103 _05663_ VGND VGND VPWR VPWR _05967_ sky130_fd_sc_hd__xor2_4
XFILLER_0_145_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14863_ _05871_ _05890_ VGND VGND VPWR VPWR _05892_ sky130_fd_sc_hd__xor2_1
X_16602_ _07764_ _07767_ _07798_ _07801_ VGND VGND VPWR VPWR _07804_ sky130_fd_sc_hd__o2bb2a_1
X_13814_ net224 _04735_ _03668_ _04737_ VGND VGND VPWR VPWR _04738_ sky130_fd_sc_hd__a31o_1
X_14794_ _05743_ _05753_ VGND VGND VPWR VPWR _05816_ sky130_fd_sc_hd__nor2_1
XFILLER_0_98_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16533_ _07576_ _07649_ _07654_ _07655_ VGND VGND VPWR VPWR _07729_ sky130_fd_sc_hd__a31o_1
XFILLER_0_57_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13745_ _04657_ _04661_ VGND VGND VPWR VPWR _04662_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10957_ _01584_ _01587_ _01589_ VGND VGND VPWR VPWR _01768_ sky130_fd_sc_hd__or3_1
X_16464_ _07505_ _07652_ VGND VGND VPWR VPWR _07653_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13676_ _04580_ _04585_ VGND VGND VPWR VPWR _04586_ sky130_fd_sc_hd__nand2_1
X_10888_ _01645_ _01686_ _01697_ VGND VGND VPWR VPWR _01699_ sky130_fd_sc_hd__or3_1
X_15415_ _06498_ _06467_ VGND VGND VPWR VPWR _06499_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_54_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12627_ _03463_ _03465_ VGND VGND VPWR VPWR _03466_ sky130_fd_sc_hd__nor2_1
X_16395_ _06299_ _06404_ _07499_ _07500_ VGND VGND VPWR VPWR _07577_ sky130_fd_sc_hd__a31o_1
XFILLER_0_26_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15346_ _06413_ _06414_ VGND VGND VPWR VPWR _06423_ sky130_fd_sc_hd__xor2_1
X_12558_ _03395_ _03396_ VGND VGND VPWR VPWR _03397_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11509_ _02309_ _02312_ _02314_ VGND VGND VPWR VPWR _02320_ sky130_fd_sc_hd__or3_1
X_15277_ _04000_ _05563_ VGND VGND VPWR VPWR _06347_ sky130_fd_sc_hd__xor2_4
X_12489_ _03306_ _03308_ _03310_ _03312_ VGND VGND VPWR VPWR _03325_ sky130_fd_sc_hd__a31o_4
X_17016_ _05359_ _05367_ VGND VGND VPWR VPWR _08260_ sky130_fd_sc_hd__nand2_1
X_14228_ _03993_ _05192_ _03991_ VGND VGND VPWR VPWR _05193_ sky130_fd_sc_hd__o21a_4
XFILLER_0_22_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14159_ _05082_ _05115_ _05076_ _05116_ VGND VGND VPWR VPWR _05117_ sky130_fd_sc_hd__nand4_1
XFILLER_0_0_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08720_ net20 net28 net27 net75 VGND VGND VPWR VPWR _03028_ sky130_fd_sc_hd__or4_4
XFILLER_0_28_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09203_ _08091_ _08245_ _08256_ VGND VGND VPWR VPWR _08278_ sky130_fd_sc_hd__nor3_1
XFILLER_0_119_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09134_ _05198_ _07508_ VGND VGND VPWR VPWR _07519_ sky130_fd_sc_hd__nor2_1
XFILLER_0_45_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09065_ _06672_ _06738_ VGND VGND VPWR VPWR _06760_ sky130_fd_sc_hd__nor2_1
XFILLER_0_102_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09967_ _00774_ _00775_ _00776_ VGND VGND VPWR VPWR _00778_ sky130_fd_sc_hd__and3_1
X_08918_ _03988_ _05132_ _04351_ VGND VGND VPWR VPWR _05143_ sky130_fd_sc_hd__a21o_2
X_09898_ _00619_ _00707_ _00708_ VGND VGND VPWR VPWR _00709_ sky130_fd_sc_hd__nand3_1
X_08849_ _04252_ _04318_ _04329_ _04362_ _04373_ VGND VGND VPWR VPWR _04384_ sky130_fd_sc_hd__o2111ai_4
X_11860_ _02669_ _02670_ VGND VGND VPWR VPWR _02671_ sky130_fd_sc_hd__nor2_1
XFILLER_0_79_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10811_ _01619_ _01621_ VGND VGND VPWR VPWR _01622_ sky130_fd_sc_hd__nor2_1
X_11791_ _02550_ _02552_ VGND VGND VPWR VPWR _02602_ sky130_fd_sc_hd__or2_1
X_13530_ net208 net202 _03667_ _03750_ VGND VGND VPWR VPWR _04425_ sky130_fd_sc_hd__and4_1
X_10742_ _01540_ _01547_ _01552_ VGND VGND VPWR VPWR _01553_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_94_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13461_ net208 _03667_ _04217_ VGND VGND VPWR VPWR _04349_ sky130_fd_sc_hd__and3_1
X_10673_ _01464_ _01479_ _01483_ VGND VGND VPWR VPWR _01484_ sky130_fd_sc_hd__and3_1
XFILLER_0_36_843 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15200_ _06255_ _06257_ _06261_ VGND VGND VPWR VPWR _06262_ sky130_fd_sc_hd__a21o_1
X_12412_ _03243_ VGND VGND VPWR VPWR _03244_ sky130_fd_sc_hd__inv_2
X_16180_ _07337_ _07338_ _07339_ VGND VGND VPWR VPWR _07340_ sky130_fd_sc_hd__and3b_1
XFILLER_0_63_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13392_ _04259_ _04272_ VGND VGND VPWR VPWR _04273_ sky130_fd_sc_hd__or2_1
XFILLER_0_90_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15131_ _06171_ _06179_ VGND VGND VPWR VPWR _06186_ sky130_fd_sc_hd__or2b_1
XFILLER_0_23_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12343_ _01788_ _03173_ _03174_ VGND VGND VPWR VPWR _03175_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_105_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15062_ _05841_ _06108_ _06109_ VGND VGND VPWR VPWR _06110_ sky130_fd_sc_hd__or3_1
XFILLER_0_49_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12274_ _02832_ _03105_ VGND VGND VPWR VPWR _03106_ sky130_fd_sc_hd__nand2_1
X_14013_ _04894_ _04949_ _04953_ VGND VGND VPWR VPWR _04957_ sky130_fd_sc_hd__a21oi_1
X_11225_ _01481_ _02033_ _02035_ VGND VGND VPWR VPWR _02036_ sky130_fd_sc_hd__nor3_1
X_11156_ _01964_ _01966_ VGND VGND VPWR VPWR _01967_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10107_ net342 net338 _00241_ _00315_ VGND VGND VPWR VPWR _00918_ sky130_fd_sc_hd__and4_1
X_15964_ _07019_ _07022_ VGND VGND VPWR VPWR _07103_ sky130_fd_sc_hd__xnor2_1
X_11087_ net388 net151 net155 net383 VGND VGND VPWR VPWR _01898_ sky130_fd_sc_hd__a22oi_1
X_14915_ _05943_ _05948_ VGND VGND VPWR VPWR _05949_ sky130_fd_sc_hd__xor2_2
X_10038_ _00845_ _00848_ _00846_ VGND VGND VPWR VPWR _00849_ sky130_fd_sc_hd__o21ai_1
X_15895_ _06922_ _06924_ VGND VGND VPWR VPWR _07027_ sky130_fd_sc_hd__xnor2_1
X_14846_ _05797_ _05799_ VGND VGND VPWR VPWR _05873_ sky130_fd_sc_hd__or2b_1
XFILLER_0_105_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14777_ net265 _05711_ VGND VGND VPWR VPWR _05797_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11989_ _02800_ _02801_ VGND VGND VPWR VPWR _02802_ sky130_fd_sc_hd__and2b_1
X_16516_ _07558_ _07559_ VGND VGND VPWR VPWR _07710_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13728_ _04608_ _04642_ VGND VGND VPWR VPWR _04643_ sky130_fd_sc_hd__or2_1
X_17496_ clknet_4_12_0_clock _00039_ VGND VGND VPWR VPWR ki\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_86_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16447_ i_error\[3\] _07615_ VGND VGND VPWR VPWR _07634_ sky130_fd_sc_hd__and2_1
XFILLER_0_116_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13659_ _04564_ _04566_ VGND VGND VPWR VPWR _04567_ sky130_fd_sc_hd__nand2_1
XFILLER_0_144_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_140_Right_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16378_ _07533_ _07557_ VGND VGND VPWR VPWR _07558_ sky130_fd_sc_hd__xor2_1
XFILLER_0_42_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15329_ _06300_ _06403_ VGND VGND VPWR VPWR _06404_ sky130_fd_sc_hd__or2_1
XFILLER_0_112_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_890 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout406 net408 VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__buf_2
X_09821_ _00606_ _00630_ VGND VGND VPWR VPWR _00632_ sky130_fd_sc_hd__nor2_1
Xfanout417 prev_d_error\[7\] VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__clkbuf_4
Xfanout428 net432 VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__clkbuf_4
Xfanout439 net440 VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__buf_2
X_09752_ _00558_ _00562_ VGND VGND VPWR VPWR _00563_ sky130_fd_sc_hd__nand2_1
X_08703_ _02839_ VGND VGND VPWR VPWR _02850_ sky130_fd_sc_hd__clkbuf_2
X_09683_ _00492_ _00493_ VGND VGND VPWR VPWR _00494_ sky130_fd_sc_hd__or2_1
XFILLER_0_55_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09117_ _07321_ VGND VGND VPWR VPWR _07332_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_150_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09048_ _06309_ _06540_ _06386_ VGND VGND VPWR VPWR _06573_ sky130_fd_sc_hd__nor3_1
X_11010_ _01801_ _01820_ VGND VGND VPWR VPWR _01821_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12961_ net225 VGND VGND VPWR VPWR _03805_ sky130_fd_sc_hd__inv_2
X_14700_ net277 _05711_ VGND VGND VPWR VPWR _05712_ sky130_fd_sc_hd__nand2_1
X_11912_ _02721_ _02722_ VGND VGND VPWR VPWR _02723_ sky130_fd_sc_hd__or2_1
X_15680_ _06498_ _06774_ _06775_ _06789_ VGND VGND VPWR VPWR _06790_ sky130_fd_sc_hd__a31o_1
X_12892_ _03734_ _03735_ VGND VGND VPWR VPWR _03736_ sky130_fd_sc_hd__or2_1
X_14631_ net259 net479 _05635_ VGND VGND VPWR VPWR _05636_ sky130_fd_sc_hd__and3_1
X_11843_ net414 net160 VGND VGND VPWR VPWR _02654_ sky130_fd_sc_hd__nand2_1
X_17350_ net470 i_error\[14\] VGND VGND VPWR VPWR _08577_ sky130_fd_sc_hd__or2_1
X_14562_ prev_error\[4\] _00241_ VGND VGND VPWR VPWR _05560_ sky130_fd_sc_hd__or2_1
XFILLER_0_138_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11774_ _02530_ _02531_ VGND VGND VPWR VPWR _02585_ sky130_fd_sc_hd__nor2_1
X_16301_ _07413_ _07414_ _07443_ _07419_ _07472_ VGND VGND VPWR VPWR _07473_ sky130_fd_sc_hd__a2111o_1
X_13513_ kd_1\[5\] _03248_ VGND VGND VPWR VPWR _04407_ sky130_fd_sc_hd__and2_1
X_17281_ _08527_ _08533_ VGND VGND VPWR VPWR _00089_ sky130_fd_sc_hd__nor2_1
X_10725_ _01533_ _01535_ VGND VGND VPWR VPWR _01536_ sky130_fd_sc_hd__nor2_1
X_14493_ _05482_ _05483_ VGND VGND VPWR VPWR _05485_ sky130_fd_sc_hd__nor2_1
XFILLER_0_82_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16232_ _07385_ _07394_ _07396_ VGND VGND VPWR VPWR _07397_ sky130_fd_sc_hd__o21a_1
XFILLER_0_137_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13444_ _04325_ _04328_ _04330_ VGND VGND VPWR VPWR _04331_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_126_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10656_ net427 _01462_ _01460_ VGND VGND VPWR VPWR _01467_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_113_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16163_ _07271_ _07306_ _07318_ VGND VGND VPWR VPWR _07322_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_35_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10587_ _01385_ _01388_ _01397_ VGND VGND VPWR VPWR _01398_ sky130_fd_sc_hd__and3_1
X_13375_ _04233_ _04253_ VGND VGND VPWR VPWR _04255_ sky130_fd_sc_hd__nor2_1
XFILLER_0_140_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15114_ _06156_ _06158_ VGND VGND VPWR VPWR _06168_ sky130_fd_sc_hd__xor2_1
X_12326_ _02305_ _02300_ _02304_ VGND VGND VPWR VPWR _03158_ sky130_fd_sc_hd__nor3_1
X_16094_ _07242_ _07243_ _07245_ VGND VGND VPWR VPWR _07246_ sky130_fd_sc_hd__and3_1
X_15045_ _06086_ _06087_ VGND VGND VPWR VPWR _06092_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12257_ _03082_ _03077_ _03080_ VGND VGND VPWR VPWR _03088_ sky130_fd_sc_hd__nand3_1
X_11208_ _01994_ _02018_ VGND VGND VPWR VPWR _02019_ sky130_fd_sc_hd__nor2_1
X_12188_ net436 net440 net165 net169 VGND VGND VPWR VPWR _03013_ sky130_fd_sc_hd__and4_1
X_11139_ _01944_ _01949_ VGND VGND VPWR VPWR _01950_ sky130_fd_sc_hd__nor2_1
X_16996_ _05424_ _08237_ VGND VGND VPWR VPWR _08238_ sky130_fd_sc_hd__and2_1
X_15947_ _07078_ _07082_ VGND VGND VPWR VPWR _07084_ sky130_fd_sc_hd__or2_1
X_15878_ _06995_ _06996_ _07007_ VGND VGND VPWR VPWR _07008_ sky130_fd_sc_hd__and3_1
X_14829_ _05852_ _05853_ VGND VGND VPWR VPWR _05854_ sky130_fd_sc_hd__nand2_1
XFILLER_0_148_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17479_ clknet_4_1_0_clock _00058_ VGND VGND VPWR VPWR kp\[13\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_132_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout203 net204 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__buf_2
Xfanout214 net217 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout225 net226 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__clkbuf_4
Xfanout236 net237 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__buf_2
X_09804_ net370 _04758_ _00489_ VGND VGND VPWR VPWR _00615_ sky130_fd_sc_hd__and3_1
Xfanout247 kd_1\[0\] VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__buf_2
Xfanout258 net260 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__buf_2
XFILLER_0_5_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout269 net272 VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__buf_2
X_09735_ net334 _08676_ _00362_ VGND VGND VPWR VPWR _00546_ sky130_fd_sc_hd__and3_1
X_09666_ _00475_ _00476_ VGND VGND VPWR VPWR _00477_ sky130_fd_sc_hd__or2_1
XFILLER_0_96_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09597_ _00304_ _00303_ VGND VGND VPWR VPWR _00408_ sky130_fd_sc_hd__or2b_1
XFILLER_0_96_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10510_ net379 net362 _00518_ _08675_ VGND VGND VPWR VPWR _01321_ sky130_fd_sc_hd__nand4_4
X_11490_ _02299_ _02275_ _02298_ VGND VGND VPWR VPWR _02301_ sky130_fd_sc_hd__nor3_1
XFILLER_0_134_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10441_ net346 _00652_ VGND VGND VPWR VPWR _01252_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10372_ _01181_ _01182_ VGND VGND VPWR VPWR _01183_ sky130_fd_sc_hd__nor2_1
X_13160_ _04016_ _04017_ VGND VGND VPWR VPWR _04018_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12111_ _02809_ _02935_ VGND VGND VPWR VPWR _02936_ sky130_fd_sc_hd__or2_1
XFILLER_0_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13091_ _03927_ _03941_ VGND VGND VPWR VPWR _03942_ sky130_fd_sc_hd__nand2_1
XFILLER_0_130_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12042_ _02854_ _02859_ VGND VGND VPWR VPWR _02860_ sky130_fd_sc_hd__and2_1
X_16850_ _08067_ _08073_ _08076_ VGND VGND VPWR VPWR _08077_ sky130_fd_sc_hd__or3b_4
X_15801_ net256 _04314_ _06873_ VGND VGND VPWR VPWR _06923_ sky130_fd_sc_hd__a21oi_1
X_16781_ _05443_ _07974_ VGND VGND VPWR VPWR _08001_ sky130_fd_sc_hd__nor2_1
X_13993_ _04917_ _04933_ VGND VGND VPWR VPWR _04935_ sky130_fd_sc_hd__xor2_2
X_15732_ net275 _06016_ VGND VGND VPWR VPWR _06847_ sky130_fd_sc_hd__nand2_1
X_12944_ _03203_ _03193_ VGND VGND VPWR VPWR _03788_ sky130_fd_sc_hd__and2b_2
X_15663_ _06769_ _06768_ _06746_ net508 VGND VGND VPWR VPWR _06772_ sky130_fd_sc_hd__a211oi_4
X_12875_ _03707_ _03711_ _03705_ VGND VGND VPWR VPWR _03719_ sky130_fd_sc_hd__o21a_1
X_17402_ clknet_4_11_0_clock _00080_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dfxtp_1
X_14614_ _03230_ _05612_ _05617_ VGND VGND VPWR VPWR _05618_ sky130_fd_sc_hd__and3_1
X_11826_ _02608_ _02634_ VGND VGND VPWR VPWR _02637_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15594_ net256 _06417_ _06695_ VGND VGND VPWR VPWR _06696_ sky130_fd_sc_hd__nand3_1
XFILLER_0_55_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17333_ _08564_ _08114_ _08566_ net459 VGND VGND VPWR VPWR _00113_ sky130_fd_sc_hd__o211a_1
X_14545_ _05476_ _05485_ _05482_ VGND VGND VPWR VPWR _05542_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_56_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11757_ _02562_ _02566_ _02567_ VGND VGND VPWR VPWR _02568_ sky130_fd_sc_hd__a21o_1
XFILLER_0_126_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17264_ _03867_ net78 VGND VGND VPWR VPWR _08522_ sky130_fd_sc_hd__and2_1
X_10708_ _01505_ _01517_ VGND VGND VPWR VPWR _01519_ sky130_fd_sc_hd__or2_1
X_14476_ _05424_ _05465_ VGND VGND VPWR VPWR _05466_ sky130_fd_sc_hd__and2_2
XFILLER_0_83_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11688_ _02497_ VGND VGND VPWR VPWR _02499_ sky130_fd_sc_hd__inv_2
X_16215_ net298 _06415_ VGND VGND VPWR VPWR _07379_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13427_ _04310_ _04311_ VGND VGND VPWR VPWR _04312_ sky130_fd_sc_hd__and2_2
X_10639_ _07717_ _07706_ VGND VGND VPWR VPWR _01450_ sky130_fd_sc_hd__xor2_1
X_17195_ _08242_ _08456_ VGND VGND VPWR VPWR _08457_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_11_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16146_ _07297_ _07300_ VGND VGND VPWR VPWR _07303_ sky130_fd_sc_hd__or2b_1
X_13358_ _04235_ _04199_ VGND VGND VPWR VPWR _04236_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_23_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12309_ _03140_ _02846_ VGND VGND VPWR VPWR _03141_ sky130_fd_sc_hd__xor2_1
X_16077_ _07225_ _07226_ VGND VGND VPWR VPWR _07227_ sky130_fd_sc_hd__or2_1
X_13289_ _04063_ _04085_ VGND VGND VPWR VPWR _04160_ sky130_fd_sc_hd__xnor2_1
X_15028_ _06068_ _06071_ VGND VGND VPWR VPWR _06073_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16979_ _08207_ _08218_ VGND VGND VPWR VPWR _08219_ sky130_fd_sc_hd__nand2_1
Xinput3 measurement[10] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
X_09520_ _00225_ _00227_ VGND VGND VPWR VPWR _00331_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_127_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09451_ _00177_ _00179_ _00178_ VGND VGND VPWR VPWR _00262_ sky130_fd_sc_hd__o21a_1
XFILLER_0_149_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_871 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09382_ _05429_ _00188_ VGND VGND VPWR VPWR _00193_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09718_ _00481_ _00469_ VGND VGND VPWR VPWR _00529_ sky130_fd_sc_hd__or2b_1
X_10990_ _01790_ _01800_ VGND VGND VPWR VPWR _01801_ sky130_fd_sc_hd__nand2_1
X_09649_ net347 _04626_ VGND VGND VPWR VPWR _00460_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12660_ _03439_ _03347_ VGND VGND VPWR VPWR _03499_ sky130_fd_sc_hd__nor2_2
X_11611_ _02419_ _02420_ _02421_ VGND VGND VPWR VPWR _02422_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_93_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12591_ net238 net230 _03345_ VGND VGND VPWR VPWR _03430_ sky130_fd_sc_hd__o21ai_1
X_14330_ _05200_ _05303_ _05304_ VGND VGND VPWR VPWR _05305_ sky130_fd_sc_hd__a21o_4
X_11542_ _02349_ _02352_ VGND VGND VPWR VPWR _02353_ sky130_fd_sc_hd__and2_1
XFILLER_0_108_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14261_ _05228_ VGND VGND VPWR VPWR _05229_ sky130_fd_sc_hd__inv_2
X_11473_ net392 net168 _02096_ VGND VGND VPWR VPWR _02284_ sky130_fd_sc_hd__and3_1
XFILLER_0_33_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16000_ _07070_ _07062_ _07069_ VGND VGND VPWR VPWR _07142_ sky130_fd_sc_hd__a21o_1
XFILLER_0_107_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13212_ net232 _03335_ _03327_ net237 VGND VGND VPWR VPWR _04075_ sky130_fd_sc_hd__a22o_1
XFILLER_0_122_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10424_ _01221_ _01233_ _01200_ _01234_ VGND VGND VPWR VPWR _01235_ sky130_fd_sc_hd__o211ai_2
X_14192_ _05144_ _05151_ _05152_ VGND VGND VPWR VPWR _05153_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_33_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13143_ prev_error\[2\] _00557_ VGND VGND VPWR VPWR _04000_ sky130_fd_sc_hd__xnor2_4
X_10355_ net362 _08675_ _00902_ VGND VGND VPWR VPWR _01166_ sky130_fd_sc_hd__and3_1
XFILLER_0_148_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10286_ _01091_ _01095_ _01025_ _01096_ VGND VGND VPWR VPWR _01097_ sky130_fd_sc_hd__a211o_1
XFILLER_0_130_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13074_ _03781_ _03923_ VGND VGND VPWR VPWR _03924_ sky130_fd_sc_hd__xor2_1
X_16902_ _08128_ _08130_ VGND VGND VPWR VPWR _08134_ sky130_fd_sc_hd__nor2_1
X_12025_ _02777_ _02841_ VGND VGND VPWR VPWR _02842_ sky130_fd_sc_hd__or2_1
X_16833_ _08049_ _08057_ VGND VGND VPWR VPWR _08059_ sky130_fd_sc_hd__nor2_1
X_16764_ _07829_ _07977_ VGND VGND VPWR VPWR _07983_ sky130_fd_sc_hd__nand2_1
X_13976_ _04858_ _04860_ _04915_ VGND VGND VPWR VPWR _04916_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15715_ net285 _05602_ _06828_ VGND VGND VPWR VPWR _06829_ sky130_fd_sc_hd__a21bo_1
X_12927_ _03652_ _03694_ _03740_ _03770_ VGND VGND VPWR VPWR _03771_ sky130_fd_sc_hd__o31a_1
X_16695_ _07905_ _07906_ VGND VGND VPWR VPWR _07907_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_88_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15646_ _06424_ _06752_ VGND VGND VPWR VPWR _06753_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12858_ _03369_ _03697_ _03367_ VGND VGND VPWR VPWR _03702_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_56_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11809_ _02617_ _02619_ VGND VGND VPWR VPWR _02620_ sky130_fd_sc_hd__nand2_1
X_15577_ _06589_ _06666_ _06675_ VGND VGND VPWR VPWR _06677_ sky130_fd_sc_hd__and3_1
X_12789_ _03623_ _03626_ _03631_ VGND VGND VPWR VPWR _03633_ sky130_fd_sc_hd__and3_1
XFILLER_0_56_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17316_ net461 prev_error\[16\] VGND VGND VPWR VPWR _08556_ sky130_fd_sc_hd__or2_1
X_14528_ _05471_ _05512_ _05510_ VGND VGND VPWR VPWR _05523_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_125_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17247_ _08462_ _08495_ _08474_ VGND VGND VPWR VPWR _08509_ sky130_fd_sc_hd__a21oi_2
X_14459_ _00969_ _01037_ VGND VGND VPWR VPWR _05447_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17178_ _08422_ _08437_ VGND VGND VPWR VPWR _08438_ sky130_fd_sc_hd__xnor2_1
X_16129_ _07279_ _07280_ VGND VGND VPWR VPWR _07284_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_122_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08951_ _05440_ _05484_ _05495_ VGND VGND VPWR VPWR _05506_ sky130_fd_sc_hd__or3_1
XFILLER_0_121_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08882_ _04736_ VGND VGND VPWR VPWR _04747_ sky130_fd_sc_hd__buf_6
XFILLER_0_138_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09503_ _00313_ VGND VGND VPWR VPWR _00314_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09434_ net318 _08682_ _08677_ net314 VGND VGND VPWR VPWR _00245_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_78_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09365_ _08623_ _08624_ VGND VGND VPWR VPWR _00176_ sky130_fd_sc_hd__and2_1
XFILLER_0_47_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09296_ _08521_ _08658_ VGND VGND VPWR VPWR _08660_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_30 _03371_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_145_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10140_ _00876_ _00879_ _00878_ VGND VGND VPWR VPWR _00951_ sky130_fd_sc_hd__o21a_1
XFILLER_0_30_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10071_ _00860_ _00881_ VGND VGND VPWR VPWR _00882_ sky130_fd_sc_hd__nor2_1
X_13830_ net206 _04107_ VGND VGND VPWR VPWR _04755_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13761_ _04676_ _04677_ VGND VGND VPWR VPWR _04679_ sky130_fd_sc_hd__and2_1
X_10973_ _01782_ _01754_ _01780_ VGND VGND VPWR VPWR _01784_ sky130_fd_sc_hd__and3_1
X_15500_ _06582_ _06591_ VGND VGND VPWR VPWR _06592_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12712_ _03463_ _03465_ VGND VGND VPWR VPWR _03552_ sky130_fd_sc_hd__and2_1
X_16480_ _07537_ _07539_ _07669_ VGND VGND VPWR VPWR _07670_ sky130_fd_sc_hd__o21a_1
Xmax_cap98 _06594_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__buf_6
X_13692_ _04588_ _04602_ VGND VGND VPWR VPWR _04603_ sky130_fd_sc_hd__and2_1
X_15431_ _06512_ _06515_ VGND VGND VPWR VPWR _06516_ sky130_fd_sc_hd__xnor2_2
X_12643_ _03264_ _03288_ VGND VGND VPWR VPWR _03482_ sky130_fd_sc_hd__nor2_1
X_15362_ _06326_ _06329_ VGND VGND VPWR VPWR _06440_ sky130_fd_sc_hd__nor2_1
XFILLER_0_53_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12574_ _03387_ _03401_ _03412_ VGND VGND VPWR VPWR _03413_ sky130_fd_sc_hd__o21a_1
X_17101_ _08308_ _08352_ VGND VGND VPWR VPWR _08353_ sky130_fd_sc_hd__xor2_4
XFILLER_0_108_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14313_ _05259_ _05285_ VGND VGND VPWR VPWR _05287_ sky130_fd_sc_hd__nor2_1
XFILLER_0_135_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11525_ _02324_ _02315_ _02322_ VGND VGND VPWR VPWR _02336_ sky130_fd_sc_hd__nand3_1
X_15293_ _06361_ _06363_ VGND VGND VPWR VPWR _06365_ sky130_fd_sc_hd__or2b_1
XFILLER_0_123_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17032_ _08259_ _08276_ VGND VGND VPWR VPWR _08277_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_150_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14244_ _05206_ _05208_ VGND VGND VPWR VPWR _05211_ sky130_fd_sc_hd__and2_1
XFILLER_0_7_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11456_ _02240_ _02263_ _02265_ VGND VGND VPWR VPWR _02267_ sky130_fd_sc_hd__and3_1
XFILLER_0_150_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10407_ _01212_ _01217_ VGND VGND VPWR VPWR _01218_ sky130_fd_sc_hd__or2_1
X_14175_ _05119_ _05120_ _05133_ _05134_ VGND VGND VPWR VPWR _05135_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_1_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11387_ _02195_ _02197_ VGND VGND VPWR VPWR _02198_ sky130_fd_sc_hd__nor2_1
XFILLER_0_150_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13126_ _03979_ _03980_ VGND VGND VPWR VPWR _03981_ sky130_fd_sc_hd__and2b_1
X_10338_ _01137_ _01148_ VGND VGND VPWR VPWR _01149_ sky130_fd_sc_hd__and2b_1
X_13057_ _03825_ _03904_ VGND VGND VPWR VPWR _03905_ sky130_fd_sc_hd__nor2_1
X_10269_ net358 _08681_ VGND VGND VPWR VPWR _01080_ sky130_fd_sc_hd__nand2_2
XFILLER_0_84_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12008_ _02819_ _02822_ VGND VGND VPWR VPWR _02823_ sky130_fd_sc_hd__and2_1
XFILLER_0_108_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16816_ _07730_ _07971_ VGND VGND VPWR VPWR _08040_ sky130_fd_sc_hd__nor2_1
X_16747_ _07914_ _07917_ VGND VGND VPWR VPWR _07964_ sky130_fd_sc_hd__nand2_1
X_13959_ _04891_ _04895_ VGND VGND VPWR VPWR _04897_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16678_ _05793_ _05852_ _07886_ VGND VGND VPWR VPWR _07888_ sky130_fd_sc_hd__and3_1
XFILLER_0_8_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15629_ _06649_ _06660_ VGND VGND VPWR VPWR _06734_ sky130_fd_sc_hd__or2_1
XFILLER_0_75_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09150_ _07112_ _07288_ _07684_ VGND VGND VPWR VPWR _07695_ sky130_fd_sc_hd__o21a_1
XFILLER_0_84_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09081_ _05572_ _06925_ VGND VGND VPWR VPWR _06936_ sky130_fd_sc_hd__xor2_1
XFILLER_0_126_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput50 reg_data[4] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_2
XFILLER_0_25_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput61 target[13] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_1
Xinput72 target[7] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09983_ _00792_ _00793_ VGND VGND VPWR VPWR _00794_ sky130_fd_sc_hd__and2_1
XFILLER_0_149_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08934_ net64 net9 VGND VGND VPWR VPWR _05319_ sky130_fd_sc_hd__or2b_1
XFILLER_0_58_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08865_ _04549_ VGND VGND VPWR VPWR _04560_ sky130_fd_sc_hd__clkbuf_4
X_08796_ net49 _02883_ _02916_ net162 VGND VGND VPWR VPWR _00029_ sky130_fd_sc_hd__a22o_1
XFILLER_0_74_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09417_ _00225_ _00227_ VGND VGND VPWR VPWR _00228_ sky130_fd_sc_hd__nor2_2
XFILLER_0_137_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09348_ _00157_ _00158_ VGND VGND VPWR VPWR _00159_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_90_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09279_ _07992_ _08014_ VGND VGND VPWR VPWR _08643_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11310_ _02119_ _02088_ _02117_ VGND VGND VPWR VPWR _02121_ sky130_fd_sc_hd__nor3_1
X_12290_ _02969_ VGND VGND VPWR VPWR _03122_ sky130_fd_sc_hd__inv_2
XFILLER_0_132_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11241_ _01962_ _01961_ VGND VGND VPWR VPWR _02052_ sky130_fd_sc_hd__nor2_1
X_11172_ _01981_ _01979_ VGND VGND VPWR VPWR _01983_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10123_ _00868_ _00933_ VGND VGND VPWR VPWR _00934_ sky130_fd_sc_hd__xor2_1
X_15980_ _07111_ _07118_ _07119_ VGND VGND VPWR VPWR _07120_ sky130_fd_sc_hd__o21ai_1
X_14931_ net257 _05590_ _05964_ _05965_ VGND VGND VPWR VPWR _05966_ sky130_fd_sc_hd__a31o_1
X_10054_ net373 _04758_ VGND VGND VPWR VPWR _00865_ sky130_fd_sc_hd__nand2_1
X_14862_ _05888_ _05889_ VGND VGND VPWR VPWR _05890_ sky130_fd_sc_hd__or2_1
X_16601_ _07790_ _07797_ _07802_ VGND VGND VPWR VPWR _07803_ sky130_fd_sc_hd__a21o_1
X_13813_ net228 _03576_ _04403_ VGND VGND VPWR VPWR _04737_ sky130_fd_sc_hd__and3_1
X_14793_ _05731_ _05742_ VGND VGND VPWR VPWR _05815_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_121_Right_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16532_ _07723_ _07724_ _07726_ VGND VGND VPWR VPWR _07727_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13744_ _04658_ _04660_ VGND VGND VPWR VPWR _04661_ sky130_fd_sc_hd__xnor2_1
X_10956_ _01761_ _01764_ _01766_ VGND VGND VPWR VPWR _01767_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_39_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16463_ _07504_ _07650_ VGND VGND VPWR VPWR _07652_ sky130_fd_sc_hd__and2_1
X_13675_ net212 _03751_ _04583_ _04584_ VGND VGND VPWR VPWR _04585_ sky130_fd_sc_hd__a31o_1
X_10887_ _01645_ _01686_ _01697_ VGND VGND VPWR VPWR _01698_ sky130_fd_sc_hd__o21ai_1
X_15414_ _06407_ _06425_ VGND VGND VPWR VPWR _06498_ sky130_fd_sc_hd__or2_1
XFILLER_0_128_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12626_ _03385_ _03464_ VGND VGND VPWR VPWR _03465_ sky130_fd_sc_hd__or2_1
X_16394_ i_error\[12\] _07575_ VGND VGND VPWR VPWR _07576_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15345_ _06418_ _06420_ _06421_ VGND VGND VPWR VPWR _06422_ sky130_fd_sc_hd__a21o_1
X_12557_ _03394_ _03388_ _03392_ VGND VGND VPWR VPWR _03396_ sky130_fd_sc_hd__nand3_1
XFILLER_0_53_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11508_ _02243_ _02318_ VGND VGND VPWR VPWR _02319_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_41_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15276_ net253 _06205_ VGND VGND VPWR VPWR _06346_ sky130_fd_sc_hd__nand2_1
X_12488_ _03323_ VGND VGND VPWR VPWR _03324_ sky130_fd_sc_hd__inv_2
X_17015_ _05380_ _05392_ _05390_ VGND VGND VPWR VPWR _08259_ sky130_fd_sc_hd__a21o_1
XFILLER_0_111_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14227_ _04096_ _05190_ _05191_ VGND VGND VPWR VPWR _05192_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_0_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11439_ _02196_ _02198_ VGND VGND VPWR VPWR _02250_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14158_ _05015_ net101 VGND VGND VPWR VPWR _05116_ sky130_fd_sc_hd__xor2_1
X_13109_ _03961_ _03317_ _03319_ VGND VGND VPWR VPWR _03962_ sky130_fd_sc_hd__or3_2
X_14089_ _05021_ _05039_ VGND VGND VPWR VPWR _05040_ sky130_fd_sc_hd__or2_1
XFILLER_0_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09202_ _08091_ _08245_ _08256_ VGND VGND VPWR VPWR _08267_ sky130_fd_sc_hd__o21a_1
XFILLER_0_17_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09133_ net526 _05165_ _05187_ VGND VGND VPWR VPWR _07508_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_17_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09064_ _06672_ _06738_ VGND VGND VPWR VPWR _06749_ sky130_fd_sc_hd__and2_1
XFILLER_0_60_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09966_ _00774_ _00775_ _00776_ VGND VGND VPWR VPWR _00777_ sky130_fd_sc_hd__a21oi_1
X_08917_ net492 _04318_ _04329_ VGND VGND VPWR VPWR _05132_ sky130_fd_sc_hd__o21ai_4
X_09897_ _00569_ _00617_ _00618_ VGND VGND VPWR VPWR _00708_ sky130_fd_sc_hd__a21o_1
X_08848_ _03944_ _03955_ VGND VGND VPWR VPWR _04373_ sky130_fd_sc_hd__and2_1
X_08779_ net50 _03553_ _03586_ net363 VGND VGND VPWR VPWR _00066_ sky130_fd_sc_hd__a22o_1
X_10810_ _01563_ net129 _01617_ _01620_ VGND VGND VPWR VPWR _01621_ sky130_fd_sc_hd__o22a_1
X_11790_ _02594_ _02599_ _02587_ _02600_ VGND VGND VPWR VPWR _02601_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_39_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10741_ _01550_ _01551_ VGND VGND VPWR VPWR _01552_ sky130_fd_sc_hd__and2_1
XFILLER_0_138_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13460_ net208 _03577_ _03667_ net205 VGND VGND VPWR VPWR _04348_ sky130_fd_sc_hd__a22o_1
XFILLER_0_48_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10672_ _01481_ _01482_ VGND VGND VPWR VPWR _01483_ sky130_fd_sc_hd__and2_1
XFILLER_0_47_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12411_ _03241_ _03242_ VGND VGND VPWR VPWR _03243_ sky130_fd_sc_hd__and2_2
Xclone20 _05719_ _05720_ _03331_ VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__a21o_1
XFILLER_0_36_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13391_ _04262_ _04265_ _04271_ VGND VGND VPWR VPWR _04272_ sky130_fd_sc_hd__a21oi_1
Xclone31 _03326_ VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__clkbuf_2
X_15130_ _06150_ _06182_ _06183_ _06184_ VGND VGND VPWR VPWR _06185_ sky130_fd_sc_hd__a211oi_2
X_12342_ _01786_ _01716_ VGND VGND VPWR VPWR _03174_ sky130_fd_sc_hd__or2b_1
XFILLER_0_35_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15061_ _06066_ _06070_ VGND VGND VPWR VPWR _06109_ sky130_fd_sc_hd__xor2_1
X_12273_ _02827_ _02831_ _02830_ VGND VGND VPWR VPWR _03105_ sky130_fd_sc_hd__a21o_1
XFILLER_0_121_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14012_ net222 _03935_ _04937_ _04938_ VGND VGND VPWR VPWR _04955_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_120_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11224_ _02034_ VGND VGND VPWR VPWR _02035_ sky130_fd_sc_hd__inv_2
XFILLER_0_101_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11155_ _01953_ _01965_ VGND VGND VPWR VPWR _01966_ sky130_fd_sc_hd__nor2_1
X_10106_ net342 _00241_ _00315_ net338 VGND VGND VPWR VPWR _00917_ sky130_fd_sc_hd__a22o_1
X_15963_ _07080_ _07081_ VGND VGND VPWR VPWR _07102_ sky130_fd_sc_hd__nand2_1
X_11086_ net383 net387 net151 net155 VGND VGND VPWR VPWR _01897_ sky130_fd_sc_hd__and4_1
X_14914_ _05944_ _05947_ VGND VGND VPWR VPWR _05948_ sky130_fd_sc_hd__nand2_1
X_10037_ _00846_ _00847_ VGND VGND VPWR VPWR _00848_ sky130_fd_sc_hd__nand2_1
X_15894_ _07001_ _07006_ VGND VGND VPWR VPWR _07026_ sky130_fd_sc_hd__nand2_1
X_14845_ net269 _05703_ _05798_ VGND VGND VPWR VPWR _05872_ sky130_fd_sc_hd__nand3_1
X_14776_ _05794_ _05795_ VGND VGND VPWR VPWR _05796_ sky130_fd_sc_hd__nand2_1
X_11988_ _02792_ _02794_ VGND VGND VPWR VPWR _02801_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16515_ _07659_ _07708_ VGND VGND VPWR VPWR _07709_ sky130_fd_sc_hd__xor2_1
X_13727_ _04588_ _04605_ _04607_ VGND VGND VPWR VPWR _04642_ sky130_fd_sc_hd__and3_1
X_10939_ _01731_ _01749_ VGND VGND VPWR VPWR _01750_ sky130_fd_sc_hd__nand2_1
X_17495_ clknet_4_6_0_clock _00038_ VGND VGND VPWR VPWR ki\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_129_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16446_ _07621_ _07631_ _07632_ VGND VGND VPWR VPWR _07633_ sky130_fd_sc_hd__a21o_1
XFILLER_0_73_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13658_ _04565_ _04563_ VGND VGND VPWR VPWR _04566_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_27_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12609_ _03446_ _03447_ VGND VGND VPWR VPWR _03448_ sky130_fd_sc_hd__nor2_1
X_16377_ _07555_ _07556_ VGND VGND VPWR VPWR _07557_ sky130_fd_sc_hd__and2b_1
XFILLER_0_6_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13589_ _04487_ _04488_ VGND VGND VPWR VPWR _04490_ sky130_fd_sc_hd__xor2_1
XFILLER_0_81_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15328_ _06366_ _06401_ _06402_ VGND VGND VPWR VPWR _06403_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_42_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15259_ net256 _05975_ VGND VGND VPWR VPWR _06327_ sky130_fd_sc_hd__nand2_1
XFILLER_0_112_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09820_ _00606_ _00630_ VGND VGND VPWR VPWR _00631_ sky130_fd_sc_hd__xor2_1
Xfanout407 net408 VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__buf_2
XFILLER_0_111_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout418 prev_d_error\[7\] VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__clkbuf_4
Xfanout429 net432 VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__clkbuf_2
X_09751_ _00559_ _00561_ VGND VGND VPWR VPWR _00562_ sky130_fd_sc_hd__or2b_1
X_08702_ _02784_ _02795_ _02828_ VGND VGND VPWR VPWR _02839_ sky130_fd_sc_hd__or3_2
X_09682_ _00343_ _00432_ VGND VGND VPWR VPWR _00493_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_146_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09116_ _07310_ VGND VGND VPWR VPWR _07321_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_72_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09047_ _05297_ _06210_ VGND VGND VPWR VPWR _06562_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09949_ _00713_ _00758_ _00744_ _00757_ VGND VGND VPWR VPWR _00760_ sky130_fd_sc_hd__o211ai_1
X_12960_ _03728_ _03731_ VGND VGND VPWR VPWR _03804_ sky130_fd_sc_hd__xnor2_1
X_11911_ _02717_ _02716_ _02681_ VGND VGND VPWR VPWR _02722_ sky130_fd_sc_hd__a21oi_1
X_12891_ _03721_ _03733_ VGND VGND VPWR VPWR _03735_ sky130_fd_sc_hd__and2_1
X_14630_ _05632_ _05633_ _05634_ _03180_ _03226_ VGND VGND VPWR VPWR _05635_ sky130_fd_sc_hd__a2111o_4
X_11842_ _02648_ _02650_ _02652_ VGND VGND VPWR VPWR _02653_ sky130_fd_sc_hd__o21ai_1
X_14561_ _03186_ _03266_ VGND VGND VPWR VPWR _05559_ sky130_fd_sc_hd__and2_4
X_11773_ _02581_ _02583_ VGND VGND VPWR VPWR _02584_ sky130_fd_sc_hd__or2b_1
X_16300_ _07445_ _07459_ _07471_ VGND VGND VPWR VPWR _07472_ sky130_fd_sc_hd__a21oi_1
X_13512_ net246 _03332_ _03333_ net227 _03232_ VGND VGND VPWR VPWR _04405_ sky130_fd_sc_hd__a32o_1
X_17280_ net464 net510 net454 VGND VGND VPWR VPWR _08533_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_95_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10724_ _01533_ _01534_ net401 net122 VGND VGND VPWR VPWR _01535_ sky130_fd_sc_hd__and4bb_1
X_14492_ _06463_ _06903_ _05481_ VGND VGND VPWR VPWR _05483_ sky130_fd_sc_hd__nor3_1
X_16231_ _07395_ _07359_ VGND VGND VPWR VPWR _07396_ sky130_fd_sc_hd__xnor2_1
X_13443_ _04205_ _04209_ VGND VGND VPWR VPWR _04330_ sky130_fd_sc_hd__xor2_1
X_10655_ _01459_ _01465_ VGND VGND VPWR VPWR _01466_ sky130_fd_sc_hd__nand2_2
XFILLER_0_125_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16162_ _07301_ _07302_ VGND VGND VPWR VPWR _07320_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_51_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13374_ _04233_ _04253_ VGND VGND VPWR VPWR _04254_ sky130_fd_sc_hd__nand2_1
X_10586_ _01383_ _01389_ _01396_ VGND VGND VPWR VPWR _01397_ sky130_fd_sc_hd__and3_1
XFILLER_0_24_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15113_ _06014_ _06159_ _06165_ VGND VGND VPWR VPWR _06167_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_2_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12325_ _02485_ _03154_ _03156_ VGND VGND VPWR VPWR _03157_ sky130_fd_sc_hd__a21o_1
XFILLER_0_23_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16093_ net311 _05597_ _05600_ _07241_ VGND VGND VPWR VPWR _07245_ sky130_fd_sc_hd__a31o_1
X_15044_ _06084_ _06088_ _06000_ _06090_ VGND VGND VPWR VPWR _06091_ sky130_fd_sc_hd__o211ai_4
X_12256_ _03058_ VGND VGND VPWR VPWR _03087_ sky130_fd_sc_hd__inv_2
X_11207_ _01993_ _01969_ _01991_ VGND VGND VPWR VPWR _02018_ sky130_fd_sc_hd__nor3_1
XPHY_EDGE_ROW_79_Left_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12187_ _03005_ _03009_ VGND VGND VPWR VPWR _03012_ sky130_fd_sc_hd__xnor2_2
X_11138_ _01945_ _01948_ VGND VGND VPWR VPWR _01949_ sky130_fd_sc_hd__xnor2_1
X_16995_ _08231_ _08235_ VGND VGND VPWR VPWR _08237_ sky130_fd_sc_hd__xnor2_1
X_15946_ _07078_ _07082_ VGND VGND VPWR VPWR _07083_ sky130_fd_sc_hd__nand2_1
X_11069_ _01877_ _01879_ VGND VGND VPWR VPWR _01880_ sky130_fd_sc_hd__and2b_1
XFILLER_0_92_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15877_ _07001_ _07006_ VGND VGND VPWR VPWR _07007_ sky130_fd_sc_hd__xor2_1
XFILLER_0_25_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14828_ _05698_ _05700_ _05794_ VGND VGND VPWR VPWR _05853_ sky130_fd_sc_hd__or3_1
XFILLER_0_25_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14759_ _05775_ _05776_ VGND VGND VPWR VPWR _05777_ sky130_fd_sc_hd__nor2_1
XFILLER_0_129_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17478_ clknet_4_3_0_clock _00057_ VGND VGND VPWR VPWR kp\[12\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16429_ _07049_ _07491_ VGND VGND VPWR VPWR _07614_ sky130_fd_sc_hd__nor2_1
XFILLER_0_128_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_882 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout204 net205 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout215 net217 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__clkbuf_2
Xfanout226 net229 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__clkbuf_2
X_09803_ net370 _04758_ _00489_ _00613_ VGND VGND VPWR VPWR _00614_ sky130_fd_sc_hd__a31oi_4
Xfanout237 net238 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__clkbuf_2
Xfanout248 net250 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__buf_2
Xfanout259 net260 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_66_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09734_ _00542_ _00541_ VGND VGND VPWR VPWR _00545_ sky130_fd_sc_hd__xor2_1
X_09665_ _00474_ _00471_ VGND VGND VPWR VPWR _00476_ sky130_fd_sc_hd__and2b_1
X_09596_ net323 _08682_ VGND VGND VPWR VPWR _00407_ sky130_fd_sc_hd__nand2_1
XFILLER_0_139_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10440_ _01043_ _01246_ _01250_ VGND VGND VPWR VPWR _01251_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_17_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10371_ _01171_ _01178_ _01180_ VGND VGND VPWR VPWR _01182_ sky130_fd_sc_hd__and3_1
X_12110_ net410 net169 net173 net405 VGND VGND VPWR VPWR _02935_ sky130_fd_sc_hd__a22oi_1
X_13090_ _03929_ _03940_ VGND VGND VPWR VPWR _03941_ sky130_fd_sc_hd__or2b_1
XFILLER_0_20_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12041_ _02855_ _02858_ VGND VGND VPWR VPWR _02859_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15800_ _06916_ _06921_ VGND VGND VPWR VPWR _06922_ sky130_fd_sc_hd__xnor2_1
X_16780_ _07775_ _05555_ VGND VGND VPWR VPWR _08000_ sky130_fd_sc_hd__and2_1
X_13992_ _04930_ _04931_ _04932_ VGND VGND VPWR VPWR _04933_ sky130_fd_sc_hd__a21bo_1
X_15731_ net272 _06161_ VGND VGND VPWR VPWR _06846_ sky130_fd_sc_hd__nand2_1
X_12943_ _03782_ _03785_ _03786_ VGND VGND VPWR VPWR _03787_ sky130_fd_sc_hd__o21ai_2
X_15662_ _06737_ _06746_ _06768_ _06769_ VGND VGND VPWR VPWR _06770_ sky130_fd_sc_hd__o211a_1
X_12874_ _03701_ _03715_ _03717_ VGND VGND VPWR VPWR _03718_ sky130_fd_sc_hd__a21oi_1
X_17401_ clknet_4_10_0_clock _00079_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dfxtp_1
X_14613_ _05614_ _05615_ _03246_ _03240_ _05559_ VGND VGND VPWR VPWR _05617_ sky130_fd_sc_hd__a2111o_4
X_11825_ _02587_ _02601_ _02603_ VGND VGND VPWR VPWR _02636_ sky130_fd_sc_hd__and3_1
X_15593_ _06692_ _06693_ VGND VGND VPWR VPWR _06695_ sky130_fd_sc_hd__and2_1
XFILLER_0_56_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14544_ _05572_ _05498_ _05501_ VGND VGND VPWR VPWR _05541_ sky130_fd_sc_hd__o21ai_1
X_17332_ net464 i_error\[5\] VGND VGND VPWR VPWR _08566_ sky130_fd_sc_hd__or2_1
XFILLER_0_68_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11756_ _02451_ _02483_ VGND VGND VPWR VPWR _02567_ sky130_fd_sc_hd__xnor2_1
X_10707_ _01505_ _01517_ VGND VGND VPWR VPWR _01518_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14475_ _05427_ _05428_ _05432_ _05464_ VGND VGND VPWR VPWR _05465_ sky130_fd_sc_hd__or4bb_4
X_17263_ _08519_ _08520_ net453 VGND VGND VPWR VPWR _00082_ sky130_fd_sc_hd__o21a_1
XFILLER_0_71_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11687_ _02496_ net139 net426 _02497_ VGND VGND VPWR VPWR _02498_ sky130_fd_sc_hd__and4b_1
XFILLER_0_11_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16214_ _07344_ _07377_ VGND VGND VPWR VPWR _07378_ sky130_fd_sc_hd__or2_1
X_13426_ prev_error\[0\] _00653_ VGND VGND VPWR VPWR _04311_ sky130_fd_sc_hd__or2_1
X_10638_ _00270_ _01442_ _01447_ _01448_ VGND VGND VPWR VPWR _01449_ sky130_fd_sc_hd__a31o_4
X_17194_ net487 _08249_ _08247_ VGND VGND VPWR VPWR _08456_ sky130_fd_sc_hd__a21oi_4
X_16145_ net285 net283 _04313_ _06416_ VGND VGND VPWR VPWR _07302_ sky130_fd_sc_hd__and4_1
X_13357_ net227 _03222_ VGND VGND VPWR VPWR _04235_ sky130_fd_sc_hd__nand2_2
XFILLER_0_122_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10569_ _01375_ _01377_ _01379_ VGND VGND VPWR VPWR _01380_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_140_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12308_ _02787_ _02788_ VGND VGND VPWR VPWR _03140_ sky130_fd_sc_hd__or2_1
XFILLER_0_122_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16076_ _07220_ _07221_ _07224_ VGND VGND VPWR VPWR _07226_ sky130_fd_sc_hd__and3_1
XFILLER_0_122_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13288_ _04116_ _04158_ VGND VGND VPWR VPWR _04159_ sky130_fd_sc_hd__xnor2_1
X_15027_ _06032_ _06038_ VGND VGND VPWR VPWR _06072_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_20_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12239_ _03048_ _03056_ VGND VGND VPWR VPWR _03068_ sky130_fd_sc_hd__nor2_1
X_16978_ _08215_ _08217_ VGND VGND VPWR VPWR _08218_ sky130_fd_sc_hd__and2_1
XFILLER_0_127_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput4 measurement[11] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_127_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15929_ net309 _05664_ VGND VGND VPWR VPWR _07064_ sky130_fd_sc_hd__and2_1
XFILLER_0_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09450_ _00230_ _00259_ _00260_ VGND VGND VPWR VPWR _00261_ sky130_fd_sc_hd__nand3_1
XFILLER_0_149_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09381_ _00190_ _00191_ VGND VGND VPWR VPWR _00192_ sky130_fd_sc_hd__and2_1
XFILLER_0_143_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09717_ _00467_ _00468_ VGND VGND VPWR VPWR _00528_ sky130_fd_sc_hd__or2b_1
XFILLER_0_97_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09648_ _00457_ _00458_ VGND VGND VPWR VPWR _00459_ sky130_fd_sc_hd__xor2_2
XFILLER_0_96_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09579_ net349 _04439_ _04769_ net353 VGND VGND VPWR VPWR _00390_ sky130_fd_sc_hd__a22o_1
XFILLER_0_37_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11610_ net409 net411 net152 net156 VGND VGND VPWR VPWR _02421_ sky130_fd_sc_hd__and4_1
XFILLER_0_77_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12590_ _03428_ VGND VGND VPWR VPWR _03429_ sky130_fd_sc_hd__buf_2
XFILLER_0_38_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11541_ _02350_ _02351_ VGND VGND VPWR VPWR _02352_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_147_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14260_ _05225_ _05227_ VGND VGND VPWR VPWR _05228_ sky130_fd_sc_hd__xnor2_1
X_11472_ net392 net164 net166 net387 VGND VGND VPWR VPWR _02283_ sky130_fd_sc_hd__a22o_1
XFILLER_0_52_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13211_ _03961_ _04072_ _04073_ _03327_ VGND VGND VPWR VPWR _04074_ sky130_fd_sc_hd__or4b_2
X_10423_ _01197_ _01199_ _01198_ VGND VGND VPWR VPWR _01234_ sky130_fd_sc_hd__a21o_1
XFILLER_0_33_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14191_ _05149_ _05150_ VGND VGND VPWR VPWR _05152_ sky130_fd_sc_hd__nor2_1
XFILLER_0_150_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13142_ net179 _03936_ VGND VGND VPWR VPWR _03998_ sky130_fd_sc_hd__nand2_1
X_10354_ _00902_ _01164_ VGND VGND VPWR VPWR _01165_ sky130_fd_sc_hd__xnor2_1
X_13073_ net189 _03577_ VGND VGND VPWR VPWR _03923_ sky130_fd_sc_hd__nand2_1
X_10285_ _01021_ _01024_ _01023_ VGND VGND VPWR VPWR _01096_ sky130_fd_sc_hd__a21oi_1
X_16901_ _08116_ _08126_ VGND VGND VPWR VPWR _08133_ sky130_fd_sc_hd__or2_1
X_12024_ _02751_ _02775_ _02776_ _02774_ VGND VGND VPWR VPWR _02841_ sky130_fd_sc_hd__o22a_1
X_16832_ _05422_ _08055_ _08056_ VGND VGND VPWR VPWR _08057_ sky130_fd_sc_hd__a21oi_1
X_16763_ _07846_ _07978_ _07980_ _07835_ VGND VGND VPWR VPWR _07982_ sky130_fd_sc_hd__a22oi_1
X_13975_ _04861_ _04914_ VGND VGND VPWR VPWR _04915_ sky130_fd_sc_hd__nand2_1
X_15714_ net282 _05664_ VGND VGND VPWR VPWR _06828_ sky130_fd_sc_hd__nand2_1
X_12926_ _03767_ _03769_ VGND VGND VPWR VPWR _03770_ sky130_fd_sc_hd__nand2_1
X_16694_ _07714_ _07565_ _07715_ _07712_ VGND VGND VPWR VPWR _07906_ sky130_fd_sc_hd__a31o_1
X_15645_ _06422_ _06423_ VGND VGND VPWR VPWR _06752_ sky130_fd_sc_hd__nor2_1
X_12857_ _03695_ _03699_ _03700_ VGND VGND VPWR VPWR _03701_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_68_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11808_ _02614_ _02618_ VGND VGND VPWR VPWR _02619_ sky130_fd_sc_hd__and2_1
X_15576_ _06589_ _06666_ _06675_ VGND VGND VPWR VPWR _06676_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_84_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12788_ _03623_ _03626_ _03631_ VGND VGND VPWR VPWR _03632_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_95_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17315_ _08549_ _05033_ _08555_ net450 VGND VGND VPWR VPWR _00105_ sky130_fd_sc_hd__o211a_1
XFILLER_0_7_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14527_ _07772_ _01456_ _05518_ _07750_ VGND VGND VPWR VPWR _05522_ sky130_fd_sc_hd__a211o_4
XFILLER_0_44_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11739_ net388 net174 _02549_ VGND VGND VPWR VPWR _02550_ sky130_fd_sc_hd__and3_1
XFILLER_0_126_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17246_ _08498_ net89 VGND VGND VPWR VPWR _08508_ sky130_fd_sc_hd__and2_1
XFILLER_0_118_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14458_ _01422_ _01107_ _01423_ VGND VGND VPWR VPWR _05446_ sky130_fd_sc_hd__a21o_1
XFILLER_0_114_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13409_ _04283_ _04290_ _04291_ VGND VGND VPWR VPWR _04292_ sky130_fd_sc_hd__a21oi_1
X_14389_ _03480_ _03487_ VGND VGND VPWR VPWR _05370_ sky130_fd_sc_hd__and2b_1
XFILLER_0_4_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17177_ _08423_ _08436_ VGND VGND VPWR VPWR _08437_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_141_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16128_ _07261_ _07282_ VGND VGND VPWR VPWR _07283_ sky130_fd_sc_hd__and2_1
XFILLER_0_12_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08950_ net344 _05418_ _05473_ VGND VGND VPWR VPWR _05495_ sky130_fd_sc_hd__a21oi_1
X_16059_ _07204_ _07205_ VGND VGND VPWR VPWR _07207_ sky130_fd_sc_hd__and2_1
X_08881_ _04692_ _04725_ VGND VGND VPWR VPWR _04736_ sky130_fd_sc_hd__xnor2_4
XPHY_EDGE_ROW_135_Right_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_16_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09502_ _00310_ _00312_ VGND VGND VPWR VPWR _00313_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_2_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09433_ _04549_ _00243_ VGND VGND VPWR VPWR _00244_ sky130_fd_sc_hd__or2_1
XFILLER_0_78_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09364_ _00172_ _00174_ VGND VGND VPWR VPWR _00175_ sky130_fd_sc_hd__or2_2
XFILLER_0_129_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_20 net351 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_09295_ _08521_ _08658_ VGND VGND VPWR VPWR _08659_ sky130_fd_sc_hd__or2_1
XFILLER_0_7_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_31 _03790_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_117_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_25_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10070_ _00876_ _00880_ VGND VGND VPWR VPWR _00881_ sky130_fd_sc_hd__nor2_2
XPHY_EDGE_ROW_102_Right_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_34_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13760_ _04676_ _04677_ VGND VGND VPWR VPWR _04678_ sky130_fd_sc_hd__nor2_1
X_10972_ _01754_ _01780_ _01782_ VGND VGND VPWR VPWR _01783_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_58_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12711_ _03549_ _03550_ VGND VGND VPWR VPWR _03551_ sky130_fd_sc_hd__nand2_1
X_13691_ _04579_ _04586_ _04587_ VGND VGND VPWR VPWR _04602_ sky130_fd_sc_hd__nand3_1
Xmax_cap99 _04552_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__buf_1
X_12642_ net187 _03286_ _03448_ _03447_ VGND VGND VPWR VPWR _03481_ sky130_fd_sc_hd__a31o_1
X_15430_ _06513_ _06514_ VGND VGND VPWR VPWR _06515_ sky130_fd_sc_hd__xor2_2
XFILLER_0_66_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15361_ _06429_ _06437_ _06438_ VGND VGND VPWR VPWR _06439_ sky130_fd_sc_hd__a21oi_1
X_12573_ _03410_ _03411_ VGND VGND VPWR VPWR _03412_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_43_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17100_ _08350_ _08351_ VGND VGND VPWR VPWR _08352_ sky130_fd_sc_hd__or2b_2
XFILLER_0_92_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14312_ _05263_ _05283_ _05284_ VGND VGND VPWR VPWR _05285_ sky130_fd_sc_hd__a21oi_2
X_11524_ _02329_ _02334_ VGND VGND VPWR VPWR _02335_ sky130_fd_sc_hd__xnor2_1
X_15292_ _06337_ _06362_ VGND VGND VPWR VPWR _06363_ sky130_fd_sc_hd__and2_1
XFILLER_0_80_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14243_ _05206_ _05208_ VGND VGND VPWR VPWR _05210_ sky130_fd_sc_hd__nor2_2
X_17031_ _08274_ _08275_ VGND VGND VPWR VPWR _08276_ sky130_fd_sc_hd__nand2_1
X_11455_ _02240_ _02263_ _02265_ VGND VGND VPWR VPWR _02266_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_80_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10406_ _01214_ _01216_ VGND VGND VPWR VPWR _01217_ sky130_fd_sc_hd__nand2_1
XFILLER_0_123_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14174_ _05125_ _05131_ _05126_ VGND VGND VPWR VPWR _05134_ sky130_fd_sc_hd__nand3_2
X_11386_ _02194_ _02188_ _02192_ VGND VGND VPWR VPWR _02197_ sky130_fd_sc_hd__nor3_1
X_13125_ _03844_ _03865_ VGND VGND VPWR VPWR _03980_ sky130_fd_sc_hd__xor2_1
X_10337_ _01144_ _01147_ VGND VGND VPWR VPWR _01148_ sky130_fd_sc_hd__nand2_2
X_13056_ net198 _03249_ _03824_ VGND VGND VPWR VPWR _03904_ sky130_fd_sc_hd__a21oi_1
X_10268_ _01016_ _01017_ VGND VGND VPWR VPWR _01079_ sky130_fd_sc_hd__xor2_1
X_12007_ _02818_ _02813_ _02815_ VGND VGND VPWR VPWR _02822_ sky130_fd_sc_hd__or3_1
X_10199_ net367 _07387_ VGND VGND VPWR VPWR _01010_ sky130_fd_sc_hd__nand2_1
XFILLER_0_108_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16815_ _05303_ _08038_ VGND VGND VPWR VPWR _08039_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_17_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16746_ _07921_ _07962_ VGND VGND VPWR VPWR _07963_ sky130_fd_sc_hd__xnor2_4
X_13958_ _04891_ _04895_ VGND VGND VPWR VPWR _04896_ sky130_fd_sc_hd__xor2_2
XFILLER_0_124_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12909_ _03264_ net519 VGND VGND VPWR VPWR _03753_ sky130_fd_sc_hd__nor2_1
X_16677_ _05871_ _07886_ VGND VGND VPWR VPWR _07887_ sky130_fd_sc_hd__nor2_1
X_13889_ _04810_ _04819_ VGND VGND VPWR VPWR _04820_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15628_ _06646_ _06648_ VGND VGND VPWR VPWR _06733_ sky130_fd_sc_hd__nand2_1
XFILLER_0_124_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15559_ _06653_ _06656_ VGND VGND VPWR VPWR _06657_ sky130_fd_sc_hd__and2_1
XFILLER_0_90_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09080_ _06430_ _06914_ VGND VGND VPWR VPWR _06925_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_44_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17229_ net464 _08255_ _08453_ _08493_ VGND VGND VPWR VPWR _08494_ sky130_fd_sc_hd__nand4_2
Xinput40 reg_data[11] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput51 reg_data[5] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__buf_2
XFILLER_0_114_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput62 target[14] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput73 target[8] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_12_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09982_ net331 _00316_ _00372_ net328 VGND VGND VPWR VPWR _00793_ sky130_fd_sc_hd__a22o_1
XFILLER_0_12_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08933_ net358 VGND VGND VPWR VPWR _05308_ sky130_fd_sc_hd__inv_2
XFILLER_0_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08864_ net526 VGND VGND VPWR VPWR _04549_ sky130_fd_sc_hd__inv_2
X_08795_ net48 _02883_ _02916_ net165 VGND VGND VPWR VPWR _00028_ sky130_fd_sc_hd__a22o_1
XFILLER_0_74_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09416_ _00206_ _00226_ VGND VGND VPWR VPWR _00227_ sky130_fd_sc_hd__or2_1
XFILLER_0_137_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09347_ _08630_ _08629_ VGND VGND VPWR VPWR _00158_ sky130_fd_sc_hd__and2b_1
XFILLER_0_137_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09278_ _08631_ _08633_ _08641_ VGND VGND VPWR VPWR _08642_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_74_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11240_ _01960_ _02048_ _02049_ _02050_ VGND VGND VPWR VPWR _02051_ sky130_fd_sc_hd__o22a_1
XFILLER_0_132_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11171_ _01979_ _01981_ VGND VGND VPWR VPWR _01982_ sky130_fd_sc_hd__and2b_1
X_10122_ _00871_ _00869_ VGND VGND VPWR VPWR _00933_ sky130_fd_sc_hd__or2_1
X_14930_ _05962_ _05963_ VGND VGND VPWR VPWR _05965_ sky130_fd_sc_hd__nor2_1
X_10053_ _00862_ _00863_ VGND VGND VPWR VPWR _00864_ sky130_fd_sc_hd__xnor2_1
X_14861_ _05882_ _05887_ VGND VGND VPWR VPWR _05889_ sky130_fd_sc_hd__and2_1
X_16600_ _07792_ _07796_ _07798_ _07801_ VGND VGND VPWR VPWR _07802_ sky130_fd_sc_hd__a22o_1
X_13812_ _04403_ _04734_ VGND VGND VPWR VPWR _04735_ sky130_fd_sc_hd__xnor2_1
X_14792_ _05793_ _05796_ _05812_ VGND VGND VPWR VPWR _05813_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_97_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16531_ _07725_ VGND VGND VPWR VPWR _07726_ sky130_fd_sc_hd__buf_2
XFILLER_0_97_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13743_ _04584_ _04583_ VGND VGND VPWR VPWR _04660_ sky130_fd_sc_hd__and2b_1
X_10955_ _01760_ _01765_ VGND VGND VPWR VPWR _01766_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_51_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16462_ _06091_ _06191_ _07502_ _07503_ VGND VGND VPWR VPWR _07650_ sky130_fd_sc_hd__a31o_1
XFILLER_0_85_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13674_ net219 net216 _03577_ _03668_ VGND VGND VPWR VPWR _04584_ sky130_fd_sc_hd__and4_1
XFILLER_0_128_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10886_ _01695_ _01696_ VGND VGND VPWR VPWR _01697_ sky130_fd_sc_hd__and2_1
XFILLER_0_38_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15413_ _06494_ _06495_ VGND VGND VPWR VPWR _06497_ sky130_fd_sc_hd__xor2_1
X_12625_ _03374_ _03384_ _03382_ VGND VGND VPWR VPWR _03464_ sky130_fd_sc_hd__and3_1
X_16393_ _07572_ _07573_ VGND VGND VPWR VPWR _07575_ sky130_fd_sc_hd__nor2b_1
XFILLER_0_81_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15344_ net253 net250 _06205_ _06348_ VGND VGND VPWR VPWR _06421_ sky130_fd_sc_hd__and4_1
XFILLER_0_65_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12556_ _03388_ _03392_ _03394_ VGND VGND VPWR VPWR _03395_ sky130_fd_sc_hd__a21o_1
XFILLER_0_26_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11507_ _02316_ _02317_ VGND VGND VPWR VPWR _02318_ sky130_fd_sc_hd__and2b_1
XFILLER_0_13_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12487_ prev_error\[16\] _05638_ VGND VGND VPWR VPWR _03323_ sky130_fd_sc_hd__xnor2_2
X_15275_ _06341_ _06344_ VGND VGND VPWR VPWR _06345_ sky130_fd_sc_hd__nand2_1
X_17014_ _05372_ VGND VGND VPWR VPWR _08258_ sky130_fd_sc_hd__inv_2
X_11438_ _02237_ _02247_ _02248_ VGND VGND VPWR VPWR _02249_ sky130_fd_sc_hd__nand3_1
X_14226_ _03994_ _04095_ VGND VGND VPWR VPWR _05191_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_60_Left_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14157_ _05083_ _05100_ _05112_ _05113_ _05114_ VGND VGND VPWR VPWR _05115_ sky130_fd_sc_hd__a41o_1
XFILLER_0_22_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11369_ _02179_ VGND VGND VPWR VPWR _02180_ sky130_fd_sc_hd__inv_2
XFILLER_0_21_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13108_ net236 VGND VGND VPWR VPWR _03961_ sky130_fd_sc_hd__inv_2
XFILLER_0_119_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14088_ net218 net521 _05020_ VGND VGND VPWR VPWR _05039_ sky130_fd_sc_hd__a21oi_1
X_13039_ net224 _03336_ VGND VGND VPWR VPWR _03885_ sky130_fd_sc_hd__nand2_1
XFILLER_0_119_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16729_ _07675_ _07878_ VGND VGND VPWR VPWR _07944_ sky130_fd_sc_hd__and2b_1
XFILLER_0_49_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09201_ _07299_ _07563_ VGND VGND VPWR VPWR _08256_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09132_ net321 _04527_ _07486_ VGND VGND VPWR VPWR _07497_ sky130_fd_sc_hd__and3_1
XFILLER_0_17_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09063_ _06683_ _06727_ VGND VGND VPWR VPWR _06738_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09965_ _00681_ _00684_ VGND VGND VPWR VPWR _00776_ sky130_fd_sc_hd__xor2_1
X_08916_ net317 net313 _04527_ _04626_ VGND VGND VPWR VPWR _05121_ sky130_fd_sc_hd__and4_1
X_09896_ _00698_ _00705_ _00706_ VGND VGND VPWR VPWR _00707_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08847_ _04351_ VGND VGND VPWR VPWR _04362_ sky130_fd_sc_hd__inv_2
X_08778_ net49 _03553_ _03586_ net367 VGND VGND VPWR VPWR _00065_ sky130_fd_sc_hd__a22o_1
XFILLER_0_94_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10740_ _01473_ _01527_ _01549_ VGND VGND VPWR VPWR _01551_ sky130_fd_sc_hd__or3b_1
XFILLER_0_137_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10671_ net435 net439 net107 VGND VGND VPWR VPWR _01482_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_138_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12410_ _03186_ _03209_ _03240_ VGND VGND VPWR VPWR _03242_ sky130_fd_sc_hd__a21o_1
XFILLER_0_125_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclone21 _03177_ _05678_ _05625_ _03281_ _05718_ VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__a311o_1
X_13390_ _04269_ _04270_ VGND VGND VPWR VPWR _04271_ sky130_fd_sc_hd__and2_1
XFILLER_0_62_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12341_ _01858_ _03171_ _03172_ VGND VGND VPWR VPWR _03173_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_62_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15060_ _06096_ _06101_ _06106_ _06107_ _06065_ VGND VGND VPWR VPWR _06108_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_133_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12272_ _03103_ VGND VGND VPWR VPWR _03104_ sky130_fd_sc_hd__inv_2
X_14011_ _04894_ _04949_ _04953_ VGND VGND VPWR VPWR _04954_ sky130_fd_sc_hd__and3_1
XFILLER_0_31_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11223_ net436 net114 net111 net441 VGND VGND VPWR VPWR _02034_ sky130_fd_sc_hd__a22o_1
XFILLER_0_31_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11154_ _01459_ _01952_ _01950_ VGND VGND VPWR VPWR _01965_ sky130_fd_sc_hd__nor3_1
X_10105_ _00845_ _00848_ VGND VGND VPWR VPWR _00916_ sky130_fd_sc_hd__xor2_1
XFILLER_0_65_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15962_ _07093_ _07097_ _07099_ VGND VGND VPWR VPWR _07100_ sky130_fd_sc_hd__a21bo_1
X_11085_ _01891_ _01893_ _01895_ VGND VGND VPWR VPWR _01896_ sky130_fd_sc_hd__o21ai_1
X_14913_ net266 _05746_ _05944_ _05945_ VGND VGND VPWR VPWR _05947_ sky130_fd_sc_hd__nand4_4
X_10036_ net338 _00242_ _08676_ net343 VGND VGND VPWR VPWR _00847_ sky130_fd_sc_hd__a22o_1
X_15893_ _07004_ _07005_ VGND VGND VPWR VPWR _07025_ sky130_fd_sc_hd__nand2_1
X_14844_ _05870_ VGND VGND VPWR VPWR _05871_ sky130_fd_sc_hd__clkbuf_2
X_14775_ _05700_ _05705_ _05698_ VGND VGND VPWR VPWR _05795_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11987_ _02797_ _02798_ _02799_ VGND VGND VPWR VPWR _02800_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_105_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16514_ _07705_ _07707_ VGND VGND VPWR VPWR _07708_ sky130_fd_sc_hd__or2_1
X_13726_ _04558_ _04611_ _04640_ VGND VGND VPWR VPWR _04641_ sky130_fd_sc_hd__and3_1
X_17494_ clknet_4_6_0_clock _00037_ VGND VGND VPWR VPWR ki\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_105_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10938_ _01718_ _01730_ VGND VGND VPWR VPWR _01749_ sky130_fd_sc_hd__or2_1
XFILLER_0_27_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16445_ i_error\[2\] _07620_ VGND VGND VPWR VPWR _07632_ sky130_fd_sc_hd__and2_1
X_13657_ _04479_ _04480_ VGND VGND VPWR VPWR _04565_ sky130_fd_sc_hd__xor2_2
X_10869_ _01666_ _01624_ _01678_ VGND VGND VPWR VPWR _01680_ sky130_fd_sc_hd__nand3_1
XFILLER_0_6_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12608_ net193 _03342_ _03359_ VGND VGND VPWR VPWR _03447_ sky130_fd_sc_hd__and3_1
X_16376_ _05863_ _07554_ _07534_ VGND VGND VPWR VPWR _07556_ sky130_fd_sc_hd__or3_1
XFILLER_0_54_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13588_ net212 _03668_ VGND VGND VPWR VPWR _04489_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15327_ _06399_ _06400_ VGND VGND VPWR VPWR _06402_ sky130_fd_sc_hd__or2b_1
XFILLER_0_30_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12539_ net210 _03375_ _03372_ VGND VGND VPWR VPWR _03378_ sky130_fd_sc_hd__o21a_1
XFILLER_0_81_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15258_ _06324_ _06323_ VGND VGND VPWR VPWR _06326_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14209_ _04859_ _05166_ _05170_ _05171_ VGND VGND VPWR VPWR _05172_ sky130_fd_sc_hd__a31o_4
X_15189_ _06229_ _06246_ _06248_ VGND VGND VPWR VPWR _06250_ sky130_fd_sc_hd__and3_1
XFILLER_0_111_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout408 net409 VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__clkbuf_2
Xfanout419 prev_d_error\[7\] VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_10_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09750_ _00558_ _00560_ VGND VGND VPWR VPWR _00561_ sky130_fd_sc_hd__and2_1
X_08701_ net31 net30 _02806_ _02817_ VGND VGND VPWR VPWR _02828_ sky130_fd_sc_hd__or4_1
X_09681_ net369 _05011_ _00490_ _00491_ VGND VGND VPWR VPWR _00492_ sky130_fd_sc_hd__a31o_1
XFILLER_0_146_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09115_ _05143_ _05154_ VGND VGND VPWR VPWR _07310_ sky130_fd_sc_hd__and2_1
XFILLER_0_150_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09046_ _06309_ _06386_ _06540_ VGND VGND VPWR VPWR _06551_ sky130_fd_sc_hd__o21a_1
XFILLER_0_60_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_8_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09948_ _00744_ _00757_ _00713_ _00758_ VGND VGND VPWR VPWR _00759_ sky130_fd_sc_hd__a211o_1
X_09879_ _00672_ _00686_ _00688_ VGND VGND VPWR VPWR _00690_ sky130_fd_sc_hd__nor3_1
XFILLER_0_99_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11910_ _02681_ _02717_ _02716_ VGND VGND VPWR VPWR _02721_ sky130_fd_sc_hd__and3_1
X_12890_ _03721_ _03733_ VGND VGND VPWR VPWR _03734_ sky130_fd_sc_hd__nor2_1
X_11841_ _02578_ _02651_ VGND VGND VPWR VPWR _02652_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_68_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14560_ prev_error\[7\] _07915_ VGND VGND VPWR VPWR _05558_ sky130_fd_sc_hd__nor2_1
X_11772_ _02582_ _02577_ VGND VGND VPWR VPWR _02583_ sky130_fd_sc_hd__and2_1
XFILLER_0_138_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13511_ net227 _04403_ _03332_ _03333_ VGND VGND VPWR VPWR _04404_ sky130_fd_sc_hd__nand4_1
X_10723_ net406 net117 net113 net412 VGND VGND VPWR VPWR _01534_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_138_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14491_ _06463_ _06903_ _05481_ VGND VGND VPWR VPWR _05482_ sky130_fd_sc_hd__o21a_1
XFILLER_0_126_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16230_ _07349_ _07350_ VGND VGND VPWR VPWR _07395_ sky130_fd_sc_hd__nand2_1
X_13442_ net224 _03233_ _04326_ _04327_ VGND VGND VPWR VPWR _04328_ sky130_fd_sc_hd__and4_1
XFILLER_0_126_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10654_ _01464_ VGND VGND VPWR VPWR _01465_ sky130_fd_sc_hd__inv_2
XFILLER_0_119_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16161_ _07271_ _07306_ _07318_ VGND VGND VPWR VPWR _07319_ sky130_fd_sc_hd__and3_1
X_13373_ _04248_ _04251_ VGND VGND VPWR VPWR _04253_ sky130_fd_sc_hd__and2b_1
X_10585_ net379 _00373_ _01391_ _01393_ _01395_ VGND VGND VPWR VPWR _01396_ sky130_fd_sc_hd__a41o_1
XFILLER_0_134_872 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15112_ _05595_ _06162_ _06164_ VGND VGND VPWR VPWR _06165_ sky130_fd_sc_hd__or3b_1
X_12324_ _02399_ _03155_ VGND VGND VPWR VPWR _03156_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16092_ net290 _06204_ VGND VGND VPWR VPWR _07243_ sky130_fd_sc_hd__and2_1
XFILLER_0_133_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15043_ _05998_ _05999_ _05989_ _05993_ VGND VGND VPWR VPWR _06090_ sky130_fd_sc_hd__a211o_1
X_12255_ _03002_ _03037_ VGND VGND VPWR VPWR _03086_ sky130_fd_sc_hd__xnor2_1
X_11206_ _02010_ _02016_ VGND VGND VPWR VPWR _02017_ sky130_fd_sc_hd__xor2_1
X_12186_ _02992_ _02994_ VGND VGND VPWR VPWR _03011_ sky130_fd_sc_hd__xnor2_2
X_11137_ _01946_ _01947_ _01481_ VGND VGND VPWR VPWR _01948_ sky130_fd_sc_hd__mux2_1
X_16994_ _08231_ _08235_ VGND VGND VPWR VPWR _08236_ sky130_fd_sc_hd__and2b_1
X_15945_ _07080_ _07081_ VGND VGND VPWR VPWR _07082_ sky130_fd_sc_hd__xor2_1
X_11068_ _01804_ _01878_ VGND VGND VPWR VPWR _01879_ sky130_fd_sc_hd__nor2_1
XFILLER_0_92_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10019_ net357 _00828_ _07332_ _00829_ _00453_ VGND VGND VPWR VPWR _00830_ sky130_fd_sc_hd__a32o_1
X_15876_ _07004_ _07005_ VGND VGND VPWR VPWR _07006_ sky130_fd_sc_hd__xor2_1
XFILLER_0_116_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14827_ _05698_ _05700_ _05794_ VGND VGND VPWR VPWR _05852_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_25_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14758_ net524 _05584_ _05773_ _05774_ VGND VGND VPWR VPWR _05776_ sky130_fd_sc_hd__o22a_1
XFILLER_0_129_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13709_ net236 _03247_ _03243_ net232 VGND VGND VPWR VPWR _04622_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17477_ clknet_4_1_0_clock _00056_ VGND VGND VPWR VPWR kp\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_27_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14689_ net277 _05697_ _05699_ VGND VGND VPWR VPWR _05700_ sky130_fd_sc_hd__and3_1
XFILLER_0_129_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16428_ i_error\[4\] _07612_ VGND VGND VPWR VPWR _07613_ sky130_fd_sc_hd__xor2_2
XFILLER_0_132_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16359_ net261 _07535_ _05705_ VGND VGND VPWR VPWR _07537_ sky130_fd_sc_hd__and3_1
XFILLER_0_42_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout205 kd_1\[10\] VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__buf_2
Xfanout216 net217 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__clkbuf_4
X_09802_ net369 _04879_ _04890_ _04747_ net364 VGND VGND VPWR VPWR _00613_ sky130_fd_sc_hd__a32oi_4
Xfanout227 net228 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__clkbuf_4
Xfanout238 kd_1\[2\] VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__clkbuf_4
Xfanout249 net250 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_5_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09733_ _00452_ _00539_ _00543_ VGND VGND VPWR VPWR _00544_ sky130_fd_sc_hd__nand3_2
X_09664_ _00471_ _00474_ VGND VGND VPWR VPWR _00475_ sky130_fd_sc_hd__and2b_1
XFILLER_0_69_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09595_ _00400_ _00405_ VGND VGND VPWR VPWR _00406_ sky130_fd_sc_hd__xor2_1
XFILLER_0_49_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_149_Right_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10370_ _01171_ _01178_ _01180_ VGND VGND VPWR VPWR _01181_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_115_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09029_ _06353_ VGND VGND VPWR VPWR _06364_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_131_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12040_ _02856_ _02857_ VGND VGND VPWR VPWR _02858_ sky130_fd_sc_hd__nor2_1
X_13991_ _04924_ _04929_ VGND VGND VPWR VPWR _04932_ sky130_fd_sc_hd__nand2_1
X_15730_ _06601_ _06844_ VGND VGND VPWR VPWR _06845_ sky130_fd_sc_hd__or2_1
X_12942_ _03753_ _03755_ VGND VGND VPWR VPWR _03786_ sky130_fd_sc_hd__xor2_1
X_15661_ _06493_ _06767_ _06492_ VGND VGND VPWR VPWR _06769_ sky130_fd_sc_hd__or3b_4
X_12873_ _03629_ _03716_ VGND VGND VPWR VPWR _03717_ sky130_fd_sc_hd__or2_1
XFILLER_0_99_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17400_ clknet_4_11_0_clock _00078_ VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dfxtp_1
X_14612_ net103 net522 _05571_ VGND VGND VPWR VPWR _05615_ sky130_fd_sc_hd__nand3_2
X_11824_ _02608_ _02634_ VGND VGND VPWR VPWR _02635_ sky130_fd_sc_hd__or2_1
X_15592_ net264 _06205_ _06349_ net260 VGND VGND VPWR VPWR _06693_ sky130_fd_sc_hd__a22o_1
XFILLER_0_28_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17331_ _08564_ _08122_ _08565_ net452 VGND VGND VPWR VPWR _00112_ sky130_fd_sc_hd__o211a_1
X_14543_ _05533_ _05538_ VGND VGND VPWR VPWR _05540_ sky130_fd_sc_hd__xnor2_2
X_11755_ _02563_ _02565_ VGND VGND VPWR VPWR _02566_ sky130_fd_sc_hd__or2_1
XFILLER_0_55_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17262_ _08461_ _08494_ _08491_ VGND VGND VPWR VPWR _08520_ sky130_fd_sc_hd__a21oi_1
X_10706_ _01511_ _01516_ VGND VGND VPWR VPWR _01517_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_138_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14474_ _05434_ net96 _05463_ VGND VGND VPWR VPWR _05464_ sky130_fd_sc_hd__and3b_1
XFILLER_0_83_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11686_ net431 net135 net119 net448 VGND VGND VPWR VPWR _02497_ sky130_fd_sc_hd__a22o_1
XFILLER_0_125_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16213_ _07372_ net100 VGND VGND VPWR VPWR _07377_ sky130_fd_sc_hd__nor2_1
X_13425_ prev_error\[0\] _00652_ VGND VGND VPWR VPWR _04310_ sky130_fd_sc_hd__nand2_4
X_10637_ _00268_ _01446_ _01445_ VGND VGND VPWR VPWR _01448_ sky130_fd_sc_hd__o21ba_1
X_17193_ _08061_ _08253_ VGND VGND VPWR VPWR _08455_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_106_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16144_ _07297_ _07300_ VGND VGND VPWR VPWR _07301_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_122_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10568_ _01246_ _01378_ VGND VGND VPWR VPWR _01379_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_116_Right_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13356_ _04170_ _04173_ _04172_ VGND VGND VPWR VPWR _04234_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_12_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12307_ _03135_ _03137_ VGND VGND VPWR VPWR _03139_ sky130_fd_sc_hd__and2_1
X_16075_ _07220_ _07221_ _07224_ VGND VGND VPWR VPWR _07225_ sky130_fd_sc_hd__a21oi_1
X_10499_ _01307_ _01309_ VGND VGND VPWR VPWR _01310_ sky130_fd_sc_hd__nand2_1
X_13287_ _04156_ _04157_ VGND VGND VPWR VPWR _04158_ sky130_fd_sc_hd__nor2_1
X_15026_ _06066_ _06070_ _06065_ VGND VGND VPWR VPWR _06071_ sky130_fd_sc_hd__o21a_1
X_12238_ _03058_ _03055_ VGND VGND VPWR VPWR _03067_ sky130_fd_sc_hd__nor2_1
X_12169_ _02993_ _02988_ VGND VGND VPWR VPWR _02994_ sky130_fd_sc_hd__xor2_2
XFILLER_0_127_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16977_ net485 _08216_ VGND VGND VPWR VPWR _08217_ sky130_fd_sc_hd__or2b_1
Xinput5 measurement[12] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
X_15928_ net290 _05975_ VGND VGND VPWR VPWR _07063_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15859_ net291 _05665_ VGND VGND VPWR VPWR _06987_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09380_ _06276_ _00186_ VGND VGND VPWR VPWR _00191_ sky130_fd_sc_hd__xor2_2
XFILLER_0_143_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17529_ clknet_4_7_0_clock _00035_ VGND VGND VPWR VPWR kd_2\[9\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09716_ _00511_ _00524_ _00526_ VGND VGND VPWR VPWR _00527_ sky130_fd_sc_hd__a21oi_2
XPHY_EDGE_ROW_98_Left_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09647_ _00388_ _00391_ VGND VGND VPWR VPWR _00458_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_78_840 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09578_ net353 _04439_ VGND VGND VPWR VPWR _00389_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11540_ _02279_ _02278_ VGND VGND VPWR VPWR _02351_ sky130_fd_sc_hd__and2b_1
XFILLER_0_18_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11471_ _02137_ _02281_ VGND VGND VPWR VPWR _02282_ sky130_fd_sc_hd__nor2_1
XFILLER_0_123_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10422_ _01221_ _01231_ _01232_ VGND VGND VPWR VPWR _01233_ sky130_fd_sc_hd__nor3_2
X_13210_ _03332_ _03333_ VGND VGND VPWR VPWR _04073_ sky130_fd_sc_hd__nand2_1
X_14190_ _05149_ _05150_ VGND VGND VPWR VPWR _05151_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10353_ net362 _08675_ VGND VGND VPWR VPWR _01164_ sky130_fd_sc_hd__nand2_1
X_13141_ net183 _03793_ VGND VGND VPWR VPWR _03997_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13072_ _03794_ _03920_ VGND VGND VPWR VPWR _03921_ sky130_fd_sc_hd__xnor2_1
X_10284_ _01093_ _01094_ VGND VGND VPWR VPWR _01095_ sky130_fd_sc_hd__or2_1
X_16900_ _08127_ _08131_ VGND VGND VPWR VPWR _08132_ sky130_fd_sc_hd__and2b_1
X_12023_ _02835_ _02837_ _02838_ VGND VGND VPWR VPWR _02840_ sky130_fd_sc_hd__nand3_1
X_16831_ _08050_ _08054_ VGND VGND VPWR VPWR _08056_ sky130_fd_sc_hd__and2_1
X_16762_ _07837_ _07975_ VGND VGND VPWR VPWR _07980_ sky130_fd_sc_hd__or2_1
X_13974_ _04882_ _04911_ _04913_ VGND VGND VPWR VPWR _04914_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_88_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15713_ _06543_ _06810_ _06825_ VGND VGND VPWR VPWR _06827_ sky130_fd_sc_hd__and3_4
X_12925_ _03768_ _03740_ VGND VGND VPWR VPWR _03769_ sky130_fd_sc_hd__xnor2_1
X_16693_ _07902_ _07903_ VGND VGND VPWR VPWR _07905_ sky130_fd_sc_hd__or2b_1
X_15644_ _06719_ _06711_ VGND VGND VPWR VPWR _06751_ sky130_fd_sc_hd__or2b_1
X_12856_ _03425_ _03696_ VGND VGND VPWR VPWR _03700_ sky130_fd_sc_hd__xor2_1
XFILLER_0_56_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11807_ _02613_ _02609_ _02611_ VGND VGND VPWR VPWR _02618_ sky130_fd_sc_hd__or3_1
X_15575_ _06673_ _06674_ VGND VGND VPWR VPWR _06675_ sky130_fd_sc_hd__or2_1
XFILLER_0_22_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12787_ _03530_ _03532_ VGND VGND VPWR VPWR _03631_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_113_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17314_ net461 prev_error\[15\] VGND VGND VPWR VPWR _08555_ sky130_fd_sc_hd__or2_1
X_14526_ _01457_ _05421_ _05422_ _05424_ VGND VGND VPWR VPWR _05521_ sky130_fd_sc_hd__nor4_4
XFILLER_0_126_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11738_ net392 net174 _02547_ _02548_ VGND VGND VPWR VPWR _02549_ sky130_fd_sc_hd__a31o_1
XFILLER_0_113_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17245_ _08506_ _08507_ net453 VGND VGND VPWR VPWR _00076_ sky130_fd_sc_hd__o21a_1
X_14457_ _05443_ _05444_ VGND VGND VPWR VPWR _05445_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11669_ _02453_ _02478_ _02479_ VGND VGND VPWR VPWR _02480_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_4_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13408_ _04191_ _04190_ VGND VGND VPWR VPWR _04291_ sky130_fd_sc_hd__xor2_1
X_17176_ _08424_ _08435_ VGND VGND VPWR VPWR _08436_ sky130_fd_sc_hd__xnor2_1
X_14388_ _05358_ _05368_ VGND VGND VPWR VPWR _05369_ sky130_fd_sc_hd__xor2_1
XFILLER_0_12_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16127_ _07250_ _07258_ _07260_ VGND VGND VPWR VPWR _07282_ sky130_fd_sc_hd__nand3_1
X_13339_ _04203_ _04211_ _04213_ VGND VGND VPWR VPWR _04215_ sky130_fd_sc_hd__nand3_1
XFILLER_0_51_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16058_ _07204_ _07205_ VGND VGND VPWR VPWR _07206_ sky130_fd_sc_hd__nor2_1
XFILLER_0_110_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15009_ _06051_ VGND VGND VPWR VPWR _06052_ sky130_fd_sc_hd__inv_2
XFILLER_0_20_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08880_ _04703_ _04714_ VGND VGND VPWR VPWR _04725_ sky130_fd_sc_hd__and2b_1
X_09501_ _00311_ _04120_ VGND VGND VPWR VPWR _00312_ sky130_fd_sc_hd__nor2_2
X_09432_ _00242_ VGND VGND VPWR VPWR _00243_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_149_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09363_ _00171_ _00173_ VGND VGND VPWR VPWR _00174_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09294_ _08535_ _08654_ _08657_ VGND VGND VPWR VPWR _08658_ sky130_fd_sc_hd__o21a_1
XFILLER_0_47_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_10 net524 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_21 _02839_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_32 _07926_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_34_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10971_ _01613_ _01781_ VGND VGND VPWR VPWR _01782_ sky130_fd_sc_hd__or2_1
X_12710_ _03548_ _03533_ VGND VGND VPWR VPWR _03550_ sky130_fd_sc_hd__or2b_1
XFILLER_0_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13690_ _04597_ _04600_ _04595_ VGND VGND VPWR VPWR _04601_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12641_ _03404_ _03407_ _03405_ VGND VGND VPWR VPWR _03480_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_38_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15360_ _06436_ _06435_ VGND VGND VPWR VPWR _06438_ sky130_fd_sc_hd__and2b_1
XFILLER_0_136_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12572_ _03277_ _03301_ _03299_ VGND VGND VPWR VPWR _03411_ sky130_fd_sc_hd__a21o_1
XFILLER_0_93_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14311_ _05261_ _05262_ VGND VGND VPWR VPWR _05284_ sky130_fd_sc_hd__and2_1
XFILLER_0_53_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11523_ net136 _02330_ _02331_ _02333_ VGND VGND VPWR VPWR _02334_ sky130_fd_sc_hd__o2bb2a_1
X_15291_ _06317_ _06335_ _06336_ VGND VGND VPWR VPWR _06362_ sky130_fd_sc_hd__or3_1
XFILLER_0_108_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17030_ _08260_ _08261_ _08273_ VGND VGND VPWR VPWR _08275_ sky130_fd_sc_hd__nand3_1
XFILLER_0_34_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14242_ _03171_ _05207_ VGND VGND VPWR VPWR _05208_ sky130_fd_sc_hd__xnor2_1
X_11454_ _02170_ _02264_ VGND VGND VPWR VPWR _02265_ sky130_fd_sc_hd__or2_1
XFILLER_0_34_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10405_ net375 _08680_ _01214_ _01215_ VGND VGND VPWR VPWR _01216_ sky130_fd_sc_hd__nand4_2
X_14173_ _05125_ _05126_ _05131_ VGND VGND VPWR VPWR _05133_ sky130_fd_sc_hd__a21o_1
X_11385_ _02156_ _02154_ VGND VGND VPWR VPWR _02196_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_150_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13124_ _03951_ _03973_ _03978_ VGND VGND VPWR VPWR _03979_ sky130_fd_sc_hd__o21ba_1
X_10336_ _01144_ _01145_ _01146_ VGND VGND VPWR VPWR _01147_ sky130_fd_sc_hd__nand3_2
X_10267_ _01027_ _01029_ _01028_ VGND VGND VPWR VPWR _01078_ sky130_fd_sc_hd__a21oi_1
X_13055_ net198 _03261_ _03902_ VGND VGND VPWR VPWR _03903_ sky130_fd_sc_hd__and3_1
X_12006_ _02820_ _02790_ VGND VGND VPWR VPWR _02821_ sky130_fd_sc_hd__xnor2_1
X_10198_ _01007_ _01008_ VGND VGND VPWR VPWR _01009_ sky130_fd_sc_hd__xor2_1
XFILLER_0_17_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16814_ _05199_ _05304_ VGND VGND VPWR VPWR _08038_ sky130_fd_sc_hd__nor2_2
X_16745_ _07922_ _07961_ VGND VGND VPWR VPWR _07962_ sky130_fd_sc_hd__xnor2_4
X_13957_ _04892_ _04894_ VGND VGND VPWR VPWR _04895_ sky130_fd_sc_hd__nand2_1
XFILLER_0_88_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12908_ _03751_ VGND VGND VPWR VPWR _03752_ sky130_fd_sc_hd__buf_1
X_16676_ _07685_ _07885_ VGND VGND VPWR VPWR _07886_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13888_ _04810_ _04815_ _04817_ _04818_ VGND VGND VPWR VPWR _04819_ sky130_fd_sc_hd__and4b_1
XFILLER_0_124_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15627_ _06663_ _06679_ VGND VGND VPWR VPWR _06732_ sky130_fd_sc_hd__nand2_1
X_12839_ _03614_ _03653_ _03682_ VGND VGND VPWR VPWR _03683_ sky130_fd_sc_hd__o21a_1
XFILLER_0_146_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15558_ _06654_ _06655_ VGND VGND VPWR VPWR _06656_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_29_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14509_ _05500_ _05499_ VGND VGND VPWR VPWR _05502_ sky130_fd_sc_hd__or2b_1
XFILLER_0_142_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15489_ _06576_ _06578_ _06579_ VGND VGND VPWR VPWR _06580_ sky130_fd_sc_hd__and3_4
X_17228_ _08455_ _08457_ _08458_ _08492_ VGND VGND VPWR VPWR _08493_ sky130_fd_sc_hd__and4_1
Xinput30 reg_addr[2] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_140_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput41 reg_data[12] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_4_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput52 reg_data[6] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__buf_2
XFILLER_0_142_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput63 target[15] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput74 target[9] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__clkbuf_1
X_17159_ _08412_ _08416_ VGND VGND VPWR VPWR _08417_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09981_ _00791_ _00643_ VGND VGND VPWR VPWR _00792_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08932_ _05110_ _05286_ VGND VGND VPWR VPWR _05297_ sky130_fd_sc_hd__nor2_1
XFILLER_0_110_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08863_ net313 _04527_ VGND VGND VPWR VPWR _04538_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08794_ net47 _02883_ _02916_ net169 VGND VGND VPWR VPWR _00027_ sky130_fd_sc_hd__a22o_1
XFILLER_0_74_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09415_ _00205_ _00192_ _00204_ VGND VGND VPWR VPWR _00226_ sky130_fd_sc_hd__nor3_1
XFILLER_0_48_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09346_ net322 _07343_ VGND VGND VPWR VPWR _00157_ sky130_fd_sc_hd__nand2_1
XFILLER_0_90_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09277_ _08639_ _08640_ VGND VGND VPWR VPWR _08641_ sky130_fd_sc_hd__and2_1
XFILLER_0_63_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_868 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11170_ _01876_ _01980_ VGND VGND VPWR VPWR _01981_ sky130_fd_sc_hd__nor2_1
X_10121_ _00888_ _00887_ _00858_ VGND VGND VPWR VPWR _00932_ sky130_fd_sc_hd__a21oi_1
X_10052_ net357 _07332_ VGND VGND VPWR VPWR _00863_ sky130_fd_sc_hd__nand2_1
X_14860_ _05882_ _05887_ VGND VGND VPWR VPWR _05888_ sky130_fd_sc_hd__nor2_1
X_13811_ net225 _03576_ VGND VGND VPWR VPWR _04734_ sky130_fd_sc_hd__nand2_1
X_14791_ _05805_ _05811_ VGND VGND VPWR VPWR _05812_ sky130_fd_sc_hd__xnor2_1
X_16530_ _05553_ _05554_ _05520_ _07723_ VGND VGND VPWR VPWR _07725_ sky130_fd_sc_hd__o22a_2
X_13742_ net212 _03751_ VGND VGND VPWR VPWR _04658_ sky130_fd_sc_hd__nand2_1
X_10954_ _01755_ _01757_ _01759_ VGND VGND VPWR VPWR _01765_ sky130_fd_sc_hd__or3_1
XFILLER_0_85_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16461_ _07583_ _07598_ _07647_ _07648_ VGND VGND VPWR VPWR _07649_ sky130_fd_sc_hd__a31o_1
X_13673_ net219 _03577_ _04581_ VGND VGND VPWR VPWR _04583_ sky130_fd_sc_hd__a21bo_1
X_10885_ _01505_ _01694_ VGND VGND VPWR VPWR _01696_ sky130_fd_sc_hd__or2_1
XFILLER_0_39_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15412_ _06390_ _06391_ VGND VGND VPWR VPWR _06495_ sky130_fd_sc_hd__xor2_1
X_12624_ _03462_ VGND VGND VPWR VPWR _03463_ sky130_fd_sc_hd__inv_2
X_16392_ _06191_ _07502_ _07503_ _07571_ VGND VGND VPWR VPWR _07573_ sky130_fd_sc_hd__a211o_1
XFILLER_0_54_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15343_ net253 _06205_ _06348_ net250 VGND VGND VPWR VPWR _06420_ sky130_fd_sc_hd__a22o_1
X_12555_ _03341_ _03393_ VGND VGND VPWR VPWR _03394_ sky130_fd_sc_hd__or2_1
X_11506_ net431 net126 net111 net449 VGND VGND VPWR VPWR _02317_ sky130_fd_sc_hd__a22o_1
X_15274_ _06209_ _06343_ VGND VGND VPWR VPWR _06344_ sky130_fd_sc_hd__and2_1
X_12486_ _03321_ VGND VGND VPWR VPWR _03322_ sky130_fd_sc_hd__buf_2
X_17013_ _03489_ _05378_ _05376_ VGND VGND VPWR VPWR _08257_ sky130_fd_sc_hd__a21o_1
XFILLER_0_124_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14225_ _04193_ _05188_ _05189_ VGND VGND VPWR VPWR _05190_ sky130_fd_sc_hd__a21o_2
XFILLER_0_80_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11437_ _02236_ _02226_ _02234_ VGND VGND VPWR VPWR _02248_ sky130_fd_sc_hd__nand3_1
XFILLER_0_21_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14156_ _05049_ _05113_ VGND VGND VPWR VPWR _05114_ sky130_fd_sc_hd__nor2_1
X_11368_ _02143_ _02178_ VGND VGND VPWR VPWR _02179_ sky130_fd_sc_hd__xor2_2
X_13107_ _03429_ _03959_ VGND VGND VPWR VPWR _03960_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10319_ _01127_ _01129_ VGND VGND VPWR VPWR _01130_ sky130_fd_sc_hd__xor2_2
X_14087_ _05037_ VGND VGND VPWR VPWR _05038_ sky130_fd_sc_hd__inv_2
X_11299_ _02107_ _02109_ VGND VGND VPWR VPWR _02110_ sky130_fd_sc_hd__nand2_1
X_13038_ net245 _03345_ net501 net225 VGND VGND VPWR VPWR _03884_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_119_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14989_ net288 _05692_ _05703_ _05688_ VGND VGND VPWR VPWR _06030_ sky130_fd_sc_hd__a31o_1
XFILLER_0_44_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16728_ _07879_ _07895_ _07942_ VGND VGND VPWR VPWR _07943_ sky130_fd_sc_hd__a21o_1
XFILLER_0_88_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16659_ net524 _05739_ VGND VGND VPWR VPWR _07867_ sky130_fd_sc_hd__or2_1
X_09200_ _08113_ _08234_ VGND VGND VPWR VPWR _08245_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09131_ _07464_ _07475_ VGND VGND VPWR VPWR _07486_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09062_ _06694_ _06716_ VGND VGND VPWR VPWR _06727_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09964_ _00749_ _00755_ VGND VGND VPWR VPWR _00775_ sky130_fd_sc_hd__or2b_1
XFILLER_0_0_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08915_ _04670_ _05099_ VGND VGND VPWR VPWR _05110_ sky130_fd_sc_hd__xnor2_1
X_09895_ _00702_ _00704_ VGND VGND VPWR VPWR _00706_ sky130_fd_sc_hd__and2_1
X_08846_ _03977_ _04340_ VGND VGND VPWR VPWR _04351_ sky130_fd_sc_hd__nand2_2
X_08777_ net48 _03553_ _03586_ net372 VGND VGND VPWR VPWR _00064_ sky130_fd_sc_hd__a22o_1
XFILLER_0_138_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10670_ net445 net107 VGND VGND VPWR VPWR _01481_ sky130_fd_sc_hd__nand2_2
X_09329_ net348 _05022_ _05649_ net352 VGND VGND VPWR VPWR _08693_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_63_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12340_ _01853_ _01857_ _01785_ _01789_ VGND VGND VPWR VPWR _03172_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_23_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12271_ _02936_ _02934_ VGND VGND VPWR VPWR _03103_ sky130_fd_sc_hd__and2b_1
XFILLER_0_31_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14010_ net239 _03666_ _04952_ _04950_ VGND VGND VPWR VPWR _04953_ sky130_fd_sc_hd__a31o_1
XFILLER_0_120_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11222_ net436 net439 net114 net110 VGND VGND VPWR VPWR _02033_ sky130_fd_sc_hd__and4_1
XFILLER_0_120_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11153_ _01958_ _01963_ VGND VGND VPWR VPWR _01964_ sky130_fd_sc_hd__xnor2_1
X_10104_ _00905_ _00913_ _00914_ VGND VGND VPWR VPWR _00915_ sky130_fd_sc_hd__o21ai_2
X_15961_ _07020_ _07098_ VGND VGND VPWR VPWR _07099_ sky130_fd_sc_hd__or2b_1
X_11084_ _01835_ _01894_ VGND VGND VPWR VPWR _01895_ sky130_fd_sc_hd__nor2_1
X_14912_ net270 _05631_ _05736_ net276 VGND VGND VPWR VPWR _05945_ sky130_fd_sc_hd__a22o_1
X_10035_ net343 net338 _00242_ _08676_ VGND VGND VPWR VPWR _00846_ sky130_fd_sc_hd__nand4_1
X_15892_ _07014_ _07018_ _07019_ _07022_ VGND VGND VPWR VPWR _07023_ sky130_fd_sc_hd__a22oi_2
X_14843_ _05793_ _05852_ VGND VGND VPWR VPWR _05870_ sky130_fd_sc_hd__and2_1
X_14774_ _05696_ _05791_ VGND VGND VPWR VPWR _05794_ sky130_fd_sc_hd__xor2_2
XFILLER_0_98_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11986_ net416 net420 net158 net163 VGND VGND VPWR VPWR _02799_ sky130_fd_sc_hd__and4_1
X_16513_ _07704_ _07555_ _07660_ VGND VGND VPWR VPWR _07707_ sky130_fd_sc_hd__nor3_1
XFILLER_0_58_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13725_ _04635_ _04639_ VGND VGND VPWR VPWR _04640_ sky130_fd_sc_hd__or2_1
X_17493_ clknet_4_6_0_clock _00053_ VGND VGND VPWR VPWR ki\[9\] sky130_fd_sc_hd__dfxtp_1
X_10937_ _01745_ _01746_ _01738_ _01742_ VGND VGND VPWR VPWR _01748_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_14_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16444_ _07626_ _07628_ _07630_ VGND VGND VPWR VPWR _07631_ sky130_fd_sc_hd__a21o_1
XFILLER_0_128_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13656_ _04521_ _04522_ _04532_ VGND VGND VPWR VPWR _04564_ sky130_fd_sc_hd__a21bo_2
X_10868_ _01666_ _01624_ _01678_ VGND VGND VPWR VPWR _01679_ sky130_fd_sc_hd__a21o_1
XFILLER_0_144_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12607_ net193 _03342_ _03359_ VGND VGND VPWR VPWR _03446_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_27_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16375_ _05863_ _07534_ _07554_ VGND VGND VPWR VPWR _07555_ sky130_fd_sc_hd__o21a_1
XFILLER_0_109_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13587_ net216 _03577_ VGND VGND VPWR VPWR _04488_ sky130_fd_sc_hd__nand2_1
XFILLER_0_137_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10799_ _01592_ _01609_ VGND VGND VPWR VPWR _01610_ sky130_fd_sc_hd__xor2_1
XFILLER_0_121_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15326_ _06399_ _06400_ VGND VGND VPWR VPWR _06401_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_121_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12538_ _03371_ _03376_ VGND VGND VPWR VPWR _03377_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15257_ _06323_ _06324_ VGND VGND VPWR VPWR _06325_ sky130_fd_sc_hd__and2b_1
X_12469_ _03257_ _03276_ _03302_ VGND VGND VPWR VPWR _03303_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_1_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14208_ _05167_ _05168_ _05169_ VGND VGND VPWR VPWR _05171_ sky130_fd_sc_hd__nor3_1
XFILLER_0_111_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15188_ _06229_ _06246_ _06248_ VGND VGND VPWR VPWR _06249_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_50_882 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14139_ _05068_ _05094_ VGND VGND VPWR VPWR _05095_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout409 prev_d_error\[10\] VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__clkbuf_2
X_08700_ net24 net23 net26 net25 VGND VGND VPWR VPWR _02817_ sky130_fd_sc_hd__or4_1
X_09680_ net526 _00489_ VGND VGND VPWR VPWR _00491_ sky130_fd_sc_hd__and2_1
XFILLER_0_55_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09114_ _05209_ _05264_ VGND VGND VPWR VPWR _07299_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_44_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09045_ _06397_ _06529_ VGND VGND VPWR VPWR _06540_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09947_ _00709_ _00712_ _00711_ VGND VGND VPWR VPWR _00758_ sky130_fd_sc_hd__a21oi_1
X_09878_ _00672_ _00686_ _00688_ VGND VGND VPWR VPWR _00689_ sky130_fd_sc_hd__o21a_1
XFILLER_0_99_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08829_ _04142_ _04153_ VGND VGND VPWR VPWR _04164_ sky130_fd_sc_hd__and2_1
X_11840_ _02580_ _02579_ VGND VGND VPWR VPWR _02651_ sky130_fd_sc_hd__nor2_1
X_11771_ _02571_ _02573_ _02576_ VGND VGND VPWR VPWR _02582_ sky130_fd_sc_hd__or3_1
X_13510_ _03229_ _03231_ _04195_ VGND VGND VPWR VPWR _04403_ sky130_fd_sc_hd__a21oi_2
X_10722_ net406 net412 net117 net113 VGND VGND VPWR VPWR _01533_ sky130_fd_sc_hd__and4_1
X_14490_ _05477_ _05480_ VGND VGND VPWR VPWR _05481_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_48_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13441_ net227 _03216_ _03326_ net246 VGND VGND VPWR VPWR _04327_ sky130_fd_sc_hd__a22o_1
XFILLER_0_82_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10653_ net425 _01462_ _01463_ VGND VGND VPWR VPWR _01464_ sky130_fd_sc_hd__a21o_1
XFILLER_0_24_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16160_ _07307_ _07308_ _07317_ _07316_ _07311_ VGND VGND VPWR VPWR _07318_ sky130_fd_sc_hd__a32o_1
X_13372_ _04248_ _04249_ _04250_ VGND VGND VPWR VPWR _04251_ sky130_fd_sc_hd__or3_2
XFILLER_0_134_840 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10584_ _00373_ _01391_ _01394_ _01350_ VGND VGND VPWR VPWR _01395_ sky130_fd_sc_hd__o211a_1
X_15111_ _06014_ _06159_ _06163_ VGND VGND VPWR VPWR _06164_ sky130_fd_sc_hd__o21a_1
XFILLER_0_140_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12323_ _02398_ _02393_ _02397_ VGND VGND VPWR VPWR _03155_ sky130_fd_sc_hd__or3_1
X_16091_ net311 _05597_ _05600_ _07241_ VGND VGND VPWR VPWR _07242_ sky130_fd_sc_hd__nand4_1
XFILLER_0_106_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15042_ _06086_ _06087_ VGND VGND VPWR VPWR _06088_ sky130_fd_sc_hd__nor2_1
X_12254_ _03066_ _03070_ _03084_ VGND VGND VPWR VPWR _03085_ sky130_fd_sc_hd__or3_1
XFILLER_0_121_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11205_ _02014_ _02015_ VGND VGND VPWR VPWR _02016_ sky130_fd_sc_hd__nand2_1
X_12185_ _03005_ _03009_ VGND VGND VPWR VPWR _03010_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_118_Left_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11136_ net111 _01458_ VGND VGND VPWR VPWR _01947_ sky130_fd_sc_hd__and2_1
X_16993_ _08012_ _08233_ _08033_ VGND VGND VPWR VPWR _08235_ sky130_fd_sc_hd__mux2_1
X_15944_ _06998_ _06999_ VGND VGND VPWR VPWR _07081_ sky130_fd_sc_hd__xnor2_1
X_11067_ net402 net130 _01802_ _01803_ VGND VGND VPWR VPWR _01878_ sky130_fd_sc_hd__o2bb2a_1
X_10018_ net378 _04604_ VGND VGND VPWR VPWR _00829_ sky130_fd_sc_hd__and2_1
X_15875_ _06906_ _06908_ VGND VGND VPWR VPWR _07005_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14826_ _05848_ _05849_ _05850_ VGND VGND VPWR VPWR _05851_ sky130_fd_sc_hd__o21a_1
XFILLER_0_98_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14757_ net524 _05584_ _05773_ _05774_ VGND VGND VPWR VPWR _05775_ sky130_fd_sc_hd__nor4_1
X_11969_ _02705_ _02755_ _02778_ VGND VGND VPWR VPWR _02780_ sky130_fd_sc_hd__or3_1
X_13708_ net233 _03247_ _04620_ VGND VGND VPWR VPWR _04621_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_127_Left_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17476_ clknet_4_1_0_clock _00055_ VGND VGND VPWR VPWR kp\[10\] sky130_fd_sc_hd__dfxtp_2
X_14688_ net284 net281 _05698_ VGND VGND VPWR VPWR _05699_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_132_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16427_ _07609_ _07611_ VGND VGND VPWR VPWR _07612_ sky130_fd_sc_hd__xor2_2
X_13639_ net243 _03216_ _04543_ _04544_ VGND VGND VPWR VPWR _04545_ sky130_fd_sc_hd__a31o_1
XFILLER_0_26_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16358_ net261 _05705_ _07535_ VGND VGND VPWR VPWR _07536_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_15_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15309_ _06367_ _06368_ _06381_ VGND VGND VPWR VPWR _06382_ sky130_fd_sc_hd__a21o_1
X_16289_ _07457_ _07451_ _07455_ VGND VGND VPWR VPWR _07460_ sky130_fd_sc_hd__and3_1
XFILLER_0_140_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_136_Left_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout206 net209 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__clkbuf_4
X_09801_ _00611_ _00490_ VGND VGND VPWR VPWR _00612_ sky130_fd_sc_hd__xnor2_1
Xfanout217 kd_1\[7\] VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout228 net229 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_5_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout239 net240 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_66_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09732_ _00541_ _00542_ VGND VGND VPWR VPWR _00543_ sky130_fd_sc_hd__or2b_1
X_09663_ net333 _07937_ _00472_ _00473_ VGND VGND VPWR VPWR _00474_ sky130_fd_sc_hd__a31o_1
X_09594_ net333 _07420_ _00404_ _00402_ VGND VGND VPWR VPWR _00405_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_145_Left_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09028_ _06309_ _06342_ VGND VGND VPWR VPWR _06353_ sky130_fd_sc_hd__or2_1
XFILLER_0_142_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13990_ net221 net215 net521 _04107_ VGND VGND VPWR VPWR _04931_ sky130_fd_sc_hd__and4_1
XFILLER_0_99_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12941_ net186 _03578_ _03784_ VGND VGND VPWR VPWR _03785_ sky130_fd_sc_hd__and3_1
X_15660_ _06493_ _06767_ _06492_ VGND VGND VPWR VPWR _06768_ sky130_fd_sc_hd__o21bai_2
X_12872_ _03463_ _03628_ VGND VGND VPWR VPWR _03716_ sky130_fd_sc_hd__and2_1
X_14611_ _05613_ VGND VGND VPWR VPWR _05614_ sky130_fd_sc_hd__inv_2
X_11823_ _02630_ _02633_ VGND VGND VPWR VPWR _02634_ sky130_fd_sc_hd__nor2_1
X_15591_ net264 net260 _06206_ _06349_ VGND VGND VPWR VPWR _06692_ sky130_fd_sc_hd__nand4_2
XFILLER_0_68_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17330_ net463 i_error\[4\] VGND VGND VPWR VPWR _08565_ sky130_fd_sc_hd__or2_1
X_14542_ _05534_ _05537_ VGND VGND VPWR VPWR _05538_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_95_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11754_ _02562_ _02564_ VGND VGND VPWR VPWR _02565_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17261_ _08498_ net77 VGND VGND VPWR VPWR _08519_ sky130_fd_sc_hd__and2_1
X_10705_ _01512_ _01515_ VGND VGND VPWR VPWR _01516_ sky130_fd_sc_hd__xnor2_1
X_14473_ _05459_ _05461_ VGND VGND VPWR VPWR _05463_ sky130_fd_sc_hd__xor2_4
XFILLER_0_71_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11685_ net431 net448 net135 net119 VGND VGND VPWR VPWR _02496_ sky130_fd_sc_hd__and4_1
X_16212_ _07373_ _07372_ _07374_ VGND VGND VPWR VPWR _07375_ sky130_fd_sc_hd__nor3_1
X_13424_ _04308_ VGND VGND VPWR VPWR _04309_ sky130_fd_sc_hd__inv_2
X_10636_ _01445_ _01446_ VGND VGND VPWR VPWR _01447_ sky130_fd_sc_hd__nor2_2
X_17192_ _08375_ _08452_ VGND VGND VPWR VPWR _08453_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_11_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16143_ _07256_ _07298_ VGND VGND VPWR VPWR _07300_ sky130_fd_sc_hd__nor2_1
X_13355_ _04163_ _04177_ VGND VGND VPWR VPWR _04233_ sky130_fd_sc_hd__xnor2_1
X_10567_ _01375_ _01377_ VGND VGND VPWR VPWR _01378_ sky130_fd_sc_hd__xnor2_1
X_12306_ _03131_ _03132_ _03135_ _03137_ VGND VGND VPWR VPWR _03138_ sky130_fd_sc_hd__o22a_1
XFILLER_0_133_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16074_ _07166_ _07223_ VGND VGND VPWR VPWR _07224_ sky130_fd_sc_hd__or2_1
X_13286_ _04135_ _04152_ _04155_ VGND VGND VPWR VPWR _04157_ sky130_fd_sc_hd__and3_1
X_10498_ _01225_ _01255_ _01308_ VGND VGND VPWR VPWR _01309_ sky130_fd_sc_hd__o21a_1
XFILLER_0_121_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15025_ _05692_ _06069_ VGND VGND VPWR VPWR _06070_ sky130_fd_sc_hd__xor2_1
X_12237_ _03041_ _03059_ VGND VGND VPWR VPWR _03066_ sky130_fd_sc_hd__xor2_1
XFILLER_0_121_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12168_ _02953_ _02974_ VGND VGND VPWR VPWR _02993_ sky130_fd_sc_hd__nand2_1
X_11119_ _01906_ _01907_ VGND VGND VPWR VPWR _01930_ sky130_fd_sc_hd__and2_1
X_16976_ _08209_ _08214_ VGND VGND VPWR VPWR _08216_ sky130_fd_sc_hd__xnor2_1
X_12099_ _02886_ _02888_ _02921_ VGND VGND VPWR VPWR _02923_ sky130_fd_sc_hd__or3_1
Xinput6 measurement[13] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
X_15927_ _07054_ _07055_ _07061_ VGND VGND VPWR VPWR _07062_ sky130_fd_sc_hd__a21o_1
XFILLER_0_36_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15858_ _06979_ _06981_ _06985_ VGND VGND VPWR VPWR _06986_ sky130_fd_sc_hd__a21o_1
XFILLER_0_143_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14809_ _05830_ _05831_ VGND VGND VPWR VPWR _05832_ sky130_fd_sc_hd__nand2_1
X_15789_ _06899_ _06902_ VGND VGND VPWR VPWR _06910_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_52_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17528_ clknet_4_6_0_clock _00034_ VGND VGND VPWR VPWR kd_2\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_86_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17459_ clknet_4_15_0_clock _00137_ VGND VGND VPWR VPWR prev_d_error\[11\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09715_ _00379_ _00525_ VGND VGND VPWR VPWR _00526_ sky130_fd_sc_hd__or2_1
X_09646_ _00454_ _00455_ _00456_ VGND VGND VPWR VPWR _00457_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_96_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09577_ net344 _04527_ VGND VGND VPWR VPWR _00388_ sky130_fd_sc_hd__nand2_1
XFILLER_0_148_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11470_ _01561_ net171 _02135_ _02136_ VGND VGND VPWR VPWR _02281_ sky130_fd_sc_hd__o22a_1
XFILLER_0_80_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10421_ _01204_ _01205_ _01220_ VGND VGND VPWR VPWR _01232_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_123_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13140_ _03940_ _03929_ VGND VGND VPWR VPWR _03996_ sky130_fd_sc_hd__xor2_1
X_10352_ _01110_ _01162_ VGND VGND VPWR VPWR _01163_ sky130_fd_sc_hd__or2_1
XFILLER_0_131_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13071_ _03796_ _03795_ VGND VGND VPWR VPWR _03920_ sky130_fd_sc_hd__and2b_1
XFILLER_0_20_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10283_ _01079_ _01090_ VGND VGND VPWR VPWR _01094_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_130_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12022_ _02834_ _02827_ _02832_ VGND VGND VPWR VPWR _02838_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16830_ _08050_ _08054_ VGND VGND VPWR VPWR _08055_ sky130_fd_sc_hd__xor2_1
X_16761_ net528 _07977_ _07978_ _07846_ VGND VGND VPWR VPWR _07979_ sky130_fd_sc_hd__o22ai_2
X_13973_ _04906_ _04910_ _04850_ _04883_ VGND VGND VPWR VPWR _04913_ sky130_fd_sc_hd__o211a_1
X_15712_ _06817_ _06823_ _06824_ VGND VGND VPWR VPWR _06825_ sky130_fd_sc_hd__a21o_1
X_12924_ _03652_ _03694_ VGND VGND VPWR VPWR _03768_ sky130_fd_sc_hd__nor2_1
X_16692_ _07901_ _07705_ _07861_ VGND VGND VPWR VPWR _07903_ sky130_fd_sc_hd__or3_1
X_15643_ _06665_ _06677_ _06676_ VGND VGND VPWR VPWR _06750_ sky130_fd_sc_hd__o21bai_2
X_12855_ _03696_ _03698_ VGND VGND VPWR VPWR _03699_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11806_ _02573_ _02616_ VGND VGND VPWR VPWR _02617_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15574_ _06670_ _06671_ VGND VGND VPWR VPWR _06674_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12786_ _03426_ _03629_ VGND VGND VPWR VPWR _03630_ sky130_fd_sc_hd__nor2_1
X_17313_ _08549_ _04934_ _08553_ net450 VGND VGND VPWR VPWR _00104_ sky130_fd_sc_hd__o211a_1
X_14525_ _05469_ _05519_ VGND VGND VPWR VPWR _05520_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_56_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11737_ net396 net400 net167 net170 VGND VGND VPWR VPWR _02548_ sky130_fd_sc_hd__and4_1
XFILLER_0_138_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17244_ net494 _08495_ _08475_ VGND VGND VPWR VPWR _08507_ sky130_fd_sc_hd__a21oi_2
X_14456_ _01422_ _01107_ VGND VGND VPWR VPWR _05444_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_4_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11668_ _02473_ _02477_ _02364_ _02454_ VGND VGND VPWR VPWR _02479_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_37_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13407_ _04287_ _04289_ VGND VGND VPWR VPWR _04290_ sky130_fd_sc_hd__nand2_1
X_10619_ _00816_ _00896_ _01427_ _01429_ VGND VGND VPWR VPWR _01430_ sky130_fd_sc_hd__a31o_4
X_17175_ _08426_ _08434_ VGND VGND VPWR VPWR _08435_ sky130_fd_sc_hd__xnor2_1
X_14387_ _05359_ _05367_ VGND VGND VPWR VPWR _05368_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_107_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11599_ net414 net148 VGND VGND VPWR VPWR _02410_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16126_ _07279_ _07280_ VGND VGND VPWR VPWR _07281_ sky130_fd_sc_hd__or2b_1
X_13338_ _04203_ _04211_ _04213_ VGND VGND VPWR VPWR _04214_ sky130_fd_sc_hd__a21o_1
XFILLER_0_122_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16057_ net283 _06347_ VGND VGND VPWR VPWR _07205_ sky130_fd_sc_hd__nand2_1
X_13269_ _04136_ _04137_ VGND VGND VPWR VPWR _04138_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15008_ _06050_ _06049_ VGND VGND VPWR VPWR _06051_ sky130_fd_sc_hd__xor2_2
XFILLER_0_138_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16959_ _05221_ _05299_ _08196_ VGND VGND VPWR VPWR _08197_ sky130_fd_sc_hd__and3_1
XFILLER_0_2_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09500_ net68 net13 VGND VGND VPWR VPWR _00311_ sky130_fd_sc_hd__and2b_1
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09431_ _00241_ VGND VGND VPWR VPWR _00242_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_94_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09362_ _00168_ _00170_ VGND VGND VPWR VPWR _00173_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09293_ _08655_ _08656_ VGND VGND VPWR VPWR _08657_ sky130_fd_sc_hd__or2b_1
XANTENNA_11 _05605_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_22 _03229_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_33 _08175_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_145_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_879 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10970_ _01610_ _01612_ VGND VGND VPWR VPWR _01781_ sky130_fd_sc_hd__nor2_1
X_09629_ _00424_ _00438_ _00439_ VGND VGND VPWR VPWR _00440_ sky130_fd_sc_hd__a21o_1
XFILLER_0_97_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12640_ _03409_ _03402_ VGND VGND VPWR VPWR _03479_ sky130_fd_sc_hd__and2b_1
XFILLER_0_77_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12571_ _03402_ _03409_ VGND VGND VPWR VPWR _03410_ sky130_fd_sc_hd__xor2_1
XFILLER_0_148_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14310_ _05267_ _05281_ _05282_ VGND VGND VPWR VPWR _05283_ sky130_fd_sc_hd__o21ai_2
X_11522_ net135 _02330_ _02332_ VGND VGND VPWR VPWR _02333_ sky130_fd_sc_hd__a21bo_1
X_15290_ _06345_ _06358_ _06360_ VGND VGND VPWR VPWR _06361_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14241_ _01858_ _03172_ VGND VGND VPWR VPWR _05207_ sky130_fd_sc_hd__or2_1
X_11453_ _02167_ _02169_ VGND VGND VPWR VPWR _02264_ sky130_fd_sc_hd__nor2_1
XFILLER_0_135_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10404_ net366 _00241_ _08674_ net371 VGND VGND VPWR VPWR _01215_ sky130_fd_sc_hd__a22o_1
X_14172_ _05128_ _05130_ VGND VGND VPWR VPWR _05131_ sky130_fd_sc_hd__xor2_2
X_11384_ _02188_ _02192_ _02194_ VGND VGND VPWR VPWR _02195_ sky130_fd_sc_hd__o21a_1
XFILLER_0_150_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13123_ _03975_ _03976_ VGND VGND VPWR VPWR _03978_ sky130_fd_sc_hd__nor2_1
X_10335_ _01086_ _01138_ _01143_ VGND VGND VPWR VPWR _01146_ sky130_fd_sc_hd__a21o_1
X_13054_ _03899_ _03901_ VGND VGND VPWR VPWR _03902_ sky130_fd_sc_hd__nor2_1
X_10266_ _01027_ _01028_ _01029_ VGND VGND VPWR VPWR _01077_ sky130_fd_sc_hd__and3_1
X_12005_ _02791_ _02789_ VGND VGND VPWR VPWR _02820_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10197_ _00937_ _00935_ VGND VGND VPWR VPWR _01008_ sky130_fd_sc_hd__and2b_1
X_16813_ _01457_ _08035_ VGND VGND VPWR VPWR _08037_ sky130_fd_sc_hd__xnor2_2
X_16744_ _07925_ _07960_ VGND VGND VPWR VPWR _07961_ sky130_fd_sc_hd__xnor2_2
X_13956_ net239 _03576_ _04892_ _04893_ VGND VGND VPWR VPWR _04894_ sky130_fd_sc_hd__nand4_1
X_12907_ _03750_ VGND VGND VPWR VPWR _03751_ sky130_fd_sc_hd__clkbuf_4
X_16675_ _07881_ _07884_ VGND VGND VPWR VPWR _07885_ sky130_fd_sc_hd__xnor2_1
X_13887_ _04768_ _04805_ _04809_ VGND VGND VPWR VPWR _04818_ sky130_fd_sc_hd__a21o_1
XFILLER_0_33_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15626_ _06644_ _06662_ VGND VGND VPWR VPWR _06731_ sky130_fd_sc_hd__or2b_1
X_12838_ _03680_ _03681_ VGND VGND VPWR VPWR _03682_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12769_ _03551_ _03561_ VGND VGND VPWR VPWR _03613_ sky130_fd_sc_hd__xor2_2
X_15557_ _06428_ _06427_ VGND VGND VPWR VPWR _06655_ sky130_fd_sc_hd__and2b_1
XFILLER_0_84_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14508_ _05499_ _05500_ VGND VGND VPWR VPWR _05501_ sky130_fd_sc_hd__or2b_1
X_15488_ _06572_ _06575_ _06567_ VGND VGND VPWR VPWR _06579_ sky130_fd_sc_hd__a21o_1
XFILLER_0_126_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17227_ _08466_ _08488_ _08490_ _08491_ _08459_ VGND VGND VPWR VPWR _08492_ sky130_fd_sc_hd__a41o_1
Xinput20 reg_addr[0] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_1
X_14439_ _00451_ _00544_ _01433_ VGND VGND VPWR VPWR _05425_ sky130_fd_sc_hd__and3_1
XFILLER_0_25_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput31 reg_addr[3] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_1
Xinput42 reg_data[13] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_25_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput53 reg_data[7] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__buf_2
XFILLER_0_12_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput64 target[16] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput75 write_enable VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__clkbuf_1
X_17158_ _08414_ _08415_ VGND VGND VPWR VPWR _08416_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16109_ _07185_ _07186_ net306 _05664_ VGND VGND VPWR VPWR _07262_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_141_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09980_ net331 _00372_ VGND VGND VPWR VPWR _00791_ sky130_fd_sc_hd__nand2_1
X_17089_ _01486_ _08339_ VGND VGND VPWR VPWR _08340_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_149_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08931_ _05209_ _05264_ _05275_ VGND VGND VPWR VPWR _05286_ sky130_fd_sc_hd__o21a_1
XFILLER_0_0_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08862_ _04516_ VGND VGND VPWR VPWR _04527_ sky130_fd_sc_hd__clkbuf_4
X_08793_ net38 _02894_ _02927_ net173 VGND VGND VPWR VPWR _00018_ sky130_fd_sc_hd__a22o_1
XFILLER_0_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09414_ _00223_ _00224_ VGND VGND VPWR VPWR _00225_ sky130_fd_sc_hd__or2_1
XFILLER_0_137_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09345_ _00150_ _00155_ VGND VGND VPWR VPWR _00156_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_48_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09276_ _08631_ _08633_ VGND VGND VPWR VPWR _08640_ sky130_fd_sc_hd__xor2_1
XFILLER_0_16_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10120_ _00888_ _00858_ _00887_ VGND VGND VPWR VPWR _00931_ sky130_fd_sc_hd__and3_1
XFILLER_0_101_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10051_ _00829_ _00453_ _00828_ VGND VGND VPWR VPWR _00862_ sky130_fd_sc_hd__a21boi_1
X_13810_ _04663_ _04732_ VGND VGND VPWR VPWR _04733_ sky130_fd_sc_hd__xnor2_1
X_14790_ _05809_ _05810_ VGND VGND VPWR VPWR _05811_ sky130_fd_sc_hd__or2_1
X_13741_ net224 _03577_ _04656_ _04655_ VGND VGND VPWR VPWR _04657_ sky130_fd_sc_hd__a31o_1
X_10953_ _01562_ net151 _01763_ VGND VGND VPWR VPWR _01764_ sky130_fd_sc_hd__nor3_1
XFILLER_0_97_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16460_ i_error\[12\] _07575_ VGND VGND VPWR VPWR _07648_ sky130_fd_sc_hd__xnor2_2
X_13672_ net216 _03667_ VGND VGND VPWR VPWR _04581_ sky130_fd_sc_hd__nand2_1
X_10884_ _01505_ _01694_ VGND VGND VPWR VPWR _01695_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15411_ _06491_ _06492_ _06493_ VGND VGND VPWR VPWR _06494_ sky130_fd_sc_hd__a21o_1
XFILLER_0_109_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12623_ _03426_ _03432_ VGND VGND VPWR VPWR _03462_ sky130_fd_sc_hd__nor2_1
X_16391_ _07571_ _07503_ _07502_ _06191_ VGND VGND VPWR VPWR _07572_ sky130_fd_sc_hd__o211a_1
XFILLER_0_54_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15342_ _05593_ _06417_ VGND VGND VPWR VPWR _06418_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12554_ net198 _03337_ _03339_ VGND VGND VPWR VPWR _03393_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_80_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11505_ net430 net449 net126 net111 VGND VGND VPWR VPWR _02316_ sky130_fd_sc_hd__and4_1
XFILLER_0_124_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15273_ _05595_ _06206_ _06208_ VGND VGND VPWR VPWR _06343_ sky130_fd_sc_hd__o21ai_1
X_12485_ _03320_ VGND VGND VPWR VPWR _03321_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_124_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17012_ _08048_ _08254_ VGND VGND VPWR VPWR _08255_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_123_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14224_ _04189_ _04192_ _04097_ VGND VGND VPWR VPWR _05189_ sky130_fd_sc_hd__a21oi_1
X_11436_ _02242_ _02246_ VGND VGND VPWR VPWR _02247_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14155_ _05075_ _05098_ _05084_ VGND VGND VPWR VPWR _05113_ sky130_fd_sc_hd__or3_1
XFILLER_0_1_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11367_ _02176_ _02177_ VGND VGND VPWR VPWR _02178_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13106_ _03853_ _03852_ VGND VGND VPWR VPWR _03959_ sky130_fd_sc_hd__and2b_1
X_10318_ _00996_ _01128_ VGND VGND VPWR VPWR _01129_ sky130_fd_sc_hd__xnor2_4
X_14086_ _05030_ _05035_ _05036_ VGND VGND VPWR VPWR _05037_ sky130_fd_sc_hd__o21a_1
X_11298_ _02010_ _02108_ VGND VGND VPWR VPWR _02109_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13037_ _03876_ _03875_ VGND VGND VPWR VPWR _03883_ sky130_fd_sc_hd__xor2_1
X_10249_ _00994_ _01059_ VGND VGND VPWR VPWR _01060_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14988_ _06028_ _05922_ VGND VGND VPWR VPWR _06029_ sky130_fd_sc_hd__xor2_2
XFILLER_0_89_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16727_ _07880_ _07894_ VGND VGND VPWR VPWR _07942_ sky130_fd_sc_hd__and2b_1
X_13939_ net218 _03935_ _04874_ VGND VGND VPWR VPWR _04875_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_135_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16658_ _07665_ _07666_ _07667_ VGND VGND VPWR VPWR _07866_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_147_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15609_ _06339_ _06603_ VGND VGND VPWR VPWR _06712_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16589_ _07776_ _07781_ _07784_ _07788_ _07789_ VGND VGND VPWR VPWR _07790_ sky130_fd_sc_hd__o221ai_1
XFILLER_0_8_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09130_ net325 _04450_ _04780_ net329 VGND VGND VPWR VPWR _07475_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_57_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09061_ _06705_ _06056_ net313 VGND VGND VPWR VPWR _06716_ sky130_fd_sc_hd__or3b_1
XFILLER_0_4_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09963_ _00751_ _00754_ VGND VGND VPWR VPWR _00774_ sky130_fd_sc_hd__nand2_1
X_08914_ _05077_ _05088_ VGND VGND VPWR VPWR _05099_ sky130_fd_sc_hd__nor2_1
X_09894_ _00702_ _00704_ VGND VGND VPWR VPWR _00705_ sky130_fd_sc_hd__or2_1
X_08845_ _03999_ VGND VGND VPWR VPWR _04340_ sky130_fd_sc_hd__inv_2
X_08776_ net47 _03553_ _03586_ net376 VGND VGND VPWR VPWR _00063_ sky130_fd_sc_hd__a22o_1
XFILLER_0_67_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09328_ net352 net348 _05011_ _05649_ VGND VGND VPWR VPWR _08692_ sky130_fd_sc_hd__and4_1
XFILLER_0_47_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclone34 _07968_ VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__clkbuf_2
X_09259_ _08610_ _08622_ VGND VGND VPWR VPWR _08623_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_133_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12270_ _02970_ _03036_ _03063_ _03101_ VGND VGND VPWR VPWR _03102_ sky130_fd_sc_hd__a22o_1
X_11221_ _01950_ _02031_ VGND VGND VPWR VPWR _02032_ sky130_fd_sc_hd__or2_1
X_11152_ _01959_ _01961_ _01962_ VGND VGND VPWR VPWR _01963_ sky130_fd_sc_hd__o21ba_1
X_10103_ _00842_ _00850_ VGND VGND VPWR VPWR _00914_ sky130_fd_sc_hd__xor2_1
X_15960_ _07093_ _07097_ VGND VGND VPWR VPWR _07098_ sky130_fd_sc_hd__xor2_1
X_11083_ _01562_ net155 _01834_ VGND VGND VPWR VPWR _01894_ sky130_fd_sc_hd__o21a_1
X_14911_ net276 net270 _05631_ _05738_ VGND VGND VPWR VPWR _05944_ sky130_fd_sc_hd__nand4_2
X_10034_ net334 _00316_ VGND VGND VPWR VPWR _00845_ sky130_fd_sc_hd__nand2_1
X_15891_ _06871_ _07020_ _07021_ VGND VGND VPWR VPWR _07022_ sky130_fd_sc_hd__o21a_1
X_14842_ _05800_ _05804_ _05867_ VGND VGND VPWR VPWR _05868_ sky130_fd_sc_hd__a21bo_1
X_14773_ _05696_ _05791_ VGND VGND VPWR VPWR _05793_ sky130_fd_sc_hd__nand2_1
X_11985_ net420 net158 net163 net416 VGND VGND VPWR VPWR _02798_ sky130_fd_sc_hd__a22oi_1
X_16512_ _07555_ _07660_ _07704_ VGND VGND VPWR VPWR _07705_ sky130_fd_sc_hd__o21a_1
X_13724_ _04635_ _04636_ _04638_ VGND VGND VPWR VPWR _04639_ sky130_fd_sc_hd__nor3_2
X_10936_ _01738_ _01742_ _01745_ _01746_ VGND VGND VPWR VPWR _01747_ sky130_fd_sc_hd__o211a_1
X_17492_ clknet_4_6_0_clock _00052_ VGND VGND VPWR VPWR ki\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_128_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16443_ i_error\[1\] _07627_ VGND VGND VPWR VPWR _07630_ sky130_fd_sc_hd__and2_1
XFILLER_0_129_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13655_ _04534_ _04561_ _04562_ VGND VGND VPWR VPWR _04563_ sky130_fd_sc_hd__a21oi_4
X_10867_ _01676_ _01677_ VGND VGND VPWR VPWR _01678_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12606_ net186 _03286_ VGND VGND VPWR VPWR _03445_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16374_ _05866_ _07553_ VGND VGND VPWR VPWR _07554_ sky130_fd_sc_hd__xor2_1
X_13586_ net219 _03269_ VGND VGND VPWR VPWR _04487_ sky130_fd_sc_hd__nand2_1
X_10798_ _01607_ _01608_ VGND VGND VPWR VPWR _01609_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15325_ _06252_ _06286_ VGND VGND VPWR VPWR _06400_ sky130_fd_sc_hd__xor2_2
X_12537_ _03372_ _03375_ VGND VGND VPWR VPWR _03376_ sky130_fd_sc_hd__nand2_1
XFILLER_0_136_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12468_ _03277_ _03301_ VGND VGND VPWR VPWR _03302_ sky130_fd_sc_hd__xnor2_1
X_15256_ _06233_ _06236_ VGND VGND VPWR VPWR _06324_ sky130_fd_sc_hd__xor2_1
XFILLER_0_124_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14207_ _05167_ _05168_ _05169_ VGND VGND VPWR VPWR _05170_ sky130_fd_sc_hd__o21ai_4
X_11419_ net430 kd_2\[13\] _02229_ VGND VGND VPWR VPWR _02230_ sky130_fd_sc_hd__and3_1
X_15187_ _06171_ _06247_ VGND VGND VPWR VPWR _06248_ sky130_fd_sc_hd__nand2_1
X_12399_ _03183_ _03212_ _03230_ VGND VGND VPWR VPWR _03231_ sky130_fd_sc_hd__a21o_2
XFILLER_0_10_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14138_ _05065_ _05067_ VGND VGND VPWR VPWR _05094_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14069_ _05016_ _05017_ VGND VGND VPWR VPWR _05018_ sky130_fd_sc_hd__and2_1
XFILLER_0_146_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_146_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09113_ _06364_ _07277_ _06309_ VGND VGND VPWR VPWR _07288_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_95_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09044_ _06419_ _06518_ VGND VGND VPWR VPWR _06529_ sky130_fd_sc_hd__xor2_1
XFILLER_0_44_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09946_ _00745_ _00756_ VGND VGND VPWR VPWR _00757_ sky130_fd_sc_hd__nand2_1
X_09877_ _00566_ _00687_ VGND VGND VPWR VPWR _00688_ sky130_fd_sc_hd__and2_1
X_08828_ net16 net71 VGND VGND VPWR VPWR _04153_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08759_ net53 _03318_ _03351_ net283 VGND VGND VPWR VPWR _00051_ sky130_fd_sc_hd__a22o_1
X_11770_ _02578_ _02579_ _02580_ VGND VGND VPWR VPWR _02581_ sky130_fd_sc_hd__o21ba_1
X_10721_ _01466_ _01530_ _01531_ VGND VGND VPWR VPWR _01532_ sky130_fd_sc_hd__a21oi_1
X_13440_ net245 net228 _03216_ _03327_ VGND VGND VPWR VPWR _04326_ sky130_fd_sc_hd__nand4_1
X_10652_ net427 net107 _01462_ VGND VGND VPWR VPWR _01463_ sky130_fd_sc_hd__a21oi_1
X_13371_ _04174_ _04234_ _04247_ VGND VGND VPWR VPWR _04250_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_118_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10583_ net371 _00557_ _01376_ _00654_ net379 VGND VGND VPWR VPWR _01394_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_36_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15110_ net252 _05975_ _06017_ net249 VGND VGND VPWR VPWR _06163_ sky130_fd_sc_hd__a22o_1
X_12322_ _02568_ _03151_ _03153_ VGND VGND VPWR VPWR _03154_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16090_ net294 _06160_ VGND VGND VPWR VPWR _07241_ sky130_fd_sc_hd__and2_2
X_15041_ _06005_ _06083_ VGND VGND VPWR VPWR _06087_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_32_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12253_ _03077_ _03080_ _03082_ VGND VGND VPWR VPWR _03084_ sky130_fd_sc_hd__a21o_1
X_11204_ _02011_ _02013_ VGND VGND VPWR VPWR _02015_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12184_ _03006_ _03007_ _03008_ VGND VGND VPWR VPWR _03009_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_102_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11135_ net435 net110 net107 net439 VGND VGND VPWR VPWR _01946_ sky130_fd_sc_hd__a22oi_1
X_16992_ _07742_ _08232_ _07971_ VGND VGND VPWR VPWR _08233_ sky130_fd_sc_hd__mux2_1
X_15943_ net290 _05975_ _07066_ _07065_ VGND VGND VPWR VPWR _07080_ sky130_fd_sc_hd__a31o_1
X_11066_ _01874_ _01876_ VGND VGND VPWR VPWR _01877_ sky130_fd_sc_hd__nor2_1
X_10017_ net378 _04879_ _04890_ _00827_ VGND VGND VPWR VPWR _00828_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15874_ net290 _05665_ _06989_ _07003_ VGND VGND VPWR VPWR _07004_ sky130_fd_sc_hd__a31o_1
X_14825_ _05841_ _05843_ VGND VGND VPWR VPWR _05850_ sky130_fd_sc_hd__nand2_2
X_14756_ net248 _05622_ _05746_ net251 VGND VGND VPWR VPWR _05774_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_58_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11968_ _02705_ _02755_ _02778_ VGND VGND VPWR VPWR _02779_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_128_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13707_ net236 _03241_ _03242_ VGND VGND VPWR VPWR _04620_ sky130_fd_sc_hd__and3_1
X_17475_ clknet_4_1_0_clock _00071_ VGND VGND VPWR VPWR kp\[9\] sky130_fd_sc_hd__dfxtp_1
X_10919_ _01524_ _01729_ _01466_ VGND VGND VPWR VPWR _01730_ sky130_fd_sc_hd__o21ai_1
X_14687_ net284 net281 _05691_ VGND VGND VPWR VPWR _05698_ sky130_fd_sc_hd__and3_2
XFILLER_0_41_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11899_ _02708_ _02709_ VGND VGND VPWR VPWR _02710_ sky130_fd_sc_hd__or2b_1
XFILLER_0_128_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16426_ _06895_ _07610_ VGND VGND VPWR VPWR _07611_ sky130_fd_sc_hd__nand2_1
X_13638_ net236 net234 _03232_ _03248_ VGND VGND VPWR VPWR _04544_ sky130_fd_sc_hd__and4_1
XFILLER_0_41_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16357_ net258 _05711_ VGND VGND VPWR VPWR _07535_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13569_ _04465_ _04466_ _04408_ _04467_ VGND VGND VPWR VPWR _04468_ sky130_fd_sc_hd__or4_1
XFILLER_0_82_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15308_ _06377_ _06379_ _06380_ VGND VGND VPWR VPWR _06381_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_125_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16288_ _07447_ _07458_ VGND VGND VPWR VPWR _07459_ sky130_fd_sc_hd__nor2_1
XFILLER_0_42_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15239_ _06302_ _06304_ VGND VGND VPWR VPWR _06305_ sky130_fd_sc_hd__nor2_1
XFILLER_0_140_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09800_ net369 _05000_ VGND VGND VPWR VPWR _00611_ sky130_fd_sc_hd__nand2_1
Xfanout207 net208 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__buf_2
Xfanout218 net221 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__clkbuf_4
Xfanout229 kd_1\[4\] VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__clkbuf_2
X_09731_ _00527_ _00534_ _00532_ VGND VGND VPWR VPWR _00542_ sky130_fd_sc_hd__a21o_1
X_09662_ net337 _07398_ _00401_ VGND VGND VPWR VPWR _00473_ sky130_fd_sc_hd__and3_1
X_09593_ _00402_ _00403_ VGND VGND VPWR VPWR _00404_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09027_ _06298_ _06331_ VGND VGND VPWR VPWR _06342_ sky130_fd_sc_hd__and2_2
XFILLER_0_131_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09929_ net357 _04615_ _00737_ _00738_ VGND VGND VPWR VPWR _00740_ sky130_fd_sc_hd__a22oi_2
XPHY_EDGE_ROW_130_Right_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12940_ _03780_ _03781_ _03783_ VGND VGND VPWR VPWR _03784_ sky130_fd_sc_hd__o21a_1
X_12871_ _03712_ _03714_ VGND VGND VPWR VPWR _03715_ sky130_fd_sc_hd__nand2_1
X_14610_ prev_error\[6\] _08680_ net103 _05574_ VGND VGND VPWR VPWR _05613_ sky130_fd_sc_hd__a31o_1
XFILLER_0_68_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11822_ _02630_ _02631_ _02601_ _02632_ VGND VGND VPWR VPWR _02633_ sky130_fd_sc_hd__and4bb_1
X_15590_ _06689_ _06690_ VGND VGND VPWR VPWR _06691_ sky130_fd_sc_hd__nor2_1
X_14541_ _05535_ _05536_ VGND VGND VPWR VPWR _05537_ sky130_fd_sc_hd__nor2_1
X_11753_ _02561_ _02543_ _02558_ VGND VGND VPWR VPWR _02564_ sky130_fd_sc_hd__nand3_1
XFILLER_0_138_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10704_ _01513_ _01514_ VGND VGND VPWR VPWR _01515_ sky130_fd_sc_hd__nor2_1
X_17260_ _08517_ _08518_ net453 VGND VGND VPWR VPWR _00081_ sky130_fd_sc_hd__o21a_1
X_14472_ _00639_ _00727_ _01430_ _05460_ VGND VGND VPWR VPWR _05461_ sky130_fd_sc_hd__a31o_1
X_11684_ _02491_ _02494_ VGND VGND VPWR VPWR _02495_ sky130_fd_sc_hd__and2b_1
XFILLER_0_126_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16211_ _07370_ _07371_ _07362_ _07369_ VGND VGND VPWR VPWR _07374_ sky130_fd_sc_hd__a211oi_2
X_10635_ _00182_ _01444_ _01443_ VGND VGND VPWR VPWR _01446_ sky130_fd_sc_hd__o21a_1
X_13423_ _04300_ _04304_ _04306_ VGND VGND VPWR VPWR _04308_ sky130_fd_sc_hd__nor3_1
XFILLER_0_119_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17191_ _08449_ _08451_ VGND VGND VPWR VPWR _08452_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_102_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16142_ net279 _04313_ _07254_ VGND VGND VPWR VPWR _07298_ sky130_fd_sc_hd__a21oi_1
X_13354_ _04216_ _04231_ VGND VGND VPWR VPWR _04232_ sky130_fd_sc_hd__xor2_2
X_10566_ net371 _00653_ _01376_ VGND VGND VPWR VPWR _01377_ sky130_fd_sc_hd__and3_1
XFILLER_0_24_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12305_ _03111_ _03136_ _03128_ VGND VGND VPWR VPWR _03137_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_140_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16073_ _07164_ _07165_ VGND VGND VPWR VPWR _07223_ sky130_fd_sc_hd__nor2_1
XFILLER_0_122_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13285_ _04135_ _04152_ _04155_ VGND VGND VPWR VPWR _04156_ sky130_fd_sc_hd__a21oi_1
X_10497_ net351 _00653_ _00519_ net355 VGND VGND VPWR VPWR _01308_ sky130_fd_sc_hd__a22o_1
XFILLER_0_122_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15024_ net288 _05702_ VGND VGND VPWR VPWR _06069_ sky130_fd_sc_hd__nand2_1
X_12236_ _03062_ _03064_ VGND VGND VPWR VPWR _03065_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12167_ _02989_ _02991_ VGND VGND VPWR VPWR _02992_ sky130_fd_sc_hd__xnor2_2
X_11118_ _01923_ _01927_ _01822_ _01928_ VGND VGND VPWR VPWR _01929_ sky130_fd_sc_hd__o211a_1
X_16975_ _08209_ _08214_ VGND VGND VPWR VPWR _08215_ sky130_fd_sc_hd__or2b_1
X_12098_ _02886_ _02888_ _02921_ VGND VGND VPWR VPWR _02922_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_36_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15926_ _07056_ _07059_ _07060_ VGND VGND VPWR VPWR _07061_ sky130_fd_sc_hd__o21ai_1
X_11049_ net425 net110 _01462_ VGND VGND VPWR VPWR _01860_ sky130_fd_sc_hd__and3_1
XFILLER_0_127_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput7 measurement[14] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15857_ net306 _05582_ _06982_ _06984_ VGND VGND VPWR VPWR _06985_ sky130_fd_sc_hd__a31o_1
X_14808_ _05820_ _05829_ VGND VGND VPWR VPWR _05831_ sky130_fd_sc_hd__or2_1
X_15788_ _06906_ _06908_ VGND VGND VPWR VPWR _06909_ sky130_fd_sc_hd__or2b_1
XFILLER_0_59_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17527_ clknet_4_4_0_clock _00033_ VGND VGND VPWR VPWR kd_2\[7\] sky130_fd_sc_hd__dfxtp_1
X_14739_ _05708_ _05717_ _05754_ VGND VGND VPWR VPWR _05755_ sky130_fd_sc_hd__o21a_1
XFILLER_0_143_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17458_ clknet_4_14_0_clock _00136_ VGND VGND VPWR VPWR prev_d_error\[10\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16409_ _06806_ _07591_ _06799_ VGND VGND VPWR VPWR _07592_ sky130_fd_sc_hd__a21o_1
XFILLER_0_15_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17389_ net465 net388 net458 _08600_ VGND VGND VPWR VPWR _00141_ sky130_fd_sc_hd__o211a_1
XFILLER_0_42_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09714_ _00368_ _00377_ _00378_ VGND VGND VPWR VPWR _00525_ sky130_fd_sc_hd__nor3_1
X_09645_ net377 _00453_ net520 VGND VGND VPWR VPWR _00456_ sky130_fd_sc_hd__and3_1
XFILLER_0_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09576_ _00382_ _00384_ _00386_ VGND VGND VPWR VPWR _00387_ sky130_fd_sc_hd__nor3_1
XFILLER_0_96_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_878 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10420_ _01229_ _01230_ VGND VGND VPWR VPWR _01231_ sky130_fd_sc_hd__nand2_1
XFILLER_0_150_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10351_ _01134_ _01160_ _01161_ VGND VGND VPWR VPWR _01162_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_104_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13070_ _03797_ _03799_ VGND VGND VPWR VPWR _03919_ sky130_fd_sc_hd__xnor2_1
X_10282_ _01053_ _01092_ VGND VGND VPWR VPWR _01093_ sky130_fd_sc_hd__or2_1
X_12021_ _02836_ _02810_ VGND VGND VPWR VPWR _02837_ sky130_fd_sc_hd__xnor2_1
X_16760_ _07848_ _07975_ VGND VGND VPWR VPWR _07978_ sky130_fd_sc_hd__or2_2
X_13972_ _04850_ _04883_ _04906_ _04910_ VGND VGND VPWR VPWR _04911_ sky130_fd_sc_hd__a211o_1
X_15711_ _06816_ _06814_ VGND VGND VPWR VPWR _06824_ sky130_fd_sc_hd__and2b_1
X_12923_ _03760_ _03766_ VGND VGND VPWR VPWR _03767_ sky130_fd_sc_hd__xor2_1
X_16691_ _07705_ _07861_ _07901_ VGND VGND VPWR VPWR _07902_ sky130_fd_sc_hd__o21a_1
XFILLER_0_88_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15642_ _06746_ _06745_ _06732_ _06731_ VGND VGND VPWR VPWR _06748_ sky130_fd_sc_hd__o211ai_4
X_12854_ _03369_ _03697_ VGND VGND VPWR VPWR _03698_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_96_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11805_ net426 net143 _02571_ _02615_ VGND VGND VPWR VPWR _02616_ sky130_fd_sc_hd__o2bb2a_1
X_15573_ _06670_ _06671_ VGND VGND VPWR VPWR _06673_ sky130_fd_sc_hd__and2_1
XFILLER_0_139_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12785_ _03463_ _03628_ VGND VGND VPWR VPWR _03629_ sky130_fd_sc_hd__nor2_1
XFILLER_0_83_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17312_ net461 prev_error\[14\] VGND VGND VPWR VPWR _08553_ sky130_fd_sc_hd__or2_1
XFILLER_0_84_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14524_ _05516_ _05518_ VGND VGND VPWR VPWR _05519_ sky130_fd_sc_hd__nor2_4
X_11736_ net400 net167 net170 net396 VGND VGND VPWR VPWR _02547_ sky130_fd_sc_hd__a22o_1
XFILLER_0_139_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17243_ _08498_ net88 VGND VGND VPWR VPWR _08506_ sky130_fd_sc_hd__and2_1
XFILLER_0_138_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14455_ _01422_ _05442_ VGND VGND VPWR VPWR _05443_ sky130_fd_sc_hd__or2_4
XFILLER_0_71_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11667_ _02364_ _02454_ _02473_ _02477_ VGND VGND VPWR VPWR _02478_ sky130_fd_sc_hd__a211o_1
XFILLER_0_52_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13406_ _04283_ _04288_ VGND VGND VPWR VPWR _04289_ sky130_fd_sc_hd__and2_1
X_10618_ _00814_ _01428_ VGND VGND VPWR VPWR _01429_ sky130_fd_sc_hd__nand2_1
X_17174_ _08428_ _08433_ VGND VGND VPWR VPWR _08434_ sky130_fd_sc_hd__xnor2_1
X_14386_ _05360_ _05366_ VGND VGND VPWR VPWR _05367_ sky130_fd_sc_hd__xnor2_1
X_11598_ net422 net139 net143 net417 VGND VGND VPWR VPWR _02409_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_24_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16125_ _07203_ _07215_ VGND VGND VPWR VPWR _07280_ sky130_fd_sc_hd__xor2_1
XFILLER_0_24_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10549_ _01350_ _01354_ _01359_ VGND VGND VPWR VPWR _01360_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_106_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13337_ _04148_ _04212_ VGND VGND VPWR VPWR _04213_ sky130_fd_sc_hd__or2_1
XFILLER_0_122_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16056_ net286 _06204_ VGND VGND VPWR VPWR _07204_ sky130_fd_sc_hd__nand2_1
X_13268_ _04044_ _04042_ VGND VGND VPWR VPWR _04137_ sky130_fd_sc_hd__and2b_1
X_15007_ _05947_ _06044_ VGND VGND VPWR VPWR _06050_ sky130_fd_sc_hd__nand2_1
X_12219_ net444 net166 _03044_ _03045_ VGND VGND VPWR VPWR _03046_ sky130_fd_sc_hd__a31o_1
X_13199_ _03978_ _04060_ VGND VGND VPWR VPWR _04061_ sky130_fd_sc_hd__or2_1
XFILLER_0_138_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16958_ _05300_ _05216_ VGND VGND VPWR VPWR _08196_ sky130_fd_sc_hd__and2b_1
X_15909_ _07034_ _07041_ VGND VGND VPWR VPWR _07042_ sky130_fd_sc_hd__nor2_2
XFILLER_0_2_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16889_ _07801_ VGND VGND VPWR VPWR _08120_ sky130_fd_sc_hd__inv_2
X_09430_ _00240_ VGND VGND VPWR VPWR _00241_ sky130_fd_sc_hd__buf_6
XFILLER_0_63_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09361_ _00148_ _00161_ VGND VGND VPWR VPWR _00172_ sky130_fd_sc_hd__xnor2_1
X_09292_ _08644_ _08650_ _08648_ VGND VGND VPWR VPWR _08656_ sky130_fd_sc_hd__a21o_1
XFILLER_0_117_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_12 _05616_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_23 _03282_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_117_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_34 ki\[11\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09628_ _00425_ _00437_ VGND VGND VPWR VPWR _00439_ sky130_fd_sc_hd__and2b_1
XFILLER_0_66_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09559_ _04065_ _00369_ VGND VGND VPWR VPWR _00370_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_65_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12570_ _03403_ _03408_ VGND VGND VPWR VPWR _03409_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11521_ net417 net140 net135 net422 VGND VGND VPWR VPWR _02332_ sky130_fd_sc_hd__a22o_1
XFILLER_0_93_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14240_ _03778_ _05194_ VGND VGND VPWR VPWR _05206_ sky130_fd_sc_hd__xnor2_4
X_11452_ _02246_ _02242_ VGND VGND VPWR VPWR _02263_ sky130_fd_sc_hd__or2b_1
XFILLER_0_61_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10403_ net366 _08674_ _01213_ VGND VGND VPWR VPWR _01214_ sky130_fd_sc_hd__nand3_1
XFILLER_0_123_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_12_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14171_ _04755_ _05129_ _04845_ VGND VGND VPWR VPWR _05130_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_1_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11383_ _02046_ _02193_ VGND VGND VPWR VPWR _02194_ sky130_fd_sc_hd__and2_1
X_10334_ _01113_ _01114_ VGND VGND VPWR VPWR _01145_ sky130_fd_sc_hd__xor2_1
X_13122_ _03951_ _03973_ VGND VGND VPWR VPWR _03976_ sky130_fd_sc_hd__xnor2_1
X_13053_ net207 _03233_ _03249_ net203 VGND VGND VPWR VPWR _03901_ sky130_fd_sc_hd__a22oi_1
X_10265_ _01070_ _01075_ VGND VGND VPWR VPWR _01076_ sky130_fd_sc_hd__and2_1
X_12004_ _02813_ _02815_ _02818_ VGND VGND VPWR VPWR _02819_ sky130_fd_sc_hd__o21ai_1
X_10196_ net374 _04505_ VGND VGND VPWR VPWR _01007_ sky130_fd_sc_hd__nand2_1
X_16812_ _05417_ _08034_ VGND VGND VPWR VPWR _08035_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_108_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout390 prev_d_error\[14\] VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__dlymetal6s2s_1
XPHY_EDGE_ROW_21_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16743_ _07941_ _07958_ VGND VGND VPWR VPWR _07960_ sky130_fd_sc_hd__xnor2_2
X_13955_ net235 _03666_ _03749_ net231 VGND VGND VPWR VPWR _04893_ sky130_fd_sc_hd__a22o_1
X_12906_ _03749_ VGND VGND VPWR VPWR _03750_ sky130_fd_sc_hd__clkbuf_4
X_16674_ _07687_ _07883_ VGND VGND VPWR VPWR _07884_ sky130_fd_sc_hd__nor2_1
X_13886_ _04816_ _04814_ _04812_ VGND VGND VPWR VPWR _04817_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_69_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15625_ _06682_ _06729_ VGND VGND VPWR VPWR _06730_ sky130_fd_sc_hd__nand2b_2
X_12837_ _03613_ _03653_ VGND VGND VPWR VPWR _03681_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_68_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15556_ net280 _05584_ VGND VGND VPWR VPWR _06654_ sky130_fd_sc_hd__nand2_1
X_12768_ _03595_ _03597_ VGND VGND VPWR VPWR _03612_ sky130_fd_sc_hd__xor2_1
XFILLER_0_57_878 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14507_ _06430_ _06914_ _06408_ VGND VGND VPWR VPWR _05500_ sky130_fd_sc_hd__a21o_1
X_11719_ _02442_ _02529_ VGND VGND VPWR VPWR _02530_ sky130_fd_sc_hd__xnor2_1
X_15487_ _06517_ _06523_ _06577_ VGND VGND VPWR VPWR _06578_ sky130_fd_sc_hd__a21o_1
XFILLER_0_72_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12699_ _03374_ _03343_ _03537_ VGND VGND VPWR VPWR _03538_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_127_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17226_ _08195_ _08226_ VGND VGND VPWR VPWR _08491_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_116_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14438_ _01447_ _05423_ VGND VGND VPWR VPWR _05424_ sky130_fd_sc_hd__xnor2_4
Xinput10 measurement[17] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
Xinput21 reg_addr[10] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
Xinput32 reg_addr[4] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__buf_2
Xinput43 reg_data[14] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput54 reg_data[8] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_4
X_17157_ _03452_ _08285_ _08287_ VGND VGND VPWR VPWR _08415_ sky130_fd_sc_hd__a21oi_1
Xinput65 target[17] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14369_ _01703_ _01706_ _05346_ VGND VGND VPWR VPWR _05348_ sky130_fd_sc_hd__and3_1
XFILLER_0_149_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16108_ _07250_ _07258_ _07260_ VGND VGND VPWR VPWR _07261_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17088_ _08337_ _08338_ VGND VGND VPWR VPWR _08339_ sky130_fd_sc_hd__xnor2_1
X_08930_ _05242_ _05253_ VGND VGND VPWR VPWR _05275_ sky130_fd_sc_hd__nand2_1
X_16039_ net301 _05973_ _07184_ VGND VGND VPWR VPWR _07185_ sky130_fd_sc_hd__and3_1
X_08861_ _04505_ VGND VGND VPWR VPWR _04516_ sky130_fd_sc_hd__buf_2
X_08792_ net46 _03542_ _03575_ net526 VGND VGND VPWR VPWR _00062_ sky130_fd_sc_hd__a22o_1
XFILLER_0_74_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09413_ _00210_ _00222_ VGND VGND VPWR VPWR _00224_ sky130_fd_sc_hd__and2_1
X_09344_ _00151_ _00154_ VGND VGND VPWR VPWR _00155_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09275_ net526 _08636_ _08637_ _08638_ VGND VGND VPWR VPWR _08639_ sky130_fd_sc_hd__a31o_1
XFILLER_0_75_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10050_ _00739_ _00740_ _00735_ _00741_ VGND VGND VPWR VPWR _00861_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_98_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13740_ _04654_ _04655_ VGND VGND VPWR VPWR _04656_ sky130_fd_sc_hd__nor2_1
X_10952_ _01761_ _01762_ VGND VGND VPWR VPWR _01763_ sky130_fd_sc_hd__or2_1
X_13671_ _04577_ _04578_ VGND VGND VPWR VPWR _04580_ sky130_fd_sc_hd__xor2_1
X_10883_ _01687_ _01693_ VGND VGND VPWR VPWR _01694_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_128_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15410_ _06490_ _06489_ _06471_ _06470_ VGND VGND VPWR VPWR _06493_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_128_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12622_ _03459_ _03460_ VGND VGND VPWR VPWR _03461_ sky130_fd_sc_hd__nor2_2
X_16390_ _06091_ VGND VGND VPWR VPWR _07571_ sky130_fd_sc_hd__inv_2
XFILLER_0_39_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15341_ _06416_ VGND VGND VPWR VPWR _06417_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_66_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12553_ _03389_ _03391_ VGND VGND VPWR VPWR _03392_ sky130_fd_sc_hd__or2b_1
XFILLER_0_65_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11504_ _02309_ _02312_ _02314_ VGND VGND VPWR VPWR _02315_ sky130_fd_sc_hd__o21ai_2
X_15272_ net256 _06017_ _06338_ _06340_ VGND VGND VPWR VPWR _06341_ sky130_fd_sc_hd__a31o_1
X_12484_ _03317_ _03319_ VGND VGND VPWR VPWR _03320_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17011_ _08061_ _08253_ _08059_ VGND VGND VPWR VPWR _08254_ sky130_fd_sc_hd__a21o_1
X_14223_ _04294_ _04402_ _05186_ _04292_ VGND VGND VPWR VPWR _05188_ sky130_fd_sc_hd__a31o_2
XFILLER_0_34_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11435_ _02048_ _02243_ _02244_ _02245_ VGND VGND VPWR VPWR _02246_ sky130_fd_sc_hd__o22a_1
XFILLER_0_1_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14154_ _05101_ _05105_ _05107_ _05111_ VGND VGND VPWR VPWR _05112_ sky130_fd_sc_hd__a31o_1
X_11366_ _02173_ _02175_ VGND VGND VPWR VPWR _02177_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10317_ _01066_ _01065_ VGND VGND VPWR VPWR _01128_ sky130_fd_sc_hd__nor2_2
X_13105_ _03957_ _03885_ VGND VGND VPWR VPWR _03958_ sky130_fd_sc_hd__xor2_2
X_14085_ _04995_ _04996_ VGND VGND VPWR VPWR _05036_ sky130_fd_sc_hd__xnor2_1
X_11297_ _02009_ _02000_ _02007_ VGND VGND VPWR VPWR _02108_ sky130_fd_sc_hd__nand3_1
XFILLER_0_21_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13036_ _03880_ _03881_ VGND VGND VPWR VPWR _03882_ sky130_fd_sc_hd__nand2_2
X_10248_ net334 _00519_ _00993_ VGND VGND VPWR VPWR _01059_ sky130_fd_sc_hd__a21oi_1
X_10179_ _00988_ _00989_ VGND VGND VPWR VPWR _00990_ sky130_fd_sc_hd__xnor2_1
X_14987_ net277 _05724_ VGND VGND VPWR VPWR _06028_ sky130_fd_sc_hd__nand2_1
XFILLER_0_135_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16726_ _07929_ _07940_ VGND VGND VPWR VPWR _07941_ sky130_fd_sc_hd__xnor2_1
X_13938_ net214 _04002_ VGND VGND VPWR VPWR _04874_ sky130_fd_sc_hd__nand2_1
XFILLER_0_135_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16657_ _07664_ _07672_ _07670_ VGND VGND VPWR VPWR _07865_ sky130_fd_sc_hd__a21oi_2
X_13869_ _04792_ _04796_ _04726_ _04797_ VGND VGND VPWR VPWR _04798_ sky130_fd_sc_hd__o211a_1
XFILLER_0_147_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15608_ _06685_ _06710_ VGND VGND VPWR VPWR _06711_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16588_ _07770_ _07775_ _07773_ VGND VGND VPWR VPWR _07789_ sky130_fd_sc_hd__a21o_1
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15539_ _06633_ _06634_ VGND VGND VPWR VPWR _06635_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09060_ _05011_ VGND VGND VPWR VPWR _06705_ sky130_fd_sc_hd__inv_2
XFILLER_0_8_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17209_ _08163_ _08467_ VGND VGND VPWR VPWR _08472_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_114_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09962_ _00770_ _00772_ _00768_ VGND VGND VPWR VPWR _00773_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08913_ _05066_ _04824_ VGND VGND VPWR VPWR _05088_ sky130_fd_sc_hd__and2b_1
X_09893_ _00703_ _00614_ VGND VGND VPWR VPWR _00704_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08844_ net18 net73 VGND VGND VPWR VPWR _04329_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_85_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08775_ net38 _03553_ _03586_ net380 VGND VGND VPWR VPWR _00054_ sky130_fd_sc_hd__a22o_1
XFILLER_0_79_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09327_ _05440_ _08690_ VGND VGND VPWR VPWR _08691_ sky130_fd_sc_hd__and2b_1
XFILLER_0_146_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclone13 _08028_ _08030_ _08031_ VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__a21oi_2
Xclone24 _08461_ VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__buf_6
XFILLER_0_118_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09258_ _08618_ _08620_ _08621_ VGND VGND VPWR VPWR _08622_ sky130_fd_sc_hd__o21a_1
XFILLER_0_63_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09189_ net333 _04923_ VGND VGND VPWR VPWR _08124_ sky130_fd_sc_hd__nand2_1
X_11220_ _01944_ _01949_ VGND VGND VPWR VPWR _02031_ sky130_fd_sc_hd__and2_1
XFILLER_0_31_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11151_ net419 net423 net123 net118 VGND VGND VPWR VPWR _01962_ sky130_fd_sc_hd__and4_1
X_10102_ _00906_ _00912_ VGND VGND VPWR VPWR _00913_ sky130_fd_sc_hd__nor2_1
X_11082_ _01891_ _01892_ net391 net149 VGND VGND VPWR VPWR _01893_ sky130_fd_sc_hd__and4bb_1
X_14910_ _05941_ _05942_ VGND VGND VPWR VPWR _05943_ sky130_fd_sc_hd__xor2_2
X_10033_ _00764_ _00843_ VGND VGND VPWR VPWR _00844_ sky130_fd_sc_hd__or2_1
X_15890_ net259 _04313_ _06416_ net263 VGND VGND VPWR VPWR _07021_ sky130_fd_sc_hd__a22o_1
X_14841_ _05805_ _05811_ VGND VGND VPWR VPWR _05867_ sky130_fd_sc_hd__or2_1
X_14772_ _05700_ _05790_ VGND VGND VPWR VPWR _05791_ sky130_fd_sc_hd__nor2_1
X_11984_ net415 net165 VGND VGND VPWR VPWR _02797_ sky130_fd_sc_hd__nand2_1
X_16511_ _07702_ _07703_ VGND VGND VPWR VPWR _07704_ sky130_fd_sc_hd__nor2_1
X_13723_ _04601_ _04603_ VGND VGND VPWR VPWR _04638_ sky130_fd_sc_hd__xnor2_1
X_17491_ clknet_4_6_0_clock _00051_ VGND VGND VPWR VPWR ki\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_105_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10935_ _01724_ _01727_ _01744_ VGND VGND VPWR VPWR _01746_ sky130_fd_sc_hd__nand3_1
XFILLER_0_129_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16442_ i_error\[1\] _07627_ VGND VGND VPWR VPWR _07628_ sky130_fd_sc_hd__or2_1
X_13654_ _04559_ _04535_ VGND VGND VPWR VPWR _04562_ sky130_fd_sc_hd__and2b_1
XFILLER_0_14_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10866_ _01617_ _01619_ _01675_ VGND VGND VPWR VPWR _01677_ sky130_fd_sc_hd__or3_1
XFILLER_0_39_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12605_ _03442_ _03443_ VGND VGND VPWR VPWR _03444_ sky130_fd_sc_hd__nor2_1
X_16373_ _07550_ _07551_ VGND VGND VPWR VPWR _07553_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13585_ _04479_ _04480_ VGND VGND VPWR VPWR _04486_ sky130_fd_sc_hd__and2_1
XFILLER_0_109_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10797_ _01550_ _01553_ _01606_ VGND VGND VPWR VPWR _01608_ sky130_fd_sc_hd__a21o_1
X_15324_ _06395_ _06396_ _06398_ VGND VGND VPWR VPWR _06399_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_54_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12536_ net221 net214 _03374_ VGND VGND VPWR VPWR _03375_ sky130_fd_sc_hd__o21a_1
XFILLER_0_30_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15255_ _06235_ _06318_ _06322_ VGND VGND VPWR VPWR _06323_ sky130_fd_sc_hd__o21ba_1
X_12467_ _03299_ _03300_ VGND VGND VPWR VPWR _03301_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_144_Right_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14206_ _04763_ _04800_ _04798_ VGND VGND VPWR VPWR _05169_ sky130_fd_sc_hd__o21ba_1
X_11418_ _02227_ _02228_ VGND VGND VPWR VPWR _02229_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15186_ _06151_ _06170_ VGND VGND VPWR VPWR _06247_ sky130_fd_sc_hd__nand2_1
X_12398_ _03225_ _03226_ VGND VGND VPWR VPWR _03230_ sky130_fd_sc_hd__nor2_1
XFILLER_0_39_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14137_ _05087_ _05090_ _05092_ VGND VGND VPWR VPWR _05093_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_120_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11349_ net407 net143 _02071_ VGND VGND VPWR VPWR _02160_ sky130_fd_sc_hd__and3_1
X_14068_ net226 _04106_ _03749_ net244 VGND VGND VPWR VPWR _05017_ sky130_fd_sc_hd__a22o_1
XFILLER_0_39_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13019_ _03846_ _03862_ VGND VGND VPWR VPWR _03863_ sky130_fd_sc_hd__nor2_1
XFILLER_0_146_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16709_ _07903_ _07906_ _07902_ VGND VGND VPWR VPWR _07922_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_18_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09112_ _07244_ _07266_ VGND VGND VPWR VPWR _07277_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_45_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09043_ _05572_ _06507_ VGND VGND VPWR VPWR _06518_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_111_Right_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_13_0_clock clknet_0_clock VGND VGND VPWR VPWR clknet_4_13_0_clock sky130_fd_sc_hd__clkbuf_8
XFILLER_0_40_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09945_ _00749_ _00755_ VGND VGND VPWR VPWR _00756_ sky130_fd_sc_hd__xnor2_4
X_09876_ _00565_ _00553_ _00564_ VGND VGND VPWR VPWR _00687_ sky130_fd_sc_hd__nand3_1
XFILLER_0_99_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08827_ net17 net72 VGND VGND VPWR VPWR _04142_ sky130_fd_sc_hd__xnor2_4
X_08758_ net52 _03318_ _03351_ net286 VGND VGND VPWR VPWR _00050_ sky130_fd_sc_hd__a22o_1
XFILLER_0_138_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10720_ _01479_ _01524_ VGND VGND VPWR VPWR _01531_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_55_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10651_ _01460_ _01461_ VGND VGND VPWR VPWR _01462_ sky130_fd_sc_hd__nor2_2
XFILLER_0_119_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10582_ _01379_ _01392_ VGND VGND VPWR VPWR _01393_ sky130_fd_sc_hd__nor2_1
X_13370_ _04204_ _04210_ VGND VGND VPWR VPWR _04249_ sky130_fd_sc_hd__xor2_1
XFILLER_0_51_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12321_ _02485_ _03152_ VGND VGND VPWR VPWR _03153_ sky130_fd_sc_hd__nand2_1
XFILLER_0_133_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15040_ _06058_ _06060_ _06085_ VGND VGND VPWR VPWR _06086_ sky130_fd_sc_hd__a21oi_2
X_12252_ _03052_ _03081_ VGND VGND VPWR VPWR _03082_ sky130_fd_sc_hd__or2_1
X_11203_ _02011_ _02013_ VGND VGND VPWR VPWR _02014_ sky130_fd_sc_hd__or2_1
X_12183_ net429 net449 net157 net172 VGND VGND VPWR VPWR _03008_ sky130_fd_sc_hd__and4_1
X_11134_ _01458_ _01482_ VGND VGND VPWR VPWR _01945_ sky130_fd_sc_hd__nor2_1
X_16991_ _07745_ VGND VGND VPWR VPWR _08232_ sky130_fd_sc_hd__inv_2
X_15942_ net279 _06206_ _07075_ _07077_ VGND VGND VPWR VPWR _07078_ sky130_fd_sc_hd__a31o_1
X_11065_ _01874_ _01875_ net403 net136 VGND VGND VPWR VPWR _01876_ sky130_fd_sc_hd__and4bb_1
X_10016_ net363 _04593_ VGND VGND VPWR VPWR _00827_ sky130_fd_sc_hd__and2_1
X_15873_ net294 _05603_ _06520_ VGND VGND VPWR VPWR _07003_ sky130_fd_sc_hd__and3_1
X_14824_ _05794_ _05795_ VGND VGND VPWR VPWR _05849_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_99_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14755_ net251 net248 _05622_ _05746_ VGND VGND VPWR VPWR _05773_ sky130_fd_sc_hd__and4_1
X_11967_ _02774_ _02777_ VGND VGND VPWR VPWR _02778_ sky130_fd_sc_hd__nor2_1
XFILLER_0_98_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13706_ _04617_ _04618_ VGND VGND VPWR VPWR _04619_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_129_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17474_ clknet_4_0_0_clock _00070_ VGND VGND VPWR VPWR kp\[8\] sky130_fd_sc_hd__dfxtp_1
X_10918_ _01727_ _01728_ VGND VGND VPWR VPWR _01729_ sky130_fd_sc_hd__nand2_1
X_14686_ _05691_ VGND VGND VPWR VPWR _05697_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11898_ _02706_ _02707_ _02701_ _02705_ VGND VGND VPWR VPWR _02709_ sky130_fd_sc_hd__a211o_1
X_16425_ _06973_ VGND VGND VPWR VPWR _07610_ sky130_fd_sc_hd__clkinvlp_2
X_13637_ net238 _03232_ _03248_ net234 VGND VGND VPWR VPWR _04543_ sky130_fd_sc_hd__a22o_1
XFILLER_0_128_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10849_ _01658_ _01659_ VGND VGND VPWR VPWR _01660_ sky130_fd_sc_hd__and2b_1
XFILLER_0_144_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16356_ _05894_ VGND VGND VPWR VPWR _07534_ sky130_fd_sc_hd__inv_2
XFILLER_0_27_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13568_ _04404_ _04405_ _04407_ VGND VGND VPWR VPWR _04467_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_109_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15307_ _06369_ _06376_ _06370_ VGND VGND VPWR VPWR _06380_ sky130_fd_sc_hd__nand3_1
X_12519_ net185 _03278_ VGND VGND VPWR VPWR _03358_ sky130_fd_sc_hd__nand2_1
X_16287_ _07451_ _07455_ _07457_ VGND VGND VPWR VPWR _07458_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13499_ _04366_ _04390_ VGND VGND VPWR VPWR _04391_ sky130_fd_sc_hd__and2b_1
X_15238_ net281 _05631_ _06301_ _06303_ VGND VGND VPWR VPWR _06304_ sky130_fd_sc_hd__a31o_1
XFILLER_0_140_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15169_ _06136_ _06138_ VGND VGND VPWR VPWR _06228_ sky130_fd_sc_hd__xor2_2
XFILLER_0_2_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout208 net209 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__buf_2
XFILLER_0_1_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout219 net221 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__clkbuf_4
X_09730_ _00539_ _00540_ VGND VGND VPWR VPWR _00541_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09661_ net336 _07398_ _00401_ VGND VGND VPWR VPWR _00472_ sky130_fd_sc_hd__a21o_1
X_09592_ net341 _04615_ _07332_ net337 VGND VGND VPWR VPWR _00403_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_96_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09026_ _06276_ _06320_ VGND VGND VPWR VPWR _06331_ sky130_fd_sc_hd__nor2_2
XFILLER_0_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09928_ net357 _04604_ _00737_ _00738_ VGND VGND VPWR VPWR _00739_ sky130_fd_sc_hd__and4_1
X_09859_ _00668_ _00669_ VGND VGND VPWR VPWR _00670_ sky130_fd_sc_hd__and2b_1
X_12870_ _03701_ _03713_ VGND VGND VPWR VPWR _03714_ sky130_fd_sc_hd__and2_1
XFILLER_0_99_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11821_ _02587_ _02600_ _02594_ _02599_ VGND VGND VPWR VPWR _02632_ sky130_fd_sc_hd__a211o_1
XFILLER_0_68_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14540_ net318 _05759_ _05033_ _04560_ VGND VGND VPWR VPWR _05536_ sky130_fd_sc_hd__a211oi_1
X_11752_ _02544_ _02545_ _02554_ VGND VGND VPWR VPWR _02563_ sky130_fd_sc_hd__a21oi_2
X_10703_ net393 net116 net112 net397 VGND VGND VPWR VPWR _01514_ sky130_fd_sc_hd__a22oi_2
X_14471_ _00637_ VGND VGND VPWR VPWR _05460_ sky130_fd_sc_hd__inv_2
X_11683_ _02458_ _02493_ VGND VGND VPWR VPWR _02494_ sky130_fd_sc_hd__nor2_1
XFILLER_0_138_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16210_ _07363_ _07366_ VGND VGND VPWR VPWR _07373_ sky130_fd_sc_hd__nand2_1
XFILLER_0_125_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13422_ _04305_ _04268_ VGND VGND VPWR VPWR _04306_ sky130_fd_sc_hd__xnor2_1
X_17190_ _07768_ _08362_ _08450_ VGND VGND VPWR VPWR _08451_ sky130_fd_sc_hd__a21o_1
X_10634_ _01443_ _00182_ _01444_ VGND VGND VPWR VPWR _01445_ sky130_fd_sc_hd__nor3_1
X_16141_ _07293_ _07294_ _07296_ VGND VGND VPWR VPWR _07297_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_141_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13353_ _04226_ _04229_ _04224_ VGND VGND VPWR VPWR _04231_ sky130_fd_sc_hd__o21a_1
X_10565_ net376 _00519_ VGND VGND VPWR VPWR _01376_ sky130_fd_sc_hd__and2_1
XFILLER_0_134_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12304_ _03130_ VGND VGND VPWR VPWR _03136_ sky130_fd_sc_hd__inv_2
X_16072_ _07209_ _07214_ VGND VGND VPWR VPWR _07221_ sky130_fd_sc_hd__nand2_1
X_13284_ _04020_ _04154_ VGND VGND VPWR VPWR _04155_ sky130_fd_sc_hd__or2_1
X_10496_ net359 _00519_ _01293_ _01306_ VGND VGND VPWR VPWR _01307_ sky130_fd_sc_hd__a31o_1
X_15023_ _05843_ _06066_ VGND VGND VPWR VPWR _06068_ sky130_fd_sc_hd__xor2_1
XFILLER_0_20_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12235_ _03040_ _03060_ VGND VGND VPWR VPWR _03064_ sky130_fd_sc_hd__nand2_1
XFILLER_0_121_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12166_ _02864_ _02990_ VGND VGND VPWR VPWR _02991_ sky130_fd_sc_hd__or2_1
X_11117_ _01818_ _01819_ _01821_ VGND VGND VPWR VPWR _01928_ sky130_fd_sc_hd__o21ai_1
X_16974_ _08210_ _08213_ _08033_ VGND VGND VPWR VPWR _08214_ sky130_fd_sc_hd__mux2_1
X_12097_ _02797_ _02920_ VGND VGND VPWR VPWR _02921_ sky130_fd_sc_hd__xnor2_1
X_11048_ _01854_ _01856_ VGND VGND VPWR VPWR _01859_ sky130_fd_sc_hd__xnor2_1
X_15925_ net297 _05665_ _06983_ VGND VGND VPWR VPWR _07060_ sky130_fd_sc_hd__nand3_1
XFILLER_0_36_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput8 measurement[15] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
X_15856_ net297 _05588_ _06983_ VGND VGND VPWR VPWR _06984_ sky130_fd_sc_hd__and3_1
X_14807_ _05820_ _05829_ VGND VGND VPWR VPWR _05830_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15787_ _06905_ _06907_ VGND VGND VPWR VPWR _06908_ sky130_fd_sc_hd__and2_1
X_12999_ _03834_ _03833_ VGND VGND VPWR VPWR _03843_ sky130_fd_sc_hd__and2b_1
XFILLER_0_143_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14738_ _05743_ _05753_ VGND VGND VPWR VPWR _05754_ sky130_fd_sc_hd__xor2_1
X_17526_ clknet_4_6_0_clock _00032_ VGND VGND VPWR VPWR kd_2\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_87_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17457_ clknet_4_14_0_clock _00135_ VGND VGND VPWR VPWR prev_d_error\[9\] sky130_fd_sc_hd__dfxtp_2
X_14669_ prev_error\[13\] _04747_ VGND VGND VPWR VPWR _05678_ sky130_fd_sc_hd__nand2_1
XFILLER_0_129_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16408_ _06788_ _06796_ _07589_ _06797_ _07590_ VGND VGND VPWR VPWR _07591_ sky130_fd_sc_hd__a311o_1
XFILLER_0_6_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17388_ net465 _05417_ VGND VGND VPWR VPWR _08600_ sky130_fd_sc_hd__nand2_1
XFILLER_0_116_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16339_ net254 _05739_ _05886_ _07514_ VGND VGND VPWR VPWR _07515_ sky130_fd_sc_hd__a31o_1
XFILLER_0_82_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_58_Left_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09713_ _00513_ _00523_ VGND VGND VPWR VPWR _00524_ sky130_fd_sc_hd__or2b_1
X_09644_ net356 _04758_ VGND VGND VPWR VPWR _00455_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09575_ _00385_ _00280_ VGND VGND VPWR VPWR _00386_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_67_Left_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10350_ _01136_ _01159_ VGND VGND VPWR VPWR _01161_ sky130_fd_sc_hd__or2b_1
XFILLER_0_103_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09009_ _04670_ _05099_ _05077_ VGND VGND VPWR VPWR _06144_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_60_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10281_ _01052_ _01048_ VGND VGND VPWR VPWR _01092_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_76_Left_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12020_ _02811_ _02805_ VGND VGND VPWR VPWR _02836_ sky130_fd_sc_hd__or2b_1
X_13971_ _04908_ _04909_ VGND VGND VPWR VPWR _04910_ sky130_fd_sc_hd__nor2_1
X_15710_ _06818_ _06822_ VGND VGND VPWR VPWR _06823_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_88_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12922_ _03764_ _03765_ VGND VGND VPWR VPWR _03766_ sky130_fd_sc_hd__nor2_1
X_16690_ _07899_ _07900_ VGND VGND VPWR VPWR _07901_ sky130_fd_sc_hd__nor2_1
X_15641_ _06731_ _06732_ _06745_ _06746_ VGND VGND VPWR VPWR _06747_ sky130_fd_sc_hd__a211o_4
XPHY_EDGE_ROW_85_Left_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12853_ net222 _03321_ VGND VGND VPWR VPWR _03697_ sky130_fd_sc_hd__nand2_1
X_11804_ _02572_ VGND VGND VPWR VPWR _02615_ sky130_fd_sc_hd__inv_2
X_15572_ _06410_ _06411_ VGND VGND VPWR VPWR _06671_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12784_ _03626_ _03627_ VGND VGND VPWR VPWR _03628_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17311_ _08549_ _04780_ _08552_ net450 VGND VGND VPWR VPWR _00103_ sky130_fd_sc_hd__o211a_1
X_14523_ _07035_ _05514_ _05513_ VGND VGND VPWR VPWR _05518_ sky130_fd_sc_hd__a21oi_2
X_11735_ _02544_ _02545_ VGND VGND VPWR VPWR _02546_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_113_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17242_ _08503_ _08504_ net453 VGND VGND VPWR VPWR _00075_ sky130_fd_sc_hd__o21a_1
X_14454_ _01163_ _01421_ _01108_ VGND VGND VPWR VPWR _05442_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_83_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11666_ _02432_ _02474_ _02476_ VGND VGND VPWR VPWR _02477_ sky130_fd_sc_hd__and3_1
XFILLER_0_36_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13405_ _04282_ _04257_ _04280_ VGND VGND VPWR VPWR _04288_ sky130_fd_sc_hd__or3_1
X_10617_ _00723_ _00726_ _00640_ VGND VGND VPWR VPWR _01428_ sky130_fd_sc_hd__a21o_1
X_17173_ _08430_ _08431_ VGND VGND VPWR VPWR _08433_ sky130_fd_sc_hd__xnor2_1
X_14385_ _05364_ _05365_ VGND VGND VPWR VPWR _05366_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11597_ _02402_ _02406_ _02407_ VGND VGND VPWR VPWR _02408_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_51_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16124_ _07274_ _07278_ VGND VGND VPWR VPWR _07279_ sky130_fd_sc_hd__and2b_1
X_13336_ _04145_ _04147_ VGND VGND VPWR VPWR _04212_ sky130_fd_sc_hd__nor2_1
XFILLER_0_52_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10548_ _01357_ _01358_ VGND VGND VPWR VPWR _01359_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_94_Left_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16055_ _07198_ _07201_ VGND VGND VPWR VPWR _07203_ sky130_fd_sc_hd__xnor2_1
X_13267_ net199 _03270_ VGND VGND VPWR VPWR _04136_ sky130_fd_sc_hd__nand2_1
X_10479_ _01275_ _01276_ VGND VGND VPWR VPWR _01290_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_110_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15006_ net266 _05622_ _06046_ _06048_ VGND VGND VPWR VPWR _06049_ sky130_fd_sc_hd__a31o_2
X_12218_ net436 net440 net171 net175 VGND VGND VPWR VPWR _03045_ sky130_fd_sc_hd__and4_1
X_13198_ _03975_ _03976_ VGND VGND VPWR VPWR _04060_ sky130_fd_sc_hd__and2_1
XFILLER_0_20_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12149_ _02950_ _02952_ VGND VGND VPWR VPWR _02974_ sky130_fd_sc_hd__or2_1
X_16957_ _08160_ _08164_ _08192_ _08194_ VGND VGND VPWR VPWR _08195_ sky130_fd_sc_hd__o31ai_4
X_15908_ _07039_ _07034_ _07040_ VGND VGND VPWR VPWR _07041_ sky130_fd_sc_hd__nor3_4
X_16888_ _07990_ VGND VGND VPWR VPWR _08119_ sky130_fd_sc_hd__inv_2
XFILLER_0_79_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15839_ _06962_ _06964_ VGND VGND VPWR VPWR _06965_ sky130_fd_sc_hd__nand2b_4
X_09360_ _00168_ _00170_ VGND VGND VPWR VPWR _00171_ sky130_fd_sc_hd__or2_1
XFILLER_0_93_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17509_ clknet_4_1_0_clock _00015_ VGND VGND VPWR VPWR kd_1\[7\] sky130_fd_sc_hd__dfxtp_1
X_09291_ _08529_ _08654_ VGND VGND VPWR VPWR _08655_ sky130_fd_sc_hd__xor2_1
XFILLER_0_75_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_13 _08231_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_24 _03285_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_35 ki\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09627_ _00425_ _00437_ VGND VGND VPWR VPWR _00438_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09558_ _04076_ _04087_ _04098_ VGND VGND VPWR VPWR _00369_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_66_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09489_ _00283_ _00285_ _00299_ VGND VGND VPWR VPWR _00300_ sky130_fd_sc_hd__a21o_1
XFILLER_0_136_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11520_ net414 net143 VGND VGND VPWR VPWR _02331_ sky130_fd_sc_hd__nand2_1
XFILLER_0_65_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11451_ _02259_ _02261_ VGND VGND VPWR VPWR _02262_ sky130_fd_sc_hd__nand2_1
X_10402_ net371 _00238_ _00239_ VGND VGND VPWR VPWR _01213_ sky130_fd_sc_hd__and3_1
X_14170_ net202 net518 VGND VGND VPWR VPWR _05129_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11382_ _02044_ _02045_ VGND VGND VPWR VPWR _02193_ sky130_fd_sc_hd__nand2_1
XFILLER_0_150_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13121_ _03915_ _03974_ VGND VGND VPWR VPWR _03975_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10333_ _01086_ _01138_ _01143_ VGND VGND VPWR VPWR _01144_ sky130_fd_sc_hd__nand3_2
XFILLER_0_103_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13052_ net207 net203 _03233_ _03249_ VGND VGND VPWR VPWR _03899_ sky130_fd_sc_hd__and4_1
X_10264_ _01069_ _01057_ _01068_ VGND VGND VPWR VPWR _01075_ sky130_fd_sc_hd__or3_1
XFILLER_0_103_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12003_ _02758_ _02816_ VGND VGND VPWR VPWR _02818_ sky130_fd_sc_hd__nor2_1
X_10195_ _00952_ _00953_ _00954_ VGND VGND VPWR VPWR _01006_ sky130_fd_sc_hd__o21a_1
XFILLER_0_100_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16811_ _05557_ _07973_ _08033_ VGND VGND VPWR VPWR _08034_ sky130_fd_sc_hd__mux2_2
Xfanout380 kp\[0\] VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__clkbuf_4
Xfanout391 prev_d_error\[14\] VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__buf_2
X_16742_ _07943_ _07957_ VGND VGND VPWR VPWR _07958_ sky130_fd_sc_hd__xnor2_1
X_13954_ net235 net231 _03666_ _03749_ VGND VGND VPWR VPWR _04892_ sky130_fd_sc_hd__nand4_2
X_12905_ _03748_ _03204_ VGND VGND VPWR VPWR _03749_ sky130_fd_sc_hd__xnor2_4
X_16673_ net261 net258 _05697_ VGND VGND VPWR VPWR _07883_ sky130_fd_sc_hd__o21ai_1
X_13885_ net245 net225 _03667_ _03248_ VGND VGND VPWR VPWR _04816_ sky130_fd_sc_hd__nand4_1
X_15624_ _06707_ _06728_ VGND VGND VPWR VPWR _06729_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_124_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12836_ _03675_ _03679_ VGND VGND VPWR VPWR _03680_ sky130_fd_sc_hd__xor2_1
XFILLER_0_33_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15555_ net293 _05631_ _06571_ _06569_ VGND VGND VPWR VPWR _06653_ sky130_fd_sc_hd__a31o_1
XFILLER_0_57_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12767_ _03605_ _03610_ VGND VGND VPWR VPWR _03611_ sky130_fd_sc_hd__nand2_1
X_14506_ _05572_ _05498_ VGND VGND VPWR VPWR _05499_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_83_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11718_ net392 net170 VGND VGND VPWR VPWR _02529_ sky130_fd_sc_hd__nand2_1
XFILLER_0_126_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15486_ _06516_ _06511_ VGND VGND VPWR VPWR _06577_ sky130_fd_sc_hd__and2b_1
X_12698_ net214 _03321_ _03373_ VGND VGND VPWR VPWR _03537_ sky130_fd_sc_hd__a21o_1
X_14437_ _00270_ _01442_ _00268_ VGND VGND VPWR VPWR _05423_ sky130_fd_sc_hd__a21oi_2
X_17225_ _08184_ _08489_ VGND VGND VPWR VPWR _08490_ sky130_fd_sc_hd__xor2_1
XFILLER_0_71_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput11 measurement[1] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_2
X_11649_ _02312_ _02459_ VGND VGND VPWR VPWR _02460_ sky130_fd_sc_hd__nor2_1
Xinput22 reg_addr[11] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_126_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput33 reg_addr[5] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
Xinput44 reg_data[15] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_109_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17156_ _08274_ _08413_ VGND VGND VPWR VPWR _08414_ sky130_fd_sc_hd__xnor2_1
Xinput55 reg_data[9] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_141_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14368_ _01703_ _01706_ _05346_ VGND VGND VPWR VPWR _05347_ sky130_fd_sc_hd__a21oi_1
Xinput66 target[1] VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_40_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16107_ _07095_ _07259_ _07165_ VGND VGND VPWR VPWR _07260_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13319_ _04097_ _04189_ _04192_ VGND VGND VPWR VPWR _04193_ sky130_fd_sc_hd__nand3_1
XFILLER_0_122_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17087_ _01687_ _05332_ _01686_ VGND VGND VPWR VPWR _08338_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_150_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14299_ _05270_ _03142_ VGND VGND VPWR VPWR _05271_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16038_ net297 _06015_ VGND VGND VPWR VPWR _07184_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08860_ _04494_ VGND VGND VPWR VPWR _04505_ sky130_fd_sc_hd__buf_4
X_08791_ net45 _03542_ _03575_ net316 VGND VGND VPWR VPWR _00061_ sky130_fd_sc_hd__a22o_1
XFILLER_0_74_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09412_ _00210_ _00222_ VGND VGND VPWR VPWR _00223_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09343_ net332 _04516_ _00153_ VGND VGND VPWR VPWR _00154_ sky130_fd_sc_hd__and3_1
XFILLER_0_59_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09274_ net318 net314 _07948_ _07409_ VGND VGND VPWR VPWR _08638_ sky130_fd_sc_hd__and4_1
XFILLER_0_114_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08989_ _05902_ _05913_ VGND VGND VPWR VPWR _05924_ sky130_fd_sc_hd__xor2_1
XFILLER_0_97_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10951_ net387 net142 net146 net383 VGND VGND VPWR VPWR _01762_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_85_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13670_ _04577_ _04578_ VGND VGND VPWR VPWR _04579_ sky130_fd_sc_hd__nand2_1
X_10882_ _01691_ _01692_ VGND VGND VPWR VPWR _01693_ sky130_fd_sc_hd__nor2_1
XFILLER_0_97_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12621_ _03434_ _03458_ VGND VGND VPWR VPWR _03460_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_125_Right_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15340_ _06415_ VGND VGND VPWR VPWR _06416_ sky130_fd_sc_hd__clkbuf_4
X_12552_ _03388_ _03390_ VGND VGND VPWR VPWR _03391_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11503_ _02224_ _02313_ VGND VGND VPWR VPWR _02314_ sky130_fd_sc_hd__nor2_1
X_15271_ _06195_ _06339_ VGND VGND VPWR VPWR _06340_ sky130_fd_sc_hd__nor2_1
X_12483_ _03316_ _03304_ _03313_ VGND VGND VPWR VPWR _03319_ sky130_fd_sc_hd__and3_2
X_17010_ _08229_ _08250_ _08252_ VGND VGND VPWR VPWR _08253_ sky130_fd_sc_hd__a21o_1
X_14222_ _05179_ _05183_ _05184_ _05185_ VGND VGND VPWR VPWR _05186_ sky130_fd_sc_hd__a211o_1
XFILLER_0_123_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11434_ net423 net130 net525 net427 VGND VGND VPWR VPWR _02245_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_21_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14153_ _05104_ _05107_ _05109_ _05101_ VGND VGND VPWR VPWR _05111_ sky130_fd_sc_hd__and4b_1
XFILLER_0_22_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11365_ _02173_ _02175_ VGND VGND VPWR VPWR _02176_ sky130_fd_sc_hd__or2_1
X_13104_ _03367_ _03328_ _03884_ VGND VGND VPWR VPWR _03957_ sky130_fd_sc_hd__a21oi_1
X_10316_ _01122_ _01126_ _01120_ VGND VGND VPWR VPWR _01127_ sky130_fd_sc_hd__a21o_2
XFILLER_0_95_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14084_ _05032_ _05034_ VGND VGND VPWR VPWR _05035_ sky130_fd_sc_hd__nor2_1
X_11296_ _02069_ _02082_ _02068_ VGND VGND VPWR VPWR _02107_ sky130_fd_sc_hd__o21ba_1
X_13035_ _03779_ _03879_ VGND VGND VPWR VPWR _03881_ sky130_fd_sc_hd__nand2_1
X_10247_ _01054_ _01056_ VGND VGND VPWR VPWR _01058_ sky130_fd_sc_hd__xnor2_1
X_10178_ _00918_ _00917_ VGND VGND VPWR VPWR _00989_ sky130_fd_sc_hd__and2b_1
X_14986_ _06013_ _06024_ _06026_ VGND VGND VPWR VPWR _06027_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16725_ _07934_ _07939_ VGND VGND VPWR VPWR _07940_ sky130_fd_sc_hd__xnor2_1
X_13937_ net210 _04106_ VGND VGND VPWR VPWR _04873_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16656_ _07694_ _07863_ VGND VGND VPWR VPWR _07864_ sky130_fd_sc_hd__nand2_1
X_13868_ _04722_ _04723_ _04724_ VGND VGND VPWR VPWR _04797_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_76_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15607_ _06684_ _06687_ VGND VGND VPWR VPWR _06710_ sky130_fd_sc_hd__or2b_1
X_12819_ net177 _03578_ VGND VGND VPWR VPWR _03663_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16587_ _07770_ _07787_ VGND VGND VPWR VPWR _07788_ sky130_fd_sc_hd__and2_1
X_13799_ _04635_ _04636_ _04638_ VGND VGND VPWR VPWR _04721_ sky130_fd_sc_hd__o21a_1
XFILLER_0_29_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15538_ net259 _06162_ _06632_ VGND VGND VPWR VPWR _06634_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_72_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15469_ _06548_ _06556_ _06557_ VGND VGND VPWR VPWR _06558_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_72_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17208_ _08470_ _08191_ VGND VGND VPWR VPWR _08471_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17139_ _08326_ _08394_ VGND VGND VPWR VPWR _08395_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_123_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09961_ _00646_ _00771_ VGND VGND VPWR VPWR _00772_ sky130_fd_sc_hd__nor2_1
X_08912_ _04824_ _05066_ VGND VGND VPWR VPWR _05077_ sky130_fd_sc_hd__and2b_1
XFILLER_0_0_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09892_ net373 _05000_ VGND VGND VPWR VPWR _00703_ sky130_fd_sc_hd__nand2_1
X_08843_ _04263_ net71 _04285_ _04307_ VGND VGND VPWR VPWR _04318_ sky130_fd_sc_hd__a31o_2
XFILLER_0_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08774_ _03575_ VGND VGND VPWR VPWR _03586_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_79_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09326_ _08560_ _08573_ VGND VGND VPWR VPWR _08690_ sky130_fd_sc_hd__xor2_1
XFILLER_0_35_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclone14 _04989_ VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__clkbuf_16
X_09257_ _08613_ _08617_ VGND VGND VPWR VPWR _08621_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09188_ _08091_ _08102_ VGND VGND VPWR VPWR _08113_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11150_ net423 net118 _01960_ VGND VGND VPWR VPWR _01961_ sky130_fd_sc_hd__a21boi_1
X_10101_ _00907_ _00908_ _00909_ _00911_ VGND VGND VPWR VPWR _00912_ sky130_fd_sc_hd__o22a_1
X_11081_ net398 net141 net144 net395 VGND VGND VPWR VPWR _01892_ sky130_fd_sc_hd__a22oi_1
X_10032_ net334 _00243_ _00763_ VGND VGND VPWR VPWR _00843_ sky130_fd_sc_hd__a21oi_1
X_14840_ _05865_ VGND VGND VPWR VPWR _05866_ sky130_fd_sc_hd__buf_2
X_14771_ net277 _05699_ _05697_ VGND VGND VPWR VPWR _05790_ sky130_fd_sc_hd__o21ai_1
X_11983_ _02792_ _02794_ VGND VGND VPWR VPWR _02796_ sky130_fd_sc_hd__and2b_1
X_16510_ _07681_ _07701_ VGND VGND VPWR VPWR _07703_ sky130_fd_sc_hd__nor2_1
X_13722_ net99 _04634_ _04629_ _04633_ VGND VGND VPWR VPWR _04636_ sky130_fd_sc_hd__o211a_1
X_10934_ _01724_ _01727_ _01744_ VGND VGND VPWR VPWR _01745_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17490_ clknet_4_4_0_clock _00050_ VGND VGND VPWR VPWR ki\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_14_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16441_ _07126_ _07488_ VGND VGND VPWR VPWR _07627_ sky130_fd_sc_hd__xor2_1
X_13653_ _04535_ _04559_ VGND VGND VPWR VPWR _04561_ sky130_fd_sc_hd__xnor2_4
X_10865_ _01617_ _01619_ _01675_ VGND VGND VPWR VPWR _01676_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_128_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12604_ _03348_ _03352_ _03441_ VGND VGND VPWR VPWR _03443_ sky130_fd_sc_hd__nor3_1
X_16372_ _05879_ _05888_ _07549_ VGND VGND VPWR VPWR _07551_ sky130_fd_sc_hd__nor3_1
X_13584_ _04453_ _04484_ VGND VGND VPWR VPWR _04485_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_39_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10796_ _01550_ _01553_ _01606_ VGND VGND VPWR VPWR _01607_ sky130_fd_sc_hd__nand3_1
XFILLER_0_27_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15323_ _06393_ _06394_ VGND VGND VPWR VPWR _06398_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12535_ net214 _03373_ VGND VGND VPWR VPWR _03374_ sky130_fd_sc_hd__nand2_2
X_15254_ net267 _05604_ _06321_ VGND VGND VPWR VPWR _06322_ sky130_fd_sc_hd__and3_1
X_12466_ _03287_ _03291_ _03298_ VGND VGND VPWR VPWR _03300_ sky130_fd_sc_hd__nor3_1
X_14205_ _04729_ _04728_ _04693_ VGND VGND VPWR VPWR _05168_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_112_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11417_ net445 net110 _01939_ VGND VGND VPWR VPWR _02228_ sky130_fd_sc_hd__a21oi_1
X_15185_ _06244_ _06245_ VGND VGND VPWR VPWR _06246_ sky130_fd_sc_hd__nand2_1
X_12397_ _03227_ _03228_ _03212_ VGND VGND VPWR VPWR _03229_ sky130_fd_sc_hd__or3b_4
XFILLER_0_50_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14136_ _04918_ _05091_ VGND VGND VPWR VPWR _05092_ sky130_fd_sc_hd__nor2_1
X_11348_ _02150_ _02157_ _02158_ VGND VGND VPWR VPWR _02159_ sky130_fd_sc_hd__and3_1
XFILLER_0_10_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14067_ net244 net226 _04106_ _03750_ VGND VGND VPWR VPWR _05016_ sky130_fd_sc_hd__nand4_1
X_11279_ net395 net148 _02089_ VGND VGND VPWR VPWR _02090_ sky130_fd_sc_hd__and3_1
X_13018_ _03847_ _03861_ _03859_ VGND VGND VPWR VPWR _03862_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_89_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14969_ net260 _05590_ _05582_ net262 VGND VGND VPWR VPWR _06008_ sky130_fd_sc_hd__a22o_1
X_16708_ _07910_ _07912_ _07908_ VGND VGND VPWR VPWR _07921_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_147_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16639_ _07818_ _07819_ _07834_ _07843_ _07844_ VGND VGND VPWR VPWR _07845_ sky130_fd_sc_hd__o32a_2
XFILLER_0_71_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_840 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09111_ _05572_ _07255_ VGND VGND VPWR VPWR _07266_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09042_ _06430_ _06496_ VGND VGND VPWR VPWR _06507_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_142_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09944_ _00751_ _00754_ VGND VGND VPWR VPWR _00755_ sky130_fd_sc_hd__xor2_4
XFILLER_0_96_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09875_ _00674_ _00685_ VGND VGND VPWR VPWR _00686_ sky130_fd_sc_hd__nor2_1
X_08826_ _04065_ _04109_ _04120_ _04043_ VGND VGND VPWR VPWR _04131_ sky130_fd_sc_hd__a211o_4
X_08757_ net51 _03318_ _03351_ net291 VGND VGND VPWR VPWR _00049_ sky130_fd_sc_hd__a22o_1
XFILLER_0_83_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10650_ net430 net448 net107 VGND VGND VPWR VPWR _01461_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_35_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09309_ _04230_ _08672_ VGND VGND VPWR VPWR _08673_ sky130_fd_sc_hd__xor2_4
XFILLER_0_118_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10581_ _01246_ _01378_ VGND VGND VPWR VPWR _01392_ sky130_fd_sc_hd__and2_1
XFILLER_0_8_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12320_ _02401_ _02484_ VGND VGND VPWR VPWR _03152_ sky130_fd_sc_hd__nand2_1
XFILLER_0_133_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12251_ _03047_ _03049_ _03051_ VGND VGND VPWR VPWR _03081_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_133_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11202_ _01906_ _02012_ VGND VGND VPWR VPWR _02013_ sky130_fd_sc_hd__nand2_1
X_12182_ net427 net173 VGND VGND VPWR VPWR _03007_ sky130_fd_sc_hd__nand2_1
XFILLER_0_102_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11133_ _01942_ _01943_ VGND VGND VPWR VPWR _01944_ sky130_fd_sc_hd__or2_1
X_16990_ _05212_ net495 VGND VGND VPWR VPWR _08231_ sky130_fd_sc_hd__xnor2_4
X_15941_ _06997_ _07076_ VGND VGND VPWR VPWR _07077_ sky130_fd_sc_hd__nor2_1
X_11064_ net407 net130 net126 net413 VGND VGND VPWR VPWR _01875_ sky130_fd_sc_hd__a22oi_1
X_10015_ _00823_ _00825_ VGND VGND VPWR VPWR _00826_ sky130_fd_sc_hd__nand2_1
X_15872_ _06904_ _06997_ _07000_ VGND VGND VPWR VPWR _07001_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_99_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14823_ _05846_ VGND VGND VPWR VPWR _05848_ sky130_fd_sc_hd__buf_2
X_14754_ net254 _05746_ _05751_ _05750_ VGND VGND VPWR VPWR _05772_ sky130_fd_sc_hd__a31o_1
X_11966_ _02751_ _02774_ _02775_ _02776_ VGND VGND VPWR VPWR _02777_ sky130_fd_sc_hd__nor4_1
XFILLER_0_98_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13705_ _04544_ _04543_ VGND VGND VPWR VPWR _04618_ sky130_fd_sc_hd__and2b_1
X_10917_ _01719_ _01722_ _01726_ VGND VGND VPWR VPWR _01728_ sky130_fd_sc_hd__or3_1
X_14685_ _05695_ VGND VGND VPWR VPWR _05696_ sky130_fd_sc_hd__buf_2
X_17473_ clknet_4_0_0_clock _00069_ VGND VGND VPWR VPWR kp\[7\] sky130_fd_sc_hd__dfxtp_1
X_11897_ _02701_ _02705_ _02706_ _02707_ VGND VGND VPWR VPWR _02708_ sky130_fd_sc_hd__o211a_1
X_16424_ _06975_ _07049_ _07491_ _06972_ VGND VGND VPWR VPWR _07609_ sky130_fd_sc_hd__o31a_1
X_13636_ _04540_ _04541_ VGND VGND VPWR VPWR _04542_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_132_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10848_ _01592_ _01609_ _01608_ VGND VGND VPWR VPWR _01659_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_41_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16355_ _07510_ _07532_ VGND VGND VPWR VPWR _07533_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13567_ _04375_ _04460_ _04464_ VGND VGND VPWR VPWR _04466_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_109_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10779_ _01584_ _01587_ _01589_ VGND VGND VPWR VPWR _01590_ sky130_fd_sc_hd__o21ai_1
X_12518_ _03355_ _03356_ VGND VGND VPWR VPWR _03357_ sky130_fd_sc_hd__nor2_1
X_15306_ _06310_ _06378_ VGND VGND VPWR VPWR _06379_ sky130_fd_sc_hd__and2_1
X_16286_ _07433_ _07456_ VGND VGND VPWR VPWR _07457_ sky130_fd_sc_hd__or2_1
XFILLER_0_54_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13498_ _04251_ _04367_ _04385_ _04389_ VGND VGND VPWR VPWR _04390_ sky130_fd_sc_hd__a31oi_4
XFILLER_0_140_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12449_ prev_error\[14\] _04912_ VGND VGND VPWR VPWR _03281_ sky130_fd_sc_hd__xnor2_4
X_15237_ net281 _05745_ _06217_ VGND VGND VPWR VPWR _06303_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_2_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15168_ _06218_ _06225_ _06226_ VGND VGND VPWR VPWR _06227_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14119_ _04936_ _05062_ _05072_ VGND VGND VPWR VPWR _05073_ sky130_fd_sc_hd__and3_1
X_15099_ _06020_ _06022_ VGND VGND VPWR VPWR _06151_ sky130_fd_sc_hd__xnor2_1
Xfanout209 kd_1\[9\] VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_105_Left_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09660_ _00470_ _00404_ VGND VGND VPWR VPWR _00471_ sky130_fd_sc_hd__xor2_1
X_09591_ net337 _04604_ _00401_ VGND VGND VPWR VPWR _00402_ sky130_fd_sc_hd__and3_1
XFILLER_0_77_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_114_Left_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09025_ net373 net369 net364 _05418_ VGND VGND VPWR VPWR _06320_ sky130_fd_sc_hd__o31a_1
XFILLER_0_60_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_123_Left_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09927_ net361 _04505_ _05000_ net378 VGND VGND VPWR VPWR _00738_ sky130_fd_sc_hd__a22o_1
X_09858_ _00664_ _00660_ VGND VGND VPWR VPWR _00669_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_99_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08809_ net3 net58 VGND VGND VPWR VPWR _03944_ sky130_fd_sc_hd__or2b_1
X_09789_ _00580_ _00597_ _00599_ VGND VGND VPWR VPWR _00600_ sky130_fd_sc_hd__and3_1
XFILLER_0_68_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11820_ _02623_ _02626_ _02629_ VGND VGND VPWR VPWR _02631_ sky130_fd_sc_hd__and3_1
X_11751_ _02543_ _02558_ _02561_ VGND VGND VPWR VPWR _02562_ sky130_fd_sc_hd__a21o_1
XFILLER_0_138_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10702_ net393 net397 net116 net112 VGND VGND VPWR VPWR _01513_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_132_Left_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14470_ _00544_ _01431_ VGND VGND VPWR VPWR _05459_ sky130_fd_sc_hd__nand2_2
X_11682_ net445 net124 _02456_ _02492_ VGND VGND VPWR VPWR _02493_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_48_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13421_ net179 _04108_ VGND VGND VPWR VPWR _04305_ sky130_fd_sc_hd__nand2_1
X_10633_ _00167_ _00184_ VGND VGND VPWR VPWR _01444_ sky130_fd_sc_hd__and2_1
XFILLER_0_107_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16140_ _05967_ _07295_ net294 VGND VGND VPWR VPWR _07296_ sky130_fd_sc_hd__or3b_1
X_13352_ _04227_ _04228_ VGND VGND VPWR VPWR _04229_ sky130_fd_sc_hd__xnor2_1
X_10564_ _01374_ _01353_ VGND VGND VPWR VPWR _01375_ sky130_fd_sc_hd__xnor2_1
X_12303_ _02812_ _02845_ VGND VGND VPWR VPWR _03135_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_51_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16071_ _07210_ _07213_ VGND VGND VPWR VPWR _07220_ sky130_fd_sc_hd__nand2_1
X_13283_ _03996_ _04019_ VGND VGND VPWR VPWR _04154_ sky130_fd_sc_hd__and2_1
X_10495_ net362 _00371_ _01111_ VGND VGND VPWR VPWR _01306_ sky130_fd_sc_hd__and3_1
XFILLER_0_122_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15022_ _06065_ _05844_ VGND VGND VPWR VPWR _06066_ sky130_fd_sc_hd__nand2_1
X_12234_ _03002_ _03062_ VGND VGND VPWR VPWR _03063_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_141_Left_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12165_ net420 net172 net173 net416 VGND VGND VPWR VPWR _02990_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_20_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11116_ _01887_ _01924_ _01926_ VGND VGND VPWR VPWR _01927_ sky130_fd_sc_hd__nor3_1
X_16973_ _07829_ _08211_ _07971_ VGND VGND VPWR VPWR _08213_ sky130_fd_sc_hd__mux2_1
X_12096_ _02799_ _02798_ VGND VGND VPWR VPWR _02920_ sky130_fd_sc_hd__nor2_1
X_11047_ _01785_ _01789_ _01853_ _01857_ VGND VGND VPWR VPWR _01858_ sky130_fd_sc_hd__o211a_1
X_15924_ _06983_ _07058_ VGND VGND VPWR VPWR _07059_ sky130_fd_sc_hd__xor2_2
Xinput9 measurement[16] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_1
X_15855_ net301 _05597_ _05600_ VGND VGND VPWR VPWR _06983_ sky130_fd_sc_hd__and3_2
X_14806_ _05827_ _05828_ VGND VGND VPWR VPWR _05829_ sky130_fd_sc_hd__and2_1
X_15786_ net285 _05665_ _05974_ net282 VGND VGND VPWR VPWR _06907_ sky130_fd_sc_hd__a22o_1
XFILLER_0_86_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12998_ _03739_ _03841_ VGND VGND VPWR VPWR _03842_ sky130_fd_sc_hd__or2_1
X_17525_ clknet_4_6_0_clock _00031_ VGND VGND VPWR VPWR kd_2\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_129_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14737_ _05747_ _05752_ VGND VGND VPWR VPWR _05753_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_52_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11949_ _02684_ _02759_ VGND VGND VPWR VPWR _02760_ sky130_fd_sc_hd__nor2_1
XFILLER_0_86_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17456_ clknet_4_15_0_clock _00134_ VGND VGND VPWR VPWR prev_d_error\[8\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_129_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14668_ prev_error\[13\] _04747_ _04428_ VGND VGND VPWR VPWR _05677_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16407_ _06803_ VGND VGND VPWR VPWR _07590_ sky130_fd_sc_hd__inv_2
X_13619_ _04521_ _04522_ VGND VGND VPWR VPWR _04523_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17387_ net465 net392 net458 _08599_ VGND VGND VPWR VPWR _00140_ sky130_fd_sc_hd__o211a_1
X_14599_ _05597_ _05600_ VGND VGND VPWR VPWR _05601_ sky130_fd_sc_hd__and2_1
XFILLER_0_55_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16338_ _05884_ _05885_ VGND VGND VPWR VPWR _07514_ sky130_fd_sc_hd__nor2_1
XFILLER_0_125_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16269_ _07436_ _07434_ VGND VGND VPWR VPWR _07438_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09712_ _00514_ _00515_ _00522_ VGND VGND VPWR VPWR _00523_ sky130_fd_sc_hd__o21ai_1
X_09643_ net377 net520 _00453_ VGND VGND VPWR VPWR _00454_ sky130_fd_sc_hd__a21oi_1
X_09574_ net344 _04439_ VGND VGND VPWR VPWR _00385_ sky130_fd_sc_hd__nand2_1
XFILLER_0_65_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09008_ _06111_ _06122_ VGND VGND VPWR VPWR _06133_ sky130_fd_sc_hd__nand2_1
XFILLER_0_103_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10280_ _01079_ _01090_ VGND VGND VPWR VPWR _01091_ sky130_fd_sc_hd__nand2_1
XFILLER_0_112_890 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13970_ _04884_ _04905_ VGND VGND VPWR VPWR _04909_ sky130_fd_sc_hd__xnor2_1
X_12921_ _03761_ _03734_ _03763_ VGND VGND VPWR VPWR _03765_ sky130_fd_sc_hd__nor3_1
X_15640_ _06737_ _06739_ _06744_ VGND VGND VPWR VPWR _06746_ sky130_fd_sc_hd__nor3_4
XFILLER_0_69_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12852_ _03423_ _03431_ VGND VGND VPWR VPWR _03696_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11803_ _02609_ _02611_ _02613_ VGND VGND VPWR VPWR _02614_ sky130_fd_sc_hd__o21ai_1
X_15571_ _06668_ _06669_ VGND VGND VPWR VPWR _06670_ sky130_fd_sc_hd__xor2_1
X_12783_ _03619_ _03621_ _03625_ VGND VGND VPWR VPWR _03627_ sky130_fd_sc_hd__or3_1
X_17310_ net461 prev_error\[13\] VGND VGND VPWR VPWR _08552_ sky130_fd_sc_hd__or2_1
X_14522_ _05515_ VGND VGND VPWR VPWR _05516_ sky130_fd_sc_hd__inv_2
X_11734_ _02449_ _02448_ VGND VGND VPWR VPWR _02545_ sky130_fd_sc_hd__xor2_2
XFILLER_0_138_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17241_ _08462_ _08495_ _08480_ VGND VGND VPWR VPWR _08504_ sky130_fd_sc_hd__a21oi_2
X_14453_ _05438_ _05439_ VGND VGND VPWR VPWR _05441_ sky130_fd_sc_hd__nor2_2
X_11665_ _02473_ _02475_ VGND VGND VPWR VPWR _02476_ sky130_fd_sc_hd__nor2_1
XFILLER_0_126_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10616_ _00966_ _01038_ _01424_ _01425_ _01426_ VGND VGND VPWR VPWR _01427_ sky130_fd_sc_hd__a311o_1
X_13404_ _04284_ _04286_ VGND VGND VPWR VPWR _04287_ sky130_fd_sc_hd__or2_1
X_14384_ _05361_ _05362_ VGND VGND VPWR VPWR _05365_ sky130_fd_sc_hd__nor2_1
X_17172_ net385 net106 VGND VGND VPWR VPWR _08431_ sky130_fd_sc_hd__nand2_1
XFILLER_0_98_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11596_ _02331_ _02333_ VGND VGND VPWR VPWR _02407_ sky130_fd_sc_hd__xor2_1
XFILLER_0_24_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16123_ _07274_ _07275_ _07276_ VGND VGND VPWR VPWR _07278_ sky130_fd_sc_hd__or3_4
X_13335_ _04204_ _04210_ VGND VGND VPWR VPWR _04211_ sky130_fd_sc_hd__or2b_1
XFILLER_0_134_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10547_ _01350_ _01354_ VGND VGND VPWR VPWR _01358_ sky130_fd_sc_hd__xor2_1
XFILLER_0_24_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16054_ _07198_ _07201_ VGND VGND VPWR VPWR _07202_ sky130_fd_sc_hd__nand2_1
X_13266_ _04124_ _04133_ _04134_ VGND VGND VPWR VPWR _04135_ sky130_fd_sc_hd__o21ai_1
X_10478_ _01258_ _01285_ VGND VGND VPWR VPWR _01289_ sky130_fd_sc_hd__xor2_1
XFILLER_0_20_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15005_ net269 _05630_ _06047_ VGND VGND VPWR VPWR _06048_ sky130_fd_sc_hd__and3_1
X_12217_ net440 net171 net175 net436 VGND VGND VPWR VPWR _03044_ sky130_fd_sc_hd__a22o_1
XFILLER_0_121_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13197_ _04020_ _04058_ VGND VGND VPWR VPWR _04059_ sky130_fd_sc_hd__xor2_1
X_12148_ _02956_ _02959_ _02958_ VGND VGND VPWR VPWR _02973_ sky130_fd_sc_hd__a21o_1
XFILLER_0_138_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16956_ _08174_ _08183_ _08193_ VGND VGND VPWR VPWR _08194_ sky130_fd_sc_hd__a21oi_1
X_12079_ _02876_ _02885_ _02900_ VGND VGND VPWR VPWR _02901_ sky130_fd_sc_hd__a21o_1
X_15907_ _06959_ _07033_ _07010_ _07032_ VGND VGND VPWR VPWR _07040_ sky130_fd_sc_hd__a211oi_4
X_16887_ _05287_ _08117_ VGND VGND VPWR VPWR _08118_ sky130_fd_sc_hd__or2_2
XPHY_EDGE_ROW_139_Right_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15838_ _06932_ _06963_ VGND VGND VPWR VPWR _06964_ sky130_fd_sc_hd__nor2_1
XFILLER_0_87_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15769_ _06886_ _06887_ VGND VGND VPWR VPWR _06888_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17508_ clknet_4_1_0_clock _00014_ VGND VGND VPWR VPWR kd_1\[6\] sky130_fd_sc_hd__dfxtp_1
X_09290_ _08627_ _08653_ VGND VGND VPWR VPWR _08654_ sky130_fd_sc_hd__and2b_1
XFILLER_0_129_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17439_ clknet_4_9_0_clock _00117_ VGND VGND VPWR VPWR i_error\[9\] sky130_fd_sc_hd__dfxtp_2
XANTENNA_14 _08447_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_25 _03333_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_36 kp\[5\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_144_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_106_Right_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09626_ _00428_ _00435_ _00436_ VGND VGND VPWR VPWR _00437_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_97_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09557_ net319 net315 _00242_ _00316_ VGND VGND VPWR VPWR _00368_ sky130_fd_sc_hd__and4_1
X_09488_ _00297_ _00298_ VGND VGND VPWR VPWR _00299_ sky130_fd_sc_hd__and2b_1
XFILLER_0_148_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11450_ _02131_ _02260_ VGND VGND VPWR VPWR _02261_ sky130_fd_sc_hd__nor2_1
XFILLER_0_18_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10401_ _01211_ _01191_ VGND VGND VPWR VPWR _01212_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_135_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11381_ _02190_ _02191_ VGND VGND VPWR VPWR _02192_ sky130_fd_sc_hd__and2_1
XFILLER_0_61_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13120_ _03914_ _03912_ VGND VGND VPWR VPWR _03974_ sky130_fd_sc_hd__or2b_1
X_10332_ _01139_ _01140_ _01142_ VGND VGND VPWR VPWR _01143_ sky130_fd_sc_hd__a21bo_1
X_13051_ _03890_ _03896_ _03897_ VGND VGND VPWR VPWR _03898_ sky130_fd_sc_hd__a21o_1
X_10263_ _01072_ _01073_ VGND VGND VPWR VPWR _01074_ sky130_fd_sc_hd__nand2_1
X_12002_ net443 net139 _02756_ _02757_ VGND VGND VPWR VPWR _02816_ sky130_fd_sc_hd__o2bb2a_1
X_10194_ _00960_ _00961_ VGND VGND VPWR VPWR _01005_ sky130_fd_sc_hd__xor2_4
X_16810_ _08032_ VGND VGND VPWR VPWR _08033_ sky130_fd_sc_hd__buf_6
Xfanout370 kp\[2\] VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__buf_2
Xfanout381 prev_d_error\[16\] VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__buf_2
X_16741_ _07945_ _07956_ VGND VGND VPWR VPWR _07957_ sky130_fd_sc_hd__xnor2_1
Xfanout392 prev_d_error\[14\] VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__clkbuf_4
X_13953_ _04889_ _04807_ VGND VGND VPWR VPWR _04891_ sky130_fd_sc_hd__xnor2_2
X_12904_ prev_error\[5\] _08673_ VGND VGND VPWR VPWR _03748_ sky130_fd_sc_hd__xor2_4
X_16672_ net254 _05705_ VGND VGND VPWR VPWR _07881_ sky130_fd_sc_hd__nand2_1
X_13884_ _04811_ _04812_ _04814_ VGND VGND VPWR VPWR _04815_ sky130_fd_sc_hd__or3b_1
X_15623_ _06725_ _06726_ VGND VGND VPWR VPWR _06728_ sky130_fd_sc_hd__and2_1
X_12835_ _03677_ _03678_ VGND VGND VPWR VPWR _03679_ sky130_fd_sc_hd__nor2_1
X_15554_ net289 _05622_ _06301_ _06651_ VGND VGND VPWR VPWR _06652_ sky130_fd_sc_hd__a31o_1
X_12766_ _03592_ _03602_ _03604_ VGND VGND VPWR VPWR _03610_ sky130_fd_sc_hd__or3_1
XFILLER_0_83_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14505_ _06430_ _05497_ VGND VGND VPWR VPWR _05498_ sky130_fd_sc_hd__xnor2_1
X_11717_ _02525_ _02527_ VGND VGND VPWR VPWR _02528_ sky130_fd_sc_hd__and2b_1
X_15485_ _06567_ _06572_ _06575_ VGND VGND VPWR VPWR _06576_ sky130_fd_sc_hd__nand3_1
X_12697_ net210 _03328_ VGND VGND VPWR VPWR _03536_ sky130_fd_sc_hd__nand2_1
X_17224_ _08470_ _08191_ _08188_ VGND VGND VPWR VPWR _08489_ sky130_fd_sc_hd__a21boi_1
X_14436_ _08661_ _01449_ VGND VGND VPWR VPWR _05422_ sky130_fd_sc_hd__xor2_4
X_11648_ net444 net119 _02311_ VGND VGND VPWR VPWR _02459_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_140_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput12 measurement[2] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_1
Xinput23 reg_addr[12] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_2
XFILLER_0_25_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput34 reg_addr[6] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
Xinput45 reg_data[16] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_4
X_17155_ _08282_ _08283_ _05383_ VGND VGND VPWR VPWR _08413_ sky130_fd_sc_hd__o21ba_1
X_11579_ _02366_ _02341_ _02364_ VGND VGND VPWR VPWR _02390_ sky130_fd_sc_hd__nand3_1
X_14367_ _05344_ _05345_ VGND VGND VPWR VPWR _05346_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput56 reset VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__buf_1
XFILLER_0_40_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput67 target[2] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__clkbuf_1
X_16106_ net272 _04315_ VGND VGND VPWR VPWR _07259_ sky130_fd_sc_hd__nand2_1
XFILLER_0_141_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13318_ _04190_ _04191_ VGND VGND VPWR VPWR _04192_ sky130_fd_sc_hd__or2b_1
X_14298_ _03143_ _02851_ VGND VGND VPWR VPWR _05270_ sky130_fd_sc_hd__nor2_1
X_17086_ _01505_ _08336_ VGND VGND VPWR VPWR _08337_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_150_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16037_ _07124_ _07127_ _07182_ VGND VGND VPWR VPWR _07183_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_149_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13249_ _04099_ _04115_ VGND VGND VPWR VPWR _04116_ sky130_fd_sc_hd__and2b_1
XFILLER_0_0_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08790_ net44 _03542_ _03575_ net320 VGND VGND VPWR VPWR _00060_ sky130_fd_sc_hd__a22o_1
X_16939_ _05235_ _05293_ VGND VGND VPWR VPWR _08175_ sky130_fd_sc_hd__xor2_4
XFILLER_0_79_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09411_ _00212_ _00217_ _00221_ VGND VGND VPWR VPWR _00222_ sky130_fd_sc_hd__o21a_1
XFILLER_0_149_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09342_ _00151_ _00152_ VGND VGND VPWR VPWR _00153_ sky130_fd_sc_hd__nor2_1
XFILLER_0_75_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09273_ net314 _07948_ _07420_ net318 VGND VGND VPWR VPWR _08637_ sky130_fd_sc_hd__a22o_1
XFILLER_0_7_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08988_ _05759_ _05715_ _05737_ VGND VGND VPWR VPWR _05913_ sky130_fd_sc_hd__and3_1
X_10950_ net383 net387 net145 net146 VGND VGND VPWR VPWR _01761_ sky130_fd_sc_hd__and4_1
X_09609_ _00398_ _00411_ VGND VGND VPWR VPWR _00420_ sky130_fd_sc_hd__nand2_1
X_10881_ net389 net112 _01690_ VGND VGND VPWR VPWR _01692_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_78_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12620_ _03434_ _03458_ VGND VGND VPWR VPWR _03459_ sky130_fd_sc_hd__nor2_1
XFILLER_0_39_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12551_ net204 _03336_ _03328_ net209 VGND VGND VPWR VPWR _03390_ sky130_fd_sc_hd__a22o_1
XFILLER_0_109_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11502_ net444 net115 _02222_ _02223_ VGND VGND VPWR VPWR _02313_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_108_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12482_ _03304_ _03313_ _03316_ VGND VGND VPWR VPWR _03317_ sky130_fd_sc_hd__a21oi_4
X_15270_ net263 _05974_ VGND VGND VPWR VPWR _06339_ sky130_fd_sc_hd__nand2_2
XFILLER_0_34_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14221_ _05180_ _05182_ VGND VGND VPWR VPWR _05185_ sky130_fd_sc_hd__nor2_1
X_11433_ net418 net137 VGND VGND VPWR VPWR _02244_ sky130_fd_sc_hd__nand2_1
XFILLER_0_110_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14152_ _05057_ _05062_ _05089_ _05108_ VGND VGND VPWR VPWR _05109_ sky130_fd_sc_hd__and4_1
X_11364_ _02106_ _02174_ VGND VGND VPWR VPWR _02175_ sky130_fd_sc_hd__nand2_1
XFILLER_0_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10315_ net346 _00373_ _01124_ _01125_ VGND VGND VPWR VPWR _01126_ sky130_fd_sc_hd__a31o_2
X_13103_ _03856_ _03954_ VGND VGND VPWR VPWR _03956_ sky130_fd_sc_hd__nor2_1
X_14083_ _05024_ _05029_ VGND VGND VPWR VPWR _05034_ sky130_fd_sc_hd__xnor2_1
X_11295_ _02095_ _02103_ _02105_ VGND VGND VPWR VPWR _02106_ sky130_fd_sc_hd__a21o_1
XFILLER_0_131_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13034_ _03779_ _03879_ VGND VGND VPWR VPWR _03880_ sky130_fd_sc_hd__or2_1
X_10246_ _01054_ _01056_ VGND VGND VPWR VPWR _01057_ sky130_fd_sc_hd__nor2_1
XFILLER_0_119_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10177_ net335 _00372_ VGND VGND VPWR VPWR _00988_ sky130_fd_sc_hd__nand2_1
X_14985_ _05982_ _06025_ VGND VGND VPWR VPWR _06026_ sky130_fd_sc_hd__or2_1
XFILLER_0_89_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16724_ _07935_ _07938_ VGND VGND VPWR VPWR _07939_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13936_ net218 net214 _03934_ _04002_ VGND VGND VPWR VPWR _04872_ sky130_fd_sc_hd__and4_1
X_16655_ _07697_ _07682_ VGND VGND VPWR VPWR _07863_ sky130_fd_sc_hd__or2b_1
X_13867_ _04790_ _04794_ _04795_ VGND VGND VPWR VPWR _04796_ sky130_fd_sc_hd__and3_1
X_15606_ _06621_ _06640_ VGND VGND VPWR VPWR _06709_ sky130_fd_sc_hd__and2_1
X_12818_ net180 _03270_ VGND VGND VPWR VPWR _03662_ sky130_fd_sc_hd__nand2_1
X_16586_ _07785_ _07786_ VGND VGND VPWR VPWR _07787_ sky130_fd_sc_hd__nor2_1
X_13798_ _04717_ _04718_ _04719_ VGND VGND VPWR VPWR _04720_ sky130_fd_sc_hd__nand3_2
XFILLER_0_8_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15537_ net259 _06162_ _06632_ VGND VGND VPWR VPWR _06633_ sky130_fd_sc_hd__and3_1
X_12749_ _03546_ _03549_ _03591_ VGND VGND VPWR VPWR _03593_ sky130_fd_sc_hd__and3_1
XFILLER_0_121_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15468_ net282 _05589_ _05581_ net285 VGND VGND VPWR VPWR _06557_ sky130_fd_sc_hd__a22o_1
X_17207_ _08160_ _08164_ VGND VGND VPWR VPWR _08470_ sky130_fd_sc_hd__nor2_1
XFILLER_0_127_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14419_ _05401_ _05402_ VGND VGND VPWR VPWR _05403_ sky130_fd_sc_hd__nor2_1
X_15399_ _06431_ _06433_ VGND VGND VPWR VPWR _06481_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_53_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17138_ kd_1\[17\] _04073_ VGND VGND VPWR VPWR _08394_ sky130_fd_sc_hd__nand2_1
XFILLER_0_130_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09960_ net324 _00373_ _00645_ VGND VGND VPWR VPWR _00771_ sky130_fd_sc_hd__a21oi_1
X_17069_ net381 net109 VGND VGND VPWR VPWR _08318_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08911_ net322 _04780_ _05044_ _05055_ VGND VGND VPWR VPWR _05066_ sky130_fd_sc_hd__a31o_1
X_09891_ _00699_ _00701_ VGND VGND VPWR VPWR _00702_ sky130_fd_sc_hd__nand2_1
X_08842_ _04219_ _04164_ _04296_ net72 _04274_ VGND VGND VPWR VPWR _04307_ sky130_fd_sc_hd__a32o_1
X_08773_ _03564_ VGND VGND VPWR VPWR _03575_ sky130_fd_sc_hd__buf_2
XFILLER_0_109_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09325_ _08670_ _08686_ _08688_ VGND VGND VPWR VPWR _08689_ sky130_fd_sc_hd__o21a_1
XFILLER_0_48_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09256_ _07838_ _08619_ VGND VGND VPWR VPWR _08620_ sky130_fd_sc_hd__or2_1
XFILLER_0_146_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09187_ _05506_ _08069_ _08080_ VGND VGND VPWR VPWR _08102_ sky130_fd_sc_hd__and3_1
XFILLER_0_90_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10100_ _00907_ _00908_ _00910_ VGND VGND VPWR VPWR _00911_ sky130_fd_sc_hd__o21ai_1
X_11080_ net395 net398 net141 net144 VGND VGND VPWR VPWR _01891_ sky130_fd_sc_hd__and4_1
XFILLER_0_11_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10031_ _00795_ _00841_ VGND VGND VPWR VPWR _00842_ sky130_fd_sc_hd__nand2_1
X_14770_ _05673_ _05788_ _05786_ VGND VGND VPWR VPWR _05789_ sky130_fd_sc_hd__a21o_1
X_11982_ _02731_ _02793_ VGND VGND VPWR VPWR _02794_ sky130_fd_sc_hd__xnor2_1
X_13721_ _04629_ _04633_ net99 _04634_ VGND VGND VPWR VPWR _04635_ sky130_fd_sc_hd__a211oi_2
X_10933_ _01547_ _01743_ VGND VGND VPWR VPWR _01744_ sky130_fd_sc_hd__or2_1
XFILLER_0_98_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16440_ i_error\[0\] _07625_ VGND VGND VPWR VPWR _07626_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13652_ _04554_ _04558_ VGND VGND VPWR VPWR _04559_ sky130_fd_sc_hd__and2b_2
X_10864_ _01673_ _01674_ VGND VGND VPWR VPWR _01675_ sky130_fd_sc_hd__and2_1
X_12603_ _03348_ _03352_ _03441_ VGND VGND VPWR VPWR _03442_ sky130_fd_sc_hd__o21a_1
XFILLER_0_27_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16371_ _05879_ _05888_ _07549_ VGND VGND VPWR VPWR _07550_ sky130_fd_sc_hd__o21a_1
XFILLER_0_54_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13583_ _04455_ _04482_ VGND VGND VPWR VPWR _04484_ sky130_fd_sc_hd__xnor2_4
X_10795_ _01604_ _01605_ VGND VGND VPWR VPWR _01606_ sky130_fd_sc_hd__nand2_1
XFILLER_0_137_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15322_ _06361_ _06363_ VGND VGND VPWR VPWR _06396_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_26_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12534_ net221 _03345_ VGND VGND VPWR VPWR _03373_ sky130_fd_sc_hd__and2_1
XFILLER_0_124_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15253_ _06235_ _06318_ _06319_ VGND VGND VPWR VPWR _06321_ sky130_fd_sc_hd__o21a_1
X_12465_ _03287_ _03291_ _03298_ VGND VGND VPWR VPWR _03299_ sky130_fd_sc_hd__o21a_1
XFILLER_0_53_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14204_ _04693_ _04729_ _04728_ VGND VGND VPWR VPWR _05167_ sky130_fd_sc_hd__and3_1
X_11416_ net445 net110 _01939_ VGND VGND VPWR VPWR _02227_ sky130_fd_sc_hd__and3_1
X_15184_ _06227_ _06228_ VGND VGND VPWR VPWR _06245_ sky130_fd_sc_hd__xor2_1
X_12396_ prev_error\[10\] _04593_ VGND VGND VPWR VPWR _03228_ sky130_fd_sc_hd__and2b_1
XFILLER_0_111_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14135_ _05087_ _05090_ VGND VGND VPWR VPWR _05091_ sky130_fd_sc_hd__xnor2_1
X_11347_ _02079_ _02081_ VGND VGND VPWR VPWR _02158_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11278_ net398 net153 VGND VGND VPWR VPWR _02089_ sky130_fd_sc_hd__and2_1
X_14066_ _04981_ _05014_ VGND VGND VPWR VPWR _05015_ sky130_fd_sc_hd__xnor2_2
X_10229_ net345 _00242_ VGND VGND VPWR VPWR _01040_ sky130_fd_sc_hd__nand2_1
X_13017_ _03859_ _03860_ VGND VGND VPWR VPWR _03861_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14968_ _05963_ _06006_ VGND VGND VPWR VPWR _06007_ sky130_fd_sc_hd__nor2_1
X_16707_ _07747_ _07749_ _07859_ _07919_ VGND VGND VPWR VPWR _07920_ sky130_fd_sc_hd__a31oi_4
XFILLER_0_77_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13919_ _04841_ _04844_ _04845_ _04840_ _04838_ VGND VGND VPWR VPWR _04853_ sky130_fd_sc_hd__a32o_1
X_14899_ _05848_ _05930_ _05850_ VGND VGND VPWR VPWR _05931_ sky130_fd_sc_hd__o21a_1
XFILLER_0_89_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16638_ i_error\[8\] VGND VGND VPWR VPWR _07844_ sky130_fd_sc_hd__inv_2
XFILLER_0_29_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16569_ _05469_ _05519_ VGND VGND VPWR VPWR _07768_ sky130_fd_sc_hd__xor2_4
XFILLER_0_91_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09110_ _05957_ _05990_ VGND VGND VPWR VPWR _07255_ sky130_fd_sc_hd__xor2_1
XFILLER_0_72_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_143_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09041_ _06441_ _06485_ VGND VGND VPWR VPWR _06496_ sky130_fd_sc_hd__xor2_1
XFILLER_0_26_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09943_ _00752_ _00753_ VGND VGND VPWR VPWR _00754_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_111_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09874_ _00682_ _00684_ _00679_ VGND VGND VPWR VPWR _00685_ sky130_fd_sc_hd__o21a_1
X_08825_ net13 net68 VGND VGND VPWR VPWR _04120_ sky130_fd_sc_hd__and2b_1
X_08756_ net50 _03318_ _03351_ net295 VGND VGND VPWR VPWR _00048_ sky130_fd_sc_hd__a22o_1
XFILLER_0_67_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09308_ _04197_ _04032_ _04131_ _04175_ VGND VGND VPWR VPWR _08672_ sky130_fd_sc_hd__a31o_1
X_10580_ _01377_ _01390_ VGND VGND VPWR VPWR _01391_ sky130_fd_sc_hd__nor2_1
Xclkbuf_4_7_0_clock clknet_0_clock VGND VGND VPWR VPWR clknet_4_7_0_clock sky130_fd_sc_hd__clkbuf_8
X_09239_ _08579_ _08597_ VGND VGND VPWR VPWR _08603_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12250_ net448 net164 _03079_ VGND VGND VPWR VPWR _03080_ sky130_fd_sc_hd__nand3_1
XFILLER_0_134_888 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11201_ _01905_ _01896_ _01903_ VGND VGND VPWR VPWR _02012_ sky130_fd_sc_hd__nand3_1
X_12181_ net449 net157 net172 net429 VGND VGND VPWR VPWR _03006_ sky130_fd_sc_hd__a22oi_2
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11132_ net425 net114 _01940_ _01941_ VGND VGND VPWR VPWR _01943_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_102_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15940_ net285 _06161_ VGND VGND VPWR VPWR _07076_ sky130_fd_sc_hd__nand2_2
X_11063_ net407 net413 net130 net126 VGND VGND VPWR VPWR _01874_ sky130_fd_sc_hd__and4_1
X_10014_ _00798_ _00824_ VGND VGND VPWR VPWR _00825_ sky130_fd_sc_hd__nor2_1
X_15871_ _06998_ _06999_ VGND VGND VPWR VPWR _07000_ sky130_fd_sc_hd__or2b_1
X_14822_ _05841_ _05843_ _05845_ VGND VGND VPWR VPWR _05846_ sky130_fd_sc_hd__a21o_1
X_14753_ _05643_ _05585_ _05645_ VGND VGND VPWR VPWR _05771_ sky130_fd_sc_hd__o21bai_1
X_11965_ _02699_ _02773_ _02769_ _02772_ VGND VGND VPWR VPWR _02776_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13704_ net243 _03216_ VGND VGND VPWR VPWR _04617_ sky130_fd_sc_hd__nand2_1
X_17472_ clknet_4_0_0_clock _00068_ VGND VGND VPWR VPWR kp\[6\] sky130_fd_sc_hd__dfxtp_2
X_10916_ _01719_ _01722_ _01726_ VGND VGND VPWR VPWR _01727_ sky130_fd_sc_hd__o21ai_2
X_14684_ _05688_ _05694_ VGND VGND VPWR VPWR _05695_ sky130_fd_sc_hd__or2_1
X_11896_ _02630_ _02631_ _02601_ _02632_ VGND VGND VPWR VPWR _02707_ sky130_fd_sc_hd__a2bb2o_1
X_16423_ net476 _07606_ i_error\[5\] VGND VGND VPWR VPWR _07608_ sky130_fd_sc_hd__a21oi_2
X_13635_ _04463_ _04462_ VGND VGND VPWR VPWR _04541_ sky130_fd_sc_hd__and2b_1
X_10847_ _01656_ _01657_ VGND VGND VPWR VPWR _01658_ sky130_fd_sc_hd__or2_1
XFILLER_0_66_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16354_ _07529_ _07531_ VGND VGND VPWR VPWR _07532_ sky130_fd_sc_hd__nor2_1
XFILLER_0_41_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13566_ _04375_ _04460_ _04464_ VGND VGND VPWR VPWR _04465_ sky130_fd_sc_hd__and3_1
XFILLER_0_15_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10778_ _01582_ _01588_ VGND VGND VPWR VPWR _01589_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_26_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15305_ net288 _05736_ _06307_ _06308_ VGND VGND VPWR VPWR _06378_ sky130_fd_sc_hd__a22o_1
XFILLER_0_54_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12517_ _03354_ _03330_ _03341_ VGND VGND VPWR VPWR _03356_ sky130_fd_sc_hd__nor3_1
X_16285_ _07430_ _07432_ VGND VGND VPWR VPWR _07456_ sky130_fd_sc_hd__nor2_1
XFILLER_0_136_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13497_ _04386_ _04388_ VGND VGND VPWR VPWR _04389_ sky130_fd_sc_hd__and2b_1
XFILLER_0_125_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15236_ net277 _05621_ VGND VGND VPWR VPWR _06302_ sky130_fd_sc_hd__nand2_1
XFILLER_0_124_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12448_ _03218_ _03220_ _03279_ VGND VGND VPWR VPWR _03280_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_112_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15167_ _06223_ _06224_ VGND VGND VPWR VPWR _06226_ sky130_fd_sc_hd__nor2_1
XFILLER_0_140_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12379_ prev_error\[10\] _04593_ VGND VGND VPWR VPWR _03211_ sky130_fd_sc_hd__and2b_1
XFILLER_0_10_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14118_ _05070_ _05069_ VGND VGND VPWR VPWR _05072_ sky130_fd_sc_hd__xnor2_1
X_15098_ _06127_ _06148_ _06080_ _06149_ VGND VGND VPWR VPWR _06150_ sky130_fd_sc_hd__o211ai_4
X_14049_ _04983_ _04988_ VGND VGND VPWR VPWR _04996_ sky130_fd_sc_hd__xor2_1
X_09590_ net343 _05143_ _05154_ VGND VGND VPWR VPWR _00401_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09024_ _06287_ _06298_ VGND VGND VPWR VPWR _06309_ sky130_fd_sc_hd__nor2_4
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09926_ net361 _00736_ _05000_ VGND VGND VPWR VPWR _00737_ sky130_fd_sc_hd__nand3_1
X_09857_ net347 _07420_ _00666_ _00667_ VGND VGND VPWR VPWR _00668_ sky130_fd_sc_hd__a31oi_1
X_08808_ net4 net59 VGND VGND VPWR VPWR _03933_ sky130_fd_sc_hd__or2b_1
X_09788_ _00527_ _00598_ VGND VGND VPWR VPWR _00599_ sky130_fd_sc_hd__or2_1
X_08739_ net41 _03050_ _03083_ net196 VGND VGND VPWR VPWR _00003_ sky130_fd_sc_hd__a22o_1
X_11750_ _02559_ _02560_ VGND VGND VPWR VPWR _02561_ sky130_fd_sc_hd__or2_1
X_10701_ net390 net121 VGND VGND VPWR VPWR _01512_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11681_ _02457_ VGND VGND VPWR VPWR _02492_ sky130_fd_sc_hd__inv_2
XFILLER_0_48_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13420_ net184 _04004_ _04303_ VGND VGND VPWR VPWR _04304_ sky130_fd_sc_hd__and3_1
X_10632_ _08656_ _08655_ VGND VGND VPWR VPWR _01443_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_36_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10563_ net376 _00372_ VGND VGND VPWR VPWR _01374_ sky130_fd_sc_hd__nand2_1
XFILLER_0_106_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13351_ _04101_ _04100_ VGND VGND VPWR VPWR _04228_ sky130_fd_sc_hd__or2b_1
XFILLER_0_23_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12302_ _03102_ _03125_ _03133_ VGND VGND VPWR VPWR _03134_ sky130_fd_sc_hd__a21o_1
X_16070_ _07158_ _07217_ _07216_ _07202_ VGND VGND VPWR VPWR _07219_ sky130_fd_sc_hd__o211a_1
XFILLER_0_106_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10494_ _01271_ _01291_ _01304_ VGND VGND VPWR VPWR _01305_ sky130_fd_sc_hd__nand3_1
X_13282_ _04149_ _04151_ VGND VGND VPWR VPWR _04152_ sky130_fd_sc_hd__or2b_1
XFILLER_0_16_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15021_ net304 _05840_ VGND VGND VPWR VPWR _06065_ sky130_fd_sc_hd__nand2_1
X_12233_ _03040_ _03060_ VGND VGND VPWR VPWR _03062_ sky130_fd_sc_hd__or2_1
XFILLER_0_122_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12164_ net424 net169 _02977_ _02976_ VGND VGND VPWR VPWR _02989_ sky130_fd_sc_hd__a31o_1
X_11115_ _01923_ _01925_ VGND VGND VPWR VPWR _01926_ sky130_fd_sc_hd__or2_1
X_16972_ _07831_ VGND VGND VPWR VPWR _08211_ sky130_fd_sc_hd__inv_2
X_12095_ _02895_ _02898_ _02918_ VGND VGND VPWR VPWR _02919_ sky130_fd_sc_hd__a21o_1
X_11046_ _01854_ _01856_ VGND VGND VPWR VPWR _01857_ sky130_fd_sc_hd__or2_1
X_15923_ net297 _05665_ VGND VGND VPWR VPWR _07058_ sky130_fd_sc_hd__nand2_1
XFILLER_0_127_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15854_ net297 _05602_ _05588_ net301 VGND VGND VPWR VPWR _06982_ sky130_fd_sc_hd__a22o_1
X_14805_ _05806_ _05809_ _05826_ VGND VGND VPWR VPWR _05828_ sky130_fd_sc_hd__or3_1
X_15785_ net278 _06017_ VGND VGND VPWR VPWR _06906_ sky130_fd_sc_hd__nand2_1
X_12997_ _03736_ _03738_ VGND VGND VPWR VPWR _03841_ sky130_fd_sc_hd__and2_1
XFILLER_0_99_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17524_ clknet_4_6_0_clock _00030_ VGND VGND VPWR VPWR kd_2\[4\] sky130_fd_sc_hd__dfxtp_1
X_14736_ _05750_ _05751_ VGND VGND VPWR VPWR _05752_ sky130_fd_sc_hd__or2b_1
XFILLER_0_59_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11948_ net442 net135 _02682_ _02683_ VGND VGND VPWR VPWR _02759_ sky130_fd_sc_hd__o2bb2a_1
X_17455_ clknet_4_14_0_clock _00133_ VGND VGND VPWR VPWR prev_d_error\[7\] sky130_fd_sc_hd__dfxtp_2
X_14667_ _05617_ _05624_ _05675_ _03281_ _03225_ VGND VGND VPWR VPWR _05676_ sky130_fd_sc_hd__a2111oi_4
X_11879_ _02686_ _02682_ _02684_ VGND VGND VPWR VPWR _02690_ sky130_fd_sc_hd__or3_1
XFILLER_0_7_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16406_ _06974_ _07492_ _07495_ VGND VGND VPWR VPWR _07589_ sky130_fd_sc_hd__a21o_1
X_13618_ _04449_ _04448_ VGND VGND VPWR VPWR _04522_ sky130_fd_sc_hd__xor2_1
X_17386_ net465 _08039_ VGND VGND VPWR VPWR _08599_ sky130_fd_sc_hd__nand2_1
X_14598_ _05598_ _05599_ _03267_ VGND VGND VPWR VPWR _05600_ sky130_fd_sc_hd__a21o_1
XFILLER_0_15_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16337_ _05821_ _05823_ VGND VGND VPWR VPWR _07513_ sky130_fd_sc_hd__nor2_1
X_13549_ _04440_ _04443_ _04445_ VGND VGND VPWR VPWR _04446_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_27_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16268_ _07434_ _07436_ VGND VGND VPWR VPWR _07437_ sky130_fd_sc_hd__and2b_1
XFILLER_0_11_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15219_ _06277_ _06279_ VGND VGND VPWR VPWR _06283_ sky130_fd_sc_hd__and2b_1
XFILLER_0_112_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16199_ _07349_ _07350_ _07359_ _07360_ VGND VGND VPWR VPWR _07361_ sky130_fd_sc_hd__a31o_1
XFILLER_0_121_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09711_ _04560_ _00520_ _00521_ VGND VGND VPWR VPWR _00522_ sky130_fd_sc_hd__or3_1
X_09642_ net360 _04879_ _04890_ VGND VGND VPWR VPWR _00453_ sky130_fd_sc_hd__and3_1
X_09573_ _00382_ _04923_ net356 _00383_ VGND VGND VPWR VPWR _00384_ sky130_fd_sc_hd__and4b_1
XFILLER_0_77_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09007_ _06100_ _06089_ VGND VGND VPWR VPWR _06122_ sky130_fd_sc_hd__or2b_1
XFILLER_0_20_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09909_ _00718_ _00717_ _00694_ _00693_ VGND VGND VPWR VPWR _00720_ sky130_fd_sc_hd__o211a_1
X_12920_ _03761_ _03734_ _03763_ VGND VGND VPWR VPWR _03764_ sky130_fd_sc_hd__o21a_1
XFILLER_0_69_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12851_ net240 net230 _03422_ VGND VGND VPWR VPWR _03695_ sky130_fd_sc_hd__and3_1
X_11802_ _02490_ _02612_ VGND VGND VPWR VPWR _02613_ sky130_fd_sc_hd__nor2_1
X_15570_ _06318_ _06555_ _06604_ _06625_ VGND VGND VPWR VPWR _06669_ sky130_fd_sc_hd__o22ai_2
X_12782_ _03619_ _03621_ _03625_ VGND VGND VPWR VPWR _03626_ sky130_fd_sc_hd__o21ai_2
X_14521_ _05513_ _07035_ _05514_ VGND VGND VPWR VPWR _05515_ sky130_fd_sc_hd__nand3_2
XFILLER_0_95_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11733_ _02535_ _02537_ VGND VGND VPWR VPWR _02544_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17240_ _08498_ net87 VGND VGND VPWR VPWR _08503_ sky130_fd_sc_hd__and2_1
X_14452_ _01038_ net484 _00966_ VGND VGND VPWR VPWR _05439_ sky130_fd_sc_hd__a21oi_4
X_11664_ _02337_ _02455_ _02472_ VGND VGND VPWR VPWR _02475_ sky130_fd_sc_hd__a21oi_1
X_13403_ _04273_ _04277_ VGND VGND VPWR VPWR _04286_ sky130_fd_sc_hd__and2b_1
X_10615_ _00891_ _00895_ _00812_ _00817_ VGND VGND VPWR VPWR _01426_ sky130_fd_sc_hd__a211oi_2
X_17171_ _08318_ _08429_ VGND VGND VPWR VPWR _08430_ sky130_fd_sc_hd__xnor2_1
X_14383_ _05361_ _05362_ VGND VGND VPWR VPWR _05364_ sky130_fd_sc_hd__and2_1
XFILLER_0_52_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11595_ _02404_ _02405_ VGND VGND VPWR VPWR _02406_ sky130_fd_sc_hd__nor2_1
XFILLER_0_141_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16122_ _07251_ _07257_ VGND VGND VPWR VPWR _07276_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13334_ _04205_ _04209_ _04206_ VGND VGND VPWR VPWR _04210_ sky130_fd_sc_hd__o21ai_2
X_10546_ _01355_ _01356_ VGND VGND VPWR VPWR _01357_ sky130_fd_sc_hd__or2_1
XFILLER_0_106_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16053_ _07199_ _07139_ VGND VGND VPWR VPWR _07201_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_121_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13265_ _04046_ _04048_ VGND VGND VPWR VPWR _04134_ sky130_fd_sc_hd__xnor2_1
X_10477_ _01245_ _01287_ VGND VGND VPWR VPWR _01288_ sky130_fd_sc_hd__nor2_1
X_15004_ net273 net479 _05635_ VGND VGND VPWR VPWR _06047_ sky130_fd_sc_hd__and3_1
X_12216_ _03017_ _03042_ VGND VGND VPWR VPWR _03043_ sky130_fd_sc_hd__nor2_1
XFILLER_0_121_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13196_ _04056_ _04057_ VGND VGND VPWR VPWR _04058_ sky130_fd_sc_hd__nor2_1
X_12147_ _02967_ _02971_ VGND VGND VPWR VPWR _02972_ sky130_fd_sc_hd__nand2_1
XFILLER_0_138_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16955_ _08174_ _08183_ _08188_ VGND VGND VPWR VPWR _08193_ sky130_fd_sc_hd__o21ba_1
X_12078_ _02898_ _02899_ VGND VGND VPWR VPWR _02900_ sky130_fd_sc_hd__nand2_1
X_15906_ _07037_ _07038_ VGND VGND VPWR VPWR _07039_ sky130_fd_sc_hd__xnor2_1
X_11029_ _01767_ _01839_ VGND VGND VPWR VPWR _01840_ sky130_fd_sc_hd__nand2_1
X_16886_ _05259_ _05285_ VGND VGND VPWR VPWR _08117_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15837_ _06915_ _06929_ _06931_ VGND VGND VPWR VPWR _06963_ sky130_fd_sc_hd__and3_1
XFILLER_0_149_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15768_ _06682_ _06729_ VGND VGND VPWR VPWR _06887_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_75_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14719_ _05617_ _05624_ _03225_ VGND VGND VPWR VPWR _05733_ sky130_fd_sc_hd__a21o_1
X_17507_ clknet_4_1_0_clock _00013_ VGND VGND VPWR VPWR kd_1\[5\] sky130_fd_sc_hd__dfxtp_1
X_15699_ _05618_ _05619_ _05581_ net299 net303 VGND VGND VPWR VPWR _06811_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_117_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17438_ clknet_4_9_0_clock _00116_ VGND VGND VPWR VPWR i_error\[8\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_7_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_15 kp\[9\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_117_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_26 _03344_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_37 net127 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17369_ net468 net426 net457 _08588_ VGND VGND VPWR VPWR _00131_ sky130_fd_sc_hd__o211a_1
XFILLER_0_55_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09625_ _00346_ _00429_ _00434_ VGND VGND VPWR VPWR _00436_ sky130_fd_sc_hd__nand3_1
XFILLER_0_97_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09556_ _00317_ _00319_ VGND VGND VPWR VPWR _00367_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09487_ _00283_ _00285_ VGND VGND VPWR VPWR _00298_ sky130_fd_sc_hd__xor2_2
XFILLER_0_38_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10400_ net375 net486 VGND VGND VPWR VPWR _01211_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11380_ _02187_ _02185_ VGND VGND VPWR VPWR _02191_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_104_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10331_ net367 net486 _01141_ VGND VGND VPWR VPWR _01142_ sky130_fd_sc_hd__nand3_1
XFILLER_0_104_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10262_ _01033_ _01031_ _01032_ VGND VGND VPWR VPWR _01073_ sky130_fd_sc_hd__o21ai_1
X_13050_ _03829_ _03832_ VGND VGND VPWR VPWR _03897_ sky130_fd_sc_hd__xnor2_1
X_12001_ _02813_ _02814_ net442 net145 VGND VGND VPWR VPWR _02815_ sky130_fd_sc_hd__and4bb_1
X_10193_ _01001_ _01003_ VGND VGND VPWR VPWR _01004_ sky130_fd_sc_hd__nor2_2
Xfanout360 kp\[4\] VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__clkbuf_4
Xfanout371 net372 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_108_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16740_ _07952_ _07955_ VGND VGND VPWR VPWR _07956_ sky130_fd_sc_hd__xnor2_1
Xfanout382 prev_d_error\[16\] VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__clkbuf_2
X_13952_ net239 _03268_ VGND VGND VPWR VPWR _04889_ sky130_fd_sc_hd__nand2_1
Xfanout393 net394 VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__buf_2
XFILLER_0_88_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12903_ net180 net177 _03578_ _03669_ VGND VGND VPWR VPWR _03747_ sky130_fd_sc_hd__and4_1
X_16671_ _05864_ _07698_ _05863_ VGND VGND VPWR VPWR _07880_ sky130_fd_sc_hd__a21oi_2
X_13883_ net225 _03667_ _03247_ net247 VGND VGND VPWR VPWR _04814_ sky130_fd_sc_hd__a22o_1
X_15622_ _06708_ _06709_ _06724_ VGND VGND VPWR VPWR _06726_ sky130_fd_sc_hd__or3_1
X_12834_ _03632_ _03648_ _03676_ VGND VGND VPWR VPWR _03678_ sky130_fd_sc_hd__nor3_1
X_15553_ _06556_ _06587_ VGND VGND VPWR VPWR _06651_ sky130_fd_sc_hd__nor2_1
X_12765_ _03607_ _03608_ VGND VGND VPWR VPWR _03609_ sky130_fd_sc_hd__nand2_2
XFILLER_0_139_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14504_ net321 _06870_ _05496_ _05759_ VGND VGND VPWR VPWR _05497_ sky130_fd_sc_hd__o211a_1
X_11716_ _02526_ _02420_ VGND VGND VPWR VPWR _02527_ sky130_fd_sc_hd__xnor2_1
X_15484_ _06571_ _06574_ _06570_ VGND VGND VPWR VPWR _06575_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_72_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12696_ _03370_ _03534_ VGND VGND VPWR VPWR _03535_ sky130_fd_sc_hd__and2_1
XFILLER_0_139_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17223_ _08469_ _08471_ _08486_ VGND VGND VPWR VPWR _08488_ sky130_fd_sc_hd__and3_1
X_14435_ _05420_ VGND VGND VPWR VPWR _05421_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_127_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11647_ _02456_ _02457_ net445 net124 VGND VGND VPWR VPWR _02458_ sky130_fd_sc_hd__and4b_1
XFILLER_0_64_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput13 measurement[3] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_141_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput24 reg_addr[13] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_1
X_17154_ _03581_ _03343_ VGND VGND VPWR VPWR _08412_ sky130_fd_sc_hd__nor2_1
XFILLER_0_24_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput35 reg_addr[7] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_1
X_14366_ _05326_ _05343_ VGND VGND VPWR VPWR _05345_ sky130_fd_sc_hd__or2_1
Xinput46 reg_data[17] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_4
X_11578_ _02387_ _02388_ VGND VGND VPWR VPWR _02389_ sky130_fd_sc_hd__nor2_1
Xinput57 target[0] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__buf_1
XFILLER_0_24_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput68 target[3] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__clkbuf_1
X_16105_ _07251_ _07257_ VGND VGND VPWR VPWR _07258_ sky130_fd_sc_hd__or2_1
X_13317_ _04116_ _04158_ _04156_ VGND VGND VPWR VPWR _04191_ sky130_fd_sc_hd__a21o_1
XFILLER_0_52_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10529_ _01255_ _01321_ _01323_ VGND VGND VPWR VPWR _01340_ sky130_fd_sc_hd__and3_1
X_17085_ _01687_ _08335_ VGND VGND VPWR VPWR _08336_ sky130_fd_sc_hd__xor2_2
X_14297_ _04801_ _04916_ _05163_ _04859_ _05268_ VGND VGND VPWR VPWR _05269_ sky130_fd_sc_hd__a32o_2
XFILLER_0_0_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16036_ _07180_ _07181_ VGND VGND VPWR VPWR _07182_ sky130_fd_sc_hd__and2_1
X_13248_ _04102_ _04104_ _04114_ VGND VGND VPWR VPWR _04115_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_20_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13179_ net198 _03261_ _03902_ VGND VGND VPWR VPWR _04039_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_74_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16938_ _08172_ _08173_ VGND VGND VPWR VPWR _08174_ sky130_fd_sc_hd__and2_1
X_16869_ _08097_ VGND VGND VPWR VPWR _08098_ sky130_fd_sc_hd__inv_2
X_09410_ _00218_ _00220_ VGND VGND VPWR VPWR _00221_ sky130_fd_sc_hd__or2_1
X_09341_ net336 _04428_ _04758_ net340 VGND VGND VPWR VPWR _00152_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_90_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09272_ _08634_ _08635_ VGND VGND VPWR VPWR _08636_ sky130_fd_sc_hd__nand2_4
XFILLER_0_114_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08987_ net332 _05660_ VGND VGND VPWR VPWR _05902_ sky130_fd_sc_hd__nand2_1
X_09608_ _00332_ _00353_ VGND VGND VPWR VPWR _00419_ sky130_fd_sc_hd__xnor2_2
X_10880_ net389 net112 _01690_ VGND VGND VPWR VPWR _01691_ sky130_fd_sc_hd__and3_1
X_09539_ _00336_ _00349_ VGND VGND VPWR VPWR _00350_ sky130_fd_sc_hd__xor2_2
X_12550_ net200 _03284_ VGND VGND VPWR VPWR _03389_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11501_ net444 net119 _02311_ VGND VGND VPWR VPWR _02312_ sky130_fd_sc_hd__and3_1
XFILLER_0_81_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12481_ _03314_ _03315_ VGND VGND VPWR VPWR _03316_ sky130_fd_sc_hd__nor2b_4
X_14220_ _04396_ _04401_ _04295_ VGND VGND VPWR VPWR _05184_ sky130_fd_sc_hd__a21oi_1
X_11432_ net427 net132 VGND VGND VPWR VPWR _02243_ sky130_fd_sc_hd__nand2_1
XFILLER_0_124_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14151_ net244 _04004_ _05103_ VGND VGND VPWR VPWR _05108_ sky130_fd_sc_hd__a21o_1
XFILLER_0_34_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11363_ _02105_ _02095_ _02103_ VGND VGND VPWR VPWR _02174_ sky130_fd_sc_hd__nand3_1
XFILLER_0_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13102_ _03849_ _03855_ VGND VGND VPWR VPWR _03954_ sky130_fd_sc_hd__nor2_1
X_10314_ net354 _01049_ _00315_ VGND VGND VPWR VPWR _01125_ sky130_fd_sc_hd__and3_1
X_14082_ _05019_ _05031_ VGND VGND VPWR VPWR _05032_ sky130_fd_sc_hd__nand2_1
X_11294_ _02007_ _02104_ VGND VGND VPWR VPWR _02105_ sky130_fd_sc_hd__nand2_1
X_13033_ _03873_ _03877_ VGND VGND VPWR VPWR _03879_ sky130_fd_sc_hd__and2_1
X_10245_ _01055_ _00998_ VGND VGND VPWR VPWR _01056_ sky130_fd_sc_hd__xnor2_1
X_10176_ _00985_ _00986_ VGND VGND VPWR VPWR _00987_ sky130_fd_sc_hd__nand2_1
X_14984_ _05972_ _05980_ _05981_ VGND VGND VPWR VPWR _06025_ sky130_fd_sc_hd__nor3_1
Xfanout190 net191 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__buf_2
X_16723_ _05863_ _07936_ VGND VGND VPWR VPWR _07938_ sky130_fd_sc_hd__nor2_1
XFILLER_0_88_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13935_ _04865_ _04869_ VGND VGND VPWR VPWR _04871_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_135_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16654_ _07526_ _07680_ _07678_ VGND VGND VPWR VPWR _07862_ sky130_fd_sc_hd__a21bo_1
X_13866_ _04720_ _04789_ _04784_ _04788_ VGND VGND VPWR VPWR _04795_ sky130_fd_sc_hd__a211o_1
X_15605_ _06638_ _06624_ VGND VGND VPWR VPWR _06708_ sky130_fd_sc_hd__and2b_1
XFILLER_0_147_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12817_ _03658_ _03659_ VGND VGND VPWR VPWR _03661_ sky130_fd_sc_hd__xnor2_1
X_16585_ _05445_ _05448_ VGND VGND VPWR VPWR _07786_ sky130_fd_sc_hd__and2_1
X_13797_ _04633_ _04716_ _04710_ _04715_ VGND VGND VPWR VPWR _04719_ sky130_fd_sc_hd__a211o_1
XFILLER_0_57_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15536_ _06339_ _06603_ _06631_ VGND VGND VPWR VPWR _06632_ sky130_fd_sc_hd__o21a_1
X_12748_ _03546_ _03549_ _03591_ VGND VGND VPWR VPWR _03592_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_139_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15467_ net282 _05581_ VGND VGND VPWR VPWR _06556_ sky130_fd_sc_hd__nand2_2
X_12679_ _03495_ _03517_ VGND VGND VPWR VPWR _03518_ sky130_fd_sc_hd__xnor2_1
X_17206_ _08161_ _08468_ VGND VGND VPWR VPWR _08469_ sky130_fd_sc_hd__xnor2_1
X_14418_ _03495_ _03516_ _03515_ VGND VGND VPWR VPWR _05402_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_71_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15398_ _06477_ _06479_ VGND VGND VPWR VPWR _06480_ sky130_fd_sc_hd__nor2_1
XFILLER_0_142_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17137_ _08385_ _08392_ VGND VGND VPWR VPWR _08393_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14349_ _01679_ _05325_ VGND VGND VPWR VPWR _05326_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17068_ net389 net108 _05329_ _01688_ VGND VGND VPWR VPWR _08317_ sky130_fd_sc_hd__a31o_1
XFILLER_0_40_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08910_ net330 net326 _04934_ _05033_ VGND VGND VPWR VPWR _05055_ sky130_fd_sc_hd__and4_1
XFILLER_0_0_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16019_ _07015_ _07095_ _07094_ VGND VGND VPWR VPWR _07163_ sky130_fd_sc_hd__o21a_1
X_09890_ net374 _04912_ _00699_ _00700_ VGND VGND VPWR VPWR _00701_ sky130_fd_sc_hd__nand4_1
XFILLER_0_0_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08841_ _04175_ _04208_ VGND VGND VPWR VPWR _04296_ sky130_fd_sc_hd__or2_1
XFILLER_0_85_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08772_ _03039_ _03296_ net451 VGND VGND VPWR VPWR _03564_ sky130_fd_sc_hd__o21a_1
XFILLER_0_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09324_ _08641_ _08687_ VGND VGND VPWR VPWR _08688_ sky130_fd_sc_hd__nor2_1
XFILLER_0_146_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09255_ net322 _04626_ _07827_ VGND VGND VPWR VPWR _08619_ sky130_fd_sc_hd__a21oi_1
Xclone16 _07904_ VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_90_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09186_ _05506_ _08069_ _08080_ VGND VGND VPWR VPWR _08091_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10030_ kp\[14\] _00520_ _00794_ VGND VGND VPWR VPWR _00841_ sky130_fd_sc_hd__a21o_1
Xclkbuf_4_3_0_clock clknet_0_clock VGND VGND VPWR VPWR clknet_4_3_0_clock sky130_fd_sc_hd__clkbuf_8
X_11981_ _02733_ _02732_ VGND VGND VPWR VPWR _02793_ sky130_fd_sc_hd__nor2_1
X_13720_ _04548_ _04550_ _04551_ VGND VGND VPWR VPWR _04634_ sky130_fd_sc_hd__o21a_1
X_10932_ _01541_ _01546_ VGND VGND VPWR VPWR _01743_ sky130_fd_sc_hd__nor2_1
XFILLER_0_105_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13651_ _04554_ _04556_ _04557_ VGND VGND VPWR VPWR _04558_ sky130_fd_sc_hd__or3_1
X_10863_ _01670_ _01672_ _01667_ VGND VGND VPWR VPWR _01674_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_39_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12602_ _03438_ _03440_ VGND VGND VPWR VPWR _03441_ sky130_fd_sc_hd__and2_1
X_16370_ _05871_ _07548_ VGND VGND VPWR VPWR _07549_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13582_ _04456_ _04478_ _04481_ VGND VGND VPWR VPWR _04482_ sky130_fd_sc_hd__a21oi_2
X_10794_ _01603_ _01573_ _01576_ VGND VGND VPWR VPWR _01605_ sky130_fd_sc_hd__nand3_1
XFILLER_0_81_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15321_ _06393_ _06394_ VGND VGND VPWR VPWR _06395_ sky130_fd_sc_hd__xor2_2
XFILLER_0_93_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12533_ _03345_ VGND VGND VPWR VPWR _03372_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_54_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15252_ net271 _05589_ _05582_ net274 VGND VGND VPWR VPWR _06319_ sky130_fd_sc_hd__a22o_1
X_12464_ _03295_ _03297_ VGND VGND VPWR VPWR _03298_ sky130_fd_sc_hd__and2_1
XFILLER_0_35_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14203_ _04801_ _04858_ _05164_ VGND VGND VPWR VPWR _05166_ sky130_fd_sc_hd__o21ai_4
X_11415_ _02221_ _02225_ VGND VGND VPWR VPWR _02226_ sky130_fd_sc_hd__nand2_1
X_15183_ _06231_ _06238_ _06242_ VGND VGND VPWR VPWR _06244_ sky130_fd_sc_hd__a21bo_1
X_12395_ _03225_ _03226_ VGND VGND VPWR VPWR _03227_ sky130_fd_sc_hd__or2_2
XFILLER_0_1_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14134_ net235 net521 _05089_ VGND VGND VPWR VPWR _05090_ sky130_fd_sc_hd__and3_1
X_11346_ _02154_ _02156_ VGND VGND VPWR VPWR _02157_ sky130_fd_sc_hd__or2b_1
XFILLER_0_22_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14065_ _05009_ _05013_ VGND VGND VPWR VPWR _05014_ sky130_fd_sc_hd__nor2_1
X_11277_ _02065_ _02085_ _02087_ VGND VGND VPWR VPWR _02088_ sky130_fd_sc_hd__a21oi_1
X_13016_ _03695_ _03858_ _03856_ VGND VGND VPWR VPWR _03860_ sky130_fd_sc_hd__nor3_1
X_10228_ _01004_ _01035_ VGND VGND VPWR VPWR _01039_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_146_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10159_ net363 _05132_ _07365_ VGND VGND VPWR VPWR _00970_ sky130_fd_sc_hd__and3_1
XFILLER_0_55_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14967_ net262 _05590_ VGND VGND VPWR VPWR _06006_ sky130_fd_sc_hd__nand2_1
X_16706_ _07722_ _07748_ _07913_ _07918_ VGND VGND VPWR VPWR _07919_ sky130_fd_sc_hd__a22o_1
X_13918_ _04803_ _04851_ VGND VGND VPWR VPWR _04852_ sky130_fd_sc_hd__nand2_1
X_14898_ _05928_ _05929_ VGND VGND VPWR VPWR _05930_ sky130_fd_sc_hd__or2_1
XFILLER_0_77_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16637_ _07592_ _07593_ VGND VGND VPWR VPWR _07843_ sky130_fd_sc_hd__nand2_1
X_13849_ _04696_ _04705_ VGND VGND VPWR VPWR _04776_ sky130_fd_sc_hd__xor2_1
X_16568_ _07726_ _07766_ VGND VGND VPWR VPWR _07767_ sky130_fd_sc_hd__nor2_1
XFILLER_0_18_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15519_ net257 _06349_ VGND VGND VPWR VPWR _06613_ sky130_fd_sc_hd__nand2_1
XFILLER_0_143_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16499_ net254 _05711_ _07689_ VGND VGND VPWR VPWR _07691_ sky130_fd_sc_hd__a21o_1
X_09040_ _06452_ _06474_ VGND VGND VPWR VPWR _06485_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09942_ _00667_ _00666_ VGND VGND VPWR VPWR _00753_ sky130_fd_sc_hd__and2b_1
X_09873_ _00549_ _00683_ VGND VGND VPWR VPWR _00684_ sky130_fd_sc_hd__or2_1
X_08824_ _04076_ _04087_ _04098_ VGND VGND VPWR VPWR _04109_ sky130_fd_sc_hd__a21o_4
X_08755_ net49 _03318_ _03351_ net298 VGND VGND VPWR VPWR _00047_ sky130_fd_sc_hd__a22o_1
XFILLER_0_95_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09307_ _08666_ _08669_ VGND VGND VPWR VPWR _08671_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_119_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09238_ _05440_ _08591_ VGND VGND VPWR VPWR _08597_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_91_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09169_ _04142_ _07893_ VGND VGND VPWR VPWR _07904_ sky130_fd_sc_hd__xor2_4
X_11200_ _01973_ _01987_ _01974_ VGND VGND VPWR VPWR _02011_ sky130_fd_sc_hd__o21ba_1
X_12180_ net421 net173 VGND VGND VPWR VPWR _03005_ sky130_fd_sc_hd__nand2_1
X_11131_ _01940_ _01941_ net425 net114 VGND VGND VPWR VPWR _01942_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_101_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11062_ _01863_ _01870_ _01872_ VGND VGND VPWR VPWR _01873_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_101_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10013_ _00792_ _00795_ _00797_ VGND VGND VPWR VPWR _00824_ sky130_fd_sc_hd__and3_1
X_15870_ _06904_ _06997_ VGND VGND VPWR VPWR _06999_ sky130_fd_sc_hd__xor2_1
X_14821_ _05843_ _05844_ VGND VGND VPWR VPWR _05845_ sky130_fd_sc_hd__nor2_1
XFILLER_0_116_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14752_ _05762_ _05766_ _05768_ VGND VGND VPWR VPWR _05769_ sky130_fd_sc_hd__o21a_1
X_11964_ _02740_ _02750_ _02746_ _02749_ VGND VGND VPWR VPWR _02775_ sky130_fd_sc_hd__o211a_1
X_13703_ _04614_ _04574_ VGND VGND VPWR VPWR _04616_ sky130_fd_sc_hd__xor2_1
X_17471_ clknet_4_0_0_clock _00067_ VGND VGND VPWR VPWR kp\[5\] sky130_fd_sc_hd__dfxtp_2
X_10915_ _01724_ _01725_ VGND VGND VPWR VPWR _01726_ sky130_fd_sc_hd__and2_1
X_14683_ net288 _05692_ VGND VGND VPWR VPWR _05694_ sky130_fd_sc_hd__and2_1
X_11895_ _02633_ VGND VGND VPWR VPWR _02706_ sky130_fd_sc_hd__inv_2
X_16422_ _07495_ _06974_ _07492_ VGND VGND VPWR VPWR _07606_ sky130_fd_sc_hd__nand3_1
X_13634_ net242 _03222_ VGND VGND VPWR VPWR _04540_ sky130_fd_sc_hd__nand2_1
X_10846_ _01655_ _01559_ _01613_ VGND VGND VPWR VPWR _01657_ sky130_fd_sc_hd__nor3_1
XFILLER_0_39_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16353_ _07511_ _07512_ _07528_ VGND VGND VPWR VPWR _07531_ sky130_fd_sc_hd__nor3_1
XFILLER_0_66_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13565_ net242 _03221_ _04462_ _04463_ VGND VGND VPWR VPWR _04464_ sky130_fd_sc_hd__a31o_1
X_10777_ _01566_ _01583_ VGND VGND VPWR VPWR _01588_ sky130_fd_sc_hd__nor2_1
X_15304_ _06369_ _06370_ _06376_ VGND VGND VPWR VPWR _06377_ sky130_fd_sc_hd__a21o_1
X_12516_ _03330_ _03341_ _03354_ VGND VGND VPWR VPWR _03355_ sky130_fd_sc_hd__o21a_1
X_16284_ _07295_ _07454_ VGND VGND VPWR VPWR _07455_ sky130_fd_sc_hd__or2_1
X_13496_ _04387_ _04385_ VGND VGND VPWR VPWR _04388_ sky130_fd_sc_hd__xnor2_2
X_15235_ net284 net479 _05635_ VGND VGND VPWR VPWR _06301_ sky130_fd_sc_hd__and3_2
XFILLER_0_124_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12447_ prev_error\[13\] _04769_ VGND VGND VPWR VPWR _03279_ sky130_fd_sc_hd__and2b_1
XFILLER_0_81_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15166_ _06223_ _06224_ VGND VGND VPWR VPWR _06225_ sky130_fd_sc_hd__xor2_2
XFILLER_0_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12378_ prev_error\[9\] _05165_ VGND VGND VPWR VPWR _03210_ sky130_fd_sc_hd__nor2_1
X_14117_ _05069_ _05070_ VGND VGND VPWR VPWR _05071_ sky130_fd_sc_hd__and2b_1
X_11329_ _02135_ net104 _02139_ VGND VGND VPWR VPWR _02140_ sky130_fd_sc_hd__o21ai_2
X_15097_ _06077_ _06079_ VGND VGND VPWR VPWR _06149_ sky130_fd_sc_hd__or2_1
XFILLER_0_120_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14048_ _04993_ _04994_ VGND VGND VPWR VPWR _04995_ sky130_fd_sc_hd__xor2_1
XFILLER_0_66_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15999_ _07135_ _07139_ _07140_ VGND VGND VPWR VPWR _07141_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_89_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09023_ _05539_ _05517_ VGND VGND VPWR VPWR _06298_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_28_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09925_ net378 _04494_ VGND VGND VPWR VPWR _00736_ sky130_fd_sc_hd__and2_2
X_09856_ net353 net349 _04604_ _07332_ VGND VGND VPWR VPWR _00667_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_0_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08807_ _03900_ _03911_ VGND VGND VPWR VPWR _03922_ sky130_fd_sc_hd__nand2_2
XPHY_EDGE_ROW_37_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09787_ _00526_ _00511_ _00524_ VGND VGND VPWR VPWR _00598_ sky130_fd_sc_hd__and3_1
X_08738_ net40 _03050_ _03083_ net197 VGND VGND VPWR VPWR _00002_ sky130_fd_sc_hd__a22o_1
XFILLER_0_96_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10700_ _01506_ _01510_ VGND VGND VPWR VPWR _01511_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11680_ _02488_ _02490_ VGND VGND VPWR VPWR _02491_ sky130_fd_sc_hd__nor2_1
XFILLER_0_138_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10631_ _00451_ _00544_ _01433_ _01439_ _01441_ VGND VGND VPWR VPWR _01442_ sky130_fd_sc_hd__a41o_4
XFILLER_0_9_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13350_ kd_1\[14\] _03793_ VGND VGND VPWR VPWR _04227_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_46_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10562_ _01368_ _01372_ VGND VGND VPWR VPWR _01373_ sky130_fd_sc_hd__and2_1
XFILLER_0_51_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12301_ _03131_ _03132_ _03121_ _03124_ VGND VGND VPWR VPWR _03133_ sky130_fd_sc_hd__a22o_1
XFILLER_0_134_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13281_ _04135_ _04150_ VGND VGND VPWR VPWR _04151_ sky130_fd_sc_hd__and2_1
X_10493_ _01295_ _01302_ _01303_ VGND VGND VPWR VPWR _01304_ sky130_fd_sc_hd__a21bo_1
X_15020_ _05848_ _05930_ VGND VGND VPWR VPWR _06064_ sky130_fd_sc_hd__xnor2_1
X_12232_ _03041_ _03059_ VGND VGND VPWR VPWR _03060_ sky130_fd_sc_hd__or2b_1
XFILLER_0_31_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12163_ _02979_ _02987_ _02985_ VGND VGND VPWR VPWR _02988_ sky130_fd_sc_hd__a21o_1
X_11114_ _01912_ _01922_ VGND VGND VPWR VPWR _01925_ sky130_fd_sc_hd__nor2_1
X_16971_ _07977_ VGND VGND VPWR VPWR _08210_ sky130_fd_sc_hd__inv_2
X_12094_ _02824_ _02917_ VGND VGND VPWR VPWR _02918_ sky130_fd_sc_hd__nand2_1
X_11045_ _01853_ _01855_ VGND VGND VPWR VPWR _01856_ sky130_fd_sc_hd__nand2_1
X_15922_ net306 _05589_ VGND VGND VPWR VPWR _07056_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15853_ _06938_ _06937_ _06935_ VGND VGND VPWR VPWR _06981_ sky130_fd_sc_hd__a21o_1
XFILLER_0_99_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14804_ _05806_ _05809_ _05826_ VGND VGND VPWR VPWR _05827_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_99_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15784_ _06904_ _06828_ VGND VGND VPWR VPWR _06905_ sky130_fd_sc_hd__or2_1
XFILLER_0_99_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12996_ _03803_ _03839_ VGND VGND VPWR VPWR _03840_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_87_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17523_ clknet_4_7_0_clock _00029_ VGND VGND VPWR VPWR kd_2\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_143_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14735_ net258 _05749_ _05739_ net261 VGND VGND VPWR VPWR _05751_ sky130_fd_sc_hd__a22o_1
XFILLER_0_87_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11947_ _02756_ _02757_ net442 net139 VGND VGND VPWR VPWR _02758_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_52_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_879 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14666_ _03179_ _03218_ VGND VGND VPWR VPWR _05675_ sky130_fd_sc_hd__or2_1
X_17454_ clknet_4_15_0_clock _00132_ VGND VGND VPWR VPWR prev_d_error\[6\] sky130_fd_sc_hd__dfxtp_2
X_11878_ _02650_ _02688_ VGND VGND VPWR VPWR _02689_ sky130_fd_sc_hd__nor2_1
X_16405_ _07586_ _07587_ VGND VGND VPWR VPWR _07588_ sky130_fd_sc_hd__nor2_4
X_13617_ _04503_ _04504_ _04520_ VGND VGND VPWR VPWR _04521_ sky130_fd_sc_hd__o21bai_2
X_10829_ _01638_ _01639_ VGND VGND VPWR VPWR _01640_ sky130_fd_sc_hd__nor2_1
X_14597_ net522 _05571_ _05573_ _05574_ VGND VGND VPWR VPWR _05599_ sky130_fd_sc_hd__a211o_1
X_17385_ _03878_ _08050_ _08598_ net458 VGND VGND VPWR VPWR _00139_ sky130_fd_sc_hd__o211a_1
XFILLER_0_27_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16336_ _05868_ _05892_ VGND VGND VPWR VPWR _07512_ sky130_fd_sc_hd__and2_1
X_13548_ _04320_ _04305_ _04444_ VGND VGND VPWR VPWR _04445_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_42_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16267_ _07394_ _07435_ VGND VGND VPWR VPWR _07436_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13479_ _04239_ _04244_ VGND VGND VPWR VPWR _04369_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_140_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15218_ _06246_ _06281_ VGND VGND VPWR VPWR _06282_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16198_ _07358_ _07352_ VGND VGND VPWR VPWR _07360_ sky130_fd_sc_hd__and2b_1
XFILLER_0_140_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15149_ _06205_ VGND VGND VPWR VPWR _06206_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09710_ _00514_ _00515_ VGND VGND VPWR VPWR _00521_ sky130_fd_sc_hd__xnor2_1
X_09641_ _00417_ _00448_ VGND VGND VPWR VPWR _00452_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09572_ net360 _05011_ _05385_ net377 VGND VGND VPWR VPWR _00383_ sky130_fd_sc_hd__a22o_1
XFILLER_0_78_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09006_ _06089_ _06100_ VGND VGND VPWR VPWR _06111_ sky130_fd_sc_hd__or2b_1
XFILLER_0_103_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09908_ _00693_ _00694_ _00717_ _00718_ VGND VGND VPWR VPWR _00719_ sky130_fd_sc_hd__a211oi_2
X_09839_ _00642_ _00646_ _00647_ VGND VGND VPWR VPWR _00650_ sky130_fd_sc_hd__o21a_1
X_12850_ _03650_ _03651_ VGND VGND VPWR VPWR _03694_ sky130_fd_sc_hd__and2_1
X_11801_ net443 net525 _02488_ _02489_ VGND VGND VPWR VPWR _02612_ sky130_fd_sc_hd__o2bb2a_1
X_12781_ _03623_ _03624_ VGND VGND VPWR VPWR _03625_ sky130_fd_sc_hd__and2_1
XFILLER_0_69_879 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14520_ _07057_ _06221_ VGND VGND VPWR VPWR _05514_ sky130_fd_sc_hd__or2b_1
X_11732_ _02477_ _02486_ _02542_ VGND VGND VPWR VPWR _02543_ sky130_fd_sc_hd__or3_2
XFILLER_0_56_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_54_Left_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14451_ _00966_ _01038_ net484 VGND VGND VPWR VPWR _05438_ sky130_fd_sc_hd__and3_4
XFILLER_0_83_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11663_ _02418_ _02431_ _02425_ _02430_ VGND VGND VPWR VPWR _02474_ sky130_fd_sc_hd__a211o_1
XFILLER_0_36_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13402_ _04276_ _04275_ VGND VGND VPWR VPWR _04284_ sky130_fd_sc_hd__and2b_1
X_10614_ _00965_ _00897_ VGND VGND VPWR VPWR _01425_ sky130_fd_sc_hd__and2b_1
X_17170_ _01563_ net113 VGND VGND VPWR VPWR _08429_ sky130_fd_sc_hd__or2_1
XFILLER_0_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14382_ net181 _03337_ VGND VGND VPWR VPWR _05362_ sky130_fd_sc_hd__nand2_1
X_11594_ net426 net136 VGND VGND VPWR VPWR _02405_ sky130_fd_sc_hd__nand2_1
XFILLER_0_51_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16121_ _07197_ _07273_ _07272_ VGND VGND VPWR VPWR _07275_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_106_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13333_ _04206_ _04207_ VGND VGND VPWR VPWR _04209_ sky130_fd_sc_hd__nand2_1
X_10545_ net362 _00652_ _01206_ VGND VGND VPWR VPWR _01356_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_51_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16052_ _07132_ _07133_ VGND VGND VPWR VPWR _07199_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_122_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13264_ _04126_ _04132_ VGND VGND VPWR VPWR _04133_ sky130_fd_sc_hd__nor2_1
X_10476_ _01258_ _01285_ _01286_ VGND VGND VPWR VPWR _01287_ sky130_fd_sc_hd__a21oi_1
X_15003_ net270 _05745_ _05630_ net273 VGND VGND VPWR VPWR _06046_ sky130_fd_sc_hd__a22o_1
X_12215_ _03014_ _03016_ VGND VGND VPWR VPWR _03042_ sky130_fd_sc_hd__and2_1
X_13195_ _04038_ _04053_ _04055_ VGND VGND VPWR VPWR _04057_ sky130_fd_sc_hd__nor3_1
XFILLER_0_121_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_63_Left_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12146_ _02963_ _02966_ _02965_ VGND VGND VPWR VPWR _02971_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_102_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16954_ _08184_ _08191_ VGND VGND VPWR VPWR _08192_ sky130_fd_sc_hd__nand2_1
X_12077_ _02891_ _02897_ VGND VGND VPWR VPWR _02899_ sky130_fd_sc_hd__or2_1
X_15905_ _06869_ _06875_ VGND VGND VPWR VPWR _07038_ sky130_fd_sc_hd__xnor2_1
X_11028_ _01761_ _01764_ _01766_ VGND VGND VPWR VPWR _01839_ sky130_fd_sc_hd__or3_1
X_16885_ _05437_ _08115_ VGND VGND VPWR VPWR _08116_ sky130_fd_sc_hd__xor2_1
X_15836_ _06960_ _06961_ VGND VGND VPWR VPWR _06962_ sky130_fd_sc_hd__xnor2_2
X_15767_ net505 _06885_ VGND VGND VPWR VPWR _06886_ sky130_fd_sc_hd__or2_4
X_12979_ net203 _03233_ VGND VGND VPWR VPWR _03823_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17506_ clknet_4_1_0_clock _00012_ VGND VGND VPWR VPWR kd_1\[4\] sky130_fd_sc_hd__dfxtp_1
X_14718_ net269 _05724_ VGND VGND VPWR VPWR _05732_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_72_Left_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15698_ _06538_ _06541_ _06534_ _06542_ VGND VGND VPWR VPWR _06810_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_75_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17437_ clknet_4_9_0_clock _00115_ VGND VGND VPWR VPWR i_error\[7\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_86_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14649_ net260 _05622_ _05639_ VGND VGND VPWR VPWR _05656_ sky130_fd_sc_hd__a21oi_1
XANTENNA_16 net52 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_120_Right_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_27 _03344_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_38 net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_17368_ net467 _08110_ VGND VGND VPWR VPWR _08588_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16319_ _06797_ _06796_ VGND VGND VPWR VPWR _07493_ sky130_fd_sc_hd__or2b_2
X_17299_ net461 prev_error\[8\] VGND VGND VPWR VPWR _08545_ sky130_fd_sc_hd__or2_1
XFILLER_0_3_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_81_Left_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09624_ _00346_ _00429_ _00434_ VGND VGND VPWR VPWR _00435_ sky130_fd_sc_hd__a21o_1
XFILLER_0_97_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09555_ net324 _08677_ _00365_ _00363_ VGND VGND VPWR VPWR _00366_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_90_Left_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09486_ _00287_ _00292_ _00296_ VGND VGND VPWR VPWR _00297_ sky130_fd_sc_hd__o21a_1
XFILLER_0_19_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10330_ net372 _08634_ _08635_ VGND VGND VPWR VPWR _01141_ sky130_fd_sc_hd__and3_1
XFILLER_0_104_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10261_ _01033_ _01031_ _01032_ VGND VGND VPWR VPWR _01072_ sky130_fd_sc_hd__or3_1
X_12000_ net438 net146 net150 net433 VGND VGND VPWR VPWR _02814_ sky130_fd_sc_hd__a22oi_1
X_10192_ _00823_ _01002_ VGND VGND VPWR VPWR _01003_ sky130_fd_sc_hd__or2_1
XFILLER_0_100_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout350 net351 VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__clkbuf_4
Xfanout361 kp\[4\] VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_108_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout372 kp\[2\] VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__buf_2
X_13951_ _04863_ _04887_ VGND VGND VPWR VPWR _04888_ sky130_fd_sc_hd__xnor2_2
Xfanout383 prev_d_error\[16\] VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__buf_2
Xfanout394 prev_d_error\[13\] VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_129_Left_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12902_ _03671_ _03745_ VGND VGND VPWR VPWR _03746_ sky130_fd_sc_hd__and2_1
X_16670_ _07675_ _07878_ VGND VGND VPWR VPWR _07879_ sky130_fd_sc_hd__xnor2_2
X_13882_ net222 _03750_ VGND VGND VPWR VPWR _04812_ sky130_fd_sc_hd__nand2_1
X_15621_ _06708_ _06709_ _06724_ VGND VGND VPWR VPWR _06725_ sky130_fd_sc_hd__o21ai_2
X_12833_ _03632_ _03648_ _03676_ VGND VGND VPWR VPWR _03677_ sky130_fd_sc_hd__o21a_1
XFILLER_0_124_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12764_ _03522_ _03606_ VGND VGND VPWR VPWR _03608_ sky130_fd_sc_hd__nand2_1
X_15552_ _06646_ _06648_ VGND VGND VPWR VPWR _06649_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_84_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14503_ net321 _06881_ VGND VGND VPWR VPWR _05496_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11715_ _02421_ _02419_ VGND VGND VPWR VPWR _02526_ sky130_fd_sc_hd__nor2_1
X_15483_ net304 _05702_ _06568_ VGND VGND VPWR VPWR _06574_ sky130_fd_sc_hd__nand3_1
XFILLER_0_126_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12695_ _03376_ _03381_ VGND VGND VPWR VPWR _03534_ sky130_fd_sc_hd__xor2_1
XFILLER_0_139_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17222_ _08472_ _08474_ _08475_ _08485_ VGND VGND VPWR VPWR _08486_ sky130_fd_sc_hd__and4_1
X_14434_ _01454_ _05419_ VGND VGND VPWR VPWR _05420_ sky130_fd_sc_hd__xnor2_2
X_11646_ net435 net131 net525 net439 VGND VGND VPWR VPWR _02457_ sky130_fd_sc_hd__a22o_1
Xinput14 measurement[4] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_142_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17153_ _05362_ _08265_ _08268_ _08264_ VGND VGND VPWR VPWR _08411_ sky130_fd_sc_hd__o22a_1
Xinput25 reg_addr[14] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_1
X_14365_ _05326_ _05343_ VGND VGND VPWR VPWR _05344_ sky130_fd_sc_hd__nand2_1
Xinput36 reg_addr[8] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
X_11577_ _02382_ _02386_ VGND VGND VPWR VPWR _02388_ sky130_fd_sc_hd__and2_1
XFILLER_0_80_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput47 reg_data[1] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__buf_2
Xinput58 target[10] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
X_16104_ _07205_ _07252_ _07256_ VGND VGND VPWR VPWR _07257_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_80_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13316_ _04188_ _04185_ VGND VGND VPWR VPWR _04190_ sky130_fd_sc_hd__xor2_1
Xinput69 target[4] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__clkbuf_1
X_10528_ _01326_ _01338_ VGND VGND VPWR VPWR _01339_ sky130_fd_sc_hd__and2_1
X_17084_ net389 _05329_ _08334_ VGND VGND VPWR VPWR _08335_ sky130_fd_sc_hd__a21o_1
X_14296_ _04801_ _04858_ _05164_ VGND VGND VPWR VPWR _05268_ sky130_fd_sc_hd__o21a_1
XFILLER_0_134_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16035_ _07111_ _07117_ VGND VGND VPWR VPWR _07181_ sky130_fd_sc_hd__xnor2_1
X_13247_ _04112_ _04113_ VGND VGND VPWR VPWR _04114_ sky130_fd_sc_hd__nand2_1
X_10459_ _01216_ _01263_ _01267_ VGND VGND VPWR VPWR _01270_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_58_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13178_ _04028_ _04036_ _04037_ VGND VGND VPWR VPWR _04038_ sky130_fd_sc_hd__a21oi_2
X_12129_ _02881_ _02884_ VGND VGND VPWR VPWR _02954_ sky130_fd_sc_hd__or2_1
X_16937_ _05427_ _08171_ VGND VGND VPWR VPWR _08173_ sky130_fd_sc_hd__or2_1
XFILLER_0_74_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16868_ _05272_ _08096_ VGND VGND VPWR VPWR _08097_ sky130_fd_sc_hd__or2_1
X_15819_ net290 _05604_ _06942_ _06896_ VGND VGND VPWR VPWR _06943_ sky130_fd_sc_hd__nand4_1
X_16799_ _07736_ _08017_ _08020_ _07730_ VGND VGND VPWR VPWR _08021_ sky130_fd_sc_hd__a22o_1
X_09340_ net340 net336 _04428_ _04758_ VGND VGND VPWR VPWR _00151_ sky130_fd_sc_hd__and4_1
XFILLER_0_74_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09271_ _04219_ _07882_ _04153_ VGND VGND VPWR VPWR _08635_ sky130_fd_sc_hd__a21o_1
XFILLER_0_118_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08986_ _05869_ _05880_ VGND VGND VPWR VPWR _05891_ sky130_fd_sc_hd__or2b_1
XFILLER_0_97_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09607_ _00330_ _00356_ VGND VGND VPWR VPWR _00418_ sky130_fd_sc_hd__xnor2_1
X_09538_ _00338_ _00348_ _06232_ VGND VGND VPWR VPWR _00349_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_39_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09469_ _00277_ _00279_ VGND VGND VPWR VPWR _00280_ sky130_fd_sc_hd__and2b_1
XFILLER_0_136_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11500_ _02309_ _02310_ VGND VGND VPWR VPWR _02311_ sky130_fd_sc_hd__nor2_1
X_12480_ prev_error\[17\] _05407_ VGND VGND VPWR VPWR _03315_ sky130_fd_sc_hd__or2b_1
X_11431_ _02240_ _02241_ VGND VGND VPWR VPWR _02242_ sky130_fd_sc_hd__and2_1
XFILLER_0_123_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14150_ _05098_ _05106_ VGND VGND VPWR VPWR _05107_ sky130_fd_sc_hd__and2_1
XFILLER_0_21_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11362_ _02159_ _02171_ _02172_ VGND VGND VPWR VPWR _02173_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_104_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13101_ _03896_ _03952_ VGND VGND VPWR VPWR _03953_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10313_ net355 _00241_ _01123_ VGND VGND VPWR VPWR _01124_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_131_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14081_ net223 _04315_ _05018_ VGND VGND VPWR VPWR _05031_ sky130_fd_sc_hd__a21o_1
XFILLER_0_132_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11293_ _02001_ _02004_ _02006_ VGND VGND VPWR VPWR _02104_ sky130_fd_sc_hd__or3_1
X_13032_ _03875_ _03876_ VGND VGND VPWR VPWR _03877_ sky130_fd_sc_hd__or2b_1
X_10244_ _00999_ _00995_ VGND VGND VPWR VPWR _01055_ sky130_fd_sc_hd__and2b_1
X_10175_ _00976_ _00982_ _00984_ VGND VGND VPWR VPWR _00986_ sky130_fd_sc_hd__nand3_1
XFILLER_0_28_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14983_ _06020_ _06022_ VGND VGND VPWR VPWR _06024_ sky130_fd_sc_hd__nand2_1
Xfanout180 net181 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__buf_2
Xfanout191 kd_1\[13\] VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__clkbuf_4
X_16722_ _07890_ _07891_ _05864_ VGND VGND VPWR VPWR _07936_ sky130_fd_sc_hd__o21a_1
X_13934_ _04865_ _04869_ VGND VGND VPWR VPWR _04870_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16653_ _07708_ _07659_ VGND VGND VPWR VPWR _07861_ sky130_fd_sc_hd__and2b_1
X_13865_ _04763_ _04793_ VGND VGND VPWR VPWR _04794_ sky130_fd_sc_hd__and2_1
X_15604_ _06691_ _06700_ _06706_ VGND VGND VPWR VPWR _06707_ sky130_fd_sc_hd__a21oi_2
X_12816_ _03658_ _03659_ VGND VGND VPWR VPWR _03660_ sky130_fd_sc_hd__nor2_1
X_16584_ _05445_ _05448_ VGND VGND VPWR VPWR _07785_ sky130_fd_sc_hd__nor2_1
X_13796_ _04673_ _04688_ VGND VGND VPWR VPWR _04718_ sky130_fd_sc_hd__xor2_1
XFILLER_0_97_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15535_ net267 _05974_ _06016_ net263 VGND VGND VPWR VPWR _06631_ sky130_fd_sc_hd__a22o_1
X_12747_ _03303_ _03590_ VGND VGND VPWR VPWR _03591_ sky130_fd_sc_hd__or2_1
XFILLER_0_84_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12678_ _03515_ _03516_ VGND VGND VPWR VPWR _03517_ sky130_fd_sc_hd__nor2_1
X_15466_ net278 _05603_ VGND VGND VPWR VPWR _06555_ sky130_fd_sc_hd__nand2_2
XFILLER_0_25_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17205_ _08163_ _08467_ _08156_ VGND VGND VPWR VPWR _08468_ sky130_fd_sc_hd__o21ba_1
X_14417_ _05379_ _05400_ VGND VGND VPWR VPWR _05401_ sky130_fd_sc_hd__xnor2_1
X_11629_ net396 net167 VGND VGND VPWR VPWR _02440_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15397_ _06478_ _06373_ VGND VGND VPWR VPWR _06479_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_108_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17136_ _08386_ _08391_ VGND VGND VPWR VPWR _08392_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14348_ _05323_ _05324_ VGND VGND VPWR VPWR _05325_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14279_ _03153_ _02568_ _03151_ VGND VGND VPWR VPWR _05249_ sky130_fd_sc_hd__nand3_1
X_17067_ _05311_ _05313_ _05314_ VGND VGND VPWR VPWR _08316_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_150_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16018_ net268 _04314_ VGND VGND VPWR VPWR _07162_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08840_ _04274_ net72 VGND VGND VPWR VPWR _04285_ sky130_fd_sc_hd__or2_1
X_08771_ _03542_ VGND VGND VPWR VPWR _03553_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_109_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09323_ _08639_ _08640_ VGND VGND VPWR VPWR _08687_ sky130_fd_sc_hd__nor2_1
XFILLER_0_87_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09254_ _08613_ _08617_ VGND VGND VPWR VPWR _08618_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09185_ _07200_ _07233_ VGND VGND VPWR VPWR _08080_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08969_ _05583_ _05693_ VGND VGND VPWR VPWR _05704_ sky130_fd_sc_hd__xor2_1
X_11980_ _02789_ _02790_ _02791_ VGND VGND VPWR VPWR _02792_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_98_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10931_ _01739_ _01741_ VGND VGND VPWR VPWR _01742_ sky130_fd_sc_hd__and2_1
X_13650_ _04474_ _04553_ _04548_ _04552_ VGND VGND VPWR VPWR _04557_ sky130_fd_sc_hd__a211oi_1
X_10862_ _01667_ _01670_ _01672_ VGND VGND VPWR VPWR _01673_ sky130_fd_sc_hd__or3_1
XFILLER_0_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12601_ _03439_ _03343_ _03437_ VGND VGND VPWR VPWR _03440_ sky130_fd_sc_hd__or3b_1
X_13581_ _04479_ _04480_ VGND VGND VPWR VPWR _04481_ sky130_fd_sc_hd__nor2_1
XFILLER_0_149_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10793_ _01573_ _01576_ _01603_ VGND VGND VPWR VPWR _01604_ sky130_fd_sc_hd__a21o_1
X_15320_ _06280_ _06282_ VGND VGND VPWR VPWR _06394_ sky130_fd_sc_hd__xnor2_2
X_12532_ net212 VGND VGND VPWR VPWR _03371_ sky130_fd_sc_hd__inv_2
XFILLER_0_38_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12463_ _03264_ _03250_ _03294_ VGND VGND VPWR VPWR _03297_ sky130_fd_sc_hd__o21bai_1
X_15251_ net274 _05589_ VGND VGND VPWR VPWR _06318_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14202_ _04916_ _05163_ VGND VGND VPWR VPWR _05164_ sky130_fd_sc_hd__nand2_1
X_11414_ prev_d_error\[3\] net441 net123 net118 _02224_ VGND VGND VPWR VPWR _02225_
+ sky130_fd_sc_hd__a41o_1
X_15182_ _06239_ _06241_ VGND VGND VPWR VPWR _06242_ sky130_fd_sc_hd__nand2_1
XFILLER_0_105_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12394_ prev_error\[11\] _04494_ VGND VGND VPWR VPWR _03226_ sky130_fd_sc_hd__and2_1
XFILLER_0_105_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14133_ net240 _04107_ VGND VGND VPWR VPWR _05089_ sky130_fd_sc_hd__and2_1
X_11345_ _02150_ _02155_ VGND VGND VPWR VPWR _02156_ sky130_fd_sc_hd__and2_1
X_14064_ _05010_ _05009_ _05012_ VGND VGND VPWR VPWR _05013_ sky130_fd_sc_hd__nor3_1
XFILLER_0_120_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11276_ _01991_ _02086_ VGND VGND VPWR VPWR _02087_ sky130_fd_sc_hd__or2_1
X_13015_ _03695_ _03856_ _03858_ VGND VGND VPWR VPWR _03859_ sky130_fd_sc_hd__o21a_1
X_10227_ _00969_ _01037_ VGND VGND VPWR VPWR _01038_ sky130_fd_sc_hd__or2_4
X_10158_ _00967_ _00968_ VGND VGND VPWR VPWR _00969_ sky130_fd_sc_hd__nor2_4
XFILLER_0_89_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14966_ _06004_ _05995_ VGND VGND VPWR VPWR _06005_ sky130_fd_sc_hd__xnor2_2
X_10089_ _00898_ _00899_ VGND VGND VPWR VPWR _00900_ sky130_fd_sc_hd__xnor2_1
X_16705_ _07914_ _07916_ _07917_ VGND VGND VPWR VPWR _07918_ sky130_fd_sc_hd__a21o_1
X_13917_ _04837_ _04850_ VGND VGND VPWR VPWR _04851_ sky130_fd_sc_hd__nand2_1
X_14897_ _05920_ _05923_ _05927_ VGND VGND VPWR VPWR _05929_ sky130_fd_sc_hd__nor3_1
X_16636_ _07813_ _07810_ net471 _07828_ _07841_ VGND VGND VPWR VPWR _07842_ sky130_fd_sc_hd__a221o_1
X_13848_ _04773_ _04774_ VGND VGND VPWR VPWR _04775_ sky130_fd_sc_hd__and2_1
XFILLER_0_71_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16567_ _07755_ _07765_ VGND VGND VPWR VPWR _07766_ sky130_fd_sc_hd__or2_1
XFILLER_0_128_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13779_ net241 _03248_ VGND VGND VPWR VPWR _04699_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15518_ _06610_ _06602_ VGND VGND VPWR VPWR _06612_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_139_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16498_ net254 _05711_ _07689_ VGND VGND VPWR VPWR _07690_ sky130_fd_sc_hd__nand3_1
XFILLER_0_57_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15449_ net292 _06535_ _05721_ _05722_ VGND VGND VPWR VPWR _06536_ sky130_fd_sc_hd__and4_1
XFILLER_0_143_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17119_ _08252_ _08370_ _08371_ _08372_ VGND VGND VPWR VPWR _08373_ sky130_fd_sc_hd__a22o_1
XFILLER_0_40_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09941_ net347 _07409_ VGND VGND VPWR VPWR _00752_ sky130_fd_sc_hd__nand2_2
XFILLER_0_96_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09872_ net328 _00243_ _00548_ VGND VGND VPWR VPWR _00683_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_29_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08823_ net11 net66 VGND VGND VPWR VPWR _04098_ sky130_fd_sc_hd__nor2b_2
XFILLER_0_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08754_ net48 _03318_ _03351_ net302 VGND VGND VPWR VPWR _00046_ sky130_fd_sc_hd__a22o_1
XFILLER_0_136_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09306_ _08666_ _08669_ VGND VGND VPWR VPWR _08670_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09237_ _05473_ _08585_ VGND VGND VPWR VPWR _08591_ sky130_fd_sc_hd__xor2_1
XFILLER_0_134_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09168_ _04219_ _04153_ _07882_ net71 _04263_ VGND VGND VPWR VPWR _07893_ sky130_fd_sc_hd__a32o_2
XFILLER_0_71_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09099_ net336 _05022_ _05660_ net341 VGND VGND VPWR VPWR _07134_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_101_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11130_ net432 net110 _01939_ VGND VGND VPWR VPWR _01941_ sky130_fd_sc_hd__and3_1
XFILLER_0_102_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11061_ _01812_ _01871_ VGND VGND VPWR VPWR _01872_ sky130_fd_sc_hd__or2_1
X_10012_ net320 _00654_ _00822_ VGND VGND VPWR VPWR _00823_ sky130_fd_sc_hd__and3_1
XFILLER_0_99_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14820_ net304 net300 net296 _05691_ VGND VGND VPWR VPWR _05844_ sky130_fd_sc_hd__o31a_1
XFILLER_0_116_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14751_ _05755_ _05767_ VGND VGND VPWR VPWR _05768_ sky130_fd_sc_hd__nor2_1
X_11963_ _02769_ _02772_ _02699_ _02773_ VGND VGND VPWR VPWR _02774_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_98_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13702_ _04572_ _04576_ VGND VGND VPWR VPWR _04614_ sky130_fd_sc_hd__nand2_1
X_17470_ clknet_4_0_0_clock _00066_ VGND VGND VPWR VPWR kp\[4\] sky130_fd_sc_hd__dfxtp_1
X_10914_ _01467_ _01723_ VGND VGND VPWR VPWR _01725_ sky130_fd_sc_hd__nand2_1
X_14682_ _05688_ _05689_ _05691_ VGND VGND VPWR VPWR _05692_ sky130_fd_sc_hd__and3b_1
X_11894_ _02702_ _02678_ _02704_ VGND VGND VPWR VPWR _02705_ sky130_fd_sc_hd__and3_1
X_16421_ i_error\[6\] _07604_ VGND VGND VPWR VPWR _07605_ sky130_fd_sc_hd__xnor2_2
X_13633_ _04493_ _04496_ _04495_ VGND VGND VPWR VPWR _04539_ sky130_fd_sc_hd__a21o_1
X_10845_ _01559_ _01613_ _01655_ VGND VGND VPWR VPWR _01656_ sky130_fd_sc_hd__o21a_1
XFILLER_0_132_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16352_ _07511_ _07512_ _07528_ VGND VGND VPWR VPWR _07529_ sky130_fd_sc_hd__o21a_1
XFILLER_0_54_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13564_ net236 net232 _03232_ _03215_ VGND VGND VPWR VPWR _04463_ sky130_fd_sc_hd__and4_1
X_10776_ _01563_ net146 _01586_ VGND VGND VPWR VPWR _01587_ sky130_fd_sc_hd__nor3_1
XFILLER_0_54_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15303_ net304 _05702_ _06373_ _06374_ VGND VGND VPWR VPWR _06376_ sky130_fd_sc_hd__a31o_1
X_12515_ _03352_ _03353_ VGND VGND VPWR VPWR _03354_ sky130_fd_sc_hd__nor2_1
XFILLER_0_54_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16283_ _07451_ _07452_ VGND VGND VPWR VPWR _07454_ sky130_fd_sc_hd__nand2_1
X_13495_ _04251_ _04367_ VGND VGND VPWR VPWR _04387_ sky130_fd_sc_hd__nand2_1
XFILLER_0_137_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15234_ _06294_ _06293_ VGND VGND VPWR VPWR _06300_ sky130_fd_sc_hd__xor2_1
XFILLER_0_41_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12446_ _03223_ VGND VGND VPWR VPWR _03278_ sky130_fd_sc_hd__buf_2
XFILLER_0_23_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15165_ _06114_ _06115_ VGND VGND VPWR VPWR _06224_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_2_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12377_ _03188_ _03189_ _03206_ _03207_ _03208_ VGND VGND VPWR VPWR _03209_ sky130_fd_sc_hd__a311o_2
XFILLER_0_22_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14116_ _05032_ _05034_ VGND VGND VPWR VPWR _05070_ sky130_fd_sc_hd__xor2_1
X_11328_ _02134_ _02138_ VGND VGND VPWR VPWR _02139_ sky130_fd_sc_hd__and2_1
X_15096_ _06146_ _06147_ VGND VGND VPWR VPWR _06148_ sky130_fd_sc_hd__nor2_1
XFILLER_0_120_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14047_ net222 _04107_ VGND VGND VPWR VPWR _04994_ sky130_fd_sc_hd__nand2_1
X_11259_ _02068_ _02069_ VGND VGND VPWR VPWR _02070_ sky130_fd_sc_hd__nor2_1
XFILLER_0_66_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15998_ _07132_ _07133_ VGND VGND VPWR VPWR _07140_ sky130_fd_sc_hd__nand2_1
XFILLER_0_82_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14949_ _05954_ _05940_ VGND VGND VPWR VPWR _05986_ sky130_fd_sc_hd__or2b_1
XFILLER_0_77_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16619_ _07822_ _07597_ VGND VGND VPWR VPWR _07823_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_58_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09022_ _06232_ _06276_ VGND VGND VPWR VPWR _06287_ sky130_fd_sc_hd__nand2_2
XFILLER_0_26_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09924_ _00701_ _00731_ _00734_ VGND VGND VPWR VPWR _00735_ sky130_fd_sc_hd__and3_1
X_09855_ net353 _04604_ _07332_ net349 VGND VGND VPWR VPWR _00666_ sky130_fd_sc_hd__a22o_1
XFILLER_0_147_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08806_ net60 net5 VGND VGND VPWR VPWR _03911_ sky130_fd_sc_hd__or2b_1
X_09786_ _00581_ _00596_ VGND VGND VPWR VPWR _00597_ sky130_fd_sc_hd__or2_1
X_08737_ net39 _03050_ _03083_ net205 VGND VGND VPWR VPWR _00001_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_134_Right_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10630_ _01440_ _01438_ _01437_ VGND VGND VPWR VPWR _01441_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_36_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10561_ _01367_ _01364_ _01366_ VGND VGND VPWR VPWR _01372_ sky130_fd_sc_hd__or3_1
XFILLER_0_24_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12300_ _03104_ _03119_ _03118_ VGND VGND VPWR VPWR _03132_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_101_Left_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13280_ _04124_ _04133_ _04134_ VGND VGND VPWR VPWR _04150_ sky130_fd_sc_hd__or3_1
XFILLER_0_133_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10492_ _01297_ _01301_ VGND VGND VPWR VPWR _01303_ sky130_fd_sc_hd__nand2_1
XFILLER_0_51_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12231_ _03055_ _03057_ _03058_ VGND VGND VPWR VPWR _03059_ sky130_fd_sc_hd__o21a_1
XFILLER_0_122_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12162_ _02985_ _02986_ VGND VGND VPWR VPWR _02987_ sky130_fd_sc_hd__nor2_1
XFILLER_0_20_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11113_ _01885_ _01886_ _01880_ _01884_ VGND VGND VPWR VPWR _01924_ sky130_fd_sc_hd__a211oi_1
X_16970_ _05299_ _08208_ VGND VGND VPWR VPWR _08209_ sky130_fd_sc_hd__nand2_4
X_12093_ _02821_ _02823_ VGND VGND VPWR VPWR _02917_ sky130_fd_sc_hd__or2_1
X_15921_ net306 _05582_ _07053_ _06982_ VGND VGND VPWR VPWR _07055_ sky130_fd_sc_hd__a22o_1
X_11044_ _01780_ _01852_ _01825_ _01851_ VGND VGND VPWR VPWR _01855_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_110_Left_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15852_ _06938_ _06935_ _06937_ VGND VGND VPWR VPWR _06979_ sky130_fd_sc_hd__nand3_1
X_14803_ _05823_ _05824_ VGND VGND VPWR VPWR _05826_ sky130_fd_sc_hd__nor2_1
X_15783_ net285 _05973_ VGND VGND VPWR VPWR _06904_ sky130_fd_sc_hd__nand2_2
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12995_ _03837_ _03838_ VGND VGND VPWR VPWR _03839_ sky130_fd_sc_hd__nor2_1
X_17522_ clknet_4_6_0_clock _00028_ VGND VGND VPWR VPWR kd_2\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_99_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14734_ net261 net258 _05749_ _05738_ VGND VGND VPWR VPWR _05750_ sky130_fd_sc_hd__and4_1
XFILLER_0_86_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11946_ net437 net142 net147 net433 VGND VGND VPWR VPWR _02757_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_52_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17453_ clknet_4_15_0_clock _00131_ VGND VGND VPWR VPWR prev_d_error\[5\] sky130_fd_sc_hd__dfxtp_1
X_14665_ prev_error\[15\] _04989_ VGND VGND VPWR VPWR _05674_ sky130_fd_sc_hd__xor2_1
X_11877_ net426 net147 _02648_ _02649_ VGND VGND VPWR VPWR _02688_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_39_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16404_ _07498_ _06808_ _07496_ VGND VGND VPWR VPWR _07587_ sky130_fd_sc_hd__and3_1
X_13616_ _04506_ _04519_ VGND VGND VPWR VPWR _04520_ sky130_fd_sc_hd__nor2_1
X_17384_ net465 net396 VGND VGND VPWR VPWR _08598_ sky130_fd_sc_hd__or2_1
X_10828_ net389 net116 _01636_ _01637_ VGND VGND VPWR VPWR _01639_ sky130_fd_sc_hd__o2bb2a_1
X_14596_ _05558_ VGND VGND VPWR VPWR _05598_ sky130_fd_sc_hd__inv_2
X_16335_ _05871_ _05890_ VGND VGND VPWR VPWR _07511_ sky130_fd_sc_hd__nor2_1
XFILLER_0_109_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13547_ net179 _04317_ _04108_ net183 VGND VGND VPWR VPWR _04444_ sky130_fd_sc_hd__a22o_1
X_10759_ _01542_ _01544_ VGND VGND VPWR VPWR _01570_ sky130_fd_sc_hd__nor2_1
X_16266_ _07390_ _07391_ _07393_ VGND VGND VPWR VPWR _07435_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_113_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13478_ _04338_ _04336_ VGND VGND VPWR VPWR _04368_ sky130_fd_sc_hd__xor2_4
XFILLER_0_125_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15217_ _06244_ _06245_ VGND VGND VPWR VPWR _06281_ sky130_fd_sc_hd__or2_1
X_12429_ _03260_ VGND VGND VPWR VPWR _03261_ sky130_fd_sc_hd__buf_2
X_16197_ _07352_ _07358_ VGND VGND VPWR VPWR _07359_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_124_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15148_ _06204_ VGND VGND VPWR VPWR _06205_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15079_ _06048_ _06046_ VGND VGND VPWR VPWR _06129_ sky130_fd_sc_hd__and2b_1
XFILLER_0_120_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09640_ _00360_ _00450_ VGND VGND VPWR VPWR _00451_ sky130_fd_sc_hd__xnor2_2
X_09571_ net377 net360 _05011_ _05385_ VGND VGND VPWR VPWR _00382_ sky130_fd_sc_hd__and4_1
XFILLER_0_117_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09005_ _04791_ _04461_ _04681_ _04802_ VGND VGND VPWR VPWR _06100_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_115_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_882 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09907_ _00715_ _00714_ VGND VGND VPWR VPWR _00718_ sky130_fd_sc_hd__and2b_1
X_09838_ _00648_ VGND VGND VPWR VPWR _00649_ sky130_fd_sc_hd__inv_2
X_09769_ _00578_ _00579_ VGND VGND VPWR VPWR _00580_ sky130_fd_sc_hd__or2b_1
XFILLER_0_69_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11800_ _02609_ _02610_ net443 net131 VGND VGND VPWR VPWR _02611_ sky130_fd_sc_hd__and4bb_1
X_12780_ _03370_ _03622_ VGND VGND VPWR VPWR _03624_ sky130_fd_sc_hd__or2_1
XFILLER_0_68_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11731_ _02521_ _02541_ VGND VGND VPWR VPWR _02542_ sky130_fd_sc_hd__nor2_1
XFILLER_0_139_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14450_ _05435_ _05436_ VGND VGND VPWR VPWR _05437_ sky130_fd_sc_hd__nor2_4
XFILLER_0_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11662_ _02337_ _02455_ _02472_ VGND VGND VPWR VPWR _02473_ sky130_fd_sc_hd__and3_1
X_13401_ _04257_ _04280_ _04282_ VGND VGND VPWR VPWR _04283_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_126_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10613_ _00969_ _01037_ _01107_ _01422_ _01423_ VGND VGND VPWR VPWR _01424_ sky130_fd_sc_hd__a221o_1
X_14381_ net178 _03286_ VGND VGND VPWR VPWR _05361_ sky130_fd_sc_hd__nand2_1
X_11593_ _02403_ _02402_ VGND VGND VPWR VPWR _02404_ sky130_fd_sc_hd__or2_1
XFILLER_0_106_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16120_ _07197_ _07272_ _07273_ VGND VGND VPWR VPWR _07274_ sky130_fd_sc_hd__and3_1
X_10544_ net363 _00652_ _01206_ VGND VGND VPWR VPWR _01355_ sky130_fd_sc_hd__and3_1
X_13332_ net220 _03233_ _03216_ net224 VGND VGND VPWR VPWR _04207_ sky130_fd_sc_hd__a22o_1
XFILLER_0_91_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16051_ _07191_ _07197_ VGND VGND VPWR VPWR _07198_ sky130_fd_sc_hd__or2b_1
X_10475_ _01260_ _01284_ VGND VGND VPWR VPWR _01286_ sky130_fd_sc_hd__and2_1
X_13263_ _04033_ _04127_ _04130_ VGND VGND VPWR VPWR _04132_ sky130_fd_sc_hd__o21a_1
XFILLER_0_106_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15002_ net266 _05746_ _05944_ _05945_ VGND VGND VPWR VPWR _06044_ sky130_fd_sc_hd__a22o_1
X_12214_ _03010_ _03032_ VGND VGND VPWR VPWR _03041_ sky130_fd_sc_hd__xor2_2
X_13194_ _04038_ _04053_ _04055_ VGND VGND VPWR VPWR _04056_ sky130_fd_sc_hd__o21a_1
X_12145_ _02866_ _02969_ VGND VGND VPWR VPWR _02970_ sky130_fd_sc_hd__xor2_1
X_16953_ _08188_ _08189_ VGND VGND VPWR VPWR _08191_ sky130_fd_sc_hd__and2_1
X_12076_ _02891_ _02897_ VGND VGND VPWR VPWR _02898_ sky130_fd_sc_hd__nand2_1
X_15904_ _07028_ _07036_ VGND VGND VPWR VPWR _07037_ sky130_fd_sc_hd__nor2_1
X_11027_ _01832_ _01835_ _01837_ VGND VGND VPWR VPWR _01838_ sky130_fd_sc_hd__o21ai_1
X_16884_ _08110_ _08114_ VGND VGND VPWR VPWR _08115_ sky130_fd_sc_hd__xnor2_1
X_15835_ _06841_ _06864_ VGND VGND VPWR VPWR _06961_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_87_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15766_ _06867_ _06868_ _06884_ VGND VGND VPWR VPWR _06885_ sky130_fd_sc_hd__nor3b_2
XFILLER_0_87_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12978_ net207 _03217_ VGND VGND VPWR VPWR _03822_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17505_ clknet_4_1_0_clock _00011_ VGND VGND VPWR VPWR kd_1\[3\] sky130_fd_sc_hd__dfxtp_1
X_14717_ _05725_ _05730_ VGND VGND VPWR VPWR _05731_ sky130_fd_sc_hd__xor2_1
X_11929_ _02730_ _02737_ _02739_ VGND VGND VPWR VPWR _02740_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_47_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15697_ _06546_ _06561_ VGND VGND VPWR VPWR _06809_ sky130_fd_sc_hd__xnor2_2
X_17436_ clknet_4_9_0_clock _00114_ VGND VGND VPWR VPWR i_error\[6\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_74_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14648_ net255 _05584_ VGND VGND VPWR VPWR _05655_ sky130_fd_sc_hd__nand2_1
XFILLER_0_90_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_17 net217 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_129_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_28 _03344_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_39 net469 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_17367_ net467 net431 net456 _08587_ VGND VGND VPWR VPWR _00130_ sky130_fd_sc_hd__o211a_1
XFILLER_0_144_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14579_ _05576_ _05578_ VGND VGND VPWR VPWR _05579_ sky130_fd_sc_hd__and2_1
X_16318_ _06973_ _06975_ _07049_ _07491_ VGND VGND VPWR VPWR _07492_ sky130_fd_sc_hd__or4_4
XFILLER_0_15_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17298_ _08536_ _07948_ _08544_ net451 VGND VGND VPWR VPWR _00097_ sky130_fd_sc_hd__o211a_1
XFILLER_0_103_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16249_ _07412_ _07415_ VGND VGND VPWR VPWR _07416_ sky130_fd_sc_hd__nor2_1
XFILLER_0_88_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09623_ net373 _05418_ _00432_ _00433_ VGND VGND VPWR VPWR _00434_ sky130_fd_sc_hd__a31o_1
X_09554_ _00363_ _00364_ VGND VGND VPWR VPWR _00365_ sky130_fd_sc_hd__nor2_1
X_09485_ _00293_ _00295_ VGND VGND VPWR VPWR _00296_ sky130_fd_sc_hd__or2b_1
XFILLER_0_144_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10260_ _01070_ VGND VGND VPWR VPWR _01071_ sky130_fd_sc_hd__inv_2
X_10191_ _00822_ _00655_ VGND VGND VPWR VPWR _01002_ sky130_fd_sc_hd__and2b_1
Xfanout340 net341 VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__clkbuf_4
Xfanout351 kp\[7\] VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__clkbuf_4
Xfanout362 net363 VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__clkbuf_4
Xfanout373 kp\[1\] VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__clkbuf_4
X_13950_ net223 _03792_ VGND VGND VPWR VPWR _04887_ sky130_fd_sc_hd__nand2_1
Xfanout384 prev_d_error\[16\] VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__clkbuf_2
Xfanout395 net396 VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__clkbuf_4
X_12901_ _03264_ _03669_ _03670_ VGND VGND VPWR VPWR _03745_ sky130_fd_sc_hd__o21bai_1
X_13881_ net247 net225 _03667_ _03247_ VGND VGND VPWR VPWR _04811_ sky130_fd_sc_hd__and4_1
X_15620_ _06722_ _06723_ VGND VGND VPWR VPWR _06724_ sky130_fd_sc_hd__and2_1
X_12832_ _03567_ _03588_ VGND VGND VPWR VPWR _03676_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_68_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15551_ _06647_ _06481_ VGND VGND VPWR VPWR _06648_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_96_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12763_ _03522_ _03606_ VGND VGND VPWR VPWR _03607_ sky130_fd_sc_hd__or2_1
XFILLER_0_56_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14502_ _06364_ _06947_ VGND VGND VPWR VPWR _05494_ sky130_fd_sc_hd__nor2_1
XFILLER_0_83_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11714_ _02522_ _02523_ _02524_ VGND VGND VPWR VPWR _02525_ sky130_fd_sc_hd__o21ba_1
X_15482_ _06569_ _06570_ _06571_ VGND VGND VPWR VPWR _06572_ sky130_fd_sc_hd__or3b_4
X_12694_ _03530_ _03532_ _03528_ VGND VGND VPWR VPWR _03533_ sky130_fd_sc_hd__a21oi_1
X_17221_ _08478_ _08480_ _08482_ _08484_ VGND VGND VPWR VPWR _08485_ sky130_fd_sc_hd__and4_1
X_14433_ _08661_ _01449_ _08659_ VGND VGND VPWR VPWR _05419_ sky130_fd_sc_hd__a21boi_2
X_11645_ net435 net439 net131 net525 VGND VGND VPWR VPWR _02456_ sky130_fd_sc_hd__and4_1
XFILLER_0_71_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17152_ _08403_ _08408_ VGND VGND VPWR VPWR _08409_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_92_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput15 measurement[5] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__buf_1
X_14364_ _05340_ _05342_ VGND VGND VPWR VPWR _05343_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput26 reg_addr[15] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_1
X_11576_ _02382_ _02386_ VGND VGND VPWR VPWR _02387_ sky130_fd_sc_hd__nor2_1
Xinput37 reg_addr[9] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_1
X_16103_ net279 _04312_ _07254_ VGND VGND VPWR VPWR _07256_ sky130_fd_sc_hd__and3_1
Xinput48 reg_data[2] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__buf_2
XFILLER_0_3_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput59 target[11] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_1
X_13315_ _04185_ _04188_ VGND VGND VPWR VPWR _04189_ sky130_fd_sc_hd__or2b_1
XFILLER_0_40_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10527_ _01328_ _01336_ _01337_ VGND VGND VPWR VPWR _01338_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_122_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17083_ net389 net105 _05329_ VGND VGND VPWR VPWR _08334_ sky130_fd_sc_hd__a21oi_1
X_14295_ _05265_ _05266_ VGND VGND VPWR VPWR _05267_ sky130_fd_sc_hd__xnor2_2
X_16034_ _07175_ _07179_ VGND VGND VPWR VPWR _07180_ sky130_fd_sc_hd__nand2_1
X_10458_ _01248_ _01249_ _05308_ _00557_ VGND VGND VPWR VPWR _01269_ sky130_fd_sc_hd__o2bb2a_1
X_13246_ _04102_ _04104_ VGND VGND VPWR VPWR _04113_ sky130_fd_sc_hd__xor2_1
XFILLER_0_150_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10389_ _01197_ _01198_ _01199_ VGND VGND VPWR VPWR _01200_ sky130_fd_sc_hd__nand3_1
X_13177_ _03908_ _03910_ VGND VGND VPWR VPWR _04037_ sky130_fd_sc_hd__xnor2_1
X_12128_ _02950_ _02952_ VGND VGND VPWR VPWR _02953_ sky130_fd_sc_hd__nand2_1
X_16936_ _05427_ _08171_ VGND VGND VPWR VPWR _08172_ sky130_fd_sc_hd__nand2_1
X_12059_ _02877_ _02878_ VGND VGND VPWR VPWR _02879_ sky130_fd_sc_hd__nor2_1
X_16867_ _05269_ _05271_ VGND VGND VPWR VPWR _08096_ sky130_fd_sc_hd__nor2_1
X_15818_ net295 _05626_ _05628_ _06897_ VGND VGND VPWR VPWR _06942_ sky130_fd_sc_hd__nand4_1
X_16798_ _05421_ _05467_ _08019_ VGND VGND VPWR VPWR _08020_ sky130_fd_sc_hd__o21a_1
XFILLER_0_59_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15749_ net507 _06597_ _06641_ VGND VGND VPWR VPWR _06866_ sky130_fd_sc_hd__o21a_1
XFILLER_0_90_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09270_ _04219_ _04153_ _07882_ VGND VGND VPWR VPWR _08634_ sky130_fd_sc_hd__nand3_2
XFILLER_0_59_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17419_ clknet_4_3_0_clock _00097_ VGND VGND VPWR VPWR prev_error\[7\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_74_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08985_ _05836_ _05847_ VGND VGND VPWR VPWR _05880_ sky130_fd_sc_hd__xor2_1
XFILLER_0_48_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09606_ _00381_ _00416_ _00414_ VGND VGND VPWR VPWR _00417_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_97_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09537_ _00340_ _00342_ _00346_ _00347_ _06232_ VGND VGND VPWR VPWR _00348_ sky130_fd_sc_hd__a41oi_4
XFILLER_0_149_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09468_ net353 _04912_ _00278_ VGND VGND VPWR VPWR _00279_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_38_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09399_ _00208_ _00209_ VGND VGND VPWR VPWR _00210_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_62_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11430_ _02227_ _02230_ _02239_ VGND VGND VPWR VPWR _02241_ sky130_fd_sc_hd__or3_1
XFILLER_0_136_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11361_ _02150_ _02157_ _02158_ VGND VGND VPWR VPWR _02172_ sky130_fd_sc_hd__a21oi_1
X_10312_ net351 _00314_ VGND VGND VPWR VPWR _01123_ sky130_fd_sc_hd__nand2_1
X_13100_ _03891_ _03895_ VGND VGND VPWR VPWR _03952_ sky130_fd_sc_hd__nand2_1
X_14080_ _05024_ _05029_ VGND VGND VPWR VPWR _05030_ sky130_fd_sc_hd__nor2_1
X_11292_ _02100_ _02102_ VGND VGND VPWR VPWR _02103_ sky130_fd_sc_hd__nand2_1
X_10243_ _01047_ _01053_ VGND VGND VPWR VPWR _01054_ sky130_fd_sc_hd__nor2_1
X_13031_ _03803_ _03839_ _03837_ VGND VGND VPWR VPWR _03876_ sky130_fd_sc_hd__a21o_1
XFILLER_0_119_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10174_ _00976_ _00982_ _00984_ VGND VGND VPWR VPWR _00985_ sky130_fd_sc_hd__a21o_1
X_14982_ _06013_ _06021_ VGND VGND VPWR VPWR _06022_ sky130_fd_sc_hd__and2_1
Xfanout170 net172 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__buf_2
Xfanout181 net182 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__clkbuf_2
X_16721_ net524 _05801_ VGND VGND VPWR VPWR _07935_ sky130_fd_sc_hd__or2_1
XFILLER_0_89_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout192 net196 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__clkbuf_4
X_13933_ _04866_ _04867_ VGND VGND VPWR VPWR _04869_ sky130_fd_sc_hd__xnor2_1
X_16652_ _07854_ _07856_ _07858_ _07746_ VGND VGND VPWR VPWR _07859_ sky130_fd_sc_hd__a211o_1
X_13864_ _04684_ _04750_ _04762_ VGND VGND VPWR VPWR _04793_ sky130_fd_sc_hd__or3_1
XFILLER_0_97_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15603_ _06701_ _06704_ VGND VGND VPWR VPWR _06706_ sky130_fd_sc_hd__and2b_1
X_12815_ _03579_ _03583_ VGND VGND VPWR VPWR _03659_ sky130_fd_sc_hd__xnor2_1
X_16583_ _07782_ VGND VGND VPWR VPWR _07784_ sky130_fd_sc_hd__inv_2
X_13795_ _04710_ _04715_ _04633_ _04716_ VGND VGND VPWR VPWR _04717_ sky130_fd_sc_hd__o211ai_4
X_15534_ _06627_ _06629_ VGND VGND VPWR VPWR _06630_ sky130_fd_sc_hd__xnor2_1
X_12746_ _03302_ _03257_ _03276_ VGND VGND VPWR VPWR _03590_ sky130_fd_sc_hd__and3_1
XFILLER_0_45_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_850 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15465_ net289 _05582_ _06537_ _06536_ VGND VGND VPWR VPWR _06554_ sky130_fd_sc_hd__a31o_1
XFILLER_0_84_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12677_ _03427_ _03514_ _03459_ VGND VGND VPWR VPWR _03516_ sky130_fd_sc_hd__nor3_1
X_17204_ _08109_ _08132_ _08137_ VGND VGND VPWR VPWR _08467_ sky130_fd_sc_hd__a21oi_1
X_14416_ _05398_ _05399_ VGND VGND VPWR VPWR _05400_ sky130_fd_sc_hd__nor2_1
X_11628_ _02438_ VGND VGND VPWR VPWR _02439_ sky130_fd_sc_hd__inv_2
X_15396_ net304 _05701_ VGND VGND VPWR VPWR _06478_ sky130_fd_sc_hd__nand2_1
XFILLER_0_80_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17135_ _08337_ _08390_ VGND VGND VPWR VPWR _08391_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14347_ _01695_ _01698_ _05322_ VGND VGND VPWR VPWR _05324_ sky130_fd_sc_hd__nand3_1
X_11559_ _02287_ _02369_ VGND VGND VPWR VPWR _02370_ sky130_fd_sc_hd__or2_1
XFILLER_0_69_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17066_ _05309_ _05317_ _08314_ VGND VGND VPWR VPWR _08315_ sky130_fd_sc_hd__a21bo_1
X_14278_ _05244_ _05247_ VGND VGND VPWR VPWR _05248_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_21_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16017_ _07086_ _07159_ _07158_ _07143_ VGND VGND VPWR VPWR _07161_ sky130_fd_sc_hd__a211oi_2
X_13229_ _04092_ _04093_ VGND VGND VPWR VPWR _04094_ sky130_fd_sc_hd__or2b_1
X_08770_ _03039_ _03296_ VGND VGND VPWR VPWR _03542_ sky130_fd_sc_hd__nor2_2
X_16919_ _05457_ _08149_ VGND VGND VPWR VPWR _08153_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_125_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09322_ _08671_ _08685_ VGND VGND VPWR VPWR _08686_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_148_Left_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09253_ net340 _04769_ _08146_ _08616_ VGND VGND VPWR VPWR _08617_ sky130_fd_sc_hd__a31o_1
XFILLER_0_7_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09184_ _08058_ _05539_ VGND VGND VPWR VPWR _08069_ sky130_fd_sc_hd__or2b_1
XFILLER_0_133_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08968_ _05671_ _05682_ VGND VGND VPWR VPWR _05693_ sky130_fd_sc_hd__nor2_1
X_08899_ _04923_ VGND VGND VPWR VPWR _04934_ sky130_fd_sc_hd__clkbuf_4
X_10930_ _01581_ _01740_ VGND VGND VPWR VPWR _01741_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10861_ _01563_ net125 _01668_ _01671_ VGND VGND VPWR VPWR _01672_ sky130_fd_sc_hd__o22a_1
XFILLER_0_39_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12600_ net198 VGND VGND VPWR VPWR _03439_ sky130_fd_sc_hd__inv_2
X_13580_ _04456_ _04478_ VGND VGND VPWR VPWR _04480_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_27_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10792_ _01601_ _01602_ VGND VGND VPWR VPWR _01603_ sky130_fd_sc_hd__nand2_1
XFILLER_0_93_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12531_ _03365_ _03369_ _03367_ VGND VGND VPWR VPWR _03370_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_35_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15250_ _06242_ _06315_ _06316_ VGND VGND VPWR VPWR _06317_ sky130_fd_sc_hd__and3_1
XFILLER_0_124_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12462_ _03264_ _03250_ _03294_ VGND VGND VPWR VPWR _03295_ sky130_fd_sc_hd__or3b_1
XFILLER_0_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14201_ _04860_ _05157_ _05161_ _05162_ VGND VGND VPWR VPWR _05163_ sky130_fd_sc_hd__a31o_1
X_11413_ net444 net115 _02222_ _02223_ VGND VGND VPWR VPWR _02224_ sky130_fd_sc_hd__and4_1
XFILLER_0_22_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15181_ _06154_ _06240_ VGND VGND VPWR VPWR _06241_ sky130_fd_sc_hd__nor2_1
X_12393_ prev_error\[11\] _04494_ VGND VGND VPWR VPWR _03225_ sky130_fd_sc_hd__nor2_2
X_14132_ _05085_ _05086_ VGND VGND VPWR VPWR _05087_ sky130_fd_sc_hd__xnor2_1
X_11344_ _02144_ _02146_ _02149_ VGND VGND VPWR VPWR _02155_ sky130_fd_sc_hd__or3_1
XFILLER_0_104_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14063_ _04977_ _05008_ _04999_ _05007_ VGND VGND VPWR VPWR _05012_ sky130_fd_sc_hd__o211a_1
X_11275_ _01988_ _01990_ VGND VGND VPWR VPWR _02086_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_148_Right_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13014_ _03699_ _03857_ VGND VGND VPWR VPWR _03858_ sky130_fd_sc_hd__nor2_1
X_10226_ _01004_ _01035_ _01036_ VGND VGND VPWR VPWR _01037_ sky130_fd_sc_hd__a21o_1
X_10157_ _00964_ _00963_ _00930_ VGND VGND VPWR VPWR _00968_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_55_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14965_ _05985_ _05992_ VGND VGND VPWR VPWR _06004_ sky130_fd_sc_hd__xor2_2
X_10088_ _00835_ _00834_ VGND VGND VPWR VPWR _00899_ sky130_fd_sc_hd__or2b_1
X_16704_ _05520_ _07723_ VGND VGND VPWR VPWR _07917_ sky130_fd_sc_hd__nor2_1
X_13916_ _04837_ _04848_ _04849_ VGND VGND VPWR VPWR _04850_ sky130_fd_sc_hd__nand3_1
X_14896_ _05920_ _05923_ _05927_ VGND VGND VPWR VPWR _05928_ sky130_fd_sc_hd__o21a_1
XFILLER_0_77_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16635_ _07835_ _07840_ VGND VGND VPWR VPWR _07841_ sky130_fd_sc_hd__nor2_1
X_13847_ _04764_ _04770_ VGND VGND VPWR VPWR _04774_ sky130_fd_sc_hd__xor2_1
XFILLER_0_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16566_ _05449_ _05453_ _05437_ VGND VGND VPWR VPWR _07765_ sky130_fd_sc_hd__o21a_1
XFILLER_0_85_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13778_ _04697_ _04623_ VGND VGND VPWR VPWR _04698_ sky130_fd_sc_hd__xnor2_1
X_15517_ _06602_ _06610_ VGND VGND VPWR VPWR _06611_ sky130_fd_sc_hd__and2b_1
XFILLER_0_72_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12729_ _03271_ _03273_ VGND VGND VPWR VPWR _03571_ sky130_fd_sc_hd__xnor2_1
X_16497_ _07686_ _07688_ VGND VGND VPWR VPWR _07689_ sky130_fd_sc_hd__and2_1
XFILLER_0_128_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15448_ net308 _06527_ _06528_ VGND VGND VPWR VPWR _06535_ sky130_fd_sc_hd__and3_1
XFILLER_0_26_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15379_ _06451_ _06458_ VGND VGND VPWR VPWR _06459_ sky130_fd_sc_hd__nor2_1
XFILLER_0_80_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap101 _05053_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__buf_1
X_17118_ _08037_ _08046_ VGND VGND VPWR VPWR _08372_ sky130_fd_sc_hd__nand2_1
XFILLER_0_52_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17049_ _05379_ _05400_ _05398_ VGND VGND VPWR VPWR _08296_ sky130_fd_sc_hd__a21oi_1
X_09940_ net356 _04615_ _00738_ _00750_ VGND VGND VPWR VPWR _00751_ sky130_fd_sc_hd__a31o_2
XFILLER_0_111_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_115_Right_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09871_ _00681_ VGND VGND VPWR VPWR _00682_ sky130_fd_sc_hd__inv_2
XFILLER_0_110_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08822_ net66 net11 VGND VGND VPWR VPWR _04087_ sky130_fd_sc_hd__nand2b_4
X_08753_ net47 _03318_ _03351_ net307 VGND VGND VPWR VPWR _00045_ sky130_fd_sc_hd__a22o_1
XFILLER_0_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09305_ _08667_ _08668_ VGND VGND VPWR VPWR _08669_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_48_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09236_ net344 _05660_ VGND VGND VPWR VPWR _08585_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09167_ _04197_ _04032_ _04131_ _04296_ VGND VGND VPWR VPWR _07882_ sky130_fd_sc_hd__a31o_4
XFILLER_0_31_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09098_ net340 net336 _05022_ _05649_ VGND VGND VPWR VPWR _07123_ sky130_fd_sc_hd__and4_1
X_11060_ _01809_ _01811_ VGND VGND VPWR VPWR _01871_ sky130_fd_sc_hd__nor2_1
X_10011_ net324 _00654_ _00821_ _00819_ VGND VGND VPWR VPWR _00822_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14750_ _05708_ _05717_ _05754_ VGND VGND VPWR VPWR _05767_ sky130_fd_sc_hd__nor3_1
X_11962_ _02695_ _02698_ _02697_ VGND VGND VPWR VPWR _02773_ sky130_fd_sc_hd__a21oi_1
X_13701_ _04537_ _04539_ _04546_ VGND VGND VPWR VPWR _04613_ sky130_fd_sc_hd__a21o_1
X_10913_ _01467_ _01723_ VGND VGND VPWR VPWR _01724_ sky130_fd_sc_hd__or2_1
X_14681_ _05690_ VGND VGND VPWR VPWR _05691_ sky130_fd_sc_hd__clkbuf_4
X_11893_ _02701_ _02703_ VGND VGND VPWR VPWR _02704_ sky130_fd_sc_hd__nor2_1
X_16420_ _07493_ _07603_ VGND VGND VPWR VPWR _07604_ sky130_fd_sc_hd__xnor2_2
X_13632_ _04493_ _04496_ _04495_ VGND VGND VPWR VPWR _04537_ sky130_fd_sc_hd__nand3_1
X_10844_ _01653_ _01654_ VGND VGND VPWR VPWR _01655_ sky130_fd_sc_hd__and2_1
XFILLER_0_132_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16351_ _07526_ _07527_ VGND VGND VPWR VPWR _07528_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13563_ net232 _03232_ _03216_ net236 VGND VGND VPWR VPWR _04462_ sky130_fd_sc_hd__a22o_1
X_10775_ _01584_ _01585_ VGND VGND VPWR VPWR _01586_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15302_ _06258_ _06371_ VGND VGND VPWR VPWR _06374_ sky130_fd_sc_hd__and2_1
X_12514_ net198 _03342_ _03350_ VGND VGND VPWR VPWR _03353_ sky130_fd_sc_hd__a21oi_1
X_16282_ _07449_ _07450_ VGND VGND VPWR VPWR _07452_ sky130_fd_sc_hd__or2_1
XFILLER_0_26_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13494_ _04344_ _04358_ VGND VGND VPWR VPWR _04386_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_81_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15233_ _06297_ VGND VGND VPWR VPWR _06299_ sky130_fd_sc_hd__inv_2
XFILLER_0_35_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12445_ _03251_ _03254_ VGND VGND VPWR VPWR _03277_ sky130_fd_sc_hd__or2_1
XFILLER_0_34_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15164_ net288 _05724_ _06220_ _06222_ VGND VGND VPWR VPWR _06223_ sky130_fd_sc_hd__a31oi_4
XFILLER_0_34_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12376_ prev_error\[8\] _07398_ VGND VGND VPWR VPWR _03208_ sky130_fd_sc_hd__and2b_1
XFILLER_0_133_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14115_ _05057_ _05061_ _05068_ VGND VGND VPWR VPWR _05069_ sky130_fd_sc_hd__a21oi_1
X_11327_ _02129_ _02131_ _02133_ VGND VGND VPWR VPWR _02138_ sky130_fd_sc_hd__or3_1
X_15095_ _06125_ _06126_ VGND VGND VPWR VPWR _06147_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_120_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14046_ _04991_ _04992_ VGND VGND VPWR VPWR _04993_ sky130_fd_sc_hd__xor2_1
X_11258_ _02054_ _02057_ _02067_ VGND VGND VPWR VPWR _02069_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10209_ _01014_ _01018_ _01019_ VGND VGND VPWR VPWR _01020_ sky130_fd_sc_hd__o21a_1
X_11189_ _01995_ _01997_ _01999_ VGND VGND VPWR VPWR _02000_ sky130_fd_sc_hd__o21ai_1
X_15997_ _07136_ _07138_ VGND VGND VPWR VPWR _07139_ sky130_fd_sc_hd__xnor2_1
X_14948_ _05983_ _05984_ VGND VGND VPWR VPWR _05985_ sky130_fd_sc_hd__nor2b_2
XFILLER_0_82_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14879_ _05907_ _05908_ VGND VGND VPWR VPWR _05909_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16618_ _07584_ _07820_ _07821_ VGND VGND VPWR VPWR _07822_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16549_ _07736_ _07738_ _07742_ _07745_ VGND VGND VPWR VPWR _07746_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_58_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09021_ _06243_ _05308_ _06265_ VGND VGND VPWR VPWR _06276_ sky130_fd_sc_hd__mux2_2
XFILLER_0_122_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09923_ net374 _04747_ _00732_ _00733_ VGND VGND VPWR VPWR _00734_ sky130_fd_sc_hd__a31o_1
XFILLER_0_0_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09854_ _00660_ _00664_ VGND VGND VPWR VPWR _00665_ sky130_fd_sc_hd__and2b_1
X_08805_ net5 net60 VGND VGND VPWR VPWR _03900_ sky130_fd_sc_hd__or2b_1
X_09785_ _00591_ _00594_ _00595_ VGND VGND VPWR VPWR _00596_ sky130_fd_sc_hd__o21a_1
X_08736_ net55 _03061_ _03094_ net208 VGND VGND VPWR VPWR _00017_ sky130_fd_sc_hd__a22o_1
XFILLER_0_95_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10560_ _01369_ _01370_ VGND VGND VPWR VPWR _01371_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_118_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09219_ _08388_ _08432_ _08443_ VGND VGND VPWR VPWR _08454_ sky130_fd_sc_hd__o21ai_1
X_10491_ _01297_ _01301_ VGND VGND VPWR VPWR _01302_ sky130_fd_sc_hd__or2_1
XFILLER_0_134_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12230_ _03012_ _03030_ VGND VGND VPWR VPWR _03058_ sky130_fd_sc_hd__xor2_2
XFILLER_0_115_880 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12161_ _02984_ _02980_ _02982_ VGND VGND VPWR VPWR _02986_ sky130_fd_sc_hd__nor3_1
XFILLER_0_130_850 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11112_ _01912_ _01922_ VGND VGND VPWR VPWR _01923_ sky130_fd_sc_hd__and2_1
X_12092_ _02901_ _02913_ _02914_ VGND VGND VPWR VPWR _02915_ sky130_fd_sc_hd__nand3_1
X_15920_ net306 _05582_ _07053_ _06982_ VGND VGND VPWR VPWR _07054_ sky130_fd_sc_hd__nand4_1
X_11043_ _01843_ _01845_ _01847_ VGND VGND VPWR VPWR _01854_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_127_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15851_ _06950_ _06952_ VGND VGND VPWR VPWR _06978_ sky130_fd_sc_hd__xnor2_1
X_14802_ net524 _05622_ _05821_ _05822_ VGND VGND VPWR VPWR _05824_ sky130_fd_sc_hd__o22a_1
X_15782_ _06900_ _06901_ VGND VGND VPWR VPWR _06902_ sky130_fd_sc_hd__xnor2_1
X_12994_ _03819_ _03835_ _03836_ VGND VGND VPWR VPWR _03838_ sky130_fd_sc_hd__nor3_1
XFILLER_0_98_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14733_ _05631_ VGND VGND VPWR VPWR _05749_ sky130_fd_sc_hd__buf_2
X_17521_ clknet_4_6_0_clock _00027_ VGND VGND VPWR VPWR kd_2\[1\] sky130_fd_sc_hd__dfxtp_1
X_11945_ net433 net438 net142 net147 VGND VGND VPWR VPWR _02756_ sky130_fd_sc_hd__and4_1
XFILLER_0_59_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17452_ clknet_4_15_0_clock _00130_ VGND VGND VPWR VPWR prev_d_error\[4\] sky130_fd_sc_hd__dfxtp_1
X_14664_ _05654_ _05672_ VGND VGND VPWR VPWR _05673_ sky130_fd_sc_hd__nor2_1
X_11876_ _02682_ _02684_ _02686_ VGND VGND VPWR VPWR _02687_ sky130_fd_sc_hd__o21ai_1
X_16403_ _06808_ _07496_ _07498_ VGND VGND VPWR VPWR _07586_ sky130_fd_sc_hd__a21oi_1
X_13615_ _04508_ _04517_ _04518_ VGND VGND VPWR VPWR _04519_ sky130_fd_sc_hd__o21a_1
XFILLER_0_7_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17383_ net465 net398 net458 _08596_ VGND VGND VPWR VPWR _00138_ sky130_fd_sc_hd__o211a_1
X_10827_ _01636_ _01637_ net389 net117 VGND VGND VPWR VPWR _01638_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_39_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14595_ _05558_ _05559_ _05575_ VGND VGND VPWR VPWR _05597_ sky130_fd_sc_hd__or3_1
XFILLER_0_67_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16334_ _05832_ _05833_ VGND VGND VPWR VPWR _07510_ sky130_fd_sc_hd__and2b_1
X_13546_ net184 _04108_ _04442_ VGND VGND VPWR VPWR _04443_ sky130_fd_sc_hd__nand3_1
X_10758_ net138 _01567_ _01568_ prev_d_error\[17\] VGND VGND VPWR VPWR _01569_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_70_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16265_ _07428_ _07433_ VGND VGND VPWR VPWR _07434_ sky130_fd_sc_hd__nor2_1
XFILLER_0_125_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13477_ _04248_ _04250_ _04249_ VGND VGND VPWR VPWR _04367_ sky130_fd_sc_hd__o21ai_2
X_10689_ _01498_ _01499_ VGND VGND VPWR VPWR _01500_ sky130_fd_sc_hd__nor2_1
X_15216_ _06277_ _06279_ VGND VGND VPWR VPWR _06280_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_124_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12428_ _03243_ VGND VGND VPWR VPWR _03260_ sky130_fd_sc_hd__buf_2
X_16196_ _07353_ _07355_ _07357_ VGND VGND VPWR VPWR _07358_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_124_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15147_ _03931_ _05565_ VGND VGND VPWR VPWR _06204_ sky130_fd_sc_hd__xor2_4
X_12359_ prev_error\[5\] _08674_ VGND VGND VPWR VPWR _03191_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_10_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15078_ net266 _05621_ VGND VGND VPWR VPWR _06128_ sky130_fd_sc_hd__nand2_1
X_14029_ _04958_ _04962_ _04973_ VGND VGND VPWR VPWR _04974_ sky130_fd_sc_hd__and3_1
XFILLER_0_93_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09570_ _00361_ _00380_ VGND VGND VPWR VPWR _00381_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09004_ _06034_ _06078_ VGND VGND VPWR VPWR _06089_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_41_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09906_ _00696_ _00716_ VGND VGND VPWR VPWR _00717_ sky130_fd_sc_hd__and2_1
XFILLER_0_6_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09837_ _00642_ _00646_ _00647_ VGND VGND VPWR VPWR _00648_ sky130_fd_sc_hd__nor3_1
X_09768_ _00477_ _00480_ VGND VGND VPWR VPWR _00579_ sky130_fd_sc_hd__xnor2_1
X_08719_ net46 _02894_ _02927_ net106 VGND VGND VPWR VPWR _00026_ sky130_fd_sc_hd__a22o_1
X_09699_ _00377_ _00509_ VGND VGND VPWR VPWR _00510_ sky130_fd_sc_hd__nor2_1
X_11730_ _02537_ _02538_ _02540_ VGND VGND VPWR VPWR _02541_ sky130_fd_sc_hd__and3_1
XFILLER_0_95_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11661_ _02468_ _02471_ VGND VGND VPWR VPWR _02472_ sky130_fd_sc_hd__nand2_1
X_13400_ _04159_ _04281_ VGND VGND VPWR VPWR _04282_ sky130_fd_sc_hd__xnor2_1
X_10612_ _01039_ _01106_ VGND VGND VPWR VPWR _01423_ sky130_fd_sc_hd__and2b_1
XFILLER_0_92_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14380_ _03264_ _03278_ VGND VGND VPWR VPWR _05360_ sky130_fd_sc_hd__or2_1
X_11592_ net430 net131 net115 net448 VGND VGND VPWR VPWR _02403_ sky130_fd_sc_hd__a22oi_1
X_13331_ _03365_ _04029_ _04033_ VGND VGND VPWR VPWR _04206_ sky130_fd_sc_hd__or3_1
X_10543_ net375 _00371_ _01353_ _01351_ VGND VGND VPWR VPWR _01354_ sky130_fd_sc_hd__a31o_1
XFILLER_0_107_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16050_ _07191_ _07192_ _07195_ _07196_ VGND VGND VPWR VPWR _07197_ sky130_fd_sc_hd__nand4bb_1
XFILLER_0_106_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13262_ _04128_ _04129_ VGND VGND VPWR VPWR _04130_ sky130_fd_sc_hd__or2b_1
XFILLER_0_134_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10474_ _01260_ _01284_ VGND VGND VPWR VPWR _01285_ sky130_fd_sc_hd__xor2_2
XFILLER_0_121_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15001_ _06041_ _06042_ VGND VGND VPWR VPWR _06043_ sky130_fd_sc_hd__nand2_2
X_12213_ _03037_ _03038_ VGND VGND VPWR VPWR _03040_ sky130_fd_sc_hd__nand2_1
X_13193_ _03919_ _03942_ VGND VGND VPWR VPWR _04055_ sky130_fd_sc_hd__xnor2_1
X_12144_ _02941_ _02968_ VGND VGND VPWR VPWR _02969_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_138_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16952_ _08185_ _08187_ VGND VGND VPWR VPWR _08189_ sky130_fd_sc_hd__nand2_1
X_12075_ _02895_ _02896_ VGND VGND VPWR VPWR _02897_ sky130_fd_sc_hd__and2_1
X_15903_ _07023_ _07030_ VGND VGND VPWR VPWR _07036_ sky130_fd_sc_hd__and2b_1
X_11026_ _01831_ _01836_ VGND VGND VPWR VPWR _01837_ sky130_fd_sc_hd__and2_1
X_16883_ _07988_ _08032_ _08111_ _08112_ VGND VGND VPWR VPWR _08114_ sky130_fd_sc_hd__o22a_1
XFILLER_0_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15834_ _06955_ _06959_ VGND VGND VPWR VPWR _06960_ sky130_fd_sc_hd__nand2b_4
X_15765_ _06879_ _06883_ VGND VGND VPWR VPWR _06884_ sky130_fd_sc_hd__xor2_1
X_12977_ _03723_ _03820_ VGND VGND VPWR VPWR _03821_ sky130_fd_sc_hd__xnor2_1
X_17504_ clknet_4_1_0_clock _00010_ VGND VGND VPWR VPWR kd_1\[2\] sky130_fd_sc_hd__dfxtp_1
X_14716_ _05727_ _05728_ _05729_ VGND VGND VPWR VPWR _05730_ sky130_fd_sc_hd__o21a_1
X_11928_ _02676_ _02738_ VGND VGND VPWR VPWR _02739_ sky130_fd_sc_hd__or2_1
X_15696_ _06405_ _06505_ _06798_ _06805_ _06807_ VGND VGND VPWR VPWR _06808_ sky130_fd_sc_hd__o221a_1
X_14647_ _05652_ _05653_ VGND VGND VPWR VPWR _05654_ sky130_fd_sc_hd__nand2_1
X_17435_ clknet_4_9_0_clock _00113_ VGND VGND VPWR VPWR i_error\[5\] sky130_fd_sc_hd__dfxtp_1
X_11859_ _02664_ _02668_ VGND VGND VPWR VPWR _02670_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_18 net287 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14578_ _03185_ _03239_ _05577_ VGND VGND VPWR VPWR _05578_ sky130_fd_sc_hd__a21o_1
X_17366_ net466 _08118_ VGND VGND VPWR VPWR _08587_ sky130_fd_sc_hd__nand2_1
XANTENNA_29 _03344_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_884 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16317_ _07126_ _07488_ _07489_ _07490_ VGND VGND VPWR VPWR _07491_ sky130_fd_sc_hd__a211oi_4
X_13529_ net201 _03793_ VGND VGND VPWR VPWR _04424_ sky130_fd_sc_hd__nand2_1
X_17297_ net461 prev_error\[7\] VGND VGND VPWR VPWR _08544_ sky130_fd_sc_hd__or2_1
XFILLER_0_3_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16248_ net100 _07411_ _07407_ _07410_ VGND VGND VPWR VPWR _07415_ sky130_fd_sc_hd__o211a_1
XFILLER_0_88_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16179_ _07231_ _07232_ _07225_ VGND VGND VPWR VPWR _07339_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09622_ net364 _05011_ _00431_ VGND VGND VPWR VPWR _00433_ sky130_fd_sc_hd__and3_1
X_09553_ net330 _07937_ _08682_ net327 VGND VGND VPWR VPWR _00364_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_144_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09484_ _00294_ _00234_ VGND VGND VPWR VPWR _00295_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10190_ _00987_ _01000_ _00985_ VGND VGND VPWR VPWR _01001_ sky130_fd_sc_hd__o21a_1
XFILLER_0_100_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout330 net331 VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__buf_2
Xfanout341 kp\[9\] VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__clkbuf_4
Xfanout352 kp\[6\] VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_17_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout363 kp\[4\] VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__buf_2
Xfanout374 kp\[1\] VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__clkbuf_2
Xfanout385 prev_d_error\[15\] VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__buf_2
Xfanout396 prev_d_error\[13\] VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__clkbuf_4
X_12900_ net185 _03270_ _03742_ _03743_ VGND VGND VPWR VPWR _03744_ sky130_fd_sc_hd__a31o_1
X_13880_ _04768_ _04805_ _04809_ VGND VGND VPWR VPWR _04810_ sky130_fd_sc_hd__and3_1
XFILLER_0_88_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12831_ _03660_ _03673_ _03674_ VGND VGND VPWR VPWR _03675_ sky130_fd_sc_hd__o21a_1
X_15550_ _06477_ _06479_ VGND VGND VPWR VPWR _06647_ sky130_fd_sc_hd__xor2_2
X_12762_ _03601_ _03605_ VGND VGND VPWR VPWR _03606_ sky130_fd_sc_hd__and2_1
X_14501_ _06793_ _05492_ VGND VGND VPWR VPWR _05493_ sky130_fd_sc_hd__xnor2_2
X_11713_ net405 net410 net156 net160 VGND VGND VPWR VPWR _02524_ sky130_fd_sc_hd__and4_1
X_15481_ net304 _05710_ _05701_ net308 VGND VGND VPWR VPWR _06571_ sky130_fd_sc_hd__a22o_1
X_12693_ _03237_ _03531_ VGND VGND VPWR VPWR _03532_ sky130_fd_sc_hd__nor2_1
X_14432_ _05305_ _05416_ VGND VGND VPWR VPWR _05417_ sky130_fd_sc_hd__xor2_4
X_17220_ _08483_ _08101_ VGND VGND VPWR VPWR _08484_ sky130_fd_sc_hd__xor2_1
X_11644_ _02325_ _02336_ _02335_ VGND VGND VPWR VPWR _02455_ sky130_fd_sc_hd__a21o_1
XFILLER_0_83_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17151_ _08282_ _08407_ VGND VGND VPWR VPWR _08408_ sky130_fd_sc_hd__xnor2_1
X_14363_ _01486_ _01700_ _01480_ VGND VGND VPWR VPWR _05342_ sky130_fd_sc_hd__o21ba_1
Xinput16 measurement[6] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__buf_1
XFILLER_0_80_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11575_ _02383_ _02385_ VGND VGND VPWR VPWR _02386_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_135_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput27 reg_addr[16] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_1
X_16102_ _07205_ _07252_ _07253_ VGND VGND VPWR VPWR _07254_ sky130_fd_sc_hd__o21a_1
Xinput38 reg_data[0] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__buf_2
X_13314_ _04059_ _04187_ VGND VGND VPWR VPWR _04188_ sky130_fd_sc_hd__xor2_1
Xinput49 reg_data[3] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__buf_2
X_10526_ _01300_ _01329_ _01335_ VGND VGND VPWR VPWR _01337_ sky130_fd_sc_hd__or3b_1
X_17082_ _05320_ _08331_ VGND VGND VPWR VPWR _08332_ sky130_fd_sc_hd__xnor2_1
X_14294_ _04731_ _05172_ VGND VGND VPWR VPWR _05266_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_52_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16033_ _07175_ _07176_ _07177_ VGND VGND VPWR VPWR _07179_ sky130_fd_sc_hd__nand3_1
X_13245_ _03998_ _04105_ _04110_ _04111_ VGND VGND VPWR VPWR _04112_ sky130_fd_sc_hd__a2bb2o_1
X_10457_ _01216_ _01263_ _01267_ VGND VGND VPWR VPWR _01268_ sky130_fd_sc_hd__and3_1
XFILLER_0_122_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13176_ _04034_ _04035_ VGND VGND VPWR VPWR _04036_ sky130_fd_sc_hd__or2b_1
XFILLER_0_20_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10388_ _01147_ _01185_ _01196_ VGND VGND VPWR VPWR _01199_ sky130_fd_sc_hd__a21o_1
X_12127_ _02947_ _02951_ VGND VGND VPWR VPWR _02952_ sky130_fd_sc_hd__and2_1
X_16935_ _08165_ _08170_ VGND VGND VPWR VPWR _08171_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_74_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12058_ net446 net145 net158 net428 VGND VGND VPWR VPWR _02878_ sky130_fd_sc_hd__a22oi_2
X_11009_ _01790_ _01800_ VGND VGND VPWR VPWR _01820_ sky130_fd_sc_hd__or2_1
X_16866_ _08001_ _08032_ VGND VGND VPWR VPWR _08095_ sky130_fd_sc_hd__or2_1
XFILLER_0_74_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15817_ _06813_ _06939_ _06940_ VGND VGND VPWR VPWR _06941_ sky130_fd_sc_hd__nand3_2
XFILLER_0_59_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16797_ _05421_ _05467_ _07975_ VGND VGND VPWR VPWR _08019_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_90_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15748_ _06841_ _06864_ VGND VGND VPWR VPWR _06865_ sky130_fd_sc_hd__or2b_4
XFILLER_0_90_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15679_ _06754_ _06777_ VGND VGND VPWR VPWR _06789_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17418_ clknet_4_3_0_clock _00096_ VGND VGND VPWR VPWR prev_error\[6\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_99_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17349_ _08564_ _08054_ _08576_ net455 VGND VGND VPWR VPWR _00121_ sky130_fd_sc_hd__o211a_1
XFILLER_0_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08984_ net333 _05022_ VGND VGND VPWR VPWR _05869_ sky130_fd_sc_hd__nand2_1
X_09605_ _00414_ _00415_ VGND VGND VPWR VPWR _00416_ sky130_fd_sc_hd__nor2_1
X_09536_ _00339_ _00341_ _00343_ VGND VGND VPWR VPWR _00347_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_93_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09467_ net349 _04758_ VGND VGND VPWR VPWR _00278_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09398_ _00156_ _00159_ VGND VGND VPWR VPWR _00209_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_65_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_884 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_129_Right_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11360_ _02166_ _02170_ VGND VGND VPWR VPWR _02171_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10311_ _01120_ _01121_ VGND VGND VPWR VPWR _01122_ sky130_fd_sc_hd__nor2_2
XFILLER_0_104_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11291_ _02095_ _02101_ VGND VGND VPWR VPWR _02102_ sky130_fd_sc_hd__and2_1
X_13030_ _03873_ _03874_ VGND VGND VPWR VPWR _03875_ sky130_fd_sc_hd__nand2_1
X_10242_ _01048_ _01052_ VGND VGND VPWR VPWR _01053_ sky130_fd_sc_hd__and2b_1
X_10173_ _00923_ _00983_ VGND VGND VPWR VPWR _00984_ sky130_fd_sc_hd__or2_1
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14981_ _06007_ _06010_ _06011_ VGND VGND VPWR VPWR _06021_ sky130_fd_sc_hd__or3_1
Xfanout160 net161 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__buf_4
Xfanout171 net172 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__buf_2
X_16720_ _07930_ _07933_ VGND VGND VPWR VPWR _07934_ sky130_fd_sc_hd__xnor2_1
Xfanout182 net183 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__clkbuf_2
X_13932_ _04828_ _04827_ VGND VGND VPWR VPWR _04867_ sky130_fd_sc_hd__and2b_1
Xfanout193 net194 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__buf_2
XFILLER_0_135_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16651_ _07730_ _07733_ _07736_ _07738_ _07857_ VGND VGND VPWR VPWR _07858_ sky130_fd_sc_hd__a221o_1
XFILLER_0_88_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13863_ _04790_ VGND VGND VPWR VPWR _04792_ sky130_fd_sc_hd__inv_2
XFILLER_0_88_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15602_ _06691_ _06703_ VGND VGND VPWR VPWR _06704_ sky130_fd_sc_hd__xnor2_1
X_12814_ _03654_ _03657_ VGND VGND VPWR VPWR _03658_ sky130_fd_sc_hd__nor2_1
X_16582_ _07621_ _07631_ VGND VGND VPWR VPWR _07782_ sky130_fd_sc_hd__xor2_1
X_13794_ _04629_ _04632_ _04631_ VGND VGND VPWR VPWR _04716_ sky130_fd_sc_hd__a21o_1
XFILLER_0_96_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12745_ _03567_ _03588_ VGND VGND VPWR VPWR _03589_ sky130_fd_sc_hd__or2b_1
X_15533_ _06605_ _06608_ VGND VGND VPWR VPWR _06629_ sky130_fd_sc_hd__nor2_1
XFILLER_0_139_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15464_ _06549_ _06550_ _06552_ VGND VGND VPWR VPWR _06553_ sky130_fd_sc_hd__o21ai_2
X_12676_ _03427_ _03459_ _03514_ VGND VGND VPWR VPWR _03515_ sky130_fd_sc_hd__o21a_1
X_14415_ _03427_ _03512_ _05397_ VGND VGND VPWR VPWR _05399_ sky130_fd_sc_hd__nor3_1
XFILLER_0_37_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17203_ _08463_ _08464_ VGND VGND VPWR VPWR _08466_ sky130_fd_sc_hd__xnor2_1
X_11627_ _02374_ _02377_ VGND VGND VPWR VPWR _02438_ sky130_fd_sc_hd__xnor2_2
X_15395_ _06371_ _06475_ _06476_ VGND VGND VPWR VPWR _06477_ sky130_fd_sc_hd__a21o_1
XFILLER_0_71_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14346_ _01695_ _01698_ _05322_ VGND VGND VPWR VPWR _05323_ sky130_fd_sc_hd__a21o_1
X_17134_ _08387_ _08389_ VGND VGND VPWR VPWR _08390_ sky130_fd_sc_hd__xnor2_1
X_11558_ _02285_ _02286_ VGND VGND VPWR VPWR _02369_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10509_ _01316_ _01318_ _01283_ _01319_ VGND VGND VPWR VPWR _01320_ sky130_fd_sc_hd__o211a_1
X_17065_ _05310_ _05316_ VGND VGND VPWR VPWR _08314_ sky130_fd_sc_hd__nand2_1
X_14277_ _05245_ _05246_ VGND VGND VPWR VPWR _05247_ sky130_fd_sc_hd__xnor2_4
X_11489_ _02275_ _02298_ _02299_ VGND VGND VPWR VPWR _02300_ sky130_fd_sc_hd__o21a_1
X_16016_ _07143_ _07158_ _07159_ _07086_ VGND VGND VPWR VPWR _07160_ sky130_fd_sc_hd__o211a_1
X_13228_ _04020_ _04058_ _04056_ VGND VGND VPWR VPWR _04093_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13159_ _04013_ _04015_ VGND VGND VPWR VPWR _04017_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16918_ _08144_ _08151_ VGND VGND VPWR VPWR _08152_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_69_Left_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16849_ _08074_ _08073_ _08075_ VGND VGND VPWR VPWR _08076_ sky130_fd_sc_hd__or3_4
XFILLER_0_149_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09321_ _08678_ _08683_ _08684_ VGND VGND VPWR VPWR _08685_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_88_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09252_ net332 _04439_ _08615_ VGND VGND VPWR VPWR _08616_ sky130_fd_sc_hd__and3_1
XFILLER_0_146_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09183_ _05726_ _05484_ _05451_ VGND VGND VPWR VPWR _08058_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_44_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08967_ net329 net325 _05022_ _05660_ VGND VGND VPWR VPWR _05682_ sky130_fd_sc_hd__and4_1
X_08898_ _04912_ VGND VGND VPWR VPWR _04923_ sky130_fd_sc_hd__buf_4
XFILLER_0_98_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10860_ _01669_ VGND VGND VPWR VPWR _01671_ sky130_fd_sc_hd__inv_2
X_09519_ _00324_ _00325_ VGND VGND VPWR VPWR _00330_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10791_ _01567_ _01569_ _01600_ VGND VGND VPWR VPWR _01602_ sky130_fd_sc_hd__or3_1
XFILLER_0_38_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12530_ _03367_ _03368_ VGND VGND VPWR VPWR _03369_ sky130_fd_sc_hd__or2_2
XFILLER_0_109_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12461_ _03292_ _03293_ VGND VGND VPWR VPWR _03294_ sky130_fd_sc_hd__xor2_1
XFILLER_0_30_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14200_ _04861_ _04914_ VGND VGND VPWR VPWR _05162_ sky130_fd_sc_hd__nor2_1
XFILLER_0_35_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11412_ net435 net124 net119 net439 VGND VGND VPWR VPWR _02223_ sky130_fd_sc_hd__a22o_1
X_15180_ net255 _05666_ _06153_ VGND VGND VPWR VPWR _06240_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_62_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12392_ net195 net190 _03217_ _03223_ VGND VGND VPWR VPWR _03224_ sky130_fd_sc_hd__and4_1
XFILLER_0_50_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14131_ _05026_ _05059_ _05058_ VGND VGND VPWR VPWR _05086_ sky130_fd_sc_hd__o21a_1
XFILLER_0_1_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11343_ _02151_ _02152_ _02153_ VGND VGND VPWR VPWR _02154_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_132_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14062_ _05002_ _05004_ VGND VGND VPWR VPWR _05010_ sky130_fd_sc_hd__nand2_1
X_11274_ _02083_ _02084_ VGND VGND VPWR VPWR _02085_ sky130_fd_sc_hd__nand2_1
X_13013_ _03696_ _03698_ VGND VGND VPWR VPWR _03857_ sky130_fd_sc_hd__and2_1
X_10225_ _01034_ _01005_ VGND VGND VPWR VPWR _01036_ sky130_fd_sc_hd__and2b_1
X_10156_ _00930_ _00964_ _00963_ VGND VGND VPWR VPWR _00967_ sky130_fd_sc_hd__and3_1
XFILLER_0_146_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14964_ _05918_ _06002_ VGND VGND VPWR VPWR _06003_ sky130_fd_sc_hd__nor2_1
X_10087_ net345 _08682_ VGND VGND VPWR VPWR _00898_ sky130_fd_sc_hd__nand2_1
X_16703_ _07768_ _07769_ VGND VGND VPWR VPWR _07916_ sky130_fd_sc_hd__nor2_1
X_13915_ _04781_ _04836_ _04821_ _04834_ VGND VGND VPWR VPWR _04849_ sky130_fd_sc_hd__a211o_1
X_14895_ _05696_ _05926_ VGND VGND VPWR VPWR _05927_ sky130_fd_sc_hd__xor2_1
X_16634_ _07839_ VGND VGND VPWR VPWR _07840_ sky130_fd_sc_hd__inv_2
X_13846_ _04735_ _04772_ VGND VGND VPWR VPWR _04773_ sky130_fd_sc_hd__xnor2_1
X_16565_ _07762_ _07763_ VGND VGND VPWR VPWR _07764_ sky130_fd_sc_hd__xnor2_2
X_13777_ net242 _03233_ VGND VGND VPWR VPWR _04697_ sky130_fd_sc_hd__nand2_1
X_10989_ _01524_ _01799_ _01466_ VGND VGND VPWR VPWR _01800_ sky130_fd_sc_hd__o21ai_1
X_15516_ _06608_ _06609_ VGND VGND VPWR VPWR _06610_ sky130_fd_sc_hd__nor2_1
X_12728_ net185 _03250_ _03568_ _03569_ VGND VGND VPWR VPWR _03570_ sky130_fd_sc_hd__a31o_1
X_16496_ _05705_ _07687_ VGND VGND VPWR VPWR _07688_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15447_ _06510_ _06525_ _06533_ VGND VGND VPWR VPWR _06534_ sky130_fd_sc_hd__nand3_1
XFILLER_0_72_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12659_ _03497_ net199 _03437_ VGND VGND VPWR VPWR _03498_ sky130_fd_sc_hd__mux2_1
XFILLER_0_5_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15378_ _06454_ _06457_ VGND VGND VPWR VPWR _06458_ sky130_fd_sc_hd__and2b_1
XFILLER_0_53_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17117_ _08037_ _08046_ _08059_ VGND VGND VPWR VPWR _08371_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_13_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14329_ _03176_ _05197_ VGND VGND VPWR VPWR _05304_ sky130_fd_sc_hd__and2_1
XFILLER_0_20_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17048_ _08279_ _08294_ VGND VGND VPWR VPWR _08295_ sky130_fd_sc_hd__xor2_1
XFILLER_0_110_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09870_ _00679_ _00680_ VGND VGND VPWR VPWR _00681_ sky130_fd_sc_hd__and2_1
X_08821_ net57 net2 VGND VGND VPWR VPWR _04076_ sky130_fd_sc_hd__nand2b_4
X_08752_ net38 _03318_ _03351_ net310 VGND VGND VPWR VPWR _00036_ sky130_fd_sc_hd__a22o_1
XFILLER_0_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09304_ _08638_ _08637_ VGND VGND VPWR VPWR _08668_ sky130_fd_sc_hd__and2b_1
XFILLER_0_76_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09235_ _05660_ _05451_ _08560_ _08573_ VGND VGND VPWR VPWR _08579_ sky130_fd_sc_hd__o2bb2ai_1
XFILLER_0_90_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09166_ _07805_ _07838_ _07860_ VGND VGND VPWR VPWR _07871_ sky130_fd_sc_hd__o21a_1
XFILLER_0_32_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09097_ _06386_ _07101_ VGND VGND VPWR VPWR _07112_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10010_ _00819_ _00820_ VGND VGND VPWR VPWR _00821_ sky130_fd_sc_hd__nor2_1
X_09999_ _00789_ _00803_ VGND VGND VPWR VPWR _00810_ sky130_fd_sc_hd__or2_1
X_11961_ _02769_ _02770_ _02771_ VGND VGND VPWR VPWR _02772_ sky130_fd_sc_hd__nand3_2
XFILLER_0_25_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13700_ _04537_ _04539_ _04546_ VGND VGND VPWR VPWR _04612_ sky130_fd_sc_hd__nand3_1
X_10912_ _01470_ _01525_ VGND VGND VPWR VPWR _01723_ sky130_fd_sc_hd__xor2_1
X_14680_ _03316_ _05686_ _05687_ VGND VGND VPWR VPWR _05690_ sky130_fd_sc_hd__o21a_1
XFILLER_0_58_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11892_ _02626_ _02700_ _02696_ _02699_ VGND VGND VPWR VPWR _02703_ sky130_fd_sc_hd__a211oi_1
X_13631_ _04465_ _04466_ _04408_ _04467_ VGND VGND VPWR VPWR _04536_ sky130_fd_sc_hd__o22ai_2
X_10843_ _01633_ _01652_ VGND VGND VPWR VPWR _01654_ sky130_fd_sc_hd__or2_1
XFILLER_0_39_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16350_ _07525_ _05827_ _05830_ VGND VGND VPWR VPWR _07527_ sky130_fd_sc_hd__and3_1
XFILLER_0_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13562_ _04372_ _04374_ _03282_ net241 VGND VGND VPWR VPWR _04460_ sky130_fd_sc_hd__a2bb2o_1
X_10774_ net386 net138 net145 net382 VGND VGND VPWR VPWR _01585_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_67_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15301_ _06258_ _06371_ _06372_ VGND VGND VPWR VPWR _06373_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_125_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12513_ net198 _03342_ _03350_ VGND VGND VPWR VPWR _03352_ sky130_fd_sc_hd__and3_1
X_16281_ _07449_ _07450_ VGND VGND VPWR VPWR _07451_ sky130_fd_sc_hd__nand2_1
X_13493_ _04368_ _04382_ _04383_ VGND VGND VPWR VPWR _04385_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_19_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12444_ _03259_ _03275_ VGND VGND VPWR VPWR _03276_ sky130_fd_sc_hd__or2b_1
X_15232_ _06292_ _06295_ _06189_ _06296_ VGND VGND VPWR VPWR _06297_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_35_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15163_ _05688_ _05710_ VGND VGND VPWR VPWR _06222_ sky130_fd_sc_hd__and2_1
XFILLER_0_140_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12375_ _03187_ net523 VGND VGND VPWR VPWR _03207_ sky130_fd_sc_hd__and2_1
XFILLER_0_105_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14114_ _05065_ _05067_ VGND VGND VPWR VPWR _05068_ sky130_fd_sc_hd__nor2_1
X_11326_ _01561_ net171 _02135_ _02136_ VGND VGND VPWR VPWR _02137_ sky130_fd_sc_hd__nor4_1
XFILLER_0_120_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15094_ _06140_ _06145_ VGND VGND VPWR VPWR _06146_ sky130_fd_sc_hd__xor2_2
XFILLER_0_22_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14045_ net225 _04002_ VGND VGND VPWR VPWR _04992_ sky130_fd_sc_hd__nand2_1
X_11257_ _02054_ _02057_ _02067_ VGND VGND VPWR VPWR _02068_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_120_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10208_ _00942_ _00943_ VGND VGND VPWR VPWR _01019_ sky130_fd_sc_hd__xnor2_1
X_11188_ _01900_ _01998_ VGND VGND VPWR VPWR _01999_ sky130_fd_sc_hd__nor2_1
X_10139_ _00946_ _00948_ _00949_ VGND VGND VPWR VPWR _00950_ sky130_fd_sc_hd__nand3_2
X_15996_ _06819_ _07137_ VGND VGND VPWR VPWR _07138_ sky130_fd_sc_hd__xnor2_1
X_14947_ _05669_ _05661_ VGND VGND VPWR VPWR _05984_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14878_ _05904_ _05903_ VGND VGND VPWR VPWR _05908_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_106_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16617_ i_error\[10\] _07581_ VGND VGND VPWR VPWR _07821_ sky130_fd_sc_hd__nand2_1
XFILLER_0_147_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13829_ net202 _04107_ _04003_ net206 VGND VGND VPWR VPWR _04754_ sky130_fd_sc_hd__a22o_1
XFILLER_0_9_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16548_ _07726_ _07744_ VGND VGND VPWR VPWR _07745_ sky130_fd_sc_hd__or2_1
XFILLER_0_85_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16479_ _07665_ _07668_ VGND VGND VPWR VPWR _07669_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_122_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09020_ _06254_ _05396_ VGND VGND VPWR VPWR _06265_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09922_ net370 net365 _04494_ _04417_ VGND VGND VPWR VPWR _00733_ sky130_fd_sc_hd__and4_1
XFILLER_0_0_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09853_ net356 _04516_ _00661_ _00663_ VGND VGND VPWR VPWR _00664_ sky130_fd_sc_hd__a31o_1
X_08804_ _03878_ net76 VGND VGND VPWR VPWR _03889_ sky130_fd_sc_hd__and2_1
X_09784_ _00584_ _00589_ VGND VGND VPWR VPWR _00595_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08735_ net54 _03061_ _03094_ net212 VGND VGND VPWR VPWR _00016_ sky130_fd_sc_hd__a22o_1
XFILLER_0_96_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09218_ _06397_ _07277_ VGND VGND VPWR VPWR _08443_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_134_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10490_ net371 net366 _00315_ _00371_ _01300_ VGND VGND VPWR VPWR _01301_ sky130_fd_sc_hd__a41o_1
XFILLER_0_32_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09149_ _07662_ _07673_ VGND VGND VPWR VPWR _07684_ sky130_fd_sc_hd__or2_1
XFILLER_0_20_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_15_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12160_ _02980_ _02982_ _02984_ VGND VGND VPWR VPWR _02985_ sky130_fd_sc_hd__o21a_1
X_11111_ _01913_ _01921_ _01919_ VGND VGND VPWR VPWR _01922_ sky130_fd_sc_hd__a21o_1
X_12091_ _02900_ _02876_ _02885_ VGND VGND VPWR VPWR _02914_ sky130_fd_sc_hd__nand3_1
XFILLER_0_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11042_ _01825_ _01851_ _01780_ _01852_ VGND VGND VPWR VPWR _01853_ sky130_fd_sc_hd__o211ai_2
X_15850_ _06968_ _06967_ _06932_ VGND VGND VPWR VPWR _06977_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14801_ net524 _05622_ _05821_ _05822_ VGND VGND VPWR VPWR _05823_ sky130_fd_sc_hd__nor4_1
X_15781_ _06830_ _06829_ VGND VGND VPWR VPWR _06901_ sky130_fd_sc_hd__and2b_1
XFILLER_0_99_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12993_ _03819_ _03835_ _03836_ VGND VGND VPWR VPWR _03837_ sky130_fd_sc_hd__o21a_1
X_17520_ clknet_4_7_0_clock _00018_ VGND VGND VPWR VPWR kd_2\[0\] sky130_fd_sc_hd__dfxtp_1
XPHY_EDGE_ROW_24_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14732_ net255 _05746_ VGND VGND VPWR VPWR _05747_ sky130_fd_sc_hd__nand2_1
X_11944_ _02702_ _02678_ _02704_ VGND VGND VPWR VPWR _02755_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_143_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17451_ clknet_4_14_0_clock _00129_ VGND VGND VPWR VPWR prev_d_error\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_98_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14663_ _05658_ _05659_ _05670_ VGND VGND VPWR VPWR _05672_ sky130_fd_sc_hd__a21oi_1
X_11875_ _02611_ _02685_ VGND VGND VPWR VPWR _02686_ sky130_fd_sc_hd__nor2_1
XFILLER_0_39_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16402_ i_error\[10\] _07581_ VGND VGND VPWR VPWR _07584_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_95_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13614_ _04510_ _04515_ VGND VGND VPWR VPWR _04518_ sky130_fd_sc_hd__or2b_1
X_10826_ net393 net397 net112 net108 VGND VGND VPWR VPWR _01637_ sky130_fd_sc_hd__and4_1
X_17382_ net465 _08231_ VGND VGND VPWR VPWR _08596_ sky130_fd_sc_hd__nand2_1
X_14594_ _05595_ VGND VGND VPWR VPWR _05596_ sky130_fd_sc_hd__buf_1
X_16333_ _05783_ _07507_ _05835_ VGND VGND VPWR VPWR _07509_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13545_ _04440_ _04441_ VGND VGND VPWR VPWR _04442_ sky130_fd_sc_hd__and2_1
X_10757_ net382 net134 net129 net386 VGND VGND VPWR VPWR _01568_ sky130_fd_sc_hd__a22o_1
XFILLER_0_137_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16264_ _07430_ _07432_ VGND VGND VPWR VPWR _07433_ sky130_fd_sc_hd__and2_1
X_13476_ _04232_ _04365_ VGND VGND VPWR VPWR _04366_ sky130_fd_sc_hd__xor2_2
XFILLER_0_42_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10688_ net393 net121 net116 net397 VGND VGND VPWR VPWR _01499_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_35_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12427_ _03257_ _03258_ VGND VGND VPWR VPWR _03259_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_33_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15215_ _06278_ _06123_ VGND VGND VPWR VPWR _06279_ sky130_fd_sc_hd__xor2_4
XFILLER_0_113_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16195_ _07313_ _07356_ VGND VGND VPWR VPWR _07357_ sky130_fd_sc_hd__nor2_1
X_15146_ _06159_ _06202_ VGND VGND VPWR VPWR _06203_ sky130_fd_sc_hd__or2_1
X_12358_ prev_error\[6\] VGND VGND VPWR VPWR _03190_ sky130_fd_sc_hd__inv_2
XFILLER_0_50_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11309_ _02088_ _02117_ _02119_ VGND VGND VPWR VPWR _02120_ sky130_fd_sc_hd__o21a_1
X_15077_ _06125_ _06126_ VGND VGND VPWR VPWR _06127_ sky130_fd_sc_hd__and2_1
X_12289_ _03104_ _03120_ VGND VGND VPWR VPWR _03121_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14028_ _04963_ _04971_ _04972_ VGND VGND VPWR VPWR _04973_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_42_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15979_ _07110_ _07109_ VGND VGND VPWR VPWR _07119_ sky130_fd_sc_hd__or2b_1
XFILLER_0_89_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09003_ _06045_ _06067_ VGND VGND VPWR VPWR _06078_ sky130_fd_sc_hd__xor2_1
XFILLER_0_5_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09905_ _00714_ _00715_ VGND VGND VPWR VPWR _00716_ sky130_fd_sc_hd__xnor2_2
X_09836_ _00559_ _00561_ VGND VGND VPWR VPWR _00647_ sky130_fd_sc_hd__xnor2_1
X_09767_ _00572_ _00576_ _00577_ VGND VGND VPWR VPWR _00578_ sky130_fd_sc_hd__o21ba_1
X_08718_ net45 _02894_ _02927_ net109 VGND VGND VPWR VPWR _00025_ sky130_fd_sc_hd__a22o_1
X_09698_ _00374_ _00376_ VGND VGND VPWR VPWR _00509_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11660_ _02468_ _02469_ _02470_ VGND VGND VPWR VPWR _02471_ sky130_fd_sc_hd__nand3_1
X_10611_ _01108_ _01163_ _01421_ VGND VGND VPWR VPWR _01422_ sky130_fd_sc_hd__and3_4
XFILLER_0_138_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11591_ net430 net448 net131 net115 VGND VGND VPWR VPWR _02402_ sky130_fd_sc_hd__and4_1
XFILLER_0_9_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13330_ net217 _03248_ VGND VGND VPWR VPWR _04205_ sky130_fd_sc_hd__nand2_2
X_10542_ _01351_ _01352_ VGND VGND VPWR VPWR _01353_ sky130_fd_sc_hd__nor2_1
XFILLER_0_107_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13261_ _04033_ _04127_ VGND VGND VPWR VPWR _04129_ sky130_fd_sc_hd__xor2_1
X_10473_ _01279_ _01283_ VGND VGND VPWR VPWR _01284_ sky130_fd_sc_hd__nand2b_1
X_15000_ _06031_ _06039_ _06040_ VGND VGND VPWR VPWR _06042_ sky130_fd_sc_hd__or3_1
X_12212_ _03004_ _03035_ VGND VGND VPWR VPWR _03038_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13192_ _04050_ _04052_ VGND VGND VPWR VPWR _04053_ sky130_fd_sc_hd__and2b_1
X_12143_ _02963_ _02967_ VGND VGND VPWR VPWR _02968_ sky130_fd_sc_hd__or2b_1
XFILLER_0_102_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16951_ _08185_ _08187_ VGND VGND VPWR VPWR _08188_ sky130_fd_sc_hd__or2_1
X_12074_ _02893_ _02870_ _02873_ VGND VGND VPWR VPWR _02896_ sky130_fd_sc_hd__or3_1
X_15902_ _07010_ _07032_ _06959_ _07033_ VGND VGND VPWR VPWR _07034_ sky130_fd_sc_hd__o211a_4
X_11025_ _01826_ _01828_ _01830_ VGND VGND VPWR VPWR _01836_ sky130_fd_sc_hd__or3_1
X_16882_ _07767_ net504 _08041_ VGND VGND VPWR VPWR _08112_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15833_ _06956_ _06955_ _06957_ VGND VGND VPWR VPWR _06959_ sky130_fd_sc_hd__or3_4
X_15764_ _06880_ _06882_ VGND VGND VPWR VPWR _06883_ sky130_fd_sc_hd__xnor2_1
X_12976_ _03725_ _03724_ VGND VGND VPWR VPWR _03820_ sky130_fd_sc_hd__or2_1
XFILLER_0_59_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17503_ clknet_4_1_0_clock _00009_ VGND VGND VPWR VPWR kd_1\[1\] sky130_fd_sc_hd__dfxtp_1
X_14715_ net269 _05711_ _05703_ net273 VGND VGND VPWR VPWR _05729_ sky130_fd_sc_hd__a22o_1
X_11927_ _02671_ _02675_ VGND VGND VPWR VPWR _02738_ sky130_fd_sc_hd__nor2_1
X_15695_ _06405_ _06505_ _06806_ VGND VGND VPWR VPWR _06807_ sky130_fd_sc_hd__a21o_1
XFILLER_0_129_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17434_ clknet_4_9_0_clock _00112_ VGND VGND VPWR VPWR i_error\[4\] sky130_fd_sc_hd__dfxtp_1
X_14646_ _05592_ _05609_ _05651_ VGND VGND VPWR VPWR _05653_ sky130_fd_sc_hd__or3_1
X_11858_ _02664_ _02668_ VGND VGND VPWR VPWR _02669_ sky130_fd_sc_hd__and2_1
XFILLER_0_27_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_19 net312 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_17365_ net466 net434 net456 _08586_ VGND VGND VPWR VPWR _00129_ sky130_fd_sc_hd__o211a_1
XFILLER_0_83_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10809_ _01618_ VGND VGND VPWR VPWR _01620_ sky130_fd_sc_hd__inv_2
XFILLER_0_6_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14577_ prev_error\[8\] _07387_ VGND VGND VPWR VPWR _05577_ sky130_fd_sc_hd__nand2_1
X_11789_ _02577_ _02584_ _02586_ VGND VGND VPWR VPWR _02600_ sky130_fd_sc_hd__nand3_2
XFILLER_0_27_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16316_ _07050_ _07125_ VGND VGND VPWR VPWR _07490_ sky130_fd_sc_hd__and2b_1
X_13528_ net208 _03668_ _03751_ net205 VGND VGND VPWR VPWR _04423_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_15_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17296_ _08536_ _08682_ _08543_ net450 VGND VGND VPWR VPWR _00096_ sky130_fd_sc_hd__o211a_1
XFILLER_0_82_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16247_ _07344_ _07377_ VGND VGND VPWR VPWR _07414_ sky130_fd_sc_hd__xnor2_1
X_13459_ _04345_ _04346_ VGND VGND VPWR VPWR _04347_ sky130_fd_sc_hd__nor2_1
XFILLER_0_23_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16178_ _07261_ _07289_ _07287_ VGND VGND VPWR VPWR _07338_ sky130_fd_sc_hd__o21bai_1
X_15129_ _06082_ _06081_ _06062_ VGND VGND VPWR VPWR _06184_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_50_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09621_ _00430_ _00431_ VGND VGND VPWR VPWR _00432_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_128_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09552_ net327 _07937_ _00362_ VGND VGND VPWR VPWR _00363_ sky130_fd_sc_hd__and3_1
X_09483_ net323 _07948_ VGND VGND VPWR VPWR _00294_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout320 kp\[15\] VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__buf_2
Xfanout331 kp\[12\] VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__buf_4
Xfanout342 net343 VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__buf_2
Xfanout353 kp\[6\] VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__clkbuf_2
Xfanout364 net368 VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__clkbuf_4
Xfanout375 net376 VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__clkbuf_4
Xfanout386 prev_d_error\[15\] VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__dlymetal6s2s_1
X_09819_ _00608_ _00628_ _00629_ VGND VGND VPWR VPWR _00630_ sky130_fd_sc_hd__a21boi_1
Xfanout397 net399 VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__buf_2
X_12830_ _03584_ _03585_ VGND VGND VPWR VPWR _03674_ sky130_fd_sc_hd__xnor2_1
X_12761_ _03592_ _03602_ _03604_ VGND VGND VPWR VPWR _03605_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_33_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14500_ _05490_ _05491_ VGND VGND VPWR VPWR _05492_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11712_ net411 net156 net160 net405 VGND VGND VPWR VPWR _02523_ sky130_fd_sc_hd__a22oi_2
X_12692_ net185 _03234_ _03236_ VGND VGND VPWR VPWR _03531_ sky130_fd_sc_hd__a21oi_1
X_15480_ net293 _05630_ VGND VGND VPWR VPWR _06570_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14431_ _05414_ _05415_ VGND VGND VPWR VPWR _05416_ sky130_fd_sc_hd__nand2_2
XFILLER_0_65_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11643_ _02361_ _02362_ _02363_ _02340_ VGND VGND VPWR VPWR _02454_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_127_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17150_ _08405_ _08406_ VGND VGND VPWR VPWR _08407_ sky130_fd_sc_hd__xnor2_1
X_11574_ _02289_ _02384_ VGND VGND VPWR VPWR _02385_ sky130_fd_sc_hd__nand2_1
X_14362_ _05338_ _05339_ VGND VGND VPWR VPWR _05340_ sky130_fd_sc_hd__nor2_1
Xinput17 measurement[7] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_2
X_16101_ net282 _06415_ _06347_ net286 VGND VGND VPWR VPWR _07253_ sky130_fd_sc_hd__a22o_1
Xinput28 reg_addr[17] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_80_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10525_ _01300_ _01329_ _01335_ VGND VGND VPWR VPWR _01336_ sky130_fd_sc_hd__o21bai_1
Xinput39 reg_data[10] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_4
X_13313_ _04090_ _04089_ VGND VGND VPWR VPWR _04187_ sky130_fd_sc_hd__and2b_1
X_14293_ _02720_ _03146_ VGND VGND VPWR VPWR _05265_ sky130_fd_sc_hd__xnor2_2
X_17081_ _08329_ _08330_ VGND VGND VPWR VPWR _08331_ sky130_fd_sc_hd__and2b_1
XFILLER_0_134_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16032_ _07108_ _07174_ _07173_ _07160_ VGND VGND VPWR VPWR _07177_ sky130_fd_sc_hd__a211o_1
X_13244_ net183 _03936_ _04004_ net179 VGND VGND VPWR VPWR _04111_ sky130_fd_sc_hd__a22o_1
X_10456_ net375 _08674_ _01265_ _01266_ VGND VGND VPWR VPWR _01267_ sky130_fd_sc_hd__a31o_1
XFILLER_0_150_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13175_ _04024_ _04027_ VGND VGND VPWR VPWR _04035_ sky130_fd_sc_hd__xor2_2
XFILLER_0_0_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10387_ _01172_ _01177_ VGND VGND VPWR VPWR _01198_ sky130_fd_sc_hd__xor2_1
XFILLER_0_103_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12126_ _02946_ _02942_ _02944_ VGND VGND VPWR VPWR _02951_ sky130_fd_sc_hd__or3_1
XFILLER_0_20_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16934_ _08166_ _08169_ _08033_ VGND VGND VPWR VPWR _08170_ sky130_fd_sc_hd__mux2_1
X_12057_ net428 net446 net145 net158 VGND VGND VPWR VPWR _02877_ sky130_fd_sc_hd__and4_1
XFILLER_0_74_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11008_ _01816_ _01817_ _01808_ _01812_ VGND VGND VPWR VPWR _01819_ sky130_fd_sc_hd__a211oi_1
X_16865_ _07777_ _07770_ net504 _08093_ net483 VGND VGND VPWR VPWR _08094_ sky130_fd_sc_hd__a311o_1
X_15816_ _06811_ _06812_ net305 _05745_ VGND VGND VPWR VPWR _06940_ sky130_fd_sc_hd__a2bb2o_1
X_16796_ _07742_ _08013_ _08017_ _07736_ VGND VGND VPWR VPWR _08018_ sky130_fd_sc_hd__o2bb2a_1
X_15747_ _06855_ _06863_ VGND VGND VPWR VPWR _06864_ sky130_fd_sc_hd__xor2_2
X_12959_ _03787_ _03800_ _03802_ VGND VGND VPWR VPWR _03803_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_142_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15678_ _06762_ _06765_ _06786_ _06787_ VGND VGND VPWR VPWR _06788_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_75_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17417_ clknet_4_3_0_clock _00095_ VGND VGND VPWR VPWR prev_error\[5\] sky130_fd_sc_hd__dfxtp_4
XFILLER_0_74_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14629_ _05610_ _05611_ _03227_ VGND VGND VPWR VPWR _05634_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_145_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17348_ net470 i_error\[13\] VGND VGND VPWR VPWR _08576_ sky130_fd_sc_hd__or2_1
XFILLER_0_43_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17279_ _08527_ _08532_ VGND VGND VPWR VPWR _00088_ sky130_fd_sc_hd__nor2_1
XFILLER_0_130_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08983_ _05836_ _05847_ VGND VGND VPWR VPWR _05858_ sky130_fd_sc_hd__or2_1
XFILLER_0_139_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09604_ _00397_ _00412_ _00413_ VGND VGND VPWR VPWR _00415_ sky130_fd_sc_hd__and3_1
XFILLER_0_3_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09535_ _00343_ _00344_ _00345_ VGND VGND VPWR VPWR _00346_ sky130_fd_sc_hd__or3_4
X_09466_ net353 net349 _04912_ _04758_ VGND VGND VPWR VPWR _00277_ sky130_fd_sc_hd__and4_1
XFILLER_0_65_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xwire96 _05458_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_47_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09397_ _00196_ _00201_ _00207_ VGND VGND VPWR VPWR _00208_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_46_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10310_ _01116_ _01119_ VGND VGND VPWR VPWR _01121_ sky130_fd_sc_hd__nor2_1
XFILLER_0_104_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11290_ _02090_ _02092_ _02094_ VGND VGND VPWR VPWR _02101_ sky130_fd_sc_hd__or3_1
XFILLER_0_15_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10241_ net345 _00316_ _01050_ _01051_ VGND VGND VPWR VPWR _01052_ sky130_fd_sc_hd__a31o_1
X_10172_ _00920_ _00922_ VGND VGND VPWR VPWR _00983_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14980_ _05971_ _06014_ _06019_ VGND VGND VPWR VPWR _06020_ sky130_fd_sc_hd__o21ai_1
Xfanout150 net153 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__clkbuf_4
Xfanout161 kd_2\[4\] VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__buf_2
Xfanout172 kd_2\[1\] VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__clkbuf_4
Xfanout183 kd_1\[15\] VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__buf_2
X_13931_ net210 _04003_ VGND VGND VPWR VPWR _04866_ sky130_fd_sc_hd__nand2_1
Xfanout194 net195 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__buf_2
X_16650_ _07742_ _07745_ VGND VGND VPWR VPWR _07857_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13862_ _04784_ _04788_ _04720_ _04789_ VGND VGND VPWR VPWR _04790_ sky130_fd_sc_hd__o211ai_2
X_15601_ _06702_ _06700_ VGND VGND VPWR VPWR _06703_ sky130_fd_sc_hd__nor2_1
X_12813_ net185 _03261_ _03656_ VGND VGND VPWR VPWR _03657_ sky130_fd_sc_hd__and3_1
X_16581_ _07777_ _07780_ _07770_ VGND VGND VPWR VPWR _07781_ sky130_fd_sc_hd__and3_1
X_13793_ _04712_ _04713_ VGND VGND VPWR VPWR _04715_ sky130_fd_sc_hd__and2b_1
XFILLER_0_69_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15532_ _06604_ _06626_ VGND VGND VPWR VPWR _06627_ sky130_fd_sc_hd__xor2_1
XFILLER_0_56_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12744_ _03570_ _03571_ _03587_ VGND VGND VPWR VPWR _03588_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_84_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15463_ _06547_ _06548_ VGND VGND VPWR VPWR _06552_ sky130_fd_sc_hd__or2_1
X_12675_ _03512_ _03513_ VGND VGND VPWR VPWR _03514_ sky130_fd_sc_hd__nor2_1
XFILLER_0_38_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17202_ _08195_ _08226_ _08224_ VGND VGND VPWR VPWR _08464_ sky130_fd_sc_hd__a21oi_1
X_14414_ _03427_ _03512_ _05397_ VGND VGND VPWR VPWR _05398_ sky130_fd_sc_hd__o21a_1
XFILLER_0_25_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11626_ _02435_ _02436_ VGND VGND VPWR VPWR _02437_ sky130_fd_sc_hd__nor2_1
X_15394_ ki\[17\] _06473_ VGND VGND VPWR VPWR _06476_ sky130_fd_sc_hd__and2_1
XFILLER_0_108_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_7_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17133_ _08310_ _08348_ _08346_ VGND VGND VPWR VPWR _08389_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_4_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14345_ _05320_ _05321_ VGND VGND VPWR VPWR _05322_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11557_ _02367_ VGND VGND VPWR VPWR _02368_ sky130_fd_sc_hd__inv_2
XFILLER_0_108_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10508_ _01279_ _01282_ _01281_ VGND VGND VPWR VPWR _01319_ sky130_fd_sc_hd__o21ai_1
X_17064_ _05327_ _05336_ _05334_ VGND VGND VPWR VPWR _08313_ sky130_fd_sc_hd__a21bo_1
X_14276_ _05184_ _04402_ VGND VGND VPWR VPWR _05246_ sky130_fd_sc_hd__and2b_1
X_11488_ _02179_ _02211_ VGND VGND VPWR VPWR _02299_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_150_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16015_ _07073_ _07074_ _07085_ VGND VGND VPWR VPWR _07159_ sky130_fd_sc_hd__a21o_1
XFILLER_0_123_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10439_ net358 _00371_ _01248_ _01249_ VGND VGND VPWR VPWR _01250_ sky130_fd_sc_hd__and4_1
X_13227_ _03995_ _04091_ VGND VGND VPWR VPWR _04092_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_21_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13158_ _04013_ _04015_ VGND VGND VPWR VPWR _04016_ sky130_fd_sc_hd__nand2_1
X_12109_ _02933_ _02911_ VGND VGND VPWR VPWR _02934_ sky130_fd_sc_hd__or2_1
X_13089_ _03937_ _03938_ _03939_ VGND VGND VPWR VPWR _03940_ sky130_fd_sc_hd__a21bo_1
X_16917_ _05457_ _08149_ _08150_ VGND VGND VPWR VPWR _08151_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_109_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16848_ net502 _08072_ _08068_ VGND VGND VPWR VPWR _08075_ sky130_fd_sc_hd__a21oi_1
X_16779_ _07995_ _07996_ _07998_ _07784_ VGND VGND VPWR VPWR _07999_ sky130_fd_sc_hd__o22a_1
X_09320_ net318 net314 _07948_ _08682_ VGND VGND VPWR VPWR _08684_ sky130_fd_sc_hd__nand4_1
XFILLER_0_125_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09251_ net340 _04769_ _08146_ _08614_ VGND VGND VPWR VPWR _08615_ sky130_fd_sc_hd__a31oi_1
XFILLER_0_75_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09182_ _07783_ _08036_ VGND VGND VPWR VPWR _08047_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08966_ net325 _05033_ _05660_ net329 VGND VGND VPWR VPWR _05671_ sky130_fd_sc_hd__a22oi_1
X_08897_ _04901_ VGND VGND VPWR VPWR _04912_ sky130_fd_sc_hd__buf_6
XFILLER_0_98_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09518_ _00261_ _00328_ VGND VGND VPWR VPWR _00329_ sky130_fd_sc_hd__and2_1
X_10790_ _01567_ _01569_ _01600_ VGND VGND VPWR VPWR _01601_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_149_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09449_ _00175_ _00229_ _00206_ _00228_ VGND VGND VPWR VPWR _00260_ sky130_fd_sc_hd__a211o_1
XFILLER_0_137_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12460_ net181 _03288_ VGND VGND VPWR VPWR _03293_ sky130_fd_sc_hd__nand2_1
XFILLER_0_62_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11411_ net435 net439 net124 net119 VGND VGND VPWR VPWR _02222_ sky130_fd_sc_hd__nand4_1
X_12391_ _03222_ VGND VGND VPWR VPWR _03223_ sky130_fd_sc_hd__buf_2
XFILLER_0_117_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14130_ net240 _04003_ VGND VGND VPWR VPWR _05085_ sky130_fd_sc_hd__nand2_1
X_11342_ net418 net130 _02147_ VGND VGND VPWR VPWR _02153_ sky130_fd_sc_hd__and3_1
XFILLER_0_61_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14061_ _04999_ _05007_ _04977_ _05008_ VGND VGND VPWR VPWR _05009_ sky130_fd_sc_hd__a211oi_2
X_11273_ _02064_ _02062_ VGND VGND VPWR VPWR _02084_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_120_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10224_ _01005_ _01034_ VGND VGND VPWR VPWR _01035_ sky130_fd_sc_hd__xnor2_4
X_13012_ _03849_ _03855_ VGND VGND VPWR VPWR _03856_ sky130_fd_sc_hd__and2_1
X_10155_ _00897_ _00965_ VGND VGND VPWR VPWR _00966_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_146_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14963_ _05998_ _06000_ VGND VGND VPWR VPWR _06002_ sky130_fd_sc_hd__and2_1
X_10086_ _00894_ _00892_ VGND VGND VPWR VPWR _00897_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_89_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16702_ _05553_ _05554_ VGND VGND VPWR VPWR _07914_ sky130_fd_sc_hd__nor2_2
X_13914_ _04841_ _04847_ VGND VGND VPWR VPWR _04848_ sky130_fd_sc_hd__xor2_1
X_14894_ _05712_ _05925_ VGND VGND VPWR VPWR _05926_ sky130_fd_sc_hd__xnor2_1
X_16633_ _07725_ _07837_ VGND VGND VPWR VPWR _07839_ sky130_fd_sc_hd__nor2_1
X_13845_ net224 _03668_ VGND VGND VPWR VPWR _04772_ sky130_fd_sc_hd__nand2_1
XFILLER_0_71_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16564_ _07636_ _07608_ VGND VGND VPWR VPWR _07763_ sky130_fd_sc_hd__nor2_1
XFILLER_0_85_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13776_ _04656_ _04695_ VGND VGND VPWR VPWR _04696_ sky130_fd_sc_hd__xor2_1
X_10988_ _01797_ _01798_ VGND VGND VPWR VPWR _01799_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15515_ _06605_ _06607_ _06603_ VGND VGND VPWR VPWR _06609_ sky130_fd_sc_hd__o21a_1
XFILLER_0_85_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12727_ net195 net190 _03234_ _03288_ VGND VGND VPWR VPWR _03569_ sky130_fd_sc_hd__and4_1
X_16495_ net261 net258 _05697_ VGND VGND VPWR VPWR _07687_ sky130_fd_sc_hd__and3_1
XFILLER_0_45_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15446_ _06526_ _06531_ _06532_ VGND VGND VPWR VPWR _06533_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12658_ net199 _03372_ VGND VGND VPWR VPWR _03497_ sky130_fd_sc_hd__nand2_1
XFILLER_0_111_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11609_ net404 net160 VGND VGND VPWR VPWR _02420_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15377_ _06455_ _06456_ VGND VGND VPWR VPWR _06457_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12589_ net239 _03345_ VGND VGND VPWR VPWR _03428_ sky130_fd_sc_hd__and2_1
X_17116_ _08048_ _08061_ VGND VGND VPWR VPWR _08370_ sky130_fd_sc_hd__and2_1
XFILLER_0_80_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14328_ _05205_ _05302_ _05203_ VGND VGND VPWR VPWR _05303_ sky130_fd_sc_hd__o21ai_4
Xmax_cap103 _03572_ VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__buf_8
X_17047_ _08292_ _08293_ VGND VGND VPWR VPWR _08294_ sky130_fd_sc_hd__nor2_1
XFILLER_0_150_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14259_ _05226_ _05190_ VGND VGND VPWR VPWR _05227_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_0_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08820_ _04043_ _04054_ VGND VGND VPWR VPWR _04065_ sky130_fd_sc_hd__nor2_8
X_08751_ _03340_ VGND VGND VPWR VPWR _03351_ sky130_fd_sc_hd__buf_2
XFILLER_0_136_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09303_ net526 _08636_ VGND VGND VPWR VPWR _08667_ sky130_fd_sc_hd__nand2_1
XFILLER_0_119_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09234_ _05649_ _05451_ _08567_ VGND VGND VPWR VPWR _08573_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_61_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09165_ _07442_ _07849_ VGND VGND VPWR VPWR _07860_ sky130_fd_sc_hd__nor2_1
XFILLER_0_133_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09096_ _06364_ _06375_ VGND VGND VPWR VPWR _07101_ sky130_fd_sc_hd__and2_1
XFILLER_0_43_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09998_ _00786_ _00788_ VGND VGND VPWR VPWR _00809_ sky130_fd_sc_hd__nand2_1
X_08949_ net344 _05473_ VGND VGND VPWR VPWR _05484_ sky130_fd_sc_hd__and2_1
X_11960_ _02768_ _02761_ _02766_ VGND VGND VPWR VPWR _02771_ sky130_fd_sc_hd__nand3_1
X_10911_ net415 net113 _01721_ VGND VGND VPWR VPWR _01722_ sky130_fd_sc_hd__and3_1
X_11891_ _02669_ _02676_ _02677_ VGND VGND VPWR VPWR _02702_ sky130_fd_sc_hd__or3_1
X_13630_ _04457_ _04476_ VGND VGND VPWR VPWR _04535_ sky130_fd_sc_hd__xor2_4
XPHY_EDGE_ROW_88_Left_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10842_ _01633_ _01652_ VGND VGND VPWR VPWR _01653_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13561_ _04328_ _04378_ _04379_ _04377_ VGND VGND VPWR VPWR _04459_ sky130_fd_sc_hd__o22ai_1
X_10773_ net382 net386 net138 net145 VGND VGND VPWR VPWR _01584_ sky130_fd_sc_hd__and4_1
XFILLER_0_54_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15300_ net296 _05721_ _05722_ _05709_ net300 VGND VGND VPWR VPWR _06372_ sky130_fd_sc_hd__a32o_1
X_12512_ _03348_ _03349_ VGND VGND VPWR VPWR _03350_ sky130_fd_sc_hd__nor2_1
X_16280_ net307 net302 _04314_ _06417_ VGND VGND VPWR VPWR _07450_ sky130_fd_sc_hd__and4_1
X_13492_ _04370_ _04381_ VGND VGND VPWR VPWR _04383_ sky130_fd_sc_hd__or2b_1
XFILLER_0_35_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15231_ _06185_ _06187_ _06176_ _06186_ VGND VGND VPWR VPWR _06296_ sky130_fd_sc_hd__o211a_1
XFILLER_0_109_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12443_ _03262_ _03274_ VGND VGND VPWR VPWR _03275_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15162_ _06103_ _06219_ VGND VGND VPWR VPWR _06220_ sky130_fd_sc_hd__or2_1
XFILLER_0_62_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12374_ _03190_ _08680_ _03191_ _03204_ _03205_ VGND VGND VPWR VPWR _03206_ sky130_fd_sc_hd__a221o_2
X_14113_ _05057_ _05061_ VGND VGND VPWR VPWR _05067_ sky130_fd_sc_hd__xnor2_1
X_11325_ net384 net168 _02096_ VGND VGND VPWR VPWR _02136_ sky130_fd_sc_hd__a21oi_1
X_15093_ _06142_ _06143_ VGND VGND VPWR VPWR _06145_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_97_Left_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14044_ net244 _03666_ VGND VGND VPWR VPWR _04991_ sky130_fd_sc_hd__nand2_1
X_11256_ _01986_ _02066_ VGND VGND VPWR VPWR _02067_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10207_ _01016_ _01017_ VGND VGND VPWR VPWR _01018_ sky130_fd_sc_hd__nor2_1
X_11187_ _01562_ net159 _01899_ VGND VGND VPWR VPWR _01998_ sky130_fd_sc_hd__o21a_1
X_10138_ _00945_ _00939_ _00944_ VGND VGND VPWR VPWR _00949_ sky130_fd_sc_hd__or3_1
X_15995_ net292 _05974_ VGND VGND VPWR VPWR _07137_ sky130_fd_sc_hd__nand2_1
X_14946_ _05966_ _05970_ _05982_ VGND VGND VPWR VPWR _05983_ sky130_fd_sc_hd__a21oi_1
X_10069_ _00878_ _00876_ _00879_ VGND VGND VPWR VPWR _00880_ sky130_fd_sc_hd__nor3_2
XFILLER_0_82_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14877_ _05769_ _05906_ VGND VGND VPWR VPWR _05907_ sky130_fd_sc_hd__and2b_1
X_16616_ _07818_ _07819_ _07646_ _07595_ VGND VGND VPWR VPWR _07820_ sky130_fd_sc_hd__o31a_1
X_13828_ _04682_ _04752_ VGND VGND VPWR VPWR _04753_ sky130_fd_sc_hd__nor2_1
XFILLER_0_58_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16547_ _05466_ _07743_ VGND VGND VPWR VPWR _07744_ sky130_fd_sc_hd__nor2_1
X_13759_ net202 _04002_ VGND VGND VPWR VPWR _04677_ sky130_fd_sc_hd__nand2_1
XFILLER_0_128_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16478_ _07666_ _07667_ VGND VGND VPWR VPWR _07668_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15429_ net300 net491 _05734_ VGND VGND VPWR VPWR _06514_ sky130_fd_sc_hd__and3_1
XFILLER_0_142_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09921_ net365 _04505_ _04417_ net370 VGND VGND VPWR VPWR _00732_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09852_ net361 _00662_ _05605_ _05616_ VGND VGND VPWR VPWR _00663_ sky130_fd_sc_hd__and4_1
XFILLER_0_147_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08803_ _03867_ VGND VGND VPWR VPWR _03878_ sky130_fd_sc_hd__clkbuf_8
X_09783_ _00592_ _00593_ VGND VGND VPWR VPWR _00594_ sky130_fd_sc_hd__xor2_1
XFILLER_0_147_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08734_ net53 _03061_ _03094_ net216 VGND VGND VPWR VPWR _00015_ sky130_fd_sc_hd__a22o_1
XFILLER_0_138_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09217_ _08245_ _08399_ _08421_ VGND VGND VPWR VPWR _08432_ sky130_fd_sc_hd__nor3_1
XFILLER_0_118_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09148_ _07112_ _07288_ VGND VGND VPWR VPWR _07673_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_871 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09079_ _06892_ _06903_ VGND VGND VPWR VPWR _06914_ sky130_fd_sc_hd__nor2_1
X_11110_ _01919_ _01920_ VGND VGND VPWR VPWR _01921_ sky130_fd_sc_hd__nor2_1
X_12090_ _02911_ _02912_ VGND VGND VPWR VPWR _02913_ sky130_fd_sc_hd__nor2_1
XFILLER_0_130_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11041_ _01753_ _01779_ _01778_ VGND VGND VPWR VPWR _01852_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_36_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14800_ net248 _05746_ _05749_ net251 VGND VGND VPWR VPWR _05822_ sky130_fd_sc_hd__a22oi_2
X_15780_ net278 _05974_ VGND VGND VPWR VPWR _06900_ sky130_fd_sc_hd__nand2_1
X_12992_ _03741_ _03759_ VGND VGND VPWR VPWR _03836_ sky130_fd_sc_hd__xnor2_1
X_14731_ _05745_ VGND VGND VPWR VPWR _05746_ sky130_fd_sc_hd__clkbuf_4
X_11943_ _02752_ _02753_ VGND VGND VPWR VPWR _02754_ sky130_fd_sc_hd__and2_1
X_17450_ clknet_4_11_0_clock _00128_ VGND VGND VPWR VPWR prev_d_error\[2\] sky130_fd_sc_hd__dfxtp_1
X_14662_ _05661_ _05669_ VGND VGND VPWR VPWR _05670_ sky130_fd_sc_hd__and2b_1
XFILLER_0_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11874_ net443 net131 _02609_ _02610_ VGND VGND VPWR VPWR _02685_ sky130_fd_sc_hd__o2bb2a_1
X_16401_ i_error\[11\] _07578_ _07582_ VGND VGND VPWR VPWR _07583_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_129_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13613_ _04510_ _04515_ VGND VGND VPWR VPWR _04517_ sky130_fd_sc_hd__xor2_1
X_17381_ net469 net404 net457 _08595_ VGND VGND VPWR VPWR _00137_ sky130_fd_sc_hd__o211a_1
X_10825_ net393 net112 net108 net397 VGND VGND VPWR VPWR _01636_ sky130_fd_sc_hd__a22oi_1
X_14593_ _05593_ VGND VGND VPWR VPWR _05595_ sky130_fd_sc_hd__buf_2
X_16332_ _05838_ VGND VGND VPWR VPWR _07507_ sky130_fd_sc_hd__inv_2
X_13544_ net196 _03935_ _04003_ net188 VGND VGND VPWR VPWR _04441_ sky130_fd_sc_hd__a22o_1
X_10756_ net382 net386 net134 net129 VGND VGND VPWR VPWR _01567_ sky130_fd_sc_hd__and4_1
XFILLER_0_54_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16263_ _07427_ _07425_ VGND VGND VPWR VPWR _07432_ sky130_fd_sc_hd__xnor2_1
X_13475_ _04255_ _04254_ VGND VGND VPWR VPWR _04365_ sky130_fd_sc_hd__and2b_1
X_10687_ net393 net397 net121 net116 VGND VGND VPWR VPWR _01498_ sky130_fd_sc_hd__and4_1
X_15214_ _06124_ _06110_ VGND VGND VPWR VPWR _06278_ sky130_fd_sc_hd__and2b_2
X_12426_ _03238_ _03256_ VGND VGND VPWR VPWR _03258_ sky130_fd_sc_hd__or2_1
XFILLER_0_23_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16194_ net302 _06347_ VGND VGND VPWR VPWR _07356_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15145_ net250 _06162_ VGND VGND VPWR VPWR _06202_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12357_ prev_error\[6\] _08636_ VGND VGND VPWR VPWR _03189_ sky130_fd_sc_hd__nand2_1
XFILLER_0_133_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11308_ _02020_ _02118_ VGND VGND VPWR VPWR _02119_ sky130_fd_sc_hd__nor2_1
X_15076_ _06072_ _06073_ VGND VGND VPWR VPWR _06126_ sky130_fd_sc_hd__xor2_2
XFILLER_0_10_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12288_ _03118_ _03119_ VGND VGND VPWR VPWR _03120_ sky130_fd_sc_hd__or2_1
XFILLER_0_120_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14027_ _04965_ _04970_ VGND VGND VPWR VPWR _04972_ sky130_fd_sc_hd__nand2_1
X_11239_ net419 net126 net123 net423 VGND VGND VPWR VPWR _02050_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_93_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15978_ _07117_ VGND VGND VPWR VPWR _07118_ sky130_fd_sc_hd__inv_2
XFILLER_0_117_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14929_ _05962_ _05963_ VGND VGND VPWR VPWR _05964_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_143_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09002_ _04791_ _06056_ VGND VGND VPWR VPWR _06067_ sky130_fd_sc_hd__xor2_1
XFILLER_0_6_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09904_ _00625_ _00626_ VGND VGND VPWR VPWR _00715_ sky130_fd_sc_hd__xnor2_2
X_09835_ net324 _00373_ _00645_ VGND VGND VPWR VPWR _00646_ sky130_fd_sc_hd__and3_1
X_09766_ _00567_ _00569_ _00571_ VGND VGND VPWR VPWR _00577_ sky130_fd_sc_hd__a21oi_1
X_08717_ net44 _02894_ _02927_ net113 VGND VGND VPWR VPWR _00024_ sky130_fd_sc_hd__a22o_1
XFILLER_0_69_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09697_ net324 _00243_ _00506_ _00507_ VGND VGND VPWR VPWR _00508_ sky130_fd_sc_hd__a31o_1
XFILLER_0_68_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10610_ _01416_ _01419_ _01420_ VGND VGND VPWR VPWR _01421_ sky130_fd_sc_hd__a21o_1
XFILLER_0_64_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11590_ _02397_ _02400_ VGND VGND VPWR VPWR _02401_ sky130_fd_sc_hd__or2b_1
XFILLER_0_107_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10541_ net368 _00652_ _00518_ net372 VGND VGND VPWR VPWR _01352_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_106_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13260_ net213 _03249_ VGND VGND VPWR VPWR _04128_ sky130_fd_sc_hd__nand2_1
X_10472_ _01279_ _01281_ _01282_ VGND VGND VPWR VPWR _01283_ sky130_fd_sc_hd__or3_4
X_12211_ _03004_ _03035_ VGND VGND VPWR VPWR _03037_ sky130_fd_sc_hd__or2_1
XFILLER_0_106_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13191_ _04038_ _04051_ VGND VGND VPWR VPWR _04052_ sky130_fd_sc_hd__nor2_1
XFILLER_0_20_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12142_ _02963_ _02965_ _02966_ VGND VGND VPWR VPWR _02967_ sky130_fd_sc_hd__or3_1
XFILLER_0_102_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16950_ _05434_ _08143_ _08186_ VGND VGND VPWR VPWR _08187_ sky130_fd_sc_hd__a21boi_1
X_12073_ _02870_ _02873_ _02893_ VGND VGND VPWR VPWR _02895_ sky130_fd_sc_hd__o21ai_1
X_15901_ _06955_ _06957_ _06956_ VGND VGND VPWR VPWR _07033_ sky130_fd_sc_hd__o21ai_1
X_11024_ _01562_ net155 _01834_ VGND VGND VPWR VPWR _01835_ sky130_fd_sc_hd__nor3_1
X_16881_ _07764_ net504 VGND VGND VPWR VPWR _08111_ sky130_fd_sc_hd__nor2_1
X_15832_ _06838_ _06954_ _06949_ _06953_ VGND VGND VPWR VPWR _06957_ sky130_fd_sc_hd__a211oi_2
X_15763_ _06701_ _06704_ VGND VGND VPWR VPWR _06882_ sky130_fd_sc_hd__xnor2_1
X_12975_ _03804_ _03818_ VGND VGND VPWR VPWR _03819_ sky130_fd_sc_hd__and2b_1
X_14714_ net273 _05710_ VGND VGND VPWR VPWR _05728_ sky130_fd_sc_hd__nand2_2
X_17502_ clknet_4_1_0_clock _00000_ VGND VGND VPWR VPWR kd_1\[0\] sky130_fd_sc_hd__dfxtp_1
X_11926_ _02734_ _02736_ VGND VGND VPWR VPWR _02737_ sky130_fd_sc_hd__or2b_1
X_15694_ _06800_ _06802_ VGND VGND VPWR VPWR _06806_ sky130_fd_sc_hd__or2_1
X_17433_ clknet_4_9_0_clock _00111_ VGND VGND VPWR VPWR i_error\[3\] sky130_fd_sc_hd__dfxtp_1
X_14645_ _05592_ _05609_ _05651_ VGND VGND VPWR VPWR _05652_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_74_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11857_ _02665_ _02667_ VGND VGND VPWR VPWR _02668_ sky130_fd_sc_hd__or2_1
XFILLER_0_28_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17364_ net466 _08062_ VGND VGND VPWR VPWR _08586_ sky130_fd_sc_hd__nand2_1
X_10808_ net129 _01617_ _01618_ prev_d_error\[17\] VGND VGND VPWR VPWR _01619_ sky130_fd_sc_hd__and4bb_1
X_14576_ prev_error\[9\] _07321_ VGND VGND VPWR VPWR _05576_ sky130_fd_sc_hd__nand2_1
X_11788_ _02595_ _02598_ VGND VGND VPWR VPWR _02599_ sky130_fd_sc_hd__and2_1
XFILLER_0_55_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16315_ _07044_ _07048_ _06976_ _06977_ VGND VGND VPWR VPWR _07489_ sky130_fd_sc_hd__a211oi_4
X_13527_ _04420_ _04421_ VGND VGND VPWR VPWR _04422_ sky130_fd_sc_hd__xnor2_1
X_17295_ net461 prev_error\[6\] VGND VGND VPWR VPWR _08543_ sky130_fd_sc_hd__or2_1
X_10739_ _01473_ _01527_ _01549_ VGND VGND VPWR VPWR _01550_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_137_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16246_ _07412_ VGND VGND VPWR VPWR _07413_ sky130_fd_sc_hd__inv_2
XFILLER_0_113_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13458_ _04220_ _04218_ _04217_ VGND VGND VPWR VPWR _04346_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_3_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12409_ _03186_ _03209_ _03240_ VGND VGND VPWR VPWR _03241_ sky130_fd_sc_hd__nand3_2
XFILLER_0_113_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16177_ _07225_ _07231_ _07232_ VGND VGND VPWR VPWR _07337_ sky130_fd_sc_hd__and3_1
XFILLER_0_88_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13389_ _04262_ _04265_ VGND VGND VPWR VPWR _04270_ sky130_fd_sc_hd__xor2_1
XFILLER_0_11_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15128_ _06082_ _06062_ _06081_ VGND VGND VPWR VPWR _06183_ sky130_fd_sc_hd__and3_1
XFILLER_0_11_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15059_ _06104_ _06105_ _06102_ VGND VGND VPWR VPWR _06107_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_128_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09620_ net369 _05605_ _05616_ VGND VGND VPWR VPWR _00431_ sky130_fd_sc_hd__and3_1
X_09551_ net331 _08634_ _08635_ VGND VGND VPWR VPWR _00362_ sky130_fd_sc_hd__and3_2
X_09482_ _00287_ _00292_ VGND VGND VPWR VPWR _00293_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_144_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_872 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout310 net311 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__clkbuf_4
Xfanout321 net322 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__buf_2
XFILLER_0_10_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout332 net333 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__clkbuf_4
Xfanout343 kp\[9\] VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__buf_2
Xfanout354 kp\[6\] VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__buf_2
Xfanout365 net368 VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__clkbuf_2
Xfanout376 kp\[1\] VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__clkbuf_4
X_09818_ _00623_ _00627_ _00609_ _00610_ VGND VGND VPWR VPWR _00629_ sky130_fd_sc_hd__a211o_1
Xfanout387 net388 VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__buf_2
Xfanout398 net399 VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__clkbuf_4
X_09749_ net324 _00316_ _00373_ net320 VGND VGND VPWR VPWR _00560_ sky130_fd_sc_hd__a22o_1
XFILLER_0_69_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12760_ _03601_ _03603_ VGND VGND VPWR VPWR _03604_ sky130_fd_sc_hd__and2_1
XFILLER_0_96_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11711_ net404 net163 VGND VGND VPWR VPWR _02522_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12691_ _03528_ _03529_ VGND VGND VPWR VPWR _03530_ sky130_fd_sc_hd__nor2_1
XFILLER_0_139_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14430_ _05356_ _05413_ VGND VGND VPWR VPWR _05415_ sky130_fd_sc_hd__or2_1
XFILLER_0_127_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11642_ _02437_ _02450_ VGND VGND VPWR VPWR _02453_ sky130_fd_sc_hd__xor2_1
X_14361_ _01486_ _05337_ VGND VGND VPWR VPWR _05339_ sky130_fd_sc_hd__and2_1
X_11573_ _02277_ _02288_ VGND VGND VPWR VPWR _02384_ sky130_fd_sc_hd__nand2_1
Xinput18 measurement[8] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_2
X_16100_ net285 _06415_ VGND VGND VPWR VPWR _07252_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13312_ _04159_ _04183_ _04184_ VGND VGND VPWR VPWR _04185_ sky130_fd_sc_hd__o21ba_1
X_10524_ net371 net366 _00518_ _00371_ _01334_ VGND VGND VPWR VPWR _01335_ sky130_fd_sc_hd__a41o_1
Xinput29 reg_addr[1] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__buf_1
X_17080_ _08313_ _08328_ VGND VGND VPWR VPWR _08330_ sky130_fd_sc_hd__nand2_1
X_14292_ _05261_ _05262_ VGND VGND VPWR VPWR _05263_ sky130_fd_sc_hd__xor2_2
XFILLER_0_135_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16031_ _07164_ _07165_ _07171_ _07170_ _07169_ VGND VGND VPWR VPWR _07176_ sky130_fd_sc_hd__a32o_1
X_13243_ _03263_ _04108_ VGND VGND VPWR VPWR _04110_ sky130_fd_sc_hd__nor2_1
X_10455_ net366 _00313_ _01213_ VGND VGND VPWR VPWR _01266_ sky130_fd_sc_hd__and3_1
XFILLER_0_149_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13174_ _04030_ _04031_ _03892_ _04033_ VGND VGND VPWR VPWR _04034_ sky130_fd_sc_hd__o2bb2a_1
X_10386_ _01147_ _01185_ _01196_ VGND VGND VPWR VPWR _01197_ sky130_fd_sc_hd__nand3_1
X_12125_ _02948_ _02949_ VGND VGND VPWR VPWR _02950_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_20_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16933_ _07846_ _08167_ _07969_ VGND VGND VPWR VPWR _08169_ sky130_fd_sc_hd__mux2_1
X_12056_ _02867_ _02869_ _02875_ VGND VGND VPWR VPWR _02876_ sky130_fd_sc_hd__o21ai_1
X_11007_ _01808_ _01812_ _01816_ _01817_ VGND VGND VPWR VPWR _01818_ sky130_fd_sc_hd__o211a_1
X_16864_ net477 _07966_ _07779_ _07967_ VGND VGND VPWR VPWR _08093_ sky130_fd_sc_hd__o211a_1
X_15815_ _06935_ _06937_ _06938_ VGND VGND VPWR VPWR _06939_ sky130_fd_sc_hd__a21bo_1
X_16795_ _07737_ _05555_ VGND VGND VPWR VPWR _08017_ sky130_fd_sc_hd__and2_1
XFILLER_0_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15746_ _06861_ _06862_ VGND VGND VPWR VPWR _06863_ sky130_fd_sc_hd__nor2_1
X_12958_ _03758_ _03801_ VGND VGND VPWR VPWR _03802_ sky130_fd_sc_hd__nand2_1
XFILLER_0_114_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11909_ _02645_ _02718_ VGND VGND VPWR VPWR _02720_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_87_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15677_ _06781_ _06785_ _06784_ VGND VGND VPWR VPWR _06787_ sky130_fd_sc_hd__a21o_1
X_12889_ _03639_ _03722_ _03726_ _03732_ VGND VGND VPWR VPWR _03733_ sky130_fd_sc_hd__o31a_1
XFILLER_0_145_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14628_ _03227_ _03246_ VGND VGND VPWR VPWR _05633_ sky130_fd_sc_hd__nor2_1
X_17416_ clknet_4_3_0_clock _00094_ VGND VGND VPWR VPWR prev_error\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_135_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17347_ _08564_ _08235_ _08575_ net455 VGND VGND VPWR VPWR _00120_ sky130_fd_sc_hd__o211a_1
XFILLER_0_83_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14559_ _05468_ _05555_ _05556_ VGND VGND VPWR VPWR _05557_ sky130_fd_sc_hd__and3_1
XFILLER_0_99_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17278_ net468 net513 net457 VGND VGND VPWR VPWR _08532_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_24_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16229_ _07390_ _07391_ _07393_ VGND VGND VPWR VPWR _07394_ sky130_fd_sc_hd__and3_1
XFILLER_0_113_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08982_ net336 _05660_ VGND VGND VPWR VPWR _05847_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_143_Right_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09603_ _00397_ _00412_ _00413_ VGND VGND VPWR VPWR _00414_ sky130_fd_sc_hd__a21oi_1
X_09534_ net369 net520 _05638_ net364 VGND VGND VPWR VPWR _00345_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_78_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09465_ _00274_ _00275_ VGND VGND VPWR VPWR _00276_ sky130_fd_sc_hd__xor2_2
XFILLER_0_148_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09396_ _00195_ _00193_ VGND VGND VPWR VPWR _00207_ sky130_fd_sc_hd__and2b_1
XFILLER_0_93_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10240_ net354 _08675_ _01049_ VGND VGND VPWR VPWR _01051_ sky130_fd_sc_hd__and3_1
XFILLER_0_131_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10171_ _00978_ _00981_ VGND VGND VPWR VPWR _00982_ sky130_fd_sc_hd__nand2_1
XFILLER_0_100_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_110_Right_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout140 net141 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__clkbuf_4
Xfanout151 net153 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__buf_2
Xfanout162 kd_2\[3\] VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__clkbuf_4
X_13930_ net223 _03792_ _04863_ _04864_ VGND VGND VPWR VPWR _04865_ sky130_fd_sc_hd__a31o_1
Xfanout173 kd_2\[0\] VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__clkbuf_4
Xfanout184 kd_1\[14\] VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__clkbuf_4
Xfanout195 net196 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__buf_2
X_13861_ _04717_ _04719_ _04718_ VGND VGND VPWR VPWR _04789_ sky130_fd_sc_hd__a21o_1
X_15600_ _06697_ _06698_ VGND VGND VPWR VPWR _06702_ sky130_fd_sc_hd__nor2_1
X_12812_ _03654_ _03655_ VGND VGND VPWR VPWR _03656_ sky130_fd_sc_hd__nor2_1
X_16580_ _07779_ VGND VGND VPWR VPWR _07780_ sky130_fd_sc_hd__inv_2
X_13792_ _04709_ _04707_ VGND VGND VPWR VPWR _04713_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_57_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15531_ net278 _05603_ _06446_ _06625_ VGND VGND VPWR VPWR _06626_ sky130_fd_sc_hd__a31o_1
XFILLER_0_139_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12743_ _03584_ _03585_ VGND VGND VPWR VPWR _03587_ sky130_fd_sc_hd__or2b_1
XFILLER_0_127_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_842 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15462_ net278 _05666_ VGND VGND VPWR VPWR _06550_ sky130_fd_sc_hd__nand2_1
X_12674_ _03434_ _03511_ VGND VGND VPWR VPWR _03513_ sky130_fd_sc_hd__and2_1
XFILLER_0_60_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17201_ _08228_ _08219_ VGND VGND VPWR VPWR _08463_ sky130_fd_sc_hd__or2b_1
X_14413_ _05394_ _05395_ VGND VGND VPWR VPWR _05397_ sky130_fd_sc_hd__nor2_1
XFILLER_0_53_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11625_ _02418_ _02432_ _02434_ VGND VGND VPWR VPWR _02436_ sky130_fd_sc_hd__a21oi_1
X_15393_ _05593_ _06473_ VGND VGND VPWR VPWR _06475_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_37_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17132_ _01687_ _08335_ _01686_ VGND VGND VPWR VPWR _08387_ sky130_fd_sc_hd__o21ba_1
X_14344_ _01673_ _01676_ _05318_ VGND VGND VPWR VPWR _05321_ sky130_fd_sc_hd__nand3_1
XFILLER_0_8_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11556_ _02341_ _02364_ _02366_ VGND VGND VPWR VPWR _02367_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_52_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10507_ _01310_ _01317_ VGND VGND VPWR VPWR _01318_ sky130_fd_sc_hd__nor2_1
X_17063_ _05338_ _05339_ _05342_ VGND VGND VPWR VPWR _08312_ sky130_fd_sc_hd__or3_1
XFILLER_0_40_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14275_ _05179_ _05183_ _05185_ VGND VGND VPWR VPWR _05245_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_123_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11487_ _02295_ _02297_ VGND VGND VPWR VPWR _02298_ sky130_fd_sc_hd__nor2_1
X_16014_ _07143_ _07144_ _07157_ VGND VGND VPWR VPWR _07158_ sky130_fd_sc_hd__nor3_2
X_13226_ _04059_ _04089_ _04090_ VGND VGND VPWR VPWR _04091_ sky130_fd_sc_hd__a21oi_1
X_10438_ net380 _07915_ _00314_ net362 VGND VGND VPWR VPWR _01249_ sky130_fd_sc_hd__a22o_1
XFILLER_0_21_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13157_ _03937_ _04014_ VGND VGND VPWR VPWR _04015_ sky130_fd_sc_hd__xor2_1
XFILLER_0_0_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10369_ _01155_ _01179_ VGND VGND VPWR VPWR _01180_ sky130_fd_sc_hd__or2_1
X_12108_ _02903_ _02909_ VGND VGND VPWR VPWR _02933_ sky130_fd_sc_hd__and2b_1
XFILLER_0_109_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13088_ net182 net178 _03793_ _03752_ VGND VGND VPWR VPWR _03939_ sky130_fd_sc_hd__nand4_1
XFILLER_0_18_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16916_ _08145_ _08148_ VGND VGND VPWR VPWR _08150_ sky130_fd_sc_hd__and2b_1
X_12039_ net420 net165 net169 net416 VGND VGND VPWR VPWR _02857_ sky130_fd_sc_hd__a22oi_2
XPHY_EDGE_ROW_108_Left_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16847_ _05448_ VGND VGND VPWR VPWR _08074_ sky130_fd_sc_hd__inv_2
XFILLER_0_79_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16778_ _07997_ VGND VGND VPWR VPWR _07998_ sky130_fd_sc_hd__inv_2
XFILLER_0_125_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15729_ net268 _06162_ _06600_ VGND VGND VPWR VPWR _06844_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09250_ net340 _04923_ _04758_ net336 VGND VGND VPWR VPWR _08614_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_118_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09181_ _07871_ _08025_ VGND VGND VPWR VPWR _08036_ sky130_fd_sc_hd__nor2_1
XFILLER_0_145_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_117_Left_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08965_ _05649_ VGND VGND VPWR VPWR _05660_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_126_Left_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08896_ _04879_ _04890_ VGND VGND VPWR VPWR _04901_ sky130_fd_sc_hd__and2_1
X_09517_ _00230_ _00260_ _00259_ VGND VGND VPWR VPWR _00328_ sky130_fd_sc_hd__a21o_1
XFILLER_0_39_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09448_ _00252_ _00258_ VGND VGND VPWR VPWR _00259_ sky130_fd_sc_hd__xor2_1
XFILLER_0_93_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_135_Left_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09379_ _06232_ _00189_ VGND VGND VPWR VPWR _00190_ sky130_fd_sc_hd__or2_1
X_11410_ _02184_ _02220_ VGND VGND VPWR VPWR _02221_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12390_ _03221_ VGND VGND VPWR VPWR _03222_ sky130_fd_sc_hd__buf_2
XFILLER_0_35_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11341_ net418 net130 _02147_ VGND VGND VPWR VPWR _02152_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_34_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14060_ _04974_ _04976_ _04975_ VGND VGND VPWR VPWR _05008_ sky130_fd_sc_hd__o21a_1
X_11272_ _02070_ _02082_ VGND VGND VPWR VPWR _02083_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13011_ _03851_ _03854_ _03423_ VGND VGND VPWR VPWR _03855_ sky130_fd_sc_hd__o21a_1
X_10223_ _01031_ _01032_ _01033_ VGND VGND VPWR VPWR _01034_ sky130_fd_sc_hd__o21ba_2
XPHY_EDGE_ROW_144_Left_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10154_ _00930_ _00963_ _00964_ VGND VGND VPWR VPWR _00965_ sky130_fd_sc_hd__a21boi_2
X_14962_ _05989_ _05993_ _05998_ _05999_ VGND VGND VPWR VPWR _06000_ sky130_fd_sc_hd__o211ai_4
X_10085_ _00812_ _00817_ _00891_ _00895_ VGND VGND VPWR VPWR _00896_ sky130_fd_sc_hd__o211ai_4
X_16701_ _07910_ _07912_ VGND VGND VPWR VPWR _07913_ sky130_fd_sc_hd__xnor2_2
X_13913_ _04844_ _04845_ VGND VGND VPWR VPWR _04847_ sky130_fd_sc_hd__and2_1
X_14893_ _05698_ _05703_ _05713_ VGND VGND VPWR VPWR _05925_ sky130_fd_sc_hd__a21oi_1
X_16632_ _05464_ _07836_ VGND VGND VPWR VPWR _07837_ sky130_fd_sc_hd__or2_1
X_13844_ _04764_ _04770_ VGND VGND VPWR VPWR _04771_ sky130_fd_sc_hd__and2_1
XFILLER_0_69_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16563_ _07613_ _07635_ _07637_ VGND VGND VPWR VPWR _07762_ sky130_fd_sc_hd__a21o_1
X_13775_ net224 _03577_ VGND VGND VPWR VPWR _04695_ sky130_fd_sc_hd__nand2_1
X_10987_ _01791_ _01793_ _01796_ VGND VGND VPWR VPWR _01798_ sky130_fd_sc_hd__or3_1
X_15514_ _06603_ _06605_ _06607_ VGND VGND VPWR VPWR _06608_ sky130_fd_sc_hd__nor3_1
X_12726_ net190 _03234_ _03288_ net195 VGND VGND VPWR VPWR _03568_ sky130_fd_sc_hd__a22o_1
X_16494_ net261 _05697_ _05705_ net258 VGND VGND VPWR VPWR _07686_ sky130_fd_sc_hd__a22o_1
X_15445_ _06506_ _06530_ VGND VGND VPWR VPWR _06532_ sky130_fd_sc_hd__and2_1
XFILLER_0_128_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12657_ _03444_ _03449_ _03442_ VGND VGND VPWR VPWR _03496_ sky130_fd_sc_hd__a21o_1
XFILLER_0_38_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11608_ net410 net152 net156 net405 VGND VGND VPWR VPWR _02419_ sky130_fd_sc_hd__a22oi_2
X_15376_ _06195_ _06339_ _06338_ VGND VGND VPWR VPWR _06456_ sky130_fd_sc_hd__o21a_1
X_12588_ _03421_ _03426_ VGND VGND VPWR VPWR _03427_ sky130_fd_sc_hd__nor2b_4
XFILLER_0_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14327_ _05212_ _05301_ _05210_ VGND VGND VPWR VPWR _05302_ sky130_fd_sc_hd__a21oi_4
X_17115_ _08367_ _08368_ VGND VGND VPWR VPWR _08369_ sky130_fd_sc_hd__nor2_1
X_11539_ net396 net159 VGND VGND VPWR VPWR _02350_ sky130_fd_sc_hd__nand2_1
Xmax_cap104 _02137_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__buf_1
X_17046_ _03427_ _05394_ _08291_ VGND VGND VPWR VPWR _08293_ sky130_fd_sc_hd__nor3_1
X_14258_ _05191_ _04096_ VGND VGND VPWR VPWR _05226_ sky130_fd_sc_hd__or2b_2
XFILLER_0_21_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13209_ net232 VGND VGND VPWR VPWR _04072_ sky130_fd_sc_hd__inv_2
X_14189_ _05118_ _05136_ _05135_ VGND VGND VPWR VPWR _05150_ sky130_fd_sc_hd__a21bo_1
X_08750_ _03329_ VGND VGND VPWR VPWR _03340_ sky130_fd_sc_hd__buf_2
XFILLER_0_136_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09302_ _08662_ _08665_ VGND VGND VPWR VPWR _08666_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_146_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09233_ net352 _05385_ _05649_ net348 VGND VGND VPWR VPWR _08567_ sky130_fd_sc_hd__a22o_1
XFILLER_0_8_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09164_ _04560_ _07420_ _07354_ _07431_ VGND VGND VPWR VPWR _07849_ sky130_fd_sc_hd__o22a_1
XFILLER_0_127_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09095_ _07079_ VGND VGND VPWR VPWR _07090_ sky130_fd_sc_hd__inv_2
XFILLER_0_142_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09997_ _00783_ _00805_ _00806_ _00807_ VGND VGND VPWR VPWR _00808_ sky130_fd_sc_hd__o211a_2
X_08948_ _05451_ _05462_ VGND VGND VPWR VPWR _05473_ sky130_fd_sc_hd__nor2_1
XFILLER_0_99_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08879_ net6 net61 VGND VGND VPWR VPWR _04714_ sky130_fd_sc_hd__or2b_1
X_10910_ _01719_ _01720_ VGND VGND VPWR VPWR _01721_ sky130_fd_sc_hd__nor2_1
X_11890_ _02696_ _02699_ _02626_ _02700_ VGND VGND VPWR VPWR _02701_ sky130_fd_sc_hd__o211a_1
XFILLER_0_67_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10841_ _01650_ _01651_ VGND VGND VPWR VPWR _01652_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13560_ _04368_ _04382_ VGND VGND VPWR VPWR _04458_ sky130_fd_sc_hd__xor2_4
X_10772_ _01563_ net145 _01565_ VGND VGND VPWR VPWR _01583_ sky130_fd_sc_hd__o21a_1
X_12511_ net204 _03322_ _03346_ VGND VGND VPWR VPWR _03349_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_82_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13491_ _04370_ _04381_ VGND VGND VPWR VPWR _04382_ sky130_fd_sc_hd__xor2_4
X_15230_ _06293_ _06294_ VGND VGND VPWR VPWR _06295_ sky130_fd_sc_hd__or2b_1
XFILLER_0_81_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12442_ _03271_ _03273_ VGND VGND VPWR VPWR _03274_ sky130_fd_sc_hd__or2b_1
XFILLER_0_35_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15161_ net293 _05710_ VGND VGND VPWR VPWR _06219_ sky130_fd_sc_hd__and2_1
XFILLER_0_140_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12373_ prev_error\[5\] _08674_ VGND VGND VPWR VPWR _03205_ sky130_fd_sc_hd__and2b_1
XFILLER_0_50_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14112_ _05063_ _05064_ VGND VGND VPWR VPWR _05065_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11324_ net384 net166 _02096_ VGND VGND VPWR VPWR _02135_ sky130_fd_sc_hd__and3_1
XFILLER_0_133_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15092_ _06051_ _06055_ VGND VGND VPWR VPWR _06143_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_50_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14043_ _04983_ _04988_ VGND VGND VPWR VPWR _04990_ sky130_fd_sc_hd__and2_1
X_11255_ _01983_ _01985_ VGND VGND VPWR VPWR _02066_ sky130_fd_sc_hd__nor2_1
XFILLER_0_120_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10206_ _01009_ _01013_ VGND VGND VPWR VPWR _01017_ sky130_fd_sc_hd__xor2_1
X_11186_ _01995_ _01996_ prev_d_error\[14\] net151 VGND VGND VPWR VPWR _01997_ sky130_fd_sc_hd__and4bb_1
X_10137_ _00913_ _00947_ VGND VGND VPWR VPWR _00948_ sky130_fd_sc_hd__nor2_1
X_15994_ net290 _06017_ VGND VGND VPWR VPWR _07136_ sky130_fd_sc_hd__nand2_1
X_14945_ _05972_ _05980_ _05981_ VGND VGND VPWR VPWR _05982_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10068_ _00742_ _00861_ _00875_ VGND VGND VPWR VPWR _00879_ sky130_fd_sc_hd__a21oi_1
X_14876_ _05768_ _05762_ _05766_ VGND VGND VPWR VPWR _05906_ sky130_fd_sc_hd__or3_1
XFILLER_0_15_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16615_ _07605_ _07608_ _07638_ _07602_ _07811_ VGND VGND VPWR VPWR _07819_ sky130_fd_sc_hd__o311a_1
X_13827_ net197 _04108_ _04680_ VGND VGND VPWR VPWR _04752_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_106_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16546_ _05424_ _05465_ VGND VGND VPWR VPWR _07743_ sky130_fd_sc_hd__nor2_1
X_13758_ net206 _03934_ VGND VGND VPWR VPWR _04676_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12709_ _03533_ _03548_ VGND VGND VPWR VPWR _03549_ sky130_fd_sc_hd__or2b_1
XFILLER_0_73_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16477_ net251 net248 _05739_ _05801_ VGND VGND VPWR VPWR _07667_ sky130_fd_sc_hd__and4_1
X_13689_ _04598_ _04599_ VGND VGND VPWR VPWR _04600_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_143_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15428_ net296 _05626_ _05628_ VGND VGND VPWR VPWR _06513_ sky130_fd_sc_hd__and3_1
XFILLER_0_122_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15359_ _06435_ _06436_ VGND VGND VPWR VPWR _06437_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_80_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09920_ net374 _04912_ _00699_ _00700_ VGND VGND VPWR VPWR _00731_ sky130_fd_sc_hd__a22o_1
X_17029_ _08260_ _08261_ _08273_ VGND VGND VPWR VPWR _08274_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09851_ net378 _04417_ VGND VGND VPWR VPWR _00662_ sky130_fd_sc_hd__and2_1
X_08802_ net464 VGND VGND VPWR VPWR _03867_ sky130_fd_sc_hd__inv_4
X_09782_ _00507_ _00506_ VGND VGND VPWR VPWR _00593_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08733_ net52 _03061_ _03094_ net219 VGND VGND VPWR VPWR _00014_ sky130_fd_sc_hd__a22o_1
XFILLER_0_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09216_ _08388_ _08410_ VGND VGND VPWR VPWR _08421_ sky130_fd_sc_hd__or2_1
XFILLER_0_91_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09147_ _07574_ _07651_ VGND VGND VPWR VPWR _07662_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_134_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09078_ net321 _05726_ _06881_ VGND VGND VPWR VPWR _06903_ sky130_fd_sc_hd__and3_1
XFILLER_0_20_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11040_ _01825_ _01849_ _01850_ VGND VGND VPWR VPWR _01851_ sky130_fd_sc_hd__nor3_1
X_12991_ _03833_ _03834_ VGND VGND VPWR VPWR _03835_ sky130_fd_sc_hd__and2b_1
X_14730_ _05744_ VGND VGND VPWR VPWR _05745_ sky130_fd_sc_hd__buf_4
X_11942_ _02672_ _02740_ _02751_ VGND VGND VPWR VPWR _02753_ sky130_fd_sc_hd__or3_1
XFILLER_0_98_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14661_ _05591_ _05662_ _05668_ VGND VGND VPWR VPWR _05669_ sky130_fd_sc_hd__o21ai_1
X_11873_ _02682_ _02683_ net443 net135 VGND VGND VPWR VPWR _02684_ sky130_fd_sc_hd__and4bb_1
X_16400_ i_error\[11\] _07578_ _07581_ i_error\[10\] VGND VGND VPWR VPWR _07582_ sky130_fd_sc_hd__a22o_1
X_13612_ _04511_ _04514_ _04512_ VGND VGND VPWR VPWR _04515_ sky130_fd_sc_hd__o21ai_1
X_10824_ _01506_ _01510_ _01634_ VGND VGND VPWR VPWR _01635_ sky130_fd_sc_hd__a21oi_1
X_14592_ ki\[17\] VGND VGND VPWR VPWR _05593_ sky130_fd_sc_hd__inv_2
X_17380_ net469 _08199_ VGND VGND VPWR VPWR _08595_ sky130_fd_sc_hd__nand2_1
X_16331_ _06003_ _07505_ VGND VGND VPWR VPWR _07506_ sky130_fd_sc_hd__or2_2
XFILLER_0_54_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13543_ net196 net188 _03936_ _04003_ VGND VGND VPWR VPWR _04440_ sky130_fd_sc_hd__nand4_1
X_10755_ _01563_ net145 _01565_ VGND VGND VPWR VPWR _01566_ sky130_fd_sc_hd__nor3_2
X_16262_ net310 _04314_ _07241_ _07429_ VGND VGND VPWR VPWR _07430_ sky130_fd_sc_hd__a31oi_1
XFILLER_0_54_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13474_ _04324_ _04363_ VGND VGND VPWR VPWR _04364_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_70_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10686_ net389 net125 VGND VGND VPWR VPWR _01497_ sky130_fd_sc_hd__nand2_1
XFILLER_0_125_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15213_ _06272_ _06274_ _06275_ VGND VGND VPWR VPWR _06277_ sky130_fd_sc_hd__o21a_2
X_12425_ _03238_ _03256_ VGND VGND VPWR VPWR _03257_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16193_ net302 _06204_ _06347_ net298 VGND VGND VPWR VPWR _07355_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_124_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15144_ _06165_ _06200_ VGND VGND VPWR VPWR _06201_ sky130_fd_sc_hd__and2_1
X_12356_ _03187_ net523 VGND VGND VPWR VPWR _03188_ sky130_fd_sc_hd__or2_1
X_11307_ _02017_ _02019_ VGND VGND VPWR VPWR _02118_ sky130_fd_sc_hd__nor2_1
X_15075_ _06110_ _06123_ _06124_ VGND VGND VPWR VPWR _06125_ sky130_fd_sc_hd__a21o_1
XFILLER_0_22_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12287_ _03115_ _03116_ _03117_ VGND VGND VPWR VPWR _03119_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_121_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14026_ _04965_ _04970_ VGND VGND VPWR VPWR _04971_ sky130_fd_sc_hd__xor2_1
X_11238_ prev_d_error\[8\] net130 VGND VGND VPWR VPWR _02049_ sky130_fd_sc_hd__nand2_1
X_11169_ net403 net137 _01874_ _01875_ VGND VGND VPWR VPWR _01980_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_93_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15977_ _07115_ _07116_ VGND VGND VPWR VPWR _07117_ sky130_fd_sc_hd__and2_1
XFILLER_0_89_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14928_ net260 _05584_ VGND VGND VPWR VPWR _05963_ sky130_fd_sc_hd__nand2_1
XFILLER_0_117_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14859_ _05883_ _05886_ VGND VGND VPWR VPWR _05887_ sky130_fd_sc_hd__xor2_1
XFILLER_0_148_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16529_ _05421_ _05422_ _05466_ _01457_ VGND VGND VPWR VPWR _07724_ sky130_fd_sc_hd__a31o_1
XFILLER_0_42_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09001_ net317 _04934_ VGND VGND VPWR VPWR _06056_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09903_ _00619_ _00707_ _00708_ _00713_ VGND VGND VPWR VPWR _00714_ sky130_fd_sc_hd__a31o_1
XFILLER_0_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09834_ _00642_ _00644_ VGND VGND VPWR VPWR _00645_ sky130_fd_sc_hd__and2b_1
X_09765_ _00389_ _00573_ _00574_ _00575_ VGND VGND VPWR VPWR _00576_ sky130_fd_sc_hd__o22a_1
X_08716_ net43 _02894_ _02927_ net120 VGND VGND VPWR VPWR _00023_ sky130_fd_sc_hd__a22o_1
X_09696_ net327 _08677_ _00362_ VGND VGND VPWR VPWR _00507_ sky130_fd_sc_hd__and3_1
Xrebuffer30 _06642_ VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_68_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10540_ net372 net368 _00652_ _00518_ VGND VGND VPWR VPWR _01351_ sky130_fd_sc_hd__and4_1
XFILLER_0_64_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10471_ _01233_ _01278_ _01273_ _01277_ VGND VGND VPWR VPWR _01282_ sky130_fd_sc_hd__o211a_1
XFILLER_0_106_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12210_ _03002_ _03004_ _03035_ _03001_ _02972_ VGND VGND VPWR VPWR _03036_ sky130_fd_sc_hd__o32a_1
XFILLER_0_32_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13190_ _04028_ _04036_ _04037_ VGND VGND VPWR VPWR _04051_ sky130_fd_sc_hd__and3_1
X_12141_ _02962_ _02956_ _02960_ VGND VGND VPWR VPWR _02966_ sky130_fd_sc_hd__and3_1
XFILLER_0_20_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12072_ _02815_ _02892_ VGND VGND VPWR VPWR _02893_ sky130_fd_sc_hd__nor2_1
X_15900_ _07011_ _07031_ VGND VGND VPWR VPWR _07032_ sky130_fd_sc_hd__and2b_1
X_11023_ _01832_ _01833_ VGND VGND VPWR VPWR _01834_ sky130_fd_sc_hd__or2_1
X_16880_ _05255_ _05288_ VGND VGND VPWR VPWR _08110_ sky130_fd_sc_hd__xnor2_2
X_15831_ _06927_ _06928_ VGND VGND VPWR VPWR _06956_ sky130_fd_sc_hd__xnor2_1
X_15762_ _06855_ _06863_ _06861_ VGND VGND VPWR VPWR _06880_ sky130_fd_sc_hd__a21o_1
X_12974_ _03811_ _03816_ _03817_ VGND VGND VPWR VPWR _03818_ sky130_fd_sc_hd__a21o_1
X_17501_ clknet_4_6_0_clock _00044_ VGND VGND VPWR VPWR ki\[17\] sky130_fd_sc_hd__dfxtp_2
X_14713_ net269 _05703_ VGND VGND VPWR VPWR _05727_ sky130_fd_sc_hd__nand2_1
X_11925_ _02730_ _02735_ VGND VGND VPWR VPWR _02736_ sky130_fd_sc_hd__and2_1
X_15693_ _06799_ _06803_ VGND VGND VPWR VPWR _06805_ sky130_fd_sc_hd__nand2b_1
X_17432_ clknet_4_9_0_clock _00110_ VGND VGND VPWR VPWR i_error\[2\] sky130_fd_sc_hd__dfxtp_1
X_14644_ _05648_ _05650_ VGND VGND VPWR VPWR _05651_ sky130_fd_sc_hd__and2_1
X_11856_ _02665_ _02666_ net404 net170 VGND VGND VPWR VPWR _02667_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_55_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10807_ net381 net125 net121 net385 VGND VGND VPWR VPWR _01618_ sky130_fd_sc_hd__a22o_1
X_14575_ net522 _05571_ _05573_ _05574_ VGND VGND VPWR VPWR _05575_ sky130_fd_sc_hd__a211oi_2
X_17363_ _03878_ _08068_ _08584_ net456 VGND VGND VPWR VPWR _00128_ sky130_fd_sc_hd__o211a_1
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11787_ _02596_ _02597_ VGND VGND VPWR VPWR _02598_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16314_ _07183_ _07484_ _07485_ _07487_ VGND VGND VPWR VPWR _07488_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_83_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13526_ _04349_ _04348_ VGND VGND VPWR VPWR _04421_ sky130_fd_sc_hd__and2b_1
X_10738_ _01502_ _01548_ VGND VGND VPWR VPWR _01549_ sky130_fd_sc_hd__or2_1
X_17294_ _08536_ _08677_ _08542_ net460 VGND VGND VPWR VPWR _00095_ sky130_fd_sc_hd__o211a_1
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16245_ _07407_ _07410_ net100 _07411_ VGND VGND VPWR VPWR _07412_ sky130_fd_sc_hd__a211oi_2
X_13457_ _04220_ _04217_ _04218_ VGND VGND VPWR VPWR _04345_ sky130_fd_sc_hd__and3_1
X_10669_ _01466_ _01479_ VGND VGND VPWR VPWR _01480_ sky130_fd_sc_hd__nor2_2
XFILLER_0_113_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_124_Right_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12408_ _03185_ _03239_ VGND VGND VPWR VPWR _03240_ sky130_fd_sc_hd__and2_2
X_16176_ _07292_ _07335_ VGND VGND VPWR VPWR _07336_ sky130_fd_sc_hd__and2b_1
X_13388_ net179 _04108_ _04268_ _04266_ VGND VGND VPWR VPWR _04269_ sky130_fd_sc_hd__a31o_1
XFILLER_0_23_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12339_ _01937_ _03170_ VGND VGND VPWR VPWR _03171_ sky130_fd_sc_hd__and2_1
X_15127_ _06150_ _06180_ _06181_ VGND VGND VPWR VPWR _06182_ sky130_fd_sc_hd__nand3_1
XFILLER_0_10_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15058_ _06102_ _06104_ _06105_ VGND VGND VPWR VPWR _06106_ sky130_fd_sc_hd__nand3b_2
X_14009_ _04950_ _04951_ VGND VGND VPWR VPWR _04952_ sky130_fd_sc_hd__nor2_1
X_09550_ _00321_ _00308_ VGND VGND VPWR VPWR _00361_ sky130_fd_sc_hd__xor2_1
X_09481_ _00288_ _00291_ VGND VGND VPWR VPWR _00292_ sky130_fd_sc_hd__nor2_1
XFILLER_0_144_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout300 net303 VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__buf_2
Xfanout311 ki\[0\] VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_100_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout322 net323 VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__clkbuf_4
Xfanout333 net335 VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__clkbuf_4
Xfanout344 net347 VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__clkbuf_4
Xfanout355 kp\[6\] VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__buf_2
Xfanout366 net367 VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__buf_2
Xfanout377 net380 VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__clkbuf_4
X_09817_ _00609_ _00610_ _00623_ _00627_ VGND VGND VPWR VPWR _00628_ sky130_fd_sc_hd__o211ai_4
Xfanout388 prev_d_error\[15\] VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__buf_2
Xfanout399 net400 VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__clkbuf_2
X_09748_ net316 _00520_ VGND VGND VPWR VPWR _00559_ sky130_fd_sc_hd__nand2_1
X_09679_ _04549_ _00489_ VGND VGND VPWR VPWR _00490_ sky130_fd_sc_hd__xnor2_1
X_11710_ _02471_ _02487_ _02520_ VGND VGND VPWR VPWR _02521_ sky130_fd_sc_hd__and3_1
X_12690_ _03527_ _03523_ _03526_ VGND VGND VPWR VPWR _03529_ sky130_fd_sc_hd__nor3_1
XFILLER_0_49_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11641_ _02368_ _02390_ _02389_ VGND VGND VPWR VPWR _02452_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_139_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14360_ _01486_ _05337_ VGND VGND VPWR VPWR _05338_ sky130_fd_sc_hd__nor2_1
XFILLER_0_64_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11572_ _02358_ _02361_ VGND VGND VPWR VPWR _02383_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13311_ _04160_ _04182_ VGND VGND VPWR VPWR _04184_ sky130_fd_sc_hd__nor2_1
XFILLER_0_18_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput19 measurement[9] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_1
X_10523_ net375 _00314_ _01332_ _01333_ VGND VGND VPWR VPWR _01334_ sky130_fd_sc_hd__and4_1
X_14291_ _04651_ _05174_ VGND VGND VPWR VPWR _05262_ sky130_fd_sc_hd__xor2_4
XFILLER_0_150_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16030_ _07160_ _07173_ _07174_ _07108_ VGND VGND VPWR VPWR _07175_ sky130_fd_sc_hd__o211ai_2
X_13242_ _04107_ VGND VGND VPWR VPWR _04108_ sky130_fd_sc_hd__clkbuf_4
X_10454_ _01213_ _01264_ VGND VGND VPWR VPWR _01265_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_150_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13173_ net219 _03216_ VGND VGND VPWR VPWR _04033_ sky130_fd_sc_hd__nand2_2
XFILLER_0_0_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10385_ _01187_ _01194_ _01195_ VGND VGND VPWR VPWR _01196_ sky130_fd_sc_hd__a21bo_1
X_12124_ net424 net165 VGND VGND VPWR VPWR _02949_ sky130_fd_sc_hd__nand2_1
XFILLER_0_102_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16932_ _07850_ VGND VGND VPWR VPWR _08167_ sky130_fd_sc_hd__inv_2
X_12055_ _02873_ _02874_ VGND VGND VPWR VPWR _02875_ sky130_fd_sc_hd__nor2_1
X_11006_ _01813_ _01797_ _01815_ VGND VGND VPWR VPWR _01817_ sky130_fd_sc_hd__nand3_1
X_16863_ _08087_ net493 _05444_ VGND VGND VPWR VPWR _08092_ sky130_fd_sc_hd__o21ai_1
X_15814_ net302 net298 _05589_ _05581_ VGND VGND VPWR VPWR _06938_ sky130_fd_sc_hd__nand4_2
X_16794_ net474 _07976_ _07984_ _08011_ _08015_ VGND VGND VPWR VPWR _08016_ sky130_fd_sc_hd__a221o_1
X_15745_ _06856_ _06857_ _06860_ VGND VGND VPWR VPWR _06862_ sky130_fd_sc_hd__and3_1
X_12957_ _03747_ _03756_ _03757_ VGND VGND VPWR VPWR _03801_ sky130_fd_sc_hd__or3_1
XFILLER_0_75_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11908_ _02645_ _02718_ VGND VGND VPWR VPWR _02719_ sky130_fd_sc_hd__and2_1
X_15676_ _06781_ _06784_ _06785_ VGND VGND VPWR VPWR _06786_ sky130_fd_sc_hd__nand3_2
X_12888_ _03728_ _03731_ VGND VGND VPWR VPWR _03732_ sky130_fd_sc_hd__nand2_1
X_17415_ clknet_4_0_0_clock _00093_ VGND VGND VPWR VPWR prev_error\[3\] sky130_fd_sc_hd__dfxtp_1
X_14627_ _05598_ _05586_ _03267_ _05599_ VGND VGND VPWR VPWR _05632_ sky130_fd_sc_hd__and4_1
X_11839_ _02648_ _02649_ net426 net147 VGND VGND VPWR VPWR _02650_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_23_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17346_ net470 i_error\[12\] VGND VGND VPWR VPWR _08575_ sky130_fd_sc_hd__or2_1
XFILLER_0_128_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14558_ _05421_ _05467_ _01457_ VGND VGND VPWR VPWR _05556_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_83_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13509_ _04295_ _04396_ _04401_ VGND VGND VPWR VPWR _04402_ sky130_fd_sc_hd__nand3_1
XFILLER_0_71_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17277_ _08527_ _08531_ VGND VGND VPWR VPWR _00087_ sky130_fd_sc_hd__nor2_1
X_14489_ _05478_ _05479_ VGND VGND VPWR VPWR _05480_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16228_ _07385_ _07392_ VGND VGND VPWR VPWR _07393_ sky130_fd_sc_hd__nor2_1
XFILLER_0_130_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16159_ _07311_ _07316_ VGND VGND VPWR VPWR _07317_ sky130_fd_sc_hd__xor2_1
XFILLER_0_100_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_39_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08981_ net340 _05418_ VGND VGND VPWR VPWR _05836_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09602_ _00302_ _00323_ VGND VGND VPWR VPWR _00413_ sky130_fd_sc_hd__xor2_1
X_09533_ net369 net364 net520 _05638_ VGND VGND VPWR VPWR _00344_ sky130_fd_sc_hd__and4_1
XFILLER_0_3_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09464_ _00197_ _00200_ VGND VGND VPWR VPWR _00275_ sky130_fd_sc_hd__xor2_2
XFILLER_0_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09395_ _00192_ _00204_ _00205_ VGND VGND VPWR VPWR _00206_ sky130_fd_sc_hd__o21a_1
XFILLER_0_65_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10170_ net345 _00243_ _00979_ _00980_ VGND VGND VPWR VPWR _00981_ sky130_fd_sc_hd__a31o_1
XFILLER_0_100_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout130 net132 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__buf_2
Xfanout141 kd_2\[9\] VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__clkbuf_4
Xfanout152 net153 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__clkbuf_4
Xfanout163 kd_2\[3\] VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__clkbuf_4
Xfanout174 kd_2\[0\] VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__buf_2
Xfanout185 net187 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__buf_2
Xfanout196 kd_1\[12\] VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__clkbuf_2
X_13860_ _04786_ _04787_ VGND VGND VPWR VPWR _04788_ sky130_fd_sc_hd__and2b_1
XFILLER_0_69_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12811_ net195 _03234_ _03250_ net190 VGND VGND VPWR VPWR _03655_ sky130_fd_sc_hd__a22oi_1
X_13791_ _04668_ _04711_ VGND VGND VPWR VPWR _04712_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15530_ net274 _05603_ _05589_ net278 VGND VGND VPWR VPWR _06625_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_96_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12742_ _03570_ _03571_ VGND VGND VPWR VPWR _03585_ sky130_fd_sc_hd__xor2_1
XFILLER_0_84_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12673_ _03434_ _03511_ VGND VGND VPWR VPWR _03512_ sky130_fd_sc_hd__nor2_1
X_15461_ _06547_ _06548_ VGND VGND VPWR VPWR _06549_ sky130_fd_sc_hd__xnor2_2
X_17200_ _08461_ VGND VGND VPWR VPWR _08462_ sky130_fd_sc_hd__buf_8
X_14412_ _03434_ _05393_ VGND VGND VPWR VPWR _05395_ sky130_fd_sc_hd__and2_1
X_11624_ _02418_ _02432_ _02434_ VGND VGND VPWR VPWR _02435_ sky130_fd_sc_hd__and3_1
X_15392_ net296 _05719_ _05734_ VGND VGND VPWR VPWR _06473_ sky130_fd_sc_hd__and3_1
XFILLER_0_142_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17131_ net186 _03372_ VGND VGND VPWR VPWR _08386_ sky130_fd_sc_hd__nand2_1
XFILLER_0_107_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11555_ _02272_ _02365_ VGND VGND VPWR VPWR _02366_ sky130_fd_sc_hd__nand2_1
X_14343_ _01673_ _01676_ _05318_ VGND VGND VPWR VPWR _05320_ sky130_fd_sc_hd__a21o_1
X_10506_ _01290_ _01315_ VGND VGND VPWR VPWR _01317_ sky130_fd_sc_hd__xnor2_1
X_14274_ _05241_ _05243_ VGND VGND VPWR VPWR _05244_ sky130_fd_sc_hd__nor2_2
X_17062_ _01679_ _05325_ _05323_ VGND VGND VPWR VPWR _08310_ sky130_fd_sc_hd__o21ai_1
X_11486_ _02275_ _02296_ VGND VGND VPWR VPWR _02297_ sky130_fd_sc_hd__or2_1
XFILLER_0_21_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16013_ _07149_ _07155_ VGND VGND VPWR VPWR _07157_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_123_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13225_ _04061_ _04088_ VGND VGND VPWR VPWR _04090_ sky130_fd_sc_hd__nor2_1
X_10437_ _01247_ _01246_ _07915_ VGND VGND VPWR VPWR _01248_ sky130_fd_sc_hd__or3b_1
XFILLER_0_150_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13156_ _03939_ _03938_ VGND VGND VPWR VPWR _04014_ sky130_fd_sc_hd__and2_1
X_10368_ _01132_ _01133_ VGND VGND VPWR VPWR _01179_ sky130_fd_sc_hd__nor2_1
X_12107_ _02901_ _02915_ _02931_ VGND VGND VPWR VPWR _02932_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13087_ net178 _03793_ net519 net182 VGND VGND VPWR VPWR _03938_ sky130_fd_sc_hd__a22o_1
X_10299_ _01076_ _01109_ VGND VGND VPWR VPWR _01110_ sky130_fd_sc_hd__xnor2_1
X_16915_ _08145_ _08148_ VGND VGND VPWR VPWR _08149_ sky130_fd_sc_hd__xnor2_2
X_12038_ net416 net420 net165 net169 VGND VGND VPWR VPWR _02856_ sky130_fd_sc_hd__and4_1
X_16846_ _08068_ _08071_ _08072_ VGND VGND VPWR VPWR _08073_ sky130_fd_sc_hd__and3_1
XFILLER_0_125_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16777_ _07787_ _05555_ VGND VGND VPWR VPWR _07997_ sky130_fd_sc_hd__nand2_1
X_13989_ _04924_ _04929_ VGND VGND VPWR VPWR _04930_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15728_ _06696_ _06842_ VGND VGND VPWR VPWR _06843_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15659_ _06470_ _06471_ _06489_ _06490_ VGND VGND VPWR VPWR _06767_ sky130_fd_sc_hd__o211a_1
XFILLER_0_146_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09180_ _07992_ _08014_ VGND VGND VPWR VPWR _08025_ sky130_fd_sc_hd__and2b_1
XFILLER_0_141_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17329_ _03878_ VGND VGND VPWR VPWR _08564_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08964_ _05638_ VGND VGND VPWR VPWR _05649_ sky130_fd_sc_hd__buf_2
X_08895_ _04703_ _04868_ _04857_ VGND VGND VPWR VPWR _04890_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_75_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09516_ _00300_ _00301_ _00326_ VGND VGND VPWR VPWR _00327_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_39_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09447_ _00256_ _00257_ VGND VGND VPWR VPWR _00258_ sky130_fd_sc_hd__and2_1
XFILLER_0_94_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09378_ _00186_ _00187_ _00188_ VGND VGND VPWR VPWR _00189_ sky130_fd_sc_hd__and3_1
XFILLER_0_35_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11340_ net414 net136 VGND VGND VPWR VPWR _02151_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11271_ _02079_ _02081_ _02077_ VGND VGND VPWR VPWR _02082_ sky130_fd_sc_hd__a21oi_2
X_13010_ _03429_ _03852_ _03853_ VGND VGND VPWR VPWR _03854_ sky130_fd_sc_hd__a21o_1
XFILLER_0_132_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10222_ _01027_ _01030_ _00955_ _01006_ VGND VGND VPWR VPWR _01033_ sky130_fd_sc_hd__a211oi_1
X_10153_ _00958_ _00962_ _00931_ _00932_ VGND VGND VPWR VPWR _00964_ sky130_fd_sc_hd__a211o_1
XFILLER_0_100_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14961_ net95 _05997_ _05961_ _05996_ VGND VGND VPWR VPWR _05999_ sky130_fd_sc_hd__o211ai_4
X_10084_ _00892_ _00894_ VGND VGND VPWR VPWR _00895_ sky130_fd_sc_hd__or2b_1
X_16700_ _07911_ _07570_ _07657_ _07720_ VGND VGND VPWR VPWR _07912_ sky130_fd_sc_hd__a31o_2
X_13912_ net206 net202 _04317_ _04108_ VGND VGND VPWR VPWR _04845_ sky130_fd_sc_hd__and4_1
X_14892_ net277 _05801_ _05922_ VGND VGND VPWR VPWR _05923_ sky130_fd_sc_hd__and3_1
X_16631_ _07807_ _05463_ VGND VGND VPWR VPWR _07836_ sky130_fd_sc_hd__nor2_1
X_13843_ _04766_ _04768_ VGND VGND VPWR VPWR _04770_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16562_ _07753_ _07759_ VGND VGND VPWR VPWR _07760_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13774_ _04641_ _04644_ _04643_ VGND VGND VPWR VPWR _04694_ sky130_fd_sc_hd__o21ai_1
X_10986_ _01791_ _01793_ _01796_ VGND VGND VPWR VPWR _01797_ sky130_fd_sc_hd__o21ai_2
X_15513_ net274 _05665_ _05974_ net271 VGND VGND VPWR VPWR _06607_ sky130_fd_sc_hd__a22oi_2
X_12725_ _03275_ _03259_ VGND VGND VPWR VPWR _03567_ sky130_fd_sc_hd__xor2_1
X_16493_ _07546_ _07683_ VGND VGND VPWR VPWR _07685_ sky130_fd_sc_hd__nand2_2
X_15444_ _06506_ _06530_ VGND VGND VPWR VPWR _06531_ sky130_fd_sc_hd__xor2_1
X_12656_ _03477_ _03494_ VGND VGND VPWR VPWR _03495_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_26_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11607_ _02408_ _02415_ _02417_ VGND VGND VPWR VPWR _02418_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15375_ net256 _06017_ VGND VGND VPWR VPWR _06455_ sky130_fd_sc_hd__nand2_1
X_12587_ _03423_ _03425_ VGND VGND VPWR VPWR _03426_ sky130_fd_sc_hd__nor2_2
XFILLER_0_25_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17114_ _08363_ _08365_ VGND VGND VPWR VPWR _08368_ sky130_fd_sc_hd__and2_1
XFILLER_0_142_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14326_ _05216_ _05221_ _05299_ _05300_ VGND VGND VPWR VPWR _05301_ sky130_fd_sc_hd__a31oi_4
XFILLER_0_25_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11538_ _02347_ _02348_ VGND VGND VPWR VPWR _02349_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17045_ _03427_ _05394_ _08291_ VGND VGND VPWR VPWR _08292_ sky130_fd_sc_hd__o21a_1
XFILLER_0_150_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11469_ net395 net159 _02278_ _02279_ VGND VGND VPWR VPWR _02280_ sky130_fd_sc_hd__a31o_1
XFILLER_0_123_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14257_ _03165_ _05224_ VGND VGND VPWR VPWR _05225_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13208_ _03429_ _03964_ VGND VGND VPWR VPWR _04071_ sky130_fd_sc_hd__xor2_1
XFILLER_0_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14188_ _05145_ _05148_ VGND VGND VPWR VPWR _05149_ sky130_fd_sc_hd__xnor2_1
X_13139_ _03982_ _03984_ VGND VGND VPWR VPWR _03995_ sky130_fd_sc_hd__xor2_2
X_16829_ _08017_ _08053_ _08033_ VGND VGND VPWR VPWR _08054_ sky130_fd_sc_hd__mux2_1
X_09301_ net322 _07420_ _08664_ VGND VGND VPWR VPWR _08665_ sky130_fd_sc_hd__and3_1
XFILLER_0_75_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09232_ net344 _05022_ VGND VGND VPWR VPWR _08560_ sky130_fd_sc_hd__nand2_1
XFILLER_0_146_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09163_ net322 _04626_ _07827_ VGND VGND VPWR VPWR _07838_ sky130_fd_sc_hd__and3_1
XFILLER_0_44_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09094_ _06562_ _06584_ VGND VGND VPWR VPWR _07079_ sky130_fd_sc_hd__xor2_1
XFILLER_0_4_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09996_ _00720_ _00719_ _00692_ VGND VGND VPWR VPWR _00807_ sky130_fd_sc_hd__o21ai_1
X_08947_ net352 net348 _05418_ VGND VGND VPWR VPWR _05462_ sky130_fd_sc_hd__o21ai_1
X_08878_ net61 net6 VGND VGND VPWR VPWR _04703_ sky130_fd_sc_hd__and2b_4
XFILLER_0_99_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10840_ _01487_ _01521_ _01480_ VGND VGND VPWR VPWR _01651_ sky130_fd_sc_hd__a21o_1
X_10771_ _01579_ _01581_ VGND VGND VPWR VPWR _01582_ sky130_fd_sc_hd__nor2_1
XFILLER_0_149_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12510_ _03343_ _03347_ VGND VGND VPWR VPWR _03348_ sky130_fd_sc_hd__nor2_1
X_13490_ _04377_ _04380_ VGND VGND VPWR VPWR _04381_ sky130_fd_sc_hd__or2b_2
XFILLER_0_137_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12441_ _03262_ _03272_ VGND VGND VPWR VPWR _03273_ sky130_fd_sc_hd__and2_1
XFILLER_0_105_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15160_ _06215_ _06216_ _06113_ _06217_ VGND VGND VPWR VPWR _06218_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_62_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12372_ _03193_ _03195_ _03202_ _03203_ VGND VGND VPWR VPWR _03204_ sky130_fd_sc_hd__a31o_2
XFILLER_0_90_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14111_ net226 _04315_ _03792_ net244 VGND VGND VPWR VPWR _05064_ sky130_fd_sc_hd__a22o_1
XFILLER_0_105_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11323_ _02129_ _02131_ _02133_ VGND VGND VPWR VPWR _02134_ sky130_fd_sc_hd__o21ai_1
X_15091_ _06117_ _06121_ _06141_ VGND VGND VPWR VPWR _06142_ sky130_fd_sc_hd__a21o_1
XFILLER_0_120_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14042_ _04984_ _04987_ VGND VGND VPWR VPWR _04988_ sky130_fd_sc_hd__or2_1
X_11254_ _02062_ _02064_ VGND VGND VPWR VPWR _02065_ sky130_fd_sc_hd__or2b_1
X_10205_ _00974_ _01015_ VGND VGND VPWR VPWR _01016_ sky130_fd_sc_hd__or2_1
XFILLER_0_120_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11185_ net398 net142 net147 net395 VGND VGND VPWR VPWR _01996_ sky130_fd_sc_hd__a22oi_1
X_10136_ _00906_ _00912_ VGND VGND VPWR VPWR _00947_ sky130_fd_sc_hd__and2_1
X_15993_ _07132_ _07133_ VGND VGND VPWR VPWR _07135_ sky130_fd_sc_hd__or2_1
X_14944_ _05966_ _05970_ VGND VGND VPWR VPWR _05981_ sky130_fd_sc_hd__xor2_1
X_10067_ _00838_ _00877_ VGND VGND VPWR VPWR _00878_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14875_ _05903_ _05904_ VGND VGND VPWR VPWR _05905_ sky130_fd_sc_hd__or2b_1
XFILLER_0_15_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16614_ i_error\[7\] _07601_ VGND VGND VPWR VPWR _07818_ sky130_fd_sc_hd__nor2_1
X_13826_ _04746_ _04749_ VGND VGND VPWR VPWR _04751_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_106_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16545_ _07648_ _07741_ VGND VGND VPWR VPWR _07742_ sky130_fd_sc_hd__xor2_2
XFILLER_0_85_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13757_ _04592_ _04674_ VGND VGND VPWR VPWR _04675_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10969_ _01753_ _01778_ _01779_ VGND VGND VPWR VPWR _01780_ sky130_fd_sc_hd__or3_2
XFILLER_0_57_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12708_ _03546_ _03547_ VGND VGND VPWR VPWR _03548_ sky130_fd_sc_hd__and2_1
XFILLER_0_85_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16476_ net248 _05739_ _05801_ net251 VGND VGND VPWR VPWR _07666_ sky130_fd_sc_hd__a22oi_1
X_13688_ _04525_ _04524_ VGND VGND VPWR VPWR _04599_ sky130_fd_sc_hd__and2b_1
XFILLER_0_127_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15427_ net305 _05721_ _05722_ VGND VGND VPWR VPWR _06512_ sky130_fd_sc_hd__and3_1
X_12639_ _03403_ _03408_ VGND VGND VPWR VPWR _03478_ sky130_fd_sc_hd__nor2_1
XFILLER_0_109_870 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15358_ _06302_ _06304_ VGND VGND VPWR VPWR _06436_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_53_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14309_ _05265_ _05266_ VGND VGND VPWR VPWR _05282_ sky130_fd_sc_hd__or2_1
XFILLER_0_111_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15289_ _06212_ _06359_ VGND VGND VPWR VPWR _06360_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17028_ _08262_ _08272_ VGND VGND VPWR VPWR _08273_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_111_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09850_ net378 _05605_ _05616_ net361 _04428_ VGND VGND VPWR VPWR _00661_ sky130_fd_sc_hd__a32o_1
XFILLER_0_0_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08801_ net54 _02883_ _02916_ net145 VGND VGND VPWR VPWR _00034_ sky130_fd_sc_hd__a22o_1
X_09781_ net324 _00243_ VGND VGND VPWR VPWR _00592_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08732_ net51 _03061_ _03094_ kd_1\[5\] VGND VGND VPWR VPWR _00013_ sky130_fd_sc_hd__a22o_1
XFILLER_0_147_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_871 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_138_Right_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_12_0_clock clknet_0_clock VGND VGND VPWR VPWR clknet_4_12_0_clock sky130_fd_sc_hd__clkbuf_8
XFILLER_0_118_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09215_ _08344_ _08377_ VGND VGND VPWR VPWR _08410_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09146_ _07629_ _07640_ VGND VGND VPWR VPWR _07651_ sky130_fd_sc_hd__and2_1
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09077_ net321 _05726_ _06881_ VGND VGND VPWR VPWR _06892_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_31_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09979_ _00648_ _00650_ VGND VGND VPWR VPWR _00790_ sky130_fd_sc_hd__nor2_1
X_12990_ _03818_ _03804_ VGND VGND VPWR VPWR _03834_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11941_ _02740_ _02751_ _02672_ VGND VGND VPWR VPWR _02752_ sky130_fd_sc_hd__o21ai_1
X_14660_ _05595_ _05666_ _05667_ VGND VGND VPWR VPWR _05668_ sky130_fd_sc_hd__or3b_1
X_11872_ net437 net139 net142 net434 VGND VGND VPWR VPWR _02683_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_129_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13611_ _04512_ _04513_ VGND VGND VPWR VPWR _04514_ sky130_fd_sc_hd__nand2_1
XFILLER_0_95_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10823_ _01511_ _01516_ VGND VGND VPWR VPWR _01634_ sky130_fd_sc_hd__and2b_1
X_14591_ _05585_ _05591_ VGND VGND VPWR VPWR _05592_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_105_Right_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16330_ _06091_ _06191_ _07502_ _07503_ _07504_ VGND VGND VPWR VPWR _07505_ sky130_fd_sc_hd__a311oi_2
XFILLER_0_27_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13542_ _04308_ _04322_ VGND VGND VPWR VPWR _04438_ sky130_fd_sc_hd__nor2_1
X_10754_ _01560_ _01564_ VGND VGND VPWR VPWR _01565_ sky130_fd_sc_hd__or2_1
XFILLER_0_39_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16261_ net294 _04313_ _06162_ net310 VGND VGND VPWR VPWR _07429_ sky130_fd_sc_hd__a22oi_1
X_13473_ _04359_ _04361_ VGND VGND VPWR VPWR _04363_ sky130_fd_sc_hd__xor2_4
X_10685_ _01492_ _01495_ VGND VGND VPWR VPWR _01496_ sky130_fd_sc_hd__xor2_1
X_15212_ _06271_ _06268_ VGND VGND VPWR VPWR _06275_ sky130_fd_sc_hd__or2b_1
X_12424_ _03254_ _03255_ VGND VGND VPWR VPWR _03256_ sky130_fd_sc_hd__nor2_1
X_16192_ net307 _06160_ VGND VGND VPWR VPWR _07353_ sky130_fd_sc_hd__nand2_1
XFILLER_0_63_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15143_ _05595_ _06162_ _06164_ VGND VGND VPWR VPWR _06200_ sky130_fd_sc_hd__o21bai_1
X_12355_ prev_error\[7\] VGND VGND VPWR VPWR _03187_ sky130_fd_sc_hd__inv_2
XFILLER_0_50_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11306_ _02114_ _02116_ VGND VGND VPWR VPWR _02117_ sky130_fd_sc_hd__nor2_1
X_15074_ _05841_ _06108_ _06109_ VGND VGND VPWR VPWR _06124_ sky130_fd_sc_hd__o21a_1
X_12286_ _03115_ _03116_ _03117_ VGND VGND VPWR VPWR _03118_ sky130_fd_sc_hd__and3_1
XFILLER_0_132_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14025_ net239 _03750_ _04969_ _04966_ VGND VGND VPWR VPWR _04970_ sky130_fd_sc_hd__a31o_1
X_11237_ net423 net126 VGND VGND VPWR VPWR _02048_ sky130_fd_sc_hd__nand2_1
X_11168_ _01976_ _01978_ VGND VGND VPWR VPWR _01979_ sky130_fd_sc_hd__nor2_1
X_10119_ _00915_ _00927_ _00929_ VGND VGND VPWR VPWR _00930_ sky130_fd_sc_hd__a21oi_2
X_15976_ _07114_ _07104_ _07113_ VGND VGND VPWR VPWR _07116_ sky130_fd_sc_hd__or3_1
X_11099_ _01825_ _01850_ _01849_ VGND VGND VPWR VPWR _01910_ sky130_fd_sc_hd__o21a_1
X_14927_ net262 _05621_ VGND VGND VPWR VPWR _05962_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14858_ _05884_ _05885_ VGND VGND VPWR VPWR _05886_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_11_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13809_ _04665_ _04581_ _04664_ VGND VGND VPWR VPWR _04732_ sky130_fd_sc_hd__o21a_1
X_14789_ net255 _05749_ _05808_ VGND VGND VPWR VPWR _05810_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_58_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16528_ _01457_ _05421_ _05422_ _05466_ VGND VGND VPWR VPWR _07723_ sky130_fd_sc_hd__nand4_2
XFILLER_0_73_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16459_ _07602_ _07642_ _07646_ _07597_ _07584_ VGND VGND VPWR VPWR _07647_ sky130_fd_sc_hd__a2111o_1
X_09000_ _04560_ _04450_ VGND VGND VPWR VPWR _06045_ sky130_fd_sc_hd__nor2_1
XFILLER_0_116_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_843 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_20_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09902_ _00709_ _00711_ _00712_ VGND VGND VPWR VPWR _00713_ sky130_fd_sc_hd__and3_1
XFILLER_0_6_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09833_ net331 _00242_ _00643_ VGND VGND VPWR VPWR _00644_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_67_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09764_ net352 _04505_ _04428_ net357 VGND VGND VPWR VPWR _00575_ sky130_fd_sc_hd__a22oi_2
X_08715_ net42 _02894_ _02927_ net122 VGND VGND VPWR VPWR _00022_ sky130_fd_sc_hd__a22o_1
X_09695_ net327 _08677_ _00362_ VGND VGND VPWR VPWR _00506_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10470_ _01280_ _01257_ VGND VGND VPWR VPWR _01281_ sky130_fd_sc_hd__xor2_1
XFILLER_0_134_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09129_ net329 net325 _04450_ _04769_ VGND VGND VPWR VPWR _07464_ sky130_fd_sc_hd__and4_1
XFILLER_0_115_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12140_ _02866_ _02964_ VGND VGND VPWR VPWR _02965_ sky130_fd_sc_hd__or2_1
XFILLER_0_102_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12071_ net442 net145 _02813_ _02814_ VGND VGND VPWR VPWR _02892_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11022_ net387 net149 net151 net383 VGND VGND VPWR VPWR _01833_ sky130_fd_sc_hd__a22oi_1
X_15830_ _06949_ _06953_ _06838_ _06954_ VGND VGND VPWR VPWR _06955_ sky130_fd_sc_hd__o211a_4
X_15761_ _06876_ _06878_ VGND VGND VPWR VPWR _06879_ sky130_fd_sc_hd__nand2_1
X_12973_ _03808_ _03810_ VGND VGND VPWR VPWR _03817_ sky130_fd_sc_hd__and2b_1
X_17500_ clknet_4_12_0_clock _00043_ VGND VGND VPWR VPWR ki\[16\] sky130_fd_sc_hd__dfxtp_1
X_14712_ net265 _05724_ VGND VGND VPWR VPWR _05725_ sky130_fd_sc_hd__nand2_1
X_11924_ _02725_ _02727_ _02729_ VGND VGND VPWR VPWR _02735_ sky130_fd_sc_hd__or3_1
X_15692_ _06800_ _06802_ VGND VGND VPWR VPWR _06803_ sky130_fd_sc_hd__xor2_1
X_17431_ clknet_4_14_0_clock _00109_ VGND VGND VPWR VPWR i_error\[1\] sky130_fd_sc_hd__dfxtp_1
X_14643_ _05641_ _05647_ VGND VGND VPWR VPWR _05650_ sky130_fd_sc_hd__or2_1
XFILLER_0_129_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11855_ net411 net163 net167 net409 VGND VGND VPWR VPWR _02666_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_28_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17362_ net466 net438 VGND VGND VPWR VPWR _08584_ sky130_fd_sc_hd__or2_1
X_10806_ net381 net385 net125 net121 VGND VGND VPWR VPWR _01617_ sky130_fd_sc_hd__and4_1
X_14574_ prev_error\[7\] _07915_ VGND VGND VPWR VPWR _05574_ sky130_fd_sc_hd__and2_1
X_11786_ _02548_ _02547_ VGND VGND VPWR VPWR _02597_ sky130_fd_sc_hd__and2b_1
XFILLER_0_94_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16313_ _07124_ _07127_ VGND VGND VPWR VPWR _07487_ sky130_fd_sc_hd__and2_1
XFILLER_0_137_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13525_ net197 _03751_ VGND VGND VPWR VPWR _04420_ sky130_fd_sc_hd__nand2_1
XFILLER_0_125_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17293_ net462 prev_error\[5\] VGND VGND VPWR VPWR _08542_ sky130_fd_sc_hd__or2_1
X_10737_ _01496_ _01501_ VGND VGND VPWR VPWR _01548_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16244_ _07372_ _07374_ _07373_ VGND VGND VPWR VPWR _07411_ sky130_fd_sc_hd__o21a_1
X_13456_ _04342_ _04343_ VGND VGND VPWR VPWR _04344_ sky130_fd_sc_hd__nand2_1
XFILLER_0_125_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10668_ _01477_ _01478_ VGND VGND VPWR VPWR _01479_ sky130_fd_sc_hd__or2_2
X_12407_ _03184_ _05143_ _05154_ VGND VGND VPWR VPWR _03239_ sky130_fd_sc_hd__nand3_1
XFILLER_0_112_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16175_ _07305_ _07333_ _07334_ VGND VGND VPWR VPWR _07335_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10599_ _01154_ _01157_ _01156_ VGND VGND VPWR VPWR _01410_ sky130_fd_sc_hd__o21ai_1
X_13387_ _04266_ _04267_ VGND VGND VPWR VPWR _04268_ sky130_fd_sc_hd__nor2_1
X_15126_ _06080_ _06149_ _06127_ _06148_ VGND VGND VPWR VPWR _06181_ sky130_fd_sc_hd__a211o_1
X_12338_ _02030_ _03168_ _03169_ VGND VGND VPWR VPWR _03170_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_121_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15057_ _05688_ _05702_ VGND VGND VPWR VPWR _06105_ sky130_fd_sc_hd__nand2_1
X_12269_ _03065_ _03085_ _03086_ _03062_ _03100_ VGND VGND VPWR VPWR _03101_ sky130_fd_sc_hd__a221o_1
X_14008_ net231 _03791_ _03749_ net235 VGND VGND VPWR VPWR _04951_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_128_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15959_ net268 _04314_ _07094_ _07096_ VGND VGND VPWR VPWR _07097_ sky130_fd_sc_hd__a31o_1
X_09480_ net333 _07343_ _00290_ VGND VGND VPWR VPWR _00291_ sky130_fd_sc_hd__and3_1
XFILLER_0_78_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout301 net302 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__clkbuf_4
Xfanout312 kp\[17\] VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__clkbuf_2
Xfanout323 kp\[14\] VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__buf_2
Xfanout334 net335 VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__clkbuf_4
Xfanout345 net347 VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__clkbuf_4
Xfanout356 kp\[5\] VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__clkbuf_4
X_09816_ _00625_ _00626_ VGND VGND VPWR VPWR _00627_ sky130_fd_sc_hd__or2_1
Xfanout367 net368 VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__clkbuf_4
Xfanout378 net380 VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__buf_2
Xfanout389 net390 VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__buf_2
X_09747_ _00556_ _00557_ _00514_ VGND VGND VPWR VPWR _00558_ sky130_fd_sc_hd__or3_1
X_09678_ net364 _04879_ _04890_ VGND VGND VPWR VPWR _00489_ sky130_fd_sc_hd__and3_2
X_11640_ _02437_ _02450_ _02436_ VGND VGND VPWR VPWR _02451_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_65_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11571_ _02370_ _02381_ VGND VGND VPWR VPWR _02382_ sky130_fd_sc_hd__or2_1
XFILLER_0_9_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13310_ _04160_ _04182_ VGND VGND VPWR VPWR _04183_ sky130_fd_sc_hd__and2_1
XFILLER_0_52_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10522_ _01330_ _00557_ _01331_ VGND VGND VPWR VPWR _01333_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_135_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14290_ _03148_ _05260_ VGND VGND VPWR VPWR _05261_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_80_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10453_ net366 _00313_ VGND VGND VPWR VPWR _01264_ sky130_fd_sc_hd__nand2_1
X_13241_ _04106_ VGND VGND VPWR VPWR _04107_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_122_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10384_ _01188_ _01189_ _01193_ VGND VGND VPWR VPWR _01195_ sky130_fd_sc_hd__nand3_1
X_13172_ net216 _03217_ _03222_ net220 VGND VGND VPWR VPWR _04031_ sky130_fd_sc_hd__a22o_1
X_12123_ _02853_ _02852_ VGND VGND VPWR VPWR _02948_ sky130_fd_sc_hd__and2b_1
XFILLER_0_130_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16931_ _07978_ VGND VGND VPWR VPWR _08166_ sky130_fd_sc_hd__inv_2
X_12054_ net442 net146 _02870_ _02871_ VGND VGND VPWR VPWR _02874_ sky130_fd_sc_hd__o2bb2a_1
X_11005_ _01813_ _01797_ _01815_ VGND VGND VPWR VPWR _01816_ sky130_fd_sc_hd__a21o_1
X_16862_ _05444_ _08087_ _08086_ VGND VGND VPWR VPWR _08090_ sky130_fd_sc_hd__or3_4
XFILLER_0_74_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15813_ net297 _05588_ _05581_ net301 VGND VGND VPWR VPWR _06937_ sky130_fd_sc_hd__a22o_1
X_16793_ _07742_ _08013_ VGND VGND VPWR VPWR _08015_ sky130_fd_sc_hd__nor2_1
X_15744_ _06856_ _06857_ _06860_ VGND VGND VPWR VPWR _06861_ sky130_fd_sc_hd__a21oi_1
X_12956_ _03797_ _03799_ VGND VGND VPWR VPWR _03800_ sky130_fd_sc_hd__nand2_1
X_11907_ _02681_ _02716_ _02717_ VGND VGND VPWR VPWR _02718_ sky130_fd_sc_hd__a21bo_1
X_15675_ _06780_ _06779_ _06766_ _06747_ VGND VGND VPWR VPWR _06785_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_23_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12887_ _03730_ VGND VGND VPWR VPWR _03731_ sky130_fd_sc_hd__inv_2
X_17414_ clknet_4_1_0_clock _00092_ VGND VGND VPWR VPWR prev_error\[2\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_28_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14626_ _05630_ VGND VGND VPWR VPWR _05631_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_74_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11838_ net447 net525 net142 net431 VGND VGND VPWR VPWR _02649_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_7_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17345_ net463 i_error\[11\] net452 _08574_ VGND VGND VPWR VPWR _00119_ sky130_fd_sc_hd__o211a_1
XFILLER_0_126_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14557_ _05520_ _05521_ _05553_ _05554_ VGND VGND VPWR VPWR _05555_ sky130_fd_sc_hd__a211o_4
XFILLER_0_56_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11769_ net417 net422 net147 net152 VGND VGND VPWR VPWR _02580_ sky130_fd_sc_hd__and4_1
XFILLER_0_71_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13508_ _04398_ _04400_ VGND VGND VPWR VPWR _04401_ sky130_fd_sc_hd__or2b_1
X_17276_ net468 net511 net457 VGND VGND VPWR VPWR _08531_ sky130_fd_sc_hd__o21ai_1
X_14488_ net317 net314 _05033_ _05726_ VGND VGND VPWR VPWR _05479_ sky130_fd_sc_hd__and4_1
XFILLER_0_125_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16227_ _07384_ _07380_ _07382_ VGND VGND VPWR VPWR _07392_ sky130_fd_sc_hd__nor3_1
XFILLER_0_141_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13439_ net245 net227 _03217_ _03327_ VGND VGND VPWR VPWR _04325_ sky130_fd_sc_hd__and4_1
XFILLER_0_3_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16158_ _07312_ _07313_ _07315_ VGND VGND VPWR VPWR _07316_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_140_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15109_ _06161_ VGND VGND VPWR VPWR _06162_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08980_ _05572_ _05814_ VGND VGND VPWR VPWR _05825_ sky130_fd_sc_hd__or2b_1
X_16089_ _07182_ _07239_ VGND VGND VPWR VPWR _07240_ sky130_fd_sc_hd__nor2_1
XFILLER_0_121_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09601_ _00398_ _00411_ VGND VGND VPWR VPWR _00412_ sky130_fd_sc_hd__or2_1
XFILLER_0_3_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09532_ net373 _05385_ VGND VGND VPWR VPWR _00343_ sky130_fd_sc_hd__nand2_2
XFILLER_0_64_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09463_ net356 _05022_ _00273_ _00272_ VGND VGND VPWR VPWR _00274_ sky130_fd_sc_hd__a31o_1
XFILLER_0_59_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09394_ _08366_ _00169_ VGND VGND VPWR VPWR _00205_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_116_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout120 kd_2\[14\] VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__buf_2
Xfanout131 net133 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__buf_2
Xfanout142 net144 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__clkbuf_4
Xfanout153 kd_2\[6\] VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__clkbuf_4
Xfanout164 kd_2\[3\] VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__buf_2
Xfanout175 kd_2\[0\] VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__buf_2
Xfanout186 net187 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__buf_2
Xfanout197 net201 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__clkbuf_4
X_12810_ net195 net190 _03234_ _03250_ VGND VGND VPWR VPWR _03654_ sky130_fd_sc_hd__and4_1
X_13790_ _04667_ _04666_ VGND VGND VPWR VPWR _04711_ sky130_fd_sc_hd__or2b_1
XFILLER_0_96_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12741_ _03579_ _03583_ _03580_ VGND VGND VPWR VPWR _03584_ sky130_fd_sc_hd__a21oi_1
X_15460_ net285 _05589_ VGND VGND VPWR VPWR _06548_ sky130_fd_sc_hd__nand2_2
X_12672_ _03509_ _03510_ VGND VGND VPWR VPWR _03511_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14411_ _03434_ _05393_ VGND VGND VPWR VPWR _05394_ sky130_fd_sc_hd__nor2_1
X_11623_ _02382_ _02433_ VGND VGND VPWR VPWR _02434_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15391_ _06380_ _06377_ _06379_ VGND VGND VPWR VPWR _06472_ sky130_fd_sc_hd__nand3_1
XFILLER_0_65_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17130_ _08382_ _08384_ VGND VGND VPWR VPWR _08385_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_53_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14342_ _05309_ _05317_ VGND VGND VPWR VPWR _05318_ sky130_fd_sc_hd__xnor2_1
X_11554_ _02268_ _02269_ _02271_ _02251_ VGND VGND VPWR VPWR _02365_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_80_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17061_ _05349_ _05307_ VGND VGND VPWR VPWR _08309_ sky130_fd_sc_hd__and2b_1
X_10505_ _01290_ _01315_ VGND VGND VPWR VPWR _01316_ sky130_fd_sc_hd__nor2_1
XFILLER_0_107_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14273_ _03156_ _02485_ _03154_ VGND VGND VPWR VPWR _05243_ sky130_fd_sc_hd__and3_1
X_11485_ _02274_ _02251_ _02272_ VGND VGND VPWR VPWR _02296_ sky130_fd_sc_hd__and3_1
X_16012_ _07151_ _07154_ VGND VGND VPWR VPWR _07155_ sky130_fd_sc_hd__xor2_1
X_13224_ _04061_ _04088_ VGND VGND VPWR VPWR _04089_ sky130_fd_sc_hd__nand2_1
X_10436_ net362 VGND VGND VPWR VPWR _01247_ sky130_fd_sc_hd__inv_2
XFILLER_0_100_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13155_ _04008_ _04012_ VGND VGND VPWR VPWR _04013_ sky130_fd_sc_hd__or2_1
X_10367_ _01172_ _01177_ VGND VGND VPWR VPWR _01178_ sky130_fd_sc_hd__or2_1
X_12106_ _02929_ _02930_ VGND VGND VPWR VPWR _02931_ sky130_fd_sc_hd__nand2_1
X_10298_ _01102_ _01101_ VGND VGND VPWR VPWR _01109_ sky130_fd_sc_hd__or2b_1
X_13086_ _03263_ _03936_ VGND VGND VPWR VPWR _03937_ sky130_fd_sc_hd__nor2_1
XFILLER_0_18_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16914_ _07986_ _08147_ _08032_ VGND VGND VPWR VPWR _08148_ sky130_fd_sc_hd__mux2_2
X_12037_ net415 net173 VGND VGND VPWR VPWR _02855_ sky130_fd_sc_hd__nand2_1
XFILLER_0_109_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16845_ _07997_ _08041_ VGND VGND VPWR VPWR _08072_ sky130_fd_sc_hd__nand2_1
X_16776_ _07795_ _07975_ VGND VGND VPWR VPWR _07996_ sky130_fd_sc_hd__nor2_1
X_13988_ _04925_ _04928_ VGND VGND VPWR VPWR _04929_ sky130_fd_sc_hd__xnor2_1
X_15727_ net256 _06417_ _06695_ VGND VGND VPWR VPWR _06842_ sky130_fd_sc_hd__a21o_1
X_12939_ net194 _03260_ _03270_ net189 VGND VGND VPWR VPWR _03783_ sky130_fd_sc_hd__a22o_1
XFILLER_0_34_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15658_ _06747_ _06748_ _06758_ VGND VGND VPWR VPWR _06766_ sky130_fd_sc_hd__nand3_1
XFILLER_0_29_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14609_ _05610_ _05611_ VGND VGND VPWR VPWR _05612_ sky130_fd_sc_hd__and2_1
XFILLER_0_8_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15589_ _06614_ _06616_ _06688_ VGND VGND VPWR VPWR _06690_ sky130_fd_sc_hd__o21a_1
XFILLER_0_56_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17328_ _08549_ _08065_ _08563_ net452 VGND VGND VPWR VPWR _00111_ sky130_fd_sc_hd__o211a_1
XFILLER_0_16_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17259_ _08461_ _08495_ _08490_ VGND VGND VPWR VPWR _08518_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_141_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08963_ _05627_ VGND VGND VPWR VPWR _05638_ sky130_fd_sc_hd__clkbuf_4
X_08894_ _04857_ _04703_ _04868_ VGND VGND VPWR VPWR _04879_ sky130_fd_sc_hd__or3_4
XPHY_EDGE_ROW_3_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09515_ _00324_ _00325_ VGND VGND VPWR VPWR _00326_ sky130_fd_sc_hd__nor2_1
XFILLER_0_94_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09446_ _00253_ _00223_ _00255_ VGND VGND VPWR VPWR _00257_ sky130_fd_sc_hd__or3_1
XFILLER_0_109_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09377_ _05308_ _06254_ _05396_ _05649_ VGND VGND VPWR VPWR _00188_ sky130_fd_sc_hd__or4b_1
XFILLER_0_148_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11270_ _01997_ _02080_ VGND VGND VPWR VPWR _02081_ sky130_fd_sc_hd__nor2_1
X_10221_ _01001_ _01003_ VGND VGND VPWR VPWR _01032_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10152_ _00931_ _00932_ _00958_ _00962_ VGND VGND VPWR VPWR _00963_ sky130_fd_sc_hd__o211ai_2
X_14960_ _05961_ _05996_ net95 _05997_ VGND VGND VPWR VPWR _05998_ sky130_fd_sc_hd__a211o_1
X_10083_ _00854_ _00856_ _00893_ VGND VGND VPWR VPWR _00894_ sky130_fd_sc_hd__a21bo_1
X_13911_ _04842_ _04843_ VGND VGND VPWR VPWR _04844_ sky130_fd_sc_hd__xnor2_1
X_14891_ _05920_ _05921_ VGND VGND VPWR VPWR _05922_ sky130_fd_sc_hd__nor2_1
X_16630_ _07833_ _07834_ VGND VGND VPWR VPWR _07835_ sky130_fd_sc_hd__xnor2_2
X_13842_ net241 _03243_ _04766_ _04767_ VGND VGND VPWR VPWR _04768_ sky130_fd_sc_hd__nand4_2
X_16561_ _07758_ VGND VGND VPWR VPWR _07759_ sky130_fd_sc_hd__inv_2
X_13773_ _04689_ _04691_ VGND VGND VPWR VPWR _04693_ sky130_fd_sc_hd__nor2_1
X_10985_ _01467_ _01795_ VGND VGND VPWR VPWR _01796_ sky130_fd_sc_hd__xnor2_1
X_15512_ _06599_ _06604_ VGND VGND VPWR VPWR _06605_ sky130_fd_sc_hd__nor2_1
X_12724_ _03562_ _03565_ VGND VGND VPWR VPWR _03566_ sky130_fd_sc_hd__and2b_1
XFILLER_0_29_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16492_ _05875_ _07543_ VGND VGND VPWR VPWR _07683_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15443_ net296 _06527_ _06528_ VGND VGND VPWR VPWR _06530_ sky130_fd_sc_hd__and3_1
X_12655_ _03492_ _03493_ VGND VGND VPWR VPWR _03494_ sky130_fd_sc_hd__nor2_1
XFILLER_0_127_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11606_ _02353_ _02416_ VGND VGND VPWR VPWR _02417_ sky130_fd_sc_hd__or2_1
XFILLER_0_108_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15374_ _06451_ _06453_ VGND VGND VPWR VPWR _06454_ sky130_fd_sc_hd__or2_1
XFILLER_0_136_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12586_ net222 _03424_ _03369_ VGND VGND VPWR VPWR _03425_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17113_ _08363_ _08365_ VGND VGND VPWR VPWR _08367_ sky130_fd_sc_hd__nor2_1
X_14325_ _05214_ _05215_ VGND VGND VPWR VPWR _05300_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11537_ _02346_ _02342_ _02344_ VGND VGND VPWR VPWR _02348_ sky130_fd_sc_hd__nor3_1
XFILLER_0_20_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17044_ _03434_ _08290_ VGND VGND VPWR VPWR _08291_ sky130_fd_sc_hd__xor2_1
XFILLER_0_80_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14256_ _03164_ _02218_ _03162_ VGND VGND VPWR VPWR _05224_ sky130_fd_sc_hd__nand3_1
X_11468_ net403 net156 _02089_ VGND VGND VPWR VPWR _02279_ sky130_fd_sc_hd__and3_1
XFILLER_0_150_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13207_ _04069_ _04023_ VGND VGND VPWR VPWR _04070_ sky130_fd_sc_hd__xor2_1
X_10419_ _01224_ _01228_ VGND VGND VPWR VPWR _01230_ sky130_fd_sc_hd__nand2_1
X_14187_ _05146_ _05147_ VGND VGND VPWR VPWR _05148_ sky130_fd_sc_hd__xnor2_1
X_11399_ _02208_ _02201_ _02206_ VGND VGND VPWR VPWR _02210_ sky130_fd_sc_hd__nand3_1
XFILLER_0_0_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13138_ _03948_ _03987_ VGND VGND VPWR VPWR _03994_ sky130_fd_sc_hd__xnor2_2
X_13069_ _03898_ _03915_ _03917_ VGND VGND VPWR VPWR _03918_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_136_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_119_Right_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16828_ _08052_ VGND VGND VPWR VPWR _08053_ sky130_fd_sc_hd__inv_2
XFILLER_0_136_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16759_ _07830_ _07975_ VGND VGND VPWR VPWR _07977_ sky130_fd_sc_hd__or2_2
X_09300_ _08662_ _08663_ VGND VGND VPWR VPWR _08664_ sky130_fd_sc_hd__nor2_1
XFILLER_0_76_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09231_ _08366_ _08333_ VGND VGND VPWR VPWR _08554_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_119_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09162_ _07805_ _07816_ VGND VGND VPWR VPWR _07827_ sky130_fd_sc_hd__nor2_1
X_09093_ _06221_ _07057_ VGND VGND VPWR VPWR _07068_ sky130_fd_sc_hd__xor2_1
XFILLER_0_4_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09995_ _00720_ _00692_ _00719_ VGND VGND VPWR VPWR _00806_ sky130_fd_sc_hd__or3_4
XFILLER_0_110_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08946_ net352 net348 _05385_ VGND VGND VPWR VPWR _05451_ sky130_fd_sc_hd__and3_1
X_08877_ _03922_ _04406_ _03900_ VGND VGND VPWR VPWR _04692_ sky130_fd_sc_hd__o21a_2
XFILLER_0_67_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10770_ _01579_ _01580_ net390 net134 VGND VGND VPWR VPWR _01581_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_66_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09429_ _00238_ _00239_ VGND VGND VPWR VPWR _00240_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_57_Left_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12440_ net180 _03250_ _03261_ net176 VGND VGND VPWR VPWR _03272_ sky130_fd_sc_hd__a22o_1
XFILLER_0_35_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12371_ _03192_ _00238_ _00239_ VGND VGND VPWR VPWR _03203_ sky130_fd_sc_hd__and3_1
XFILLER_0_7_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14110_ _04936_ _05062_ VGND VGND VPWR VPWR _05063_ sky130_fd_sc_hd__nand2_1
X_11322_ _02099_ _02132_ VGND VGND VPWR VPWR _02133_ sky130_fd_sc_hd__nor2_1
X_15090_ _06120_ _06118_ VGND VGND VPWR VPWR _06141_ sky130_fd_sc_hd__and2b_1
XFILLER_0_132_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14041_ net239 _03791_ _04986_ VGND VGND VPWR VPWR _04987_ sky130_fd_sc_hd__and3_1
X_11253_ _01967_ _02063_ VGND VGND VPWR VPWR _02064_ sky130_fd_sc_hd__nor2_1
X_10204_ _00971_ _00972_ _00973_ VGND VGND VPWR VPWR _01015_ sky130_fd_sc_hd__o21a_1
X_11184_ prev_d_error\[13\] net398 net142 net147 VGND VGND VPWR VPWR _01995_ sky130_fd_sc_hd__and4_1
X_10135_ _00939_ _00944_ _00945_ VGND VGND VPWR VPWR _00946_ sky130_fd_sc_hd__o21ai_2
XPHY_EDGE_ROW_66_Left_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15992_ _07056_ _07059_ VGND VGND VPWR VPWR _07133_ sky130_fd_sc_hd__xor2_2
X_14943_ _05976_ _05978_ VGND VGND VPWR VPWR _05980_ sky130_fd_sc_hd__and2_1
X_10066_ _00836_ _00837_ VGND VGND VPWR VPWR _00877_ sky130_fd_sc_hd__or2_1
X_14874_ _05848_ _05849_ VGND VGND VPWR VPWR _05904_ sky130_fd_sc_hd__xor2_2
XFILLER_0_82_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16613_ _07760_ _07806_ _07815_ VGND VGND VPWR VPWR _07817_ sky130_fd_sc_hd__a21oi_1
X_13825_ _04746_ _04749_ VGND VGND VPWR VPWR _04750_ sky130_fd_sc_hd__nor2_1
XFILLER_0_58_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16544_ _07583_ _07598_ _07647_ VGND VGND VPWR VPWR _07741_ sky130_fd_sc_hd__and3_1
XFILLER_0_97_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13756_ net197 _04003_ _04591_ VGND VGND VPWR VPWR _04674_ sky130_fd_sc_hd__a21oi_1
X_10968_ _01557_ _01752_ _01731_ _01751_ VGND VGND VPWR VPWR _01779_ sky130_fd_sc_hd__o211a_1
X_12707_ _03535_ _03543_ _03545_ VGND VGND VPWR VPWR _03547_ sky130_fd_sc_hd__or3_1
X_16475_ net524 _05749_ VGND VGND VPWR VPWR _07665_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_75_Left_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13687_ net184 _04317_ VGND VGND VPWR VPWR _04598_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10899_ _01708_ _01662_ _01653_ VGND VGND VPWR VPWR _01710_ sky130_fd_sc_hd__and3_1
XFILLER_0_72_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15426_ _06508_ _06510_ VGND VGND VPWR VPWR _06511_ sky130_fd_sc_hd__nand2_1
X_12638_ _03410_ _03411_ VGND VGND VPWR VPWR _03477_ sky130_fd_sc_hd__and2b_1
XFILLER_0_25_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15357_ _06431_ _06433_ _06434_ VGND VGND VPWR VPWR _06435_ sky130_fd_sc_hd__o21ai_2
X_12569_ _03404_ _03407_ VGND VGND VPWR VPWR _03408_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_142_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14308_ _05272_ _05279_ _05280_ VGND VGND VPWR VPWR _05281_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_103_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15288_ _06203_ _06209_ _06211_ VGND VGND VPWR VPWR _06359_ sky130_fd_sc_hd__nand3_1
XFILLER_0_124_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17027_ _08270_ _08271_ VGND VGND VPWR VPWR _08272_ sky130_fd_sc_hd__nor2_1
X_14239_ _05203_ _05204_ VGND VGND VPWR VPWR _05205_ sky130_fd_sc_hd__nand2_4
XFILLER_0_22_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_84_Left_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08800_ net53 _02883_ _02916_ net146 VGND VGND VPWR VPWR _00033_ sky130_fd_sc_hd__a22o_1
X_09780_ _00590_ VGND VGND VPWR VPWR _00591_ sky130_fd_sc_hd__inv_2
XFILLER_0_147_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08731_ net50 _03061_ _03094_ net229 VGND VGND VPWR VPWR _00012_ sky130_fd_sc_hd__a22o_1
XFILLER_0_76_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_93_Left_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09214_ _08113_ _08234_ VGND VGND VPWR VPWR _08399_ sky130_fd_sc_hd__nor2_1
XFILLER_0_119_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09145_ _07585_ _07596_ _07618_ VGND VGND VPWR VPWR _07640_ sky130_fd_sc_hd__nand3_1
XFILLER_0_115_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09076_ _05759_ _06870_ VGND VGND VPWR VPWR _06881_ sky130_fd_sc_hd__and2_1
XFILLER_0_114_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09978_ _00786_ _00788_ VGND VGND VPWR VPWR _00789_ sky130_fd_sc_hd__xnor2_2
X_08929_ _05242_ _05253_ VGND VGND VPWR VPWR _05264_ sky130_fd_sc_hd__xnor2_1
X_11940_ _02746_ _02749_ _02740_ _02750_ VGND VGND VPWR VPWR _02751_ sky130_fd_sc_hd__a211oi_2
X_11871_ net434 net437 net139 net142 VGND VGND VPWR VPWR _02682_ sky130_fd_sc_hd__and4_1
XFILLER_0_98_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13610_ net202 _03792_ _03751_ net208 VGND VGND VPWR VPWR _04513_ sky130_fd_sc_hd__a22o_1
X_10822_ _01604_ _01632_ VGND VGND VPWR VPWR _01633_ sky130_fd_sc_hd__xor2_1
X_14590_ net252 _05590_ VGND VGND VPWR VPWR _05591_ sky130_fd_sc_hd__nand2_1
X_13541_ _04434_ _04436_ VGND VGND VPWR VPWR _04437_ sky130_fd_sc_hd__xnor2_2
X_10753_ net382 net141 net134 net386 VGND VGND VPWR VPWR _01564_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_54_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16260_ _07425_ _07427_ VGND VGND VPWR VPWR _07428_ sky130_fd_sc_hd__and2b_1
X_13472_ _04273_ _04360_ VGND VGND VPWR VPWR _04361_ sky130_fd_sc_hd__nand2_2
X_10684_ net401 net116 _01493_ _01494_ VGND VGND VPWR VPWR _01495_ sky130_fd_sc_hd__a31o_1
X_15211_ _06273_ VGND VGND VPWR VPWR _06274_ sky130_fd_sc_hd__inv_2
X_12423_ kd_1\[17\] _03244_ _03253_ VGND VGND VPWR VPWR _03255_ sky130_fd_sc_hd__a21oi_1
X_16191_ _07315_ _07351_ VGND VGND VPWR VPWR _07352_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15142_ net256 _05975_ _06196_ _06197_ VGND VGND VPWR VPWR _06198_ sky130_fd_sc_hd__a31o_1
XFILLER_0_62_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12354_ _07387_ prev_error\[8\] VGND VGND VPWR VPWR _03186_ sky130_fd_sc_hd__nand2b_2
XFILLER_0_23_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11305_ _02088_ _02115_ VGND VGND VPWR VPWR _02116_ sky130_fd_sc_hd__or2_1
X_15073_ _06117_ _06121_ VGND VGND VPWR VPWR _06123_ sky130_fd_sc_hd__xor2_4
XFILLER_0_50_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12285_ _02937_ _02938_ _02932_ VGND VGND VPWR VPWR _03117_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_121_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14024_ _04966_ _04968_ VGND VGND VPWR VPWR _04969_ sky130_fd_sc_hd__nor2_1
XFILLER_0_120_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11236_ _02037_ _02039_ _02046_ VGND VGND VPWR VPWR _02047_ sky130_fd_sc_hd__a21boi_1
X_11167_ _01976_ _01977_ net403 net141 VGND VGND VPWR VPWR _01978_ sky130_fd_sc_hd__and4bb_1
X_10118_ _00826_ _00928_ VGND VGND VPWR VPWR _00929_ sky130_fd_sc_hd__nand2_1
X_15975_ _07104_ _07113_ _07114_ VGND VGND VPWR VPWR _07115_ sky130_fd_sc_hd__o21ai_2
X_11098_ _01888_ _01890_ _01908_ VGND VGND VPWR VPWR _01909_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_26_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14926_ _05919_ _05960_ VGND VGND VPWR VPWR _05961_ sky130_fd_sc_hd__or2_1
X_10049_ _00745_ _00756_ VGND VGND VPWR VPWR _00860_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_117_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14857_ net258 _05801_ VGND VGND VPWR VPWR _05885_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13808_ _04652_ _04730_ VGND VGND VPWR VPWR _04731_ sky130_fd_sc_hd__xnor2_4
X_14788_ net255 _05749_ _05808_ VGND VGND VPWR VPWR _05809_ sky130_fd_sc_hd__and3_1
X_16527_ _07658_ _07721_ VGND VGND VPWR VPWR _07722_ sky130_fd_sc_hd__xnor2_2
X_13739_ net245 _03216_ _04653_ VGND VGND VPWR VPWR _04655_ sky130_fd_sc_hd__and3_1
XFILLER_0_128_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16458_ _07643_ _07644_ _07645_ VGND VGND VPWR VPWR _07646_ sky130_fd_sc_hd__or3_4
XFILLER_0_54_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15409_ _06459_ _06460_ VGND VGND VPWR VPWR _06492_ sky130_fd_sc_hd__xnor2_1
X_16389_ i_error\[14\] _07569_ VGND VGND VPWR VPWR _07570_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09901_ _00619_ _00708_ _00707_ VGND VGND VPWR VPWR _00712_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09832_ net328 _00315_ VGND VGND VPWR VPWR _00643_ sky130_fd_sc_hd__nand2_1
X_09763_ net348 _04615_ VGND VGND VPWR VPWR _00574_ sky130_fd_sc_hd__nand2_1
X_08714_ net41 _02894_ _02927_ net128 VGND VGND VPWR VPWR _00021_ sky130_fd_sc_hd__a22o_1
X_09694_ _00503_ _00504_ VGND VGND VPWR VPWR _00505_ sky130_fd_sc_hd__and2_1
Xrebuffer10 _07820_ VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__buf_1
XFILLER_0_69_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer32 _08071_ VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_83_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09128_ _07354_ _07442_ VGND VGND VPWR VPWR _07453_ sky130_fd_sc_hd__or2_1
XFILLER_0_121_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09059_ net313 _04934_ _05033_ net317 VGND VGND VPWR VPWR _06694_ sky130_fd_sc_hd__a22o_1
XFILLER_0_102_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12070_ _02888_ _02890_ VGND VGND VPWR VPWR _02891_ sky130_fd_sc_hd__nor2_1
XFILLER_0_130_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11021_ net383 net387 net149 net151 VGND VGND VPWR VPWR _01832_ sky130_fd_sc_hd__and4_1
X_15760_ _06700_ _06877_ VGND VGND VPWR VPWR _06878_ sky130_fd_sc_hd__nor2_1
X_12972_ _03812_ _03815_ VGND VGND VPWR VPWR _03816_ sky130_fd_sc_hd__or2_1
XFILLER_0_87_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14711_ _05723_ VGND VGND VPWR VPWR _05724_ sky130_fd_sc_hd__clkbuf_4
X_11923_ _02731_ _02732_ _02733_ VGND VGND VPWR VPWR _02734_ sky130_fd_sc_hd__o21ba_1
X_15691_ _06790_ _06794_ _06801_ VGND VGND VPWR VPWR _06802_ sky130_fd_sc_hd__a21oi_1
X_14642_ _05641_ _05647_ VGND VGND VPWR VPWR _05648_ sky130_fd_sc_hd__nand2_1
X_17430_ clknet_4_12_0_clock _00108_ VGND VGND VPWR VPWR i_error\[0\] sky130_fd_sc_hd__dfxtp_1
X_11854_ net409 net411 net163 net167 VGND VGND VPWR VPWR _02665_ sky130_fd_sc_hd__and4_1
XFILLER_0_67_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10805_ _01512_ _01514_ _01513_ VGND VGND VPWR VPWR _01616_ sky130_fd_sc_hd__o21ba_1
X_14573_ _03190_ _08636_ VGND VGND VPWR VPWR _05573_ sky130_fd_sc_hd__nor2_2
X_17361_ net466 net443 net456 _08583_ VGND VGND VPWR VPWR _00127_ sky130_fd_sc_hd__o211a_1
XFILLER_0_138_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11785_ net392 net174 VGND VGND VPWR VPWR _02596_ sky130_fd_sc_hd__nand2_1
XFILLER_0_138_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16312_ _07238_ _07240_ _07182_ VGND VGND VPWR VPWR _07485_ sky130_fd_sc_hd__a21o_1
X_13524_ _04416_ _04418_ VGND VGND VPWR VPWR _04419_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_55_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17292_ _08536_ _00243_ _08540_ net460 VGND VGND VPWR VPWR _00094_ sky130_fd_sc_hd__o211a_1
XFILLER_0_94_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10736_ _01541_ _01546_ VGND VGND VPWR VPWR _01547_ sky130_fd_sc_hd__and2_1
XFILLER_0_27_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_149_Left_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16243_ _07408_ _07401_ _07407_ VGND VGND VPWR VPWR _07410_ sky130_fd_sc_hd__nand3b_1
X_13455_ _04331_ _04339_ _04341_ VGND VGND VPWR VPWR _04343_ sky130_fd_sc_hd__nand3_1
X_10667_ _01475_ _01476_ VGND VGND VPWR VPWR _01478_ sky130_fd_sc_hd__and2_1
X_12406_ _03224_ _03237_ VGND VGND VPWR VPWR _03238_ sky130_fd_sc_hd__or2_1
XFILLER_0_3_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16174_ _07330_ _07331_ VGND VGND VPWR VPWR _07334_ sky130_fd_sc_hd__and2b_1
X_13386_ net184 _03936_ _04105_ VGND VGND VPWR VPWR _04267_ sky130_fd_sc_hd__a21boi_1
X_10598_ _01288_ _01405_ _01407_ _01408_ VGND VGND VPWR VPWR _01409_ sky130_fd_sc_hd__o31a_1
X_15125_ _06171_ _06179_ VGND VGND VPWR VPWR _06180_ sky130_fd_sc_hd__xnor2_1
X_12337_ _01859_ _01936_ VGND VGND VPWR VPWR _03169_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15056_ net293 _05702_ _06103_ VGND VGND VPWR VPWR _06104_ sky130_fd_sc_hd__a21o_1
X_12268_ _03065_ _03085_ _03095_ _03099_ VGND VGND VPWR VPWR _03100_ sky130_fd_sc_hd__o211a_1
X_14007_ net235 net230 _03790_ _03749_ VGND VGND VPWR VPWR _04950_ sky130_fd_sc_hd__and4_1
X_11219_ _02023_ _02027_ _02029_ VGND VGND VPWR VPWR _02030_ sky130_fd_sc_hd__o21a_1
X_12199_ _03020_ _03023_ VGND VGND VPWR VPWR _03024_ sky130_fd_sc_hd__and2_1
Xoutput90 net90 VGND VGND VPWR VPWR out_clocked[6] sky130_fd_sc_hd__buf_2
XFILLER_0_128_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15958_ _07015_ _07095_ VGND VGND VPWR VPWR _07096_ sky130_fd_sc_hd__nor2_1
XFILLER_0_144_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14909_ _05760_ _05758_ VGND VGND VPWR VPWR _05942_ sky130_fd_sc_hd__and2b_1
X_15889_ net263 _04313_ VGND VGND VPWR VPWR _07020_ sky130_fd_sc_hd__nand2_1
XFILLER_0_144_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout302 net303 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__buf_4
XFILLER_0_111_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout313 net315 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__buf_2
XFILLER_0_10_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout324 kp\[14\] VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__clkbuf_4
Xfanout335 kp\[11\] VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__clkbuf_4
Xfanout346 net347 VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__clkbuf_2
X_09815_ _00622_ _00620_ VGND VGND VPWR VPWR _00626_ sky130_fd_sc_hd__xor2_2
Xfanout357 kp\[5\] VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__buf_2
Xfanout368 kp\[3\] VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__buf_2
Xfanout379 net380 VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_94_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09746_ _04065_ _04109_ VGND VGND VPWR VPWR _00557_ sky130_fd_sc_hd__xnor2_4
X_09677_ _00486_ _00487_ VGND VGND VPWR VPWR _00488_ sky130_fd_sc_hd__and2_1
XFILLER_0_69_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11570_ _02374_ _02377_ _02380_ VGND VGND VPWR VPWR _02381_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_9_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10521_ _01330_ _00557_ _01331_ VGND VGND VPWR VPWR _01332_ sky130_fd_sc_hd__or3_1
XFILLER_0_134_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13240_ _03197_ _03198_ VGND VGND VPWR VPWR _04106_ sky130_fd_sc_hd__xor2_4
XFILLER_0_150_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10452_ net375 _08680_ _01214_ _01215_ VGND VGND VPWR VPWR _01263_ sky130_fd_sc_hd__a22o_1
XFILLER_0_32_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13171_ _03371_ _04029_ VGND VGND VPWR VPWR _04030_ sky130_fd_sc_hd__nor2_1
XFILLER_0_20_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10383_ _01188_ _01189_ _01193_ VGND VGND VPWR VPWR _01194_ sky130_fd_sc_hd__a21o_1
X_12122_ _02942_ _02944_ _02946_ VGND VGND VPWR VPWR _02947_ sky130_fd_sc_hd__o21ai_1
X_12053_ _02870_ _02871_ net442 net146 VGND VGND VPWR VPWR _02873_ sky130_fd_sc_hd__and4bb_1
X_16930_ _05229_ _05295_ VGND VGND VPWR VPWR _08165_ sky130_fd_sc_hd__xnor2_4
X_11004_ _01742_ _01814_ VGND VGND VPWR VPWR _01815_ sky130_fd_sc_hd__or2_1
X_16861_ _08076_ _08078_ _08088_ VGND VGND VPWR VPWR _08089_ sky130_fd_sc_hd__a21o_1
X_15812_ net306 _06527_ _06528_ VGND VGND VPWR VPWR _06935_ sky130_fd_sc_hd__and3_1
X_16792_ _08012_ VGND VGND VPWR VPWR _08013_ sky130_fd_sc_hd__inv_2
X_15743_ _06620_ _06858_ VGND VGND VPWR VPWR _06860_ sky130_fd_sc_hd__or2_1
X_12955_ _03787_ _03798_ VGND VGND VPWR VPWR _03799_ sky130_fd_sc_hd__and2_1
X_11906_ _02708_ _02713_ _02715_ VGND VGND VPWR VPWR _02717_ sky130_fd_sc_hd__o21ai_1
X_15674_ _06750_ _06756_ _06783_ VGND VGND VPWR VPWR _06784_ sky130_fd_sc_hd__a21o_1
X_12886_ _03657_ _03729_ VGND VGND VPWR VPWR _03730_ sky130_fd_sc_hd__or2_1
X_17413_ clknet_4_0_0_clock _00091_ VGND VGND VPWR VPWR prev_error\[1\] sky130_fd_sc_hd__dfxtp_2
X_14625_ _05629_ VGND VGND VPWR VPWR _05630_ sky130_fd_sc_hd__clkbuf_2
X_11837_ net431 net447 net525 net142 VGND VGND VPWR VPWR _02648_ sky130_fd_sc_hd__and4_1
XFILLER_0_83_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14556_ _05515_ _05522_ _05552_ VGND VGND VPWR VPWR _05554_ sky130_fd_sc_hd__a21oi_4
X_17344_ net463 _08203_ VGND VGND VPWR VPWR _08574_ sky130_fd_sc_hd__nand2_1
XFILLER_0_138_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11768_ net422 net147 net152 net417 VGND VGND VPWR VPWR _02579_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_23_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13507_ _04324_ _04363_ _04399_ VGND VGND VPWR VPWR _04400_ sky130_fd_sc_hd__a21o_2
X_10719_ _01524_ _01529_ VGND VGND VPWR VPWR _01530_ sky130_fd_sc_hd__or2_1
X_14487_ net313 _05033_ _05726_ net317 VGND VGND VPWR VPWR _05478_ sky130_fd_sc_hd__a22oi_1
X_17275_ _08527_ _08530_ VGND VGND VPWR VPWR _00086_ sky130_fd_sc_hd__nor2_1
XFILLER_0_83_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11699_ net426 net139 _02497_ _02496_ VGND VGND VPWR VPWR _02510_ sky130_fd_sc_hd__a31o_1
XFILLER_0_24_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16226_ net291 _04313_ _07389_ VGND VGND VPWR VPWR _07391_ sky130_fd_sc_hd__nand3_1
X_13438_ _04299_ _04323_ VGND VGND VPWR VPWR _04324_ sky130_fd_sc_hd__nor2_2
XFILLER_0_3_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer1 _07823_ VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_141_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16157_ net307 _06015_ _07314_ VGND VGND VPWR VPWR _07315_ sky130_fd_sc_hd__and3_1
XFILLER_0_24_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13369_ _04174_ _04234_ _04247_ VGND VGND VPWR VPWR _04248_ sky130_fd_sc_hd__and3_1
XFILLER_0_2_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15108_ _06160_ VGND VGND VPWR VPWR _06161_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_121_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16088_ _07180_ _07181_ VGND VGND VPWR VPWR _07239_ sky130_fd_sc_hd__nor2_1
X_15039_ _06027_ _06061_ VGND VGND VPWR VPWR _06085_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09600_ _00406_ _00409_ _00410_ VGND VGND VPWR VPWR _00411_ sky130_fd_sc_hd__o21a_1
X_09531_ net373 _00339_ _00341_ VGND VGND VPWR VPWR _00342_ sky130_fd_sc_hd__or3_1
X_09462_ _00271_ _00272_ VGND VGND VPWR VPWR _00273_ sky130_fd_sc_hd__nor2_1
XFILLER_0_149_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09393_ _00202_ _00203_ VGND VGND VPWR VPWR _00204_ sky130_fd_sc_hd__and2_1
XFILLER_0_19_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout110 net111 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__buf_2
Xfanout121 net122 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__buf_2
Xfanout132 net133 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__clkbuf_2
Xfanout143 net144 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__buf_2
Xfanout154 net157 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__clkbuf_4
Xfanout165 net168 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__clkbuf_4
Xfanout176 net177 VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__buf_2
Xfanout187 kd_1\[14\] VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__buf_2
Xfanout198 net199 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__buf_2
X_09729_ _00505_ _00537_ _00538_ VGND VGND VPWR VPWR _00540_ sky130_fd_sc_hd__or3_1
XFILLER_0_69_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12740_ _03580_ _03582_ VGND VGND VPWR VPWR _03583_ sky130_fd_sc_hd__nor2_1
X_12671_ _03507_ _03508_ _03496_ VGND VGND VPWR VPWR _03510_ sky130_fd_sc_hd__a21o_1
XFILLER_0_38_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14410_ _05380_ _05392_ VGND VGND VPWR VPWR _05393_ sky130_fd_sc_hd__xnor2_1
X_11622_ _02370_ _02381_ VGND VGND VPWR VPWR _02433_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15390_ _06469_ _06382_ _06385_ VGND VGND VPWR VPWR _06471_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_80_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14341_ _05310_ _05316_ VGND VGND VPWR VPWR _05317_ sky130_fd_sc_hd__xor2_1
X_11553_ _02340_ _02361_ _02362_ _02363_ VGND VGND VPWR VPWR _02364_ sky130_fd_sc_hd__or4_2
XFILLER_0_135_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17060_ _05354_ _05355_ _05351_ VGND VGND VPWR VPWR _08308_ sky130_fd_sc_hd__o21ai_4
X_10504_ _01305_ _01314_ VGND VGND VPWR VPWR _01315_ sky130_fd_sc_hd__and2_1
XFILLER_0_107_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14272_ _02485_ _03154_ _03156_ VGND VGND VPWR VPWR _05241_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_150_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11484_ _02294_ VGND VGND VPWR VPWR _02295_ sky130_fd_sc_hd__inv_2
X_16011_ _07152_ _07153_ VGND VGND VPWR VPWR _07154_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_123_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13223_ _04063_ _04085_ _04086_ VGND VGND VPWR VPWR _04088_ sky130_fd_sc_hd__a21oi_1
X_10435_ net379 _00314_ VGND VGND VPWR VPWR _01246_ sky130_fd_sc_hd__nand2_2
XFILLER_0_21_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13154_ net186 net519 _04011_ VGND VGND VPWR VPWR _04012_ sky130_fd_sc_hd__and3_1
X_10366_ _01123_ _01173_ _01174_ _01176_ VGND VGND VPWR VPWR _01177_ sky130_fd_sc_hd__o22a_1
X_12105_ _02919_ _02928_ _02926_ VGND VGND VPWR VPWR _02930_ sky130_fd_sc_hd__a21o_1
X_13085_ _03935_ VGND VGND VPWR VPWR _03936_ sky130_fd_sc_hd__clkbuf_4
X_10297_ _01070_ _01104_ VGND VGND VPWR VPWR _01108_ sky130_fd_sc_hd__xnor2_1
X_16913_ _07814_ _07759_ _07969_ VGND VGND VPWR VPWR _08147_ sky130_fd_sc_hd__mux2_1
X_12036_ net424 net168 _02852_ _02853_ VGND VGND VPWR VPWR _02854_ sky130_fd_sc_hd__a31o_1
XFILLER_0_18_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16844_ _07788_ _07969_ _08041_ _08070_ VGND VGND VPWR VPWR _08071_ sky130_fd_sc_hd__a211o_1
X_16775_ _07792_ VGND VGND VPWR VPWR _07995_ sky130_fd_sc_hd__inv_2
XFILLER_0_34_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13987_ _04874_ _04926_ _04927_ VGND VGND VPWR VPWR _04928_ sky130_fd_sc_hd__o21a_1
XFILLER_0_125_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15726_ _06839_ _06809_ VGND VGND VPWR VPWR _06841_ sky130_fd_sc_hd__xor2_2
XFILLER_0_125_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12938_ _03780_ _03781_ VGND VGND VPWR VPWR _03782_ sky130_fd_sc_hd__nor2_1
XFILLER_0_87_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15657_ _06725_ _06763_ _06762_ net497 VGND VGND VPWR VPWR _06765_ sky130_fd_sc_hd__a211oi_4
X_12869_ _03695_ _03699_ _03700_ VGND VGND VPWR VPWR _03713_ sky130_fd_sc_hd__or3_1
XFILLER_0_8_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14608_ _05576_ _05578_ _03246_ VGND VGND VPWR VPWR _05611_ sky130_fd_sc_hd__a21o_1
XFILLER_0_56_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15588_ _06614_ _06616_ _06688_ VGND VGND VPWR VPWR _06689_ sky130_fd_sc_hd__nor3_1
XFILLER_0_29_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17327_ net463 net516 VGND VGND VPWR VPWR _08563_ sky130_fd_sc_hd__or2_1
X_14539_ _04560_ _05033_ _05759_ net318 VGND VGND VPWR VPWR _05535_ sky130_fd_sc_hd__o211a_1
XFILLER_0_126_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17258_ _08498_ net93 VGND VGND VPWR VPWR _08517_ sky130_fd_sc_hd__and2_1
XFILLER_0_71_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16209_ _07362_ _07369_ _07370_ _07371_ VGND VGND VPWR VPWR _07372_ sky130_fd_sc_hd__o211a_1
XFILLER_0_141_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17189_ _08358_ _08361_ VGND VGND VPWR VPWR _08450_ sky130_fd_sc_hd__and2_1
XFILLER_0_59_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08962_ _05605_ _05616_ VGND VGND VPWR VPWR _05627_ sky130_fd_sc_hd__and2_1
X_08893_ _03922_ _04406_ _04714_ _03900_ VGND VGND VPWR VPWR _04868_ sky130_fd_sc_hd__o211a_4
XFILLER_0_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09514_ _00300_ _00301_ VGND VGND VPWR VPWR _00325_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_79_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09445_ _00253_ _00223_ _00255_ VGND VGND VPWR VPWR _00256_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_91_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09376_ _06254_ _05396_ net356 _05649_ VGND VGND VPWR VPWR _00187_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_148_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_104_Left_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10220_ _00955_ _01006_ _01027_ _01030_ VGND VGND VPWR VPWR _01031_ sky130_fd_sc_hd__o211a_1
XFILLER_0_120_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10151_ _00960_ _00961_ VGND VGND VPWR VPWR _00962_ sky130_fd_sc_hd__nand2_1
XFILLER_0_100_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10082_ _00826_ _00857_ VGND VGND VPWR VPWR _00893_ sky130_fd_sc_hd__or2_1
X_13910_ _04677_ _04755_ _04754_ VGND VGND VPWR VPWR _04843_ sky130_fd_sc_hd__o21a_1
X_14890_ net281 _05710_ _05702_ net284 VGND VGND VPWR VPWR _05921_ sky130_fd_sc_hd__a22oi_1
XPHY_EDGE_ROW_113_Left_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13841_ net232 _03576_ _03268_ net237 VGND VGND VPWR VPWR _04767_ sky130_fd_sc_hd__a22o_1
XFILLER_0_69_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16560_ _07726_ _07757_ VGND VGND VPWR VPWR _07758_ sky130_fd_sc_hd__or2_1
X_13772_ _04528_ _04690_ VGND VGND VPWR VPWR _04691_ sky130_fd_sc_hd__or2_1
X_10984_ _01722_ _01794_ VGND VGND VPWR VPWR _01795_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15511_ net271 _05665_ VGND VGND VPWR VPWR _06604_ sky130_fd_sc_hd__nand2_1
X_12723_ _03473_ _03563_ VGND VGND VPWR VPWR _03565_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16491_ _07542_ _07547_ _07546_ VGND VGND VPWR VPWR _07682_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_139_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12654_ _03453_ _03456_ _03491_ VGND VGND VPWR VPWR _03493_ sky130_fd_sc_hd__nor3_1
X_15442_ _05612_ _05617_ _03227_ VGND VGND VPWR VPWR _06528_ sky130_fd_sc_hd__a21o_1
XFILLER_0_38_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11605_ _02349_ _02352_ VGND VGND VPWR VPWR _02416_ sky130_fd_sc_hd__nor2_1
XFILLER_0_143_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15373_ _06450_ _06445_ VGND VGND VPWR VPWR _06453_ sky130_fd_sc_hd__and2b_1
X_12585_ net222 _03372_ VGND VGND VPWR VPWR _03424_ sky130_fd_sc_hd__nand2_1
X_17112_ _01457_ _08035_ _08364_ VGND VGND VPWR VPWR _08365_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_122_Left_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14324_ _05298_ _05223_ VGND VGND VPWR VPWR _05299_ sky130_fd_sc_hd__or2_4
X_11536_ _02342_ _02344_ _02346_ VGND VGND VPWR VPWR _02347_ sky130_fd_sc_hd__o21a_1
XFILLER_0_108_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14255_ _05221_ _05222_ VGND VGND VPWR VPWR _05223_ sky130_fd_sc_hd__nand2_1
X_17043_ _08287_ _08288_ VGND VGND VPWR VPWR _08290_ sky130_fd_sc_hd__or2_1
X_11467_ net403 net153 net157 net398 VGND VGND VPWR VPWR _02278_ sky130_fd_sc_hd__a22o_1
X_13206_ _03336_ _03367_ _04022_ VGND VGND VPWR VPWR _04069_ sky130_fd_sc_hd__a21bo_1
X_10418_ _01224_ _01228_ VGND VGND VPWR VPWR _01229_ sky130_fd_sc_hd__or2_1
X_14186_ _05125_ _05134_ VGND VGND VPWR VPWR _05147_ sky130_fd_sc_hd__nand2_1
X_11398_ _02201_ _02206_ _02208_ VGND VGND VPWR VPWR _02209_ sky130_fd_sc_hd__a21o_1
XFILLER_0_29_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13137_ _03991_ _03992_ VGND VGND VPWR VPWR _03993_ sky130_fd_sc_hd__nand2_2
X_10349_ _01136_ _01159_ VGND VGND VPWR VPWR _01160_ sky130_fd_sc_hd__xor2_1
X_13068_ _03803_ _03916_ VGND VGND VPWR VPWR _03917_ sky130_fd_sc_hd__or2_1
X_12019_ _02827_ _02832_ _02834_ VGND VGND VPWR VPWR _02835_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_131_Left_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16827_ _07736_ _08051_ _07971_ VGND VGND VPWR VPWR _08052_ sky130_fd_sc_hd__mux2_1
X_16758_ _07826_ _07975_ VGND VGND VPWR VPWR _07976_ sky130_fd_sc_hd__nor2_1
X_15709_ _06820_ _06821_ VGND VGND VPWR VPWR _06822_ sky130_fd_sc_hd__and2b_1
XFILLER_0_0_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16689_ _07862_ _07898_ VGND VGND VPWR VPWR _07900_ sky130_fd_sc_hd__nor2_1
X_09230_ _08245_ _08399_ _08421_ VGND VGND VPWR VPWR _08547_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_61_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09161_ net326 _04516_ _04439_ net330 VGND VGND VPWR VPWR _07816_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_16_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_140_Left_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09092_ _07035_ _07046_ VGND VGND VPWR VPWR _07057_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09994_ _00784_ _00804_ VGND VGND VPWR VPWR _00805_ sky130_fd_sc_hd__and2_1
X_08945_ _05308_ _05396_ _05429_ VGND VGND VPWR VPWR _05440_ sky130_fd_sc_hd__o21a_2
X_08876_ _04560_ _04527_ VGND VGND VPWR VPWR _04681_ sky130_fd_sc_hd__nor2_1
XFILLER_0_98_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09428_ _04032_ _04131_ _04197_ VGND VGND VPWR VPWR _00239_ sky130_fd_sc_hd__a21o_4
XFILLER_0_137_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09359_ _06331_ _00169_ _06287_ VGND VGND VPWR VPWR _00170_ sky130_fd_sc_hd__o21a_1
XFILLER_0_118_850 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12370_ _03194_ _00313_ _03196_ _03200_ _03201_ VGND VGND VPWR VPWR _03202_ sky130_fd_sc_hd__a221o_1
XFILLER_0_117_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11321_ _01561_ net166 _02097_ _02098_ VGND VGND VPWR VPWR _02132_ sky130_fd_sc_hd__o22a_1
XFILLER_0_133_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14040_ _04984_ _04985_ VGND VGND VPWR VPWR _04986_ sky130_fd_sc_hd__nor2_1
X_11252_ _01964_ _01966_ VGND VGND VPWR VPWR _02063_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10203_ _01009_ _01013_ VGND VGND VPWR VPWR _01014_ sky130_fd_sc_hd__and2b_1
X_11183_ _01969_ _01991_ _01993_ VGND VGND VPWR VPWR _01994_ sky130_fd_sc_hd__o21a_1
XFILLER_0_101_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10134_ _00864_ _00873_ VGND VGND VPWR VPWR _00945_ sky130_fd_sc_hd__xor2_1
X_15991_ _07129_ _07131_ VGND VGND VPWR VPWR _07132_ sky130_fd_sc_hd__nand2_1
X_14942_ _05662_ _05971_ _05977_ VGND VGND VPWR VPWR _05978_ sky130_fd_sc_hd__o21a_1
X_10065_ _00742_ _00861_ _00875_ VGND VGND VPWR VPWR _00876_ sky130_fd_sc_hd__and3_1
X_14873_ _05848_ _05901_ _05850_ VGND VGND VPWR VPWR _05903_ sky130_fd_sc_hd__o21a_1
X_16612_ _07810_ _07813_ _07758_ _07814_ VGND VGND VPWR VPWR _07815_ sky130_fd_sc_hd__a2bb2o_1
X_13824_ _04748_ _04686_ VGND VGND VPWR VPWR _04749_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_884 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16543_ _07730_ _07733_ _07736_ _07738_ VGND VGND VPWR VPWR _07740_ sky130_fd_sc_hd__a22oi_1
X_13755_ _04671_ _04672_ VGND VGND VPWR VPWR _04673_ sky130_fd_sc_hd__nand2_1
X_10967_ _01776_ _01777_ VGND VGND VPWR VPWR _01778_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12706_ _03535_ _03543_ _03545_ VGND VGND VPWR VPWR _03546_ sky130_fd_sc_hd__o21ai_1
X_16474_ _07516_ _07518_ _07517_ VGND VGND VPWR VPWR _07664_ sky130_fd_sc_hd__a21bo_1
X_13686_ _04595_ _04596_ VGND VGND VPWR VPWR _04597_ sky130_fd_sc_hd__nor2_1
X_10898_ _01662_ _01653_ _01708_ VGND VGND VPWR VPWR _01709_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_73_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15425_ net305 _05736_ _06508_ _06509_ VGND VGND VPWR VPWR _06510_ sky130_fd_sc_hd__nand4_2
X_12637_ _03418_ _03474_ _03475_ VGND VGND VPWR VPWR _03476_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_53_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12568_ _03405_ _03406_ VGND VGND VPWR VPWR _03407_ sky130_fd_sc_hd__nor2_1
X_15356_ _05738_ _05688_ VGND VGND VPWR VPWR _06434_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14307_ _05274_ _05278_ _05276_ VGND VGND VPWR VPWR _05280_ sky130_fd_sc_hd__and3_1
X_11519_ net417 net422 net140 VGND VGND VPWR VPWR _02330_ sky130_fd_sc_hd__and3_1
XFILLER_0_80_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15287_ _06355_ _06357_ VGND VGND VPWR VPWR _06358_ sky130_fd_sc_hd__nand2_1
X_12499_ _03335_ VGND VGND VPWR VPWR _03336_ sky130_fd_sc_hd__clkbuf_4
X_17026_ _08263_ _08269_ VGND VGND VPWR VPWR _08271_ sky130_fd_sc_hd__nor2_1
X_14238_ _05201_ _05202_ VGND VGND VPWR VPWR _05204_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14169_ _04940_ _04942_ _05127_ VGND VGND VPWR VPWR _05128_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_147_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08730_ net49 _03061_ _03094_ net234 VGND VGND VPWR VPWR _00011_ sky130_fd_sc_hd__a22o_1
XFILLER_0_56_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09213_ _08344_ _08377_ VGND VGND VPWR VPWR _08388_ sky130_fd_sc_hd__and2_1
XFILLER_0_146_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09144_ _07585_ _07596_ _07618_ VGND VGND VPWR VPWR _07629_ sky130_fd_sc_hd__a21o_1
XFILLER_0_17_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09075_ net329 net325 _06463_ VGND VGND VPWR VPWR _06870_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_31_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout1 _04319_ VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09977_ _00658_ _00787_ VGND VGND VPWR VPWR _00788_ sky130_fd_sc_hd__nor2_1
X_08928_ _04637_ _04648_ VGND VGND VPWR VPWR _05253_ sky130_fd_sc_hd__xnor2_1
X_08859_ _04472_ _04483_ VGND VGND VPWR VPWR _04494_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_98_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_6_0_clock clknet_0_clock VGND VGND VPWR VPWR clknet_4_6_0_clock sky130_fd_sc_hd__clkbuf_8
X_11870_ _02662_ _02678_ _02680_ VGND VGND VPWR VPWR _02681_ sky130_fd_sc_hd__a21oi_2
X_10821_ _01630_ _01631_ VGND VGND VPWR VPWR _01632_ sky130_fd_sc_hd__nand2_1
X_13540_ _04324_ _04435_ VGND VGND VPWR VPWR _04436_ sky130_fd_sc_hd__nor2_1
X_10752_ _01562_ VGND VGND VPWR VPWR _01563_ sky130_fd_sc_hd__clkbuf_4
X_13471_ _04259_ _04272_ VGND VGND VPWR VPWR _04360_ sky130_fd_sc_hd__nand2_1
X_10683_ net406 net412 net112 net109 VGND VGND VPWR VPWR _01494_ sky130_fd_sc_hd__and4_1
XFILLER_0_125_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12422_ kd_1\[17\] _03244_ _03253_ VGND VGND VPWR VPWR _03254_ sky130_fd_sc_hd__and3_1
X_15210_ _06218_ _06225_ VGND VGND VPWR VPWR _06273_ sky130_fd_sc_hd__xor2_2
X_16190_ net307 _06016_ _07314_ VGND VGND VPWR VPWR _07351_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_23_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15141_ _06194_ _06195_ VGND VGND VPWR VPWR _06197_ sky130_fd_sc_hd__nor2_1
X_12353_ _05143_ _05154_ _03184_ VGND VGND VPWR VPWR _03185_ sky130_fd_sc_hd__a21o_1
XFILLER_0_140_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11304_ _02087_ _02065_ _02085_ VGND VGND VPWR VPWR _02115_ sky130_fd_sc_hd__and3_1
X_15072_ _06118_ _06120_ VGND VGND VPWR VPWR _06121_ sky130_fd_sc_hd__xnor2_4
X_12284_ _03107_ _03114_ _03113_ VGND VGND VPWR VPWR _03116_ sky130_fd_sc_hd__a21o_1
XFILLER_0_105_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14023_ net235 _03791_ _03934_ net230 VGND VGND VPWR VPWR _04968_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_120_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11235_ _02044_ _02045_ VGND VGND VPWR VPWR _02046_ sky130_fd_sc_hd__or2_1
XFILLER_0_30_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11166_ net407 net137 net132 prev_d_error\[9\] VGND VGND VPWR VPWR _01977_ sky130_fd_sc_hd__a22oi_1
X_10117_ _00823_ _00825_ VGND VGND VPWR VPWR _00928_ sky130_fd_sc_hd__or2_1
X_15974_ _06871_ _07020_ VGND VGND VPWR VPWR _07114_ sky130_fd_sc_hd__nor2_1
X_11097_ _01906_ _01907_ VGND VGND VPWR VPWR _01908_ sky130_fd_sc_hd__nor2_1
X_14925_ _05933_ _05959_ VGND VGND VPWR VPWR _05960_ sky130_fd_sc_hd__nor2_1
X_10048_ _00759_ _00760_ _00780_ VGND VGND VPWR VPWR _00859_ sky130_fd_sc_hd__a21o_1
XFILLER_0_89_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14856_ net261 _05711_ VGND VGND VPWR VPWR _05884_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13807_ _04693_ _04728_ _04729_ VGND VGND VPWR VPWR _04730_ sky130_fd_sc_hd__a21bo_2
X_14787_ _05806_ _05807_ VGND VGND VPWR VPWR _05808_ sky130_fd_sc_hd__nor2_1
XFILLER_0_42_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11999_ net433 net437 kd_2\[7\] net150 VGND VGND VPWR VPWR _02813_ sky130_fd_sc_hd__and4_1
XFILLER_0_133_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16526_ _07719_ _07720_ VGND VGND VPWR VPWR _07721_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13738_ net245 _03216_ _04653_ VGND VGND VPWR VPWR _04654_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_133_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16457_ i_error\[9\] _07588_ VGND VGND VPWR VPWR _07645_ sky130_fd_sc_hd__xnor2_4
X_13669_ _04489_ _04490_ VGND VGND VPWR VPWR _04578_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15408_ _06470_ _06471_ _06489_ _06490_ VGND VGND VPWR VPWR _06491_ sky130_fd_sc_hd__o211ai_1
X_16388_ _07506_ _07568_ VGND VGND VPWR VPWR _07569_ sky130_fd_sc_hd__xor2_4
XFILLER_0_54_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15339_ _04310_ _03198_ VGND VGND VPWR VPWR _06415_ sky130_fd_sc_hd__xor2_4
XFILLER_0_6_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17009_ _08251_ _08247_ _08240_ VGND VGND VPWR VPWR _08252_ sky130_fd_sc_hd__o21a_1
X_09900_ _00670_ _00710_ VGND VGND VPWR VPWR _00711_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09831_ net331 net328 _00242_ _00315_ VGND VGND VPWR VPWR _00642_ sky130_fd_sc_hd__and4_1
X_09762_ net357 _04516_ VGND VGND VPWR VPWR _00573_ sky130_fd_sc_hd__nand2_2
X_08713_ net40 _02894_ _02927_ net133 VGND VGND VPWR VPWR _00020_ sky130_fd_sc_hd__a22o_1
X_09693_ _00421_ _00441_ VGND VGND VPWR VPWR _00504_ sky130_fd_sc_hd__xor2_1
XFILLER_0_20_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer11 _07913_ VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__buf_1
Xrebuffer22 _04252_ VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__buf_1
Xrebuffer33 _05299_ VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09127_ _04560_ _07420_ _07354_ _07431_ VGND VGND VPWR VPWR _07442_ sky130_fd_sc_hd__nor4_1
XFILLER_0_122_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09058_ _04560_ _04780_ VGND VGND VPWR VPWR _06683_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11020_ _01826_ _01828_ _01830_ VGND VGND VPWR VPWR _01831_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_99_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12971_ net211 _03223_ _03814_ VGND VGND VPWR VPWR _03815_ sky130_fd_sc_hd__and3_1
X_14710_ _05721_ _05722_ VGND VGND VPWR VPWR _05723_ sky130_fd_sc_hd__and2_1
X_11922_ net416 net420 net154 net160 VGND VGND VPWR VPWR _02733_ sky130_fd_sc_hd__and4_1
X_15690_ _06791_ _06792_ VGND VGND VPWR VPWR _06801_ sky130_fd_sc_hd__and2_1
XFILLER_0_68_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14641_ _05645_ _05646_ VGND VGND VPWR VPWR _05647_ sky130_fd_sc_hd__nor2_1
X_11853_ _02588_ _02663_ VGND VGND VPWR VPWR _02664_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_67_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17360_ net466 _08081_ VGND VGND VPWR VPWR _08583_ sky130_fd_sc_hd__nand2_1
X_10804_ _01596_ _01593_ _01598_ VGND VGND VPWR VPWR _01615_ sky130_fd_sc_hd__or3_1
X_14572_ _03748_ _05569_ _05570_ VGND VGND VPWR VPWR _05571_ sky130_fd_sc_hd__a21o_4
X_11784_ _02593_ _02591_ VGND VGND VPWR VPWR _02595_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_27_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16311_ _07238_ _07240_ _07483_ VGND VGND VPWR VPWR _07484_ sky130_fd_sc_hd__o21ai_2
X_13523_ _04354_ _04357_ VGND VGND VPWR VPWR _04418_ sky130_fd_sc_hd__xor2_4
X_17291_ net462 prev_error\[4\] VGND VGND VPWR VPWR _08540_ sky130_fd_sc_hd__or2_1
XFILLER_0_103_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10735_ _01544_ _01545_ VGND VGND VPWR VPWR _01546_ sky130_fd_sc_hd__nor2_1
XFILLER_0_82_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_868 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16242_ _07369_ _07406_ _07399_ _07405_ VGND VGND VPWR VPWR _07408_ sky130_fd_sc_hd__o211a_1
XFILLER_0_125_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13454_ _04331_ _04339_ _04341_ VGND VGND VPWR VPWR _04342_ sky130_fd_sc_hd__a21o_1
X_10666_ _01475_ _01476_ VGND VGND VPWR VPWR _01477_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12405_ net185 _03234_ _03236_ VGND VGND VPWR VPWR _03237_ sky130_fd_sc_hd__and3_1
X_16173_ _07330_ _07331_ VGND VGND VPWR VPWR _07333_ sky130_fd_sc_hd__xnor2_1
X_13385_ net184 net183 _03936_ _04004_ VGND VGND VPWR VPWR _04266_ sky130_fd_sc_hd__and4_1
XFILLER_0_88_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10597_ _01245_ _01287_ VGND VGND VPWR VPWR _01408_ sky130_fd_sc_hd__nand2_1
XFILLER_0_51_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15124_ _06176_ _06178_ VGND VGND VPWR VPWR _06179_ sky130_fd_sc_hd__and2_1
XFILLER_0_50_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12336_ _02126_ _03165_ _03167_ VGND VGND VPWR VPWR _03168_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_50_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15055_ _03316_ _05686_ _05687_ net308 VGND VGND VPWR VPWR _06103_ sky130_fd_sc_hd__o211a_2
X_12267_ _03041_ _03070_ _03089_ _03098_ VGND VGND VPWR VPWR _03099_ sky130_fd_sc_hd__or4b_1
XFILLER_0_120_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11218_ _01909_ _02028_ VGND VGND VPWR VPWR _02029_ sky130_fd_sc_hd__xor2_1
X_14006_ net239 _03576_ _04892_ _04893_ VGND VGND VPWR VPWR _04949_ sky130_fd_sc_hd__a22o_1
X_12198_ _03019_ _03013_ _03017_ VGND VGND VPWR VPWR _03023_ sky130_fd_sc_hd__or3_1
Xoutput80 net80 VGND VGND VPWR VPWR out_clocked[13] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput91 net91 VGND VGND VPWR VPWR out_clocked[7] sky130_fd_sc_hd__buf_2
X_11149_ net418 net123 VGND VGND VPWR VPWR _01960_ sky130_fd_sc_hd__nand2_1
X_15957_ net274 _06416_ VGND VGND VPWR VPWR _07095_ sky130_fd_sc_hd__nand2_1
X_14908_ net265 _05631_ VGND VGND VPWR VPWR _05941_ sky130_fd_sc_hd__nand2_1
X_15888_ _07014_ _07018_ VGND VGND VPWR VPWR _07019_ sky130_fd_sc_hd__xor2_1
XFILLER_0_53_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14839_ _05863_ _05864_ VGND VGND VPWR VPWR _05865_ sky130_fd_sc_hd__or2b_1
XFILLER_0_86_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16509_ _07681_ _07701_ VGND VGND VPWR VPWR _07702_ sky130_fd_sc_hd__and2_1
XFILLER_0_128_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17489_ clknet_4_5_0_clock _00049_ VGND VGND VPWR VPWR ki\[5\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_144_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout303 ki\[2\] VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__clkbuf_4
Xfanout314 net315 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__clkbuf_4
Xfanout325 net326 VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__buf_2
Xfanout336 kp\[10\] VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__clkbuf_4
X_09814_ _00624_ _00576_ VGND VGND VPWR VPWR _00625_ sky130_fd_sc_hd__xor2_2
Xfanout347 kp\[8\] VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__clkbuf_4
Xfanout358 kp\[5\] VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__clkbuf_4
Xfanout369 kp\[2\] VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__clkbuf_4
X_09745_ net324 VGND VGND VPWR VPWR _00556_ sky130_fd_sc_hd__inv_2
X_09676_ _00456_ _00454_ _00455_ VGND VGND VPWR VPWR _00487_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_49_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_879 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10520_ net366 _00518_ VGND VGND VPWR VPWR _01331_ sky130_fd_sc_hd__nand2_1
XFILLER_0_134_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10451_ _01210_ _01261_ VGND VGND VPWR VPWR _01262_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_150_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13170_ _03229_ _03231_ VGND VGND VPWR VPWR _04029_ sky130_fd_sc_hd__and2_1
XFILLER_0_134_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10382_ net376 net523 _01191_ _01192_ VGND VGND VPWR VPWR _01193_ sky130_fd_sc_hd__a31o_1
X_12121_ _02869_ _02945_ VGND VGND VPWR VPWR _02946_ sky130_fd_sc_hd__nor2_1
XFILLER_0_102_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12052_ net437 net150 net154 net433 VGND VGND VPWR VPWR _02871_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_102_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11003_ _01739_ _01741_ VGND VGND VPWR VPWR _01814_ sky130_fd_sc_hd__nor2_1
X_16860_ _05444_ net493 _08087_ VGND VGND VPWR VPWR _08088_ sky130_fd_sc_hd__o21bai_1
X_15811_ _06817_ _06823_ VGND VGND VPWR VPWR _06934_ sky130_fd_sc_hd__xnor2_1
X_16791_ _07744_ _07975_ VGND VGND VPWR VPWR _08012_ sky130_fd_sc_hd__nor2_1
X_15742_ _06612_ _06619_ VGND VGND VPWR VPWR _06858_ sky130_fd_sc_hd__nor2_1
X_12954_ _03782_ _03785_ _03786_ VGND VGND VPWR VPWR _03798_ sky130_fd_sc_hd__or3_1
X_11905_ _02708_ _02713_ _02715_ VGND VGND VPWR VPWR _02716_ sky130_fd_sc_hd__or3_1
XFILLER_0_87_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15673_ _06722_ _06757_ VGND VGND VPWR VPWR _06783_ sky130_fd_sc_hd__nor2_1
X_12885_ net185 _03261_ _03656_ VGND VGND VPWR VPWR _03729_ sky130_fd_sc_hd__a21oi_1
X_17412_ clknet_4_0_0_clock _00090_ VGND VGND VPWR VPWR prev_error\[0\] sky130_fd_sc_hd__dfxtp_1
X_14624_ _05626_ _05628_ VGND VGND VPWR VPWR _05629_ sky130_fd_sc_hd__and2_1
XFILLER_0_56_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11836_ _02599_ _02646_ VGND VGND VPWR VPWR _02647_ sky130_fd_sc_hd__or2_1
XFILLER_0_23_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17343_ _08564_ _08214_ _08572_ net452 VGND VGND VPWR VPWR _00118_ sky130_fd_sc_hd__o211a_1
X_14555_ _05515_ _05522_ _05552_ VGND VGND VPWR VPWR _05553_ sky130_fd_sc_hd__and3_4
XFILLER_0_126_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11767_ net414 net156 VGND VGND VPWR VPWR _02578_ sky130_fd_sc_hd__nand2_1
XFILLER_0_82_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13506_ _04359_ _04361_ VGND VGND VPWR VPWR _04399_ sky130_fd_sc_hd__nor2_1
X_17274_ net464 net512 net454 VGND VGND VPWR VPWR _08530_ sky130_fd_sc_hd__o21ai_1
X_10718_ _01527_ _01528_ VGND VGND VPWR VPWR _01529_ sky130_fd_sc_hd__or2_1
X_14486_ net526 _03305_ VGND VGND VPWR VPWR _05477_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11698_ _02507_ _02508_ net414 net152 VGND VGND VPWR VPWR _02509_ sky130_fd_sc_hd__and4b_1
XFILLER_0_71_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16225_ net291 _04313_ _07389_ VGND VGND VPWR VPWR _07390_ sky130_fd_sc_hd__a21o_1
XFILLER_0_82_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13437_ _04309_ _04321_ _04322_ VGND VGND VPWR VPWR _04323_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_23_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer2 net530 VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__clkbuf_1
X_10649_ net430 net448 net107 VGND VGND VPWR VPWR _01460_ sky130_fd_sc_hd__and3_2
XFILLER_0_113_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16156_ _07312_ _07313_ VGND VGND VPWR VPWR _07314_ sky130_fd_sc_hd__xor2_1
X_13368_ _04236_ _04245_ _04246_ VGND VGND VPWR VPWR _04247_ sky130_fd_sc_hd__a21o_1
XFILLER_0_23_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15107_ _03788_ _05567_ VGND VGND VPWR VPWR _06160_ sky130_fd_sc_hd__xnor2_4
X_12319_ _02569_ _03150_ VGND VGND VPWR VPWR _03151_ sky130_fd_sc_hd__or2_1
X_16087_ _07235_ _07237_ VGND VGND VPWR VPWR _07238_ sky130_fd_sc_hd__and2b_1
X_13299_ net224 _03222_ VGND VGND VPWR VPWR _04171_ sky130_fd_sc_hd__nand2_1
X_15038_ _06005_ _06083_ VGND VGND VPWR VPWR _06084_ sky130_fd_sc_hd__and2_1
XFILLER_0_48_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16989_ _05422_ _08055_ VGND VGND VPWR VPWR _08230_ sky130_fd_sc_hd__xor2_1
X_09530_ net369 net364 _05385_ VGND VGND VPWR VPWR _00341_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_3_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09461_ net377 net360 _05385_ _05638_ VGND VGND VPWR VPWR _00272_ sky130_fd_sc_hd__and4_1
XFILLER_0_148_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09392_ _00190_ _00191_ VGND VGND VPWR VPWR _00203_ sky130_fd_sc_hd__xor2_2
XFILLER_0_59_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_868 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout111 kd_2\[16\] VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__clkbuf_4
Xfanout122 kd_2\[13\] VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__clkbuf_2
Xfanout133 kd_2\[11\] VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__buf_2
Xfanout144 kd_2\[8\] VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__buf_2
Xfanout155 net156 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__buf_2
Xfanout166 net167 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__clkbuf_4
Xfanout177 net178 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout188 net191 VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__clkbuf_4
Xfanout199 net200 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09728_ _00505_ _00537_ _00538_ VGND VGND VPWR VPWR _00539_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_97_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09659_ net333 _07409_ VGND VGND VPWR VPWR _00470_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12670_ _03496_ _03507_ _03508_ VGND VGND VPWR VPWR _03509_ sky130_fd_sc_hd__nand3_1
XFILLER_0_77_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11621_ _02425_ _02430_ _02418_ _02431_ VGND VGND VPWR VPWR _02432_ sky130_fd_sc_hd__o211ai_2
X_14340_ _05311_ _05315_ VGND VGND VPWR VPWR _05316_ sky130_fd_sc_hd__xnor2_1
X_11552_ _02338_ _02339_ _02325_ _02337_ VGND VGND VPWR VPWR _02363_ sky130_fd_sc_hd__o211a_1
XFILLER_0_107_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10503_ _01305_ _01312_ _01313_ VGND VGND VPWR VPWR _01314_ sky130_fd_sc_hd__nand3_1
X_14271_ _05237_ _05239_ VGND VGND VPWR VPWR _05240_ sky130_fd_sc_hd__nand2_1
X_11483_ _02289_ _02293_ VGND VGND VPWR VPWR _02294_ sky130_fd_sc_hd__xor2_1
XFILLER_0_135_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16010_ _06997_ _07076_ _07075_ VGND VGND VPWR VPWR _07153_ sky130_fd_sc_hd__o21a_1
XFILLER_0_61_871 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10434_ _01243_ _01244_ VGND VGND VPWR VPWR _01245_ sky130_fd_sc_hd__xnor2_1
X_13222_ _04084_ _04064_ VGND VGND VPWR VPWR _04086_ sky130_fd_sc_hd__and2b_1
XFILLER_0_21_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10365_ _01123_ _01173_ _01175_ VGND VGND VPWR VPWR _01176_ sky130_fd_sc_hd__o21ai_1
X_13153_ _04008_ _04009_ VGND VGND VPWR VPWR _04011_ sky130_fd_sc_hd__nor2_1
X_12104_ _02919_ _02926_ _02928_ VGND VGND VPWR VPWR _02929_ sky130_fd_sc_hd__nand3_1
X_13084_ _03934_ VGND VGND VPWR VPWR _03935_ sky130_fd_sc_hd__clkbuf_4
X_10296_ _01039_ _01106_ VGND VGND VPWR VPWR _01107_ sky130_fd_sc_hd__xnor2_4
X_16912_ _05248_ _05289_ VGND VGND VPWR VPWR _08145_ sky130_fd_sc_hd__xnor2_2
X_12035_ net428 net446 net146 net162 VGND VGND VPWR VPWR _02853_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16843_ net478 _07966_ _07967_ _07782_ VGND VGND VPWR VPWR _08070_ sky130_fd_sc_hd__o211a_1
XFILLER_0_18_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16774_ _07813_ _07985_ _07987_ _07989_ _07993_ VGND VGND VPWR VPWR _07994_ sky130_fd_sc_hd__a221o_1
X_13986_ net214 _04106_ _04002_ net218 VGND VGND VPWR VPWR _04927_ sky130_fd_sc_hd__a22o_1
X_15725_ _06809_ _06839_ VGND VGND VPWR VPWR _06840_ sky130_fd_sc_hd__nand2b_1
XFILLER_0_88_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12937_ net194 _03270_ VGND VGND VPWR VPWR _03781_ sky130_fd_sc_hd__nand2_1
X_15656_ _06761_ _06759_ _06730_ _06681_ VGND VGND VPWR VPWR _06764_ sky130_fd_sc_hd__o211a_1
X_12868_ _03707_ _03711_ VGND VGND VPWR VPWR _03712_ sky130_fd_sc_hd__xor2_1
XFILLER_0_87_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14607_ prev_error\[10\] _04593_ VGND VGND VPWR VPWR _05610_ sky130_fd_sc_hd__nand2_1
XFILLER_0_145_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11819_ _02623_ _02626_ _02629_ VGND VGND VPWR VPWR _02630_ sky130_fd_sc_hd__a21oi_1
X_15587_ _06684_ _06687_ VGND VGND VPWR VPWR _06688_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_139_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12799_ net185 _03250_ VGND VGND VPWR VPWR _03643_ sky130_fd_sc_hd__nand2_1
XFILLER_0_55_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17326_ _08549_ _08106_ _08562_ net452 VGND VGND VPWR VPWR _00110_ sky130_fd_sc_hd__o211a_1
XFILLER_0_126_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14538_ net526 _03305_ _05480_ _05479_ VGND VGND VPWR VPWR _05534_ sky130_fd_sc_hd__a31o_1
XFILLER_0_141_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17257_ _08515_ _08516_ net454 VGND VGND VPWR VPWR _00080_ sky130_fd_sc_hd__o21a_1
XFILLER_0_70_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14469_ _05437_ _05449_ _05453_ _05457_ VGND VGND VPWR VPWR _05458_ sky130_fd_sc_hd__nor4_2
XFILLER_0_24_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16208_ _07319_ _07322_ _07320_ VGND VGND VPWR VPWR _07371_ sky130_fd_sc_hd__o21ai_1
X_17188_ _07914_ _08448_ VGND VGND VPWR VPWR _08449_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16139_ net311 _06204_ VGND VGND VPWR VPWR _07295_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08961_ _04956_ _05330_ _05594_ VGND VGND VPWR VPWR _05616_ sky130_fd_sc_hd__a21bo_2
XFILLER_0_121_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08892_ _04835_ _04846_ VGND VGND VPWR VPWR _04857_ sky130_fd_sc_hd__nand2_4
XFILLER_0_75_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09513_ _00302_ _00323_ VGND VGND VPWR VPWR _00324_ sky130_fd_sc_hd__or2b_1
XFILLER_0_149_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09444_ _08689_ _00254_ VGND VGND VPWR VPWR _00255_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09375_ _06232_ _06320_ VGND VGND VPWR VPWR _00186_ sky130_fd_sc_hd__and2b_1
XFILLER_0_19_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10150_ _00957_ _00956_ VGND VGND VPWR VPWR _00961_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_112_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10081_ _00890_ _00889_ VGND VGND VPWR VPWR _00892_ sky130_fd_sc_hd__xor2_2
X_13840_ _04072_ _04765_ _03268_ VGND VGND VPWR VPWR _04766_ sky130_fd_sc_hd__or3b_2
XFILLER_0_69_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13771_ _04526_ _04320_ VGND VGND VPWR VPWR _04690_ sky130_fd_sc_hd__and2b_1
XFILLER_0_97_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10983_ net415 net113 _01721_ VGND VGND VPWR VPWR _01794_ sky130_fd_sc_hd__a21oi_1
X_15510_ net267 _06016_ VGND VGND VPWR VPWR _06603_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12722_ _03470_ _03472_ VGND VGND VPWR VPWR _03563_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16490_ _07526_ _07680_ VGND VGND VPWR VPWR _07681_ sky130_fd_sc_hd__xor2_1
X_15441_ _03227_ _05612_ net527 VGND VGND VPWR VPWR _06527_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_133_Right_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12653_ _03453_ _03456_ _03491_ VGND VGND VPWR VPWR _03492_ sky130_fd_sc_hd__o21a_1
XFILLER_0_26_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11604_ _02412_ _02414_ VGND VGND VPWR VPWR _02415_ sky130_fd_sc_hd__or2b_1
X_15372_ _06445_ _06450_ VGND VGND VPWR VPWR _06451_ sky130_fd_sc_hd__and2b_1
XFILLER_0_65_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12584_ net239 net230 _03422_ VGND VGND VPWR VPWR _03423_ sky130_fd_sc_hd__nand3_2
X_17111_ _05417_ _08034_ VGND VGND VPWR VPWR _08364_ sky130_fd_sc_hd__and2b_1
XFILLER_0_37_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14323_ _05229_ _05295_ _05296_ VGND VGND VPWR VPWR _05298_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_108_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11535_ _02255_ _02345_ VGND VGND VPWR VPWR _02346_ sky130_fd_sc_hd__nor2_1
X_17042_ _03499_ _08280_ _08286_ VGND VGND VPWR VPWR _08288_ sky130_fd_sc_hd__nor3_1
X_14254_ _05218_ _05219_ VGND VGND VPWR VPWR _05222_ sky130_fd_sc_hd__or2_1
X_11466_ _02140_ _02276_ VGND VGND VPWR VPWR _02277_ sky130_fd_sc_hd__nand2_2
XFILLER_0_150_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13205_ _03958_ _03968_ VGND VGND VPWR VPWR _04068_ sky130_fd_sc_hd__xnor2_2
X_10417_ _01173_ _01225_ _01227_ VGND VGND VPWR VPWR _01228_ sky130_fd_sc_hd__o21ba_1
X_14185_ _04908_ _04909_ VGND VGND VPWR VPWR _05146_ sky130_fd_sc_hd__xnor2_1
X_11397_ _02085_ _02207_ VGND VGND VPWR VPWR _02208_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13136_ _03883_ _03990_ VGND VGND VPWR VPWR _03992_ sky130_fd_sc_hd__nand2_1
X_10348_ _01154_ _01158_ VGND VGND VPWR VPWR _01159_ sky130_fd_sc_hd__or2b_1
X_10279_ _01081_ _01088_ _01089_ VGND VGND VPWR VPWR _01090_ sky130_fd_sc_hd__o21ai_1
X_13067_ _03802_ _03787_ _03800_ VGND VGND VPWR VPWR _03916_ sky130_fd_sc_hd__and3_1
X_12018_ _02772_ _02833_ VGND VGND VPWR VPWR _02834_ sky130_fd_sc_hd__nand2_1
X_16826_ _07738_ VGND VGND VPWR VPWR _08051_ sky130_fd_sc_hd__inv_2
XFILLER_0_88_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16757_ _07974_ VGND VGND VPWR VPWR _07975_ sky130_fd_sc_hd__clkbuf_4
X_13969_ _04882_ _04907_ VGND VGND VPWR VPWR _04908_ sky130_fd_sc_hd__or2_1
X_15708_ net309 net491 _05734_ _05581_ net292 VGND VGND VPWR VPWR _06821_ sky130_fd_sc_hd__a32o_1
X_16688_ _07862_ _07898_ VGND VGND VPWR VPWR _07899_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15639_ _06737_ _06739_ _06744_ VGND VGND VPWR VPWR _06745_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09160_ net326 _04439_ _07794_ VGND VGND VPWR VPWR _07805_ sky130_fd_sc_hd__and3_1
XFILLER_0_28_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17309_ _08549_ _04450_ _08551_ net450 VGND VGND VPWR VPWR _00102_ sky130_fd_sc_hd__o211a_1
XFILLER_0_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09091_ _07024_ _06551_ _06595_ VGND VGND VPWR VPWR _07046_ sky130_fd_sc_hd__or3_1
XFILLER_0_126_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09993_ _00789_ _00803_ VGND VGND VPWR VPWR _00804_ sky130_fd_sc_hd__xor2_2
XFILLER_0_86_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08944_ net377 net360 _05418_ VGND VGND VPWR VPWR _05429_ sky130_fd_sc_hd__nand3_2
X_08875_ _04461_ _04538_ _04659_ VGND VGND VPWR VPWR _04670_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_79_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09427_ _04197_ _04032_ _04131_ VGND VGND VPWR VPWR _00238_ sky130_fd_sc_hd__nand3_4
XFILLER_0_94_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09358_ _08695_ _08696_ VGND VGND VPWR VPWR _00169_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09289_ _08627_ _08651_ _08652_ VGND VGND VPWR VPWR _08653_ sky130_fd_sc_hd__or3_1
XFILLER_0_90_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11320_ _02129_ _02130_ net391 net161 VGND VGND VPWR VPWR _02131_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_144_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_2_0_clock clknet_0_clock VGND VGND VPWR VPWR clknet_4_2_0_clock sky130_fd_sc_hd__clkbuf_8
XFILLER_0_31_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11251_ _02032_ _02047_ _02061_ VGND VGND VPWR VPWR _02062_ sky130_fd_sc_hd__o21ba_1
X_10202_ net367 _07409_ _00936_ _01012_ VGND VGND VPWR VPWR _01013_ sky130_fd_sc_hd__a31o_1
X_11182_ _01927_ _01992_ VGND VGND VPWR VPWR _01993_ sky130_fd_sc_hd__nor2_1
X_10133_ _00942_ _00943_ VGND VGND VPWR VPWR _00944_ sky130_fd_sc_hd__and2b_1
XFILLER_0_100_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15990_ net306 _05602_ _07129_ _07130_ VGND VGND VPWR VPWR _07131_ sky130_fd_sc_hd__nand4_1
X_14941_ net249 _05666_ _05604_ net252 VGND VGND VPWR VPWR _05977_ sky130_fd_sc_hd__a22o_1
X_10064_ _00864_ _00873_ _00874_ VGND VGND VPWR VPWR _00875_ sky130_fd_sc_hd__a21bo_1
X_14872_ _05714_ _05716_ VGND VGND VPWR VPWR _05901_ sky130_fd_sc_hd__xnor2_1
X_16611_ _07753_ VGND VGND VPWR VPWR _07814_ sky130_fd_sc_hd__inv_2
X_13823_ _04687_ _04683_ VGND VGND VPWR VPWR _04748_ sky130_fd_sc_hd__and2b_1
X_16542_ _07726_ _07737_ VGND VGND VPWR VPWR _07738_ sky130_fd_sc_hd__nor2_1
X_13754_ _04662_ _04668_ _04669_ VGND VGND VPWR VPWR _04672_ sky130_fd_sc_hd__nand3_1
X_10966_ _01770_ _01775_ VGND VGND VPWR VPWR _01777_ sky130_fd_sc_hd__nand2_1
X_12705_ _03397_ _03544_ VGND VGND VPWR VPWR _03545_ sky130_fd_sc_hd__xnor2_1
X_16473_ _07515_ _07521_ VGND VGND VPWR VPWR _07663_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13685_ _04589_ _04592_ _04594_ VGND VGND VPWR VPWR _04596_ sky130_fd_sc_hd__nor3_1
X_10897_ _01706_ _01707_ VGND VGND VPWR VPWR _01708_ sky130_fd_sc_hd__nand2_1
XFILLER_0_127_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15424_ net303 _05626_ _05628_ net296 _05745_ VGND VGND VPWR VPWR _06509_ sky130_fd_sc_hd__a32o_1
X_12636_ _03468_ _03473_ _03461_ VGND VGND VPWR VPWR _03475_ sky130_fd_sc_hd__o21a_1
XFILLER_0_122_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15355_ _06432_ _06103_ VGND VGND VPWR VPWR _06433_ sky130_fd_sc_hd__xor2_2
X_12567_ net176 _03288_ _03278_ net181 VGND VGND VPWR VPWR _03406_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_108_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14306_ _05274_ _05276_ _05278_ VGND VGND VPWR VPWR _05279_ sky130_fd_sc_hd__a21o_1
XFILLER_0_108_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11518_ _02326_ _02328_ VGND VGND VPWR VPWR _02329_ sky130_fd_sc_hd__xnor2_1
X_15286_ _06345_ _06356_ VGND VGND VPWR VPWR _06357_ sky130_fd_sc_hd__and2_1
XFILLER_0_124_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12498_ _03334_ VGND VGND VPWR VPWR _03335_ sky130_fd_sc_hd__buf_2
XFILLER_0_1_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17025_ _08263_ _08269_ VGND VGND VPWR VPWR _08270_ sky130_fd_sc_hd__and2_1
X_14237_ _05201_ _05202_ VGND VGND VPWR VPWR _05203_ sky130_fd_sc_hd__nand2_2
X_11449_ net391 net160 _02129_ _02130_ VGND VGND VPWR VPWR _02260_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_22_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14168_ _04943_ _04946_ VGND VGND VPWR VPWR _05127_ sky130_fd_sc_hd__or2_1
X_13119_ _03953_ _03971_ _03972_ VGND VGND VPWR VPWR _03973_ sky130_fd_sc_hd__o21a_1
X_14099_ _05021_ VGND VGND VPWR VPWR _05051_ sky130_fd_sc_hd__inv_2
XFILLER_0_147_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16809_ _08028_ _08030_ _08031_ VGND VGND VPWR VPWR _08032_ sky130_fd_sc_hd__a21o_4
XFILLER_0_88_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09212_ _06298_ _08366_ VGND VGND VPWR VPWR _08377_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_9_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09143_ _05297_ _07607_ VGND VGND VPWR VPWR _07618_ sky130_fd_sc_hd__or2_1
XFILLER_0_98_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09074_ _06430_ _06496_ _06408_ VGND VGND VPWR VPWR _06859_ sky130_fd_sc_hd__a21o_1
XFILLER_0_112_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2 _03752_ VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__buf_2
XFILLER_0_40_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09976_ _00649_ _00657_ _00641_ VGND VGND VPWR VPWR _00787_ sky130_fd_sc_hd__a21oi_1
X_08927_ net321 _04450_ _05220_ _05231_ VGND VGND VPWR VPWR _05242_ sky130_fd_sc_hd__a31o_1
XFILLER_0_99_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08858_ _03944_ _04021_ _04384_ VGND VGND VPWR VPWR _04483_ sky130_fd_sc_hd__and3_2
XFILLER_0_79_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08789_ net43 _03542_ _03575_ net324 VGND VGND VPWR VPWR _00059_ sky130_fd_sc_hd__a22o_1
XFILLER_0_95_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10820_ _01518_ _01614_ _01629_ VGND VGND VPWR VPWR _01631_ sky130_fd_sc_hd__nand3_1
XFILLER_0_67_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_9_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10751_ _01561_ VGND VGND VPWR VPWR _01562_ sky130_fd_sc_hd__clkbuf_4
X_13470_ _04344_ _04358_ _04342_ VGND VGND VPWR VPWR _04359_ sky130_fd_sc_hd__o21a_2
XFILLER_0_137_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10682_ net406 net112 net109 net412 VGND VGND VPWR VPWR _01493_ sky130_fd_sc_hd__a22o_1
X_12421_ _03251_ _03252_ VGND VGND VPWR VPWR _03253_ sky130_fd_sc_hd__nor2_1
XFILLER_0_63_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15140_ _06194_ _06195_ VGND VGND VPWR VPWR _06196_ sky130_fd_sc_hd__nand2_1
XFILLER_0_63_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12352_ prev_error\[9\] VGND VGND VPWR VPWR _03184_ sky130_fd_sc_hd__inv_2
XFILLER_0_106_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11303_ _02113_ VGND VGND VPWR VPWR _02114_ sky130_fd_sc_hd__inv_2
X_15071_ _06037_ _06119_ VGND VGND VPWR VPWR _06120_ sky130_fd_sc_hd__or2_2
X_12283_ _03107_ _03113_ _03114_ VGND VGND VPWR VPWR _03115_ sky130_fd_sc_hd__nand3_1
XFILLER_0_120_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14022_ net238 net230 _03791_ _03934_ VGND VGND VPWR VPWR _04966_ sky130_fd_sc_hd__and4_1
X_11234_ _02037_ _02039_ VGND VGND VPWR VPWR _02045_ sky130_fd_sc_hd__xnor2_1
X_11165_ net407 net413 net136 net130 VGND VGND VPWR VPWR _01976_ sky130_fd_sc_hd__and4_1
X_10116_ _00924_ _00926_ VGND VGND VPWR VPWR _00927_ sky130_fd_sc_hd__nand2_1
X_15973_ _07100_ _07106_ VGND VGND VPWR VPWR _07113_ sky130_fd_sc_hd__and2_1
X_11096_ _01888_ _01890_ VGND VGND VPWR VPWR _01907_ sky130_fd_sc_hd__xnor2_1
X_14924_ _05955_ _05958_ VGND VGND VPWR VPWR _05959_ sky130_fd_sc_hd__and2_1
X_10047_ _00826_ _00857_ VGND VGND VPWR VPWR _00858_ sky130_fd_sc_hd__xor2_1
X_14855_ net254 _05739_ VGND VGND VPWR VPWR _05883_ sky130_fd_sc_hd__nand2_1
X_13806_ _04722_ _04727_ _04645_ _04694_ VGND VGND VPWR VPWR _04729_ sky130_fd_sc_hd__o211ai_2
X_14786_ net258 _05739_ _05801_ net261 VGND VGND VPWR VPWR _05807_ sky130_fd_sc_hd__a22oi_1
X_11998_ _02805_ _02810_ _02811_ VGND VGND VPWR VPWR _02812_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16525_ i_error\[15\] _07718_ VGND VGND VPWR VPWR _07720_ sky130_fd_sc_hd__nor2_1
X_13737_ _03805_ _04573_ VGND VGND VPWR VPWR _04653_ sky130_fd_sc_hd__nor2_1
XFILLER_0_86_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10949_ _01755_ _01757_ _01759_ VGND VGND VPWR VPWR _01760_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_73_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16456_ net489 _07593_ i_error\[8\] VGND VGND VPWR VPWR _07644_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_6_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13668_ _04572_ _04574_ _04576_ VGND VGND VPWR VPWR _04577_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_38_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15407_ _06486_ VGND VGND VPWR VPWR _06490_ sky130_fd_sc_hd__inv_2
X_12619_ _03456_ _03457_ VGND VGND VPWR VPWR _03458_ sky130_fd_sc_hd__or2_1
X_16387_ _07566_ _07567_ VGND VGND VPWR VPWR _07568_ sky130_fd_sc_hd__nor2_2
XFILLER_0_143_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13599_ _04497_ _04500_ VGND VGND VPWR VPWR _04501_ sky130_fd_sc_hd__xor2_1
XFILLER_0_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15338_ _06350_ _06352_ VGND VGND VPWR VPWR _06414_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_53_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15269_ net263 _05666_ _05975_ net259 VGND VGND VPWR VPWR _06338_ sky130_fd_sc_hd__a22o_1
XFILLER_0_112_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17008_ _08230_ _08239_ VGND VGND VPWR VPWR _08251_ sky130_fd_sc_hd__and2_1
XFILLER_0_111_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09830_ _00563_ _00555_ VGND VGND VPWR VPWR _00641_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09761_ _00567_ _00569_ _00571_ VGND VGND VPWR VPWR _00572_ sky130_fd_sc_hd__and3_1
X_08712_ net39 _02894_ _02927_ net134 VGND VGND VPWR VPWR _00019_ sky130_fd_sc_hd__a22o_1
X_09692_ _00482_ _00501_ _00502_ VGND VGND VPWR VPWR _00503_ sky130_fd_sc_hd__a21o_1
Xrebuffer12 _07913_ VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__clkbuf_1
Xrebuffer23 _08086_ VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09126_ net317 _04626_ _07343_ net313 VGND VGND VPWR VPWR _07431_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_60_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09057_ _06441_ _06485_ _06474_ VGND VGND VPWR VPWR _06672_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_103_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09959_ _00768_ _00769_ VGND VGND VPWR VPWR _00770_ sky130_fd_sc_hd__nor2_1
X_12970_ _03812_ _03813_ VGND VGND VPWR VPWR _03814_ sky130_fd_sc_hd__nor2_1
X_11921_ net420 net156 net160 net416 VGND VGND VPWR VPWR _02732_ sky130_fd_sc_hd__a22oi_2
X_14640_ _05642_ _05644_ VGND VGND VPWR VPWR _05646_ sky130_fd_sc_hd__and2_1
X_11852_ _02590_ _02589_ VGND VGND VPWR VPWR _02663_ sky130_fd_sc_hd__nor2_1
XFILLER_0_68_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10803_ _01503_ _01520_ VGND VGND VPWR VPWR _01614_ sky130_fd_sc_hd__or2b_1
X_14571_ prev_error\[5\] _08674_ VGND VGND VPWR VPWR _05570_ sky130_fd_sc_hd__and2_1
X_11783_ _02591_ _02593_ VGND VGND VPWR VPWR _02594_ sky130_fd_sc_hd__and2b_1
XFILLER_0_95_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16310_ _07336_ _07479_ _07480_ _07481_ _07482_ VGND VGND VPWR VPWR _07483_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_83_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13522_ _04409_ _04410_ _04415_ VGND VGND VPWR VPWR _04416_ sky130_fd_sc_hd__a21o_2
X_17290_ _08536_ _00316_ _08539_ net460 VGND VGND VPWR VPWR _00093_ sky130_fd_sc_hd__o211a_1
X_10734_ net390 net129 _01542_ _01543_ VGND VGND VPWR VPWR _01545_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_137_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16241_ _07399_ _07405_ _07369_ _07406_ VGND VGND VPWR VPWR _07407_ sky130_fd_sc_hd__a211o_1
X_13453_ _04226_ _04229_ VGND VGND VPWR VPWR _04341_ sky130_fd_sc_hd__xnor2_1
X_10665_ _01469_ _01471_ _01468_ VGND VGND VPWR VPWR _01476_ sky130_fd_sc_hd__o21ba_1
X_12404_ _03224_ _03235_ VGND VGND VPWR VPWR _03236_ sky130_fd_sc_hd__nor2_1
XFILLER_0_36_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16172_ _07283_ _07284_ VGND VGND VPWR VPWR _07331_ sky130_fd_sc_hd__xor2_1
X_13384_ _04110_ _04264_ VGND VGND VPWR VPWR _04265_ sky130_fd_sc_hd__xnor2_1
X_10596_ _01320_ _01403_ _01406_ _01289_ VGND VGND VPWR VPWR _01407_ sky130_fd_sc_hd__o211a_1
XFILLER_0_35_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15123_ _06172_ _06173_ _06175_ VGND VGND VPWR VPWR _06178_ sky130_fd_sc_hd__nand3_1
X_12335_ _02030_ _03166_ VGND VGND VPWR VPWR _03167_ sky130_fd_sc_hd__or2_1
XFILLER_0_23_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15054_ net288 _05710_ VGND VGND VPWR VPWR _06102_ sky130_fd_sc_hd__nand2_1
X_12266_ _03043_ _03092_ _03097_ VGND VGND VPWR VPWR _03098_ sky130_fd_sc_hd__and3_1
X_14005_ _04888_ _04896_ VGND VGND VPWR VPWR _04948_ sky130_fd_sc_hd__xor2_2
X_11217_ _01935_ _01934_ VGND VGND VPWR VPWR _02028_ sky130_fd_sc_hd__and2_1
X_12197_ _03021_ _03007_ VGND VGND VPWR VPWR _03022_ sky130_fd_sc_hd__xor2_1
Xoutput81 net81 VGND VGND VPWR VPWR out_clocked[14] sky130_fd_sc_hd__buf_2
Xoutput92 net92 VGND VGND VPWR VPWR out_clocked[8] sky130_fd_sc_hd__buf_2
X_11148_ net414 net126 VGND VGND VPWR VPWR _01959_ sky130_fd_sc_hd__nand2_1
XFILLER_0_128_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15956_ net271 _06416_ _06348_ net274 VGND VGND VPWR VPWR _07094_ sky130_fd_sc_hd__a22o_1
X_11079_ _01841_ _01889_ VGND VGND VPWR VPWR _01890_ sky130_fd_sc_hd__nand2_1
X_14907_ _05938_ _05939_ VGND VGND VPWR VPWR _05940_ sky130_fd_sc_hd__and2_1
X_15887_ net267 _06416_ _07016_ _07017_ VGND VGND VPWR VPWR _07018_ sky130_fd_sc_hd__a31o_1
XFILLER_0_77_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14838_ _05854_ _05845_ VGND VGND VPWR VPWR _05864_ sky130_fd_sc_hd__nand2_1
X_14769_ _05786_ _05787_ VGND VGND VPWR VPWR _05788_ sky130_fd_sc_hd__nor2_1
XFILLER_0_129_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16508_ _07699_ _07700_ VGND VGND VPWR VPWR _07701_ sky130_fd_sc_hd__xor2_1
X_17488_ clknet_4_5_0_clock _00048_ VGND VGND VPWR VPWR ki\[4\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_128_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16439_ _07623_ _07624_ VGND VGND VPWR VPWR _07625_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_144_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout304 ki\[1\] VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__buf_2
Xfanout315 net316 VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__buf_2
Xfanout326 net327 VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__clkbuf_2
X_09813_ _00577_ _00572_ VGND VGND VPWR VPWR _00624_ sky130_fd_sc_hd__nor2_1
Xfanout337 kp\[10\] VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__clkbuf_2
Xfanout348 net351 VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout359 kp\[5\] VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__clkbuf_2
X_09744_ _00553_ _00554_ VGND VGND VPWR VPWR _00555_ sky130_fd_sc_hd__nand2_1
X_09675_ _00456_ _00454_ _00455_ VGND VGND VPWR VPWR _00486_ sky130_fd_sc_hd__or3_1
XFILLER_0_68_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_99_Left_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10450_ _01212_ _01217_ VGND VGND VPWR VPWR _01261_ sky130_fd_sc_hd__xnor2_1
X_09109_ _07200_ _07233_ _07178_ VGND VGND VPWR VPWR _07244_ sky130_fd_sc_hd__a21o_1
XFILLER_0_122_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10381_ net367 _08675_ _01141_ VGND VGND VPWR VPWR _01192_ sky130_fd_sc_hd__and3_1
X_12120_ net442 net150 _02867_ _02868_ VGND VGND VPWR VPWR _02945_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_130_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12051_ net433 net437 net150 net154 VGND VGND VPWR VPWR _02870_ sky130_fd_sc_hd__and4_1
XFILLER_0_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11002_ _01467_ _01795_ VGND VGND VPWR VPWR _01813_ sky130_fd_sc_hd__or2b_1
X_15810_ _06867_ _06868_ _06884_ VGND VGND VPWR VPWR _06933_ sky130_fd_sc_hd__o21ba_1
X_16790_ _07994_ _08008_ _07979_ _08009_ _08010_ VGND VGND VPWR VPWR _08011_ sky130_fd_sc_hd__a2111o_1
X_15741_ _06831_ _06834_ VGND VGND VPWR VPWR _06857_ sky130_fd_sc_hd__nand2_1
X_12953_ _03794_ _03795_ _03796_ VGND VGND VPWR VPWR _03797_ sky130_fd_sc_hd__a21o_1
XFILLER_0_87_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11904_ _02714_ _02638_ VGND VGND VPWR VPWR _02715_ sky130_fd_sc_hd__xnor2_1
X_15672_ _06747_ _06766_ _06779_ _06780_ VGND VGND VPWR VPWR _06781_ sky130_fd_sc_hd__a211o_4
XFILLER_0_59_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12884_ _03727_ _03726_ VGND VGND VPWR VPWR _03728_ sky130_fd_sc_hd__xnor2_1
X_14623_ _03177_ _03218_ net479 VGND VGND VPWR VPWR _05628_ sky130_fd_sc_hd__nand3_4
X_17411_ clknet_4_10_0_clock _00089_ VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dfxtp_1
X_11835_ _02595_ _02598_ VGND VGND VPWR VPWR _02646_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17342_ net463 i_error\[10\] VGND VGND VPWR VPWR _08572_ sky130_fd_sc_hd__or2_1
X_14554_ _05523_ _05551_ VGND VGND VPWR VPWR _05552_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_67_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11766_ _02571_ _02573_ _02576_ VGND VGND VPWR VPWR _02577_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_56_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13505_ _04396_ _04397_ VGND VGND VPWR VPWR _04398_ sky130_fd_sc_hd__nand2_2
X_17273_ _08527_ _08528_ VGND VGND VPWR VPWR _00085_ sky130_fd_sc_hd__nor2_1
X_10717_ _01475_ _01526_ VGND VGND VPWR VPWR _01528_ sky130_fd_sc_hd__and2_1
X_14485_ _06683_ _06694_ _06716_ VGND VGND VPWR VPWR _05476_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_71_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11697_ net422 net143 net148 net417 VGND VGND VPWR VPWR _02508_ sky130_fd_sc_hd__a22o_1
X_16224_ _07386_ _07388_ VGND VGND VPWR VPWR _07389_ sky130_fd_sc_hd__and2_1
XFILLER_0_125_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13436_ _04300_ _04304_ _04306_ VGND VGND VPWR VPWR _04322_ sky130_fd_sc_hd__o21a_1
XFILLER_0_130_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10648_ net445 _01458_ VGND VGND VPWR VPWR _01459_ sky130_fd_sc_hd__and2_2
XFILLER_0_141_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer3 net472 VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__clkbuf_1
X_16155_ net298 _06204_ VGND VGND VPWR VPWR _07313_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13367_ _04239_ _04244_ VGND VGND VPWR VPWR _04246_ sky130_fd_sc_hd__nor2_1
X_10579_ net371 _00654_ _01376_ VGND VGND VPWR VPWR _01390_ sky130_fd_sc_hd__a21oi_1
X_15106_ ki\[15\] _06017_ VGND VGND VPWR VPWR _06159_ sky130_fd_sc_hd__nand2_1
XFILLER_0_51_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12318_ _02570_ _02642_ _03149_ VGND VGND VPWR VPWR _03150_ sky130_fd_sc_hd__o21a_1
X_16086_ _07179_ _07236_ VGND VGND VPWR VPWR _07237_ sky130_fd_sc_hd__and2_1
X_13298_ _04077_ _04166_ _04169_ VGND VGND VPWR VPWR _04170_ sky130_fd_sc_hd__nand3_1
XFILLER_0_48_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15037_ _06062_ _06081_ _06082_ VGND VGND VPWR VPWR _06083_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_121_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12249_ _03077_ _03078_ VGND VGND VPWR VPWR _03079_ sky130_fd_sc_hd__and2_1
XFILLER_0_139_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16988_ _08195_ _08219_ _08226_ _08227_ _08228_ VGND VGND VPWR VPWR _08229_ sky130_fd_sc_hd__a311o_4
XPHY_EDGE_ROW_147_Right_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15939_ net282 _06161_ _06016_ net285 VGND VGND VPWR VPWR _07075_ sky130_fd_sc_hd__a22o_1
X_09460_ net377 _05418_ _05649_ net360 VGND VGND VPWR VPWR _00271_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_149_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09391_ _00196_ _00201_ VGND VGND VPWR VPWR _00202_ sky130_fd_sc_hd__xor2_2
XFILLER_0_129_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout112 net113 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__buf_2
Xfanout123 net124 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__clkbuf_4
Xfanout134 net137 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__clkbuf_4
Xfanout145 kd_2\[8\] VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__clkbuf_4
Xfanout156 net157 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__clkbuf_4
Xfanout167 net168 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__clkbuf_4
Xfanout178 net179 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__buf_2
Xfanout189 net191 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_114_Right_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09727_ _00444_ _00445_ VGND VGND VPWR VPWR _00538_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_96_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09658_ _00467_ _00468_ VGND VGND VPWR VPWR _00469_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09589_ _00291_ _00399_ VGND VGND VPWR VPWR _00400_ sky130_fd_sc_hd__or2_1
XFILLER_0_77_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11620_ _02408_ _02415_ _02417_ VGND VGND VPWR VPWR _02431_ sky130_fd_sc_hd__nand3_1
XFILLER_0_38_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11551_ _02360_ _02347_ _02353_ VGND VGND VPWR VPWR _02362_ sky130_fd_sc_hd__nor3_1
XFILLER_0_135_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10502_ _01271_ _01291_ _01304_ VGND VGND VPWR VPWR _01313_ sky130_fd_sc_hd__a21o_1
X_14270_ _04294_ _05238_ VGND VGND VPWR VPWR _05239_ sky130_fd_sc_hd__xor2_2
X_11482_ _02290_ _02292_ VGND VGND VPWR VPWR _02293_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_135_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13221_ _04064_ _04084_ VGND VGND VPWR VPWR _04085_ sky130_fd_sc_hd__xnor2_1
X_10433_ _01203_ _01242_ VGND VGND VPWR VPWR _01244_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13152_ net194 _03578_ _03669_ net189 VGND VGND VPWR VPWR _04009_ sky130_fd_sc_hd__a22oi_1
X_10364_ net355 _00314_ _00371_ net350 VGND VGND VPWR VPWR _01175_ sky130_fd_sc_hd__a22o_1
XFILLER_0_21_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12103_ _02918_ _02895_ _02898_ VGND VGND VPWR VPWR _02928_ sky130_fd_sc_hd__nand3_1
X_13083_ _03932_ VGND VGND VPWR VPWR _03934_ sky130_fd_sc_hd__buf_2
X_10295_ _01071_ _01104_ _01105_ VGND VGND VPWR VPWR _01106_ sky130_fd_sc_hd__a21o_2
XFILLER_0_130_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16911_ _05434_ _08143_ VGND VGND VPWR VPWR _08144_ sky130_fd_sc_hd__xnor2_1
X_12034_ net446 net146 net162 net428 VGND VGND VPWR VPWR _02852_ sky130_fd_sc_hd__a22o_1
XFILLER_0_109_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16842_ _05267_ _05281_ VGND VGND VPWR VPWR _08068_ sky130_fd_sc_hd__xor2_2
X_16773_ _07753_ _07986_ _07985_ _07813_ _07991_ VGND VGND VPWR VPWR _07993_ sky130_fd_sc_hd__o221a_1
X_13985_ net218 _04106_ VGND VGND VPWR VPWR _04926_ sky130_fd_sc_hd__nand2_1
X_15724_ _06827_ _06838_ VGND VGND VPWR VPWR _06839_ sky130_fd_sc_hd__nand2b_4
X_12936_ net189 _03261_ VGND VGND VPWR VPWR _03780_ sky130_fd_sc_hd__nand2_1
X_15655_ _06707_ _06728_ VGND VGND VPWR VPWR _06763_ sky130_fd_sc_hd__or2b_1
XFILLER_0_75_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12867_ _03708_ _03709_ _03710_ VGND VGND VPWR VPWR _03711_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_29_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14606_ _05606_ _05608_ VGND VGND VPWR VPWR _05609_ sky130_fd_sc_hd__and2b_1
X_11818_ _02627_ _02628_ VGND VGND VPWR VPWR _02629_ sky130_fd_sc_hd__or2_1
X_15586_ _06685_ _06686_ VGND VGND VPWR VPWR _06687_ sky130_fd_sc_hd__and2_1
X_12798_ _03641_ _03640_ VGND VGND VPWR VPWR _03642_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_50_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14537_ net314 _05726_ VGND VGND VPWR VPWR _05533_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17325_ net463 i_error\[2\] VGND VGND VPWR VPWR _08562_ sky130_fd_sc_hd__or2_1
X_11749_ _02479_ _02478_ _02453_ VGND VGND VPWR VPWR _02560_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_55_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14468_ _05454_ _05456_ VGND VGND VPWR VPWR _05457_ sky130_fd_sc_hd__xnor2_4
X_17256_ _08462_ _08495_ _08471_ VGND VGND VPWR VPWR _08516_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_119_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16207_ _07319_ _07320_ _07322_ VGND VGND VPWR VPWR _07370_ sky130_fd_sc_hd__or3_1
X_13419_ _04300_ _04302_ VGND VGND VPWR VPWR _04303_ sky130_fd_sc_hd__nor2_1
X_17187_ _08378_ _08447_ VGND VGND VPWR VPWR _08448_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_70_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14399_ net199 _03436_ _03372_ VGND VGND VPWR VPWR _05381_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_12_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16138_ net290 _06348_ VGND VGND VPWR VPWR _07294_ sky130_fd_sc_hd__and2_1
X_08960_ _05594_ _05330_ _04956_ VGND VGND VPWR VPWR _05605_ sky130_fd_sc_hd__nand3b_4
X_16069_ _07202_ _07216_ _07217_ _07158_ VGND VGND VPWR VPWR _07218_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_121_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08891_ net62 net7 VGND VGND VPWR VPWR _04846_ sky130_fd_sc_hd__or2b_1
X_09512_ _00305_ _00307_ _00322_ VGND VGND VPWR VPWR _00323_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_79_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09443_ _08688_ _08670_ _08686_ VGND VGND VPWR VPWR _00254_ sky130_fd_sc_hd__nor3_1
XFILLER_0_149_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09374_ _00167_ _00184_ VGND VGND VPWR VPWR _00185_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_18_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10080_ _00889_ _00890_ VGND VGND VPWR VPWR _00891_ sky130_fd_sc_hd__or2b_1
X_13770_ _04673_ _04688_ _04671_ VGND VGND VPWR VPWR _04689_ sky130_fd_sc_hd__o21a_1
X_10982_ _01791_ _01792_ net415 net118 VGND VGND VPWR VPWR _01793_ sky130_fd_sc_hd__and4bb_1
X_12721_ _03551_ _03561_ _03559_ VGND VGND VPWR VPWR _03562_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_27_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15440_ net305 _05626_ _05628_ VGND VGND VPWR VPWR _06526_ sky130_fd_sc_hd__and3_1
X_12652_ _03489_ _03490_ VGND VGND VPWR VPWR _03491_ sky130_fd_sc_hd__nor2_1
XFILLER_0_127_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11603_ _02408_ _02413_ VGND VGND VPWR VPWR _02414_ sky130_fd_sc_hd__and2_1
X_15371_ net267 _05666_ _06449_ _06447_ VGND VGND VPWR VPWR _06450_ sky130_fd_sc_hd__a31o_1
X_12583_ net235 _03344_ VGND VGND VPWR VPWR _03422_ sky130_fd_sc_hd__and2_1
XFILLER_0_25_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17110_ _07768_ _08362_ VGND VGND VPWR VPWR _08363_ sky130_fd_sc_hd__xnor2_1
X_14322_ _05225_ _05227_ VGND VGND VPWR VPWR _05296_ sky130_fd_sc_hd__and2_1
X_11534_ net407 net148 _02253_ _02254_ VGND VGND VPWR VPWR _02345_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_136_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17041_ _03499_ _08280_ _08286_ VGND VGND VPWR VPWR _08287_ sky130_fd_sc_hd__o21a_1
X_14253_ _05218_ _05219_ VGND VGND VPWR VPWR _05221_ sky130_fd_sc_hd__nand2_2
XFILLER_0_52_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11465_ _02135_ net104 _02139_ VGND VGND VPWR VPWR _02276_ sky130_fd_sc_hd__or3_1
XFILLER_0_21_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13204_ _04066_ VGND VGND VPWR VPWR _04067_ sky130_fd_sc_hd__inv_2
XFILLER_0_150_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10416_ net346 _00653_ _01226_ VGND VGND VPWR VPWR _01227_ sky130_fd_sc_hd__and3_1
XFILLER_0_111_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_36_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14184_ _05128_ _05130_ VGND VGND VPWR VPWR _05145_ sky130_fd_sc_hd__nand2_1
X_11396_ _02083_ _02084_ VGND VGND VPWR VPWR _02207_ sky130_fd_sc_hd__or2_1
X_13135_ _03883_ _03990_ VGND VGND VPWR VPWR _03991_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10347_ _01154_ _01156_ _01157_ VGND VGND VPWR VPWR _01158_ sky130_fd_sc_hd__or3_1
XFILLER_0_21_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13066_ _03912_ _03914_ VGND VGND VPWR VPWR _03915_ sky130_fd_sc_hd__or2b_1
X_10278_ _01083_ _01087_ VGND VGND VPWR VPWR _01089_ sky130_fd_sc_hd__or2b_1
X_12017_ _02769_ _02771_ _02770_ VGND VGND VPWR VPWR _02833_ sky130_fd_sc_hd__a21o_1
X_16825_ _05205_ _05302_ VGND VGND VPWR VPWR _08050_ sky130_fd_sc_hd__xor2_4
XFILLER_0_45_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_45_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16756_ _05520_ net94 _05553_ _05554_ VGND VGND VPWR VPWR _07974_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_45_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13968_ _04870_ _04878_ _04881_ VGND VGND VPWR VPWR _04907_ sky130_fd_sc_hd__and3_1
X_15707_ net292 net491 _05734_ _06819_ VGND VGND VPWR VPWR _06820_ sky130_fd_sc_hd__and4_1
XFILLER_0_76_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12919_ _03675_ _03762_ VGND VGND VPWR VPWR _03763_ sky130_fd_sc_hd__nor2_1
X_16687_ _07896_ _07897_ VGND VGND VPWR VPWR _07898_ sky130_fd_sc_hd__xnor2_1
X_13899_ _04826_ _04829_ VGND VGND VPWR VPWR _04831_ sky130_fd_sc_hd__nor2_1
XFILLER_0_119_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15638_ _06740_ _06743_ VGND VGND VPWR VPWR _06744_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_17_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15569_ _06667_ _06449_ VGND VGND VPWR VPWR _06668_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_71_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17308_ net461 prev_error\[12\] VGND VGND VPWR VPWR _08551_ sky130_fd_sc_hd__or2_1
X_09090_ _06551_ _06595_ _07024_ VGND VGND VPWR VPWR _07035_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_16_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17239_ _08501_ _08502_ net453 VGND VGND VPWR VPWR _00074_ sky130_fd_sc_hd__o21a_1
XFILLER_0_71_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09992_ _00790_ _00798_ _00802_ VGND VGND VPWR VPWR _00803_ sky130_fd_sc_hd__a21oi_2
X_08943_ net520 VGND VGND VPWR VPWR _05418_ sky130_fd_sc_hd__buf_4
XFILLER_0_110_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08874_ _04637_ _04648_ VGND VGND VPWR VPWR _04659_ sky130_fd_sc_hd__or2b_1
XFILLER_0_79_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09426_ _08678_ _00236_ VGND VGND VPWR VPWR _00237_ sky130_fd_sc_hd__xor2_2
XFILLER_0_47_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09357_ _08366_ _08603_ VGND VGND VPWR VPWR _00168_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_136_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09288_ _08541_ _08547_ _08626_ VGND VGND VPWR VPWR _08652_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_90_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11250_ _02059_ _02060_ VGND VGND VPWR VPWR _02061_ sky130_fd_sc_hd__nor2_1
XFILLER_0_15_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10201_ net376 _04604_ _01011_ VGND VGND VPWR VPWR _01012_ sky130_fd_sc_hd__and3_1
X_11181_ _01887_ _01924_ _01926_ VGND VGND VPWR VPWR _01992_ sky130_fd_sc_hd__o21a_1
X_10132_ _00934_ _00938_ VGND VGND VPWR VPWR _00943_ sky130_fd_sc_hd__xor2_1
XFILLER_0_100_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14940_ _05595_ _05975_ VGND VGND VPWR VPWR _05976_ sky130_fd_sc_hd__nor2_1
X_10063_ _00867_ _00872_ VGND VGND VPWR VPWR _00874_ sky130_fd_sc_hd__nand2_1
X_14871_ _05839_ _05899_ VGND VGND VPWR VPWR _05900_ sky130_fd_sc_hd__xor2_1
X_16610_ _07639_ _07812_ VGND VGND VPWR VPWR _07813_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_98_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13822_ _04741_ _04745_ _04739_ VGND VGND VPWR VPWR _04746_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_58_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16541_ _07731_ _05467_ VGND VGND VPWR VPWR _07737_ sky130_fd_sc_hd__and2_1
X_13753_ _04662_ _04668_ _04669_ VGND VGND VPWR VPWR _04671_ sky130_fd_sc_hd__a21o_1
X_10965_ _01770_ _01775_ VGND VGND VPWR VPWR _01776_ sky130_fd_sc_hd__or2_1
X_12704_ _03291_ _03398_ VGND VGND VPWR VPWR _03544_ sky130_fd_sc_hd__nor2_1
X_16472_ _05871_ _07548_ VGND VGND VPWR VPWR _07661_ sky130_fd_sc_hd__and2b_1
X_13684_ _04589_ _04592_ _04594_ VGND VGND VPWR VPWR _04595_ sky130_fd_sc_hd__o21a_1
X_10896_ _01685_ _01705_ VGND VGND VPWR VPWR _01707_ sky130_fd_sc_hd__or2_1
X_12635_ _03461_ _03468_ _03473_ VGND VGND VPWR VPWR _03474_ sky130_fd_sc_hd__or3_1
X_15423_ net299 _05626_ _05628_ _06506_ VGND VGND VPWR VPWR _06508_ sky130_fd_sc_hd__nand4_2
XFILLER_0_26_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15354_ net293 _05736_ VGND VGND VPWR VPWR _06432_ sky130_fd_sc_hd__nand2_1
X_12566_ net181 net176 _03288_ _03278_ VGND VGND VPWR VPWR _03405_ sky130_fd_sc_hd__and4_1
XFILLER_0_81_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14305_ _03145_ _05277_ VGND VGND VPWR VPWR _05278_ sky130_fd_sc_hd__nor2_1
X_11517_ _02244_ _02327_ VGND VGND VPWR VPWR _02328_ sky130_fd_sc_hd__xor2_1
XFILLER_0_124_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15285_ _06341_ _06344_ VGND VGND VPWR VPWR _06356_ sky130_fd_sc_hd__or2_1
X_12497_ _03332_ _03333_ VGND VGND VPWR VPWR _03334_ sky130_fd_sc_hd__and2_1
XFILLER_0_124_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14236_ _03690_ _05195_ VGND VGND VPWR VPWR _05202_ sky130_fd_sc_hd__xor2_4
XFILLER_0_40_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17024_ _08264_ _08268_ VGND VGND VPWR VPWR _08269_ sky130_fd_sc_hd__xor2_1
X_11448_ _02257_ _02258_ VGND VGND VPWR VPWR _02259_ sky130_fd_sc_hd__and2_1
XFILLER_0_22_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14167_ _04904_ _05124_ _05122_ _05123_ VGND VGND VPWR VPWR _05126_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_1_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11379_ _02146_ _02189_ VGND VGND VPWR VPWR _02190_ sky130_fd_sc_hd__nor2_1
X_13118_ _03956_ _03970_ VGND VGND VPWR VPWR _03972_ sky130_fd_sc_hd__nand2_1
X_14098_ _05009_ _05012_ _05010_ VGND VGND VPWR VPWR _05050_ sky130_fd_sc_hd__o21a_1
XFILLER_0_147_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13049_ _03891_ _03895_ VGND VGND VPWR VPWR _03896_ sky130_fd_sc_hd__or2_1
XFILLER_0_147_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_53_Left_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16808_ _07963_ _08029_ VGND VGND VPWR VPWR _08031_ sky130_fd_sc_hd__and2_2
X_16739_ _07953_ _07954_ VGND VGND VPWR VPWR _07955_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09211_ _08355_ _06331_ VGND VGND VPWR VPWR _08366_ sky130_fd_sc_hd__nor2_2
XFILLER_0_63_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09142_ _05110_ _05286_ VGND VGND VPWR VPWR _07607_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_62_Left_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09073_ _06364_ _06529_ VGND VGND VPWR VPWR _06848_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_888 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout3 _05407_ VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_130_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09975_ _00777_ _00785_ VGND VGND VPWR VPWR _00786_ sky130_fd_sc_hd__or2_2
X_08926_ net329 net325 _04923_ _04780_ VGND VGND VPWR VPWR _05231_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_71_Left_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08857_ _04395_ _03933_ VGND VGND VPWR VPWR _04472_ sky130_fd_sc_hd__and2b_1
X_08788_ net42 _03542_ _03575_ net328 VGND VGND VPWR VPWR _00058_ sky130_fd_sc_hd__a22o_1
X_10750_ prev_d_error\[17\] VGND VGND VPWR VPWR _01561_ sky130_fd_sc_hd__inv_2
XFILLER_0_137_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09409_ _08665_ _00219_ VGND VGND VPWR VPWR _00220_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_80_Left_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10681_ _01488_ _01491_ VGND VGND VPWR VPWR _01492_ sky130_fd_sc_hd__xor2_1
X_12420_ net180 _03234_ _03250_ net176 VGND VGND VPWR VPWR _03252_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_90_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12351_ _04615_ prev_error\[10\] VGND VGND VPWR VPWR _03183_ sky130_fd_sc_hd__or2b_1
XFILLER_0_133_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11302_ _02106_ _02112_ VGND VGND VPWR VPWR _02113_ sky130_fd_sc_hd__xor2_1
X_15070_ net277 _05738_ _06036_ VGND VGND VPWR VPWR _06119_ sky130_fd_sc_hd__a21oi_1
X_12282_ _03106_ _02919_ _02929_ VGND VGND VPWR VPWR _03114_ sky130_fd_sc_hd__nand3_1
X_14021_ _04964_ _04952_ VGND VGND VPWR VPWR _04965_ sky130_fd_sc_hd__xnor2_1
X_11233_ _02042_ _02043_ VGND VGND VPWR VPWR _02044_ sky130_fd_sc_hd__or2_1
X_11164_ _01973_ _01974_ VGND VGND VPWR VPWR _01975_ sky130_fd_sc_hd__nor2_1
X_10115_ _00915_ _00925_ VGND VGND VPWR VPWR _00926_ sky130_fd_sc_hd__and2_1
X_15972_ _07109_ _07110_ VGND VGND VPWR VPWR _07111_ sky130_fd_sc_hd__xor2_1
X_11095_ _01896_ _01903_ _01905_ VGND VGND VPWR VPWR _01906_ sky130_fd_sc_hd__a21o_1
X_14923_ _05933_ _05956_ VGND VGND VPWR VPWR _05958_ sky130_fd_sc_hd__nor2_1
X_10046_ _00854_ _00856_ VGND VGND VPWR VPWR _00857_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_117_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14854_ _05879_ _05881_ VGND VGND VPWR VPWR _05882_ sky130_fd_sc_hd__or2_1
XFILLER_0_98_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13805_ _04645_ _04694_ _04722_ _04727_ VGND VGND VPWR VPWR _04728_ sky130_fd_sc_hd__a211o_4
X_14785_ net261 net258 _05738_ _05724_ VGND VGND VPWR VPWR _05806_ sky130_fd_sc_hd__and4_1
XFILLER_0_58_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11997_ _02796_ _02802_ _02804_ VGND VGND VPWR VPWR _02811_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_119_Left_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16524_ i_error\[15\] _07718_ VGND VGND VPWR VPWR _07719_ sky130_fd_sc_hd__and2_1
X_13736_ _04609_ _04647_ VGND VGND VPWR VPWR _04652_ sky130_fd_sc_hd__xnor2_4
X_10948_ _01587_ _01758_ VGND VGND VPWR VPWR _01759_ sky130_fd_sc_hd__nor2_1
XFILLER_0_39_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16455_ i_error\[8\] _07592_ _07593_ VGND VGND VPWR VPWR _07643_ sky130_fd_sc_hd__and3_1
XFILLER_0_128_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13667_ net227 _03222_ _04575_ VGND VGND VPWR VPWR _04576_ sky130_fd_sc_hd__nand3_1
X_10879_ net108 _01688_ _01689_ VGND VGND VPWR VPWR _01690_ sky130_fd_sc_hd__a21oi_1
X_15406_ _06486_ _06487_ _06488_ VGND VGND VPWR VPWR _06489_ sky130_fd_sc_hd__or3_2
XFILLER_0_109_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12618_ _03435_ _03455_ VGND VGND VPWR VPWR _03457_ sky130_fd_sc_hd__nor2_1
X_16386_ _07562_ _07564_ _07561_ VGND VGND VPWR VPWR _07567_ sky130_fd_sc_hd__a21oi_1
X_13598_ _04498_ _04499_ VGND VGND VPWR VPWR _04500_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_143_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15337_ _06339_ _06409_ _06412_ VGND VGND VPWR VPWR _06413_ sky130_fd_sc_hd__o21ai_1
X_12549_ net206 net204 _03336_ _03328_ VGND VGND VPWR VPWR _03388_ sky130_fd_sc_hd__nand4_1
XFILLER_0_81_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_1 _03215_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_15268_ _06317_ _06335_ _06336_ VGND VGND VPWR VPWR _06337_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_111_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17007_ _08242_ _08249_ VGND VGND VPWR VPWR _08250_ sky130_fd_sc_hd__and2b_1
X_14219_ _05180_ _05182_ VGND VGND VPWR VPWR _05183_ sky130_fd_sc_hd__xor2_4
X_15199_ _06253_ _06259_ _06260_ VGND VGND VPWR VPWR _06261_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_10_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09760_ _00460_ _00570_ VGND VGND VPWR VPWR _00571_ sky130_fd_sc_hd__xnor2_1
X_08711_ net55 _02894_ _02927_ net138 VGND VGND VPWR VPWR _00035_ sky130_fd_sc_hd__a22o_1
X_09691_ _00500_ _00499_ VGND VGND VPWR VPWR _00502_ sky130_fd_sc_hd__and2b_1
Xrebuffer13 _07829_ VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_83_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer35 net506 VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09125_ _07409_ VGND VGND VPWR VPWR _07420_ sky130_fd_sc_hd__clkbuf_4
X_09056_ _06045_ _06067_ _06650_ VGND VGND VPWR VPWR _06661_ sky130_fd_sc_hd__a21o_1
XFILLER_0_142_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09958_ _00761_ _00764_ _00767_ VGND VGND VPWR VPWR _00769_ sky130_fd_sc_hd__nor3_1
X_08909_ net325 _04934_ _05033_ net329 VGND VGND VPWR VPWR _05044_ sky130_fd_sc_hd__a22o_1
X_09889_ net365 _04417_ _04747_ net370 VGND VGND VPWR VPWR _00700_ sky130_fd_sc_hd__a22o_1
X_11920_ net415 net163 VGND VGND VPWR VPWR _02731_ sky130_fd_sc_hd__nand2_1
X_11851_ _02647_ _02661_ VGND VGND VPWR VPWR _02662_ sky130_fd_sc_hd__or2b_1
X_10802_ _01610_ _01612_ VGND VGND VPWR VPWR _01613_ sky130_fd_sc_hd__and2_1
X_14570_ _05560_ _05567_ _05568_ VGND VGND VPWR VPWR _05569_ sky130_fd_sc_hd__a21o_4
X_11782_ _02522_ _02592_ VGND VGND VPWR VPWR _02593_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_68_878 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13521_ _04413_ _04414_ VGND VGND VPWR VPWR _04415_ sky130_fd_sc_hd__and2b_1
X_10733_ _01542_ _01543_ net390 net129 VGND VGND VPWR VPWR _01544_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_138_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16240_ _07362_ _07368_ _07367_ VGND VGND VPWR VPWR _07406_ sky130_fd_sc_hd__o21a_1
X_13452_ _04336_ _04338_ VGND VGND VPWR VPWR _04339_ sky130_fd_sc_hd__or2b_1
X_10664_ _01473_ _01474_ VGND VGND VPWR VPWR _01475_ sky130_fd_sc_hd__or2_1
X_12403_ net190 _03217_ _03223_ net195 VGND VGND VPWR VPWR _03235_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_3_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16171_ _07325_ _07329_ VGND VGND VPWR VPWR _07330_ sky130_fd_sc_hd__and2b_1
X_13383_ _03998_ _04105_ _04111_ VGND VGND VPWR VPWR _04264_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_35_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10595_ _01402_ VGND VGND VPWR VPWR _01406_ sky130_fd_sc_hd__inv_2
X_15122_ _06172_ _06173_ _06175_ VGND VGND VPWR VPWR _06176_ sky130_fd_sc_hd__a21o_1
X_12334_ _02029_ _02023_ _02027_ VGND VGND VPWR VPWR _03166_ sky130_fd_sc_hd__nor3_1
XFILLER_0_133_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15053_ _06097_ _06098_ _06099_ VGND VGND VPWR VPWR _06101_ sky130_fd_sc_hd__a21o_1
X_12265_ _03096_ net166 net175 _03071_ net448 VGND VGND VPWR VPWR _03097_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_121_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_128_Right_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14004_ _04943_ _04946_ VGND VGND VPWR VPWR _04947_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_121_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11216_ _02025_ _02026_ VGND VGND VPWR VPWR _02027_ sky130_fd_sc_hd__and2b_1
X_12196_ _03008_ _03006_ VGND VGND VPWR VPWR _03021_ sky130_fd_sc_hd__nor2_1
Xoutput82 net82 VGND VGND VPWR VPWR out_clocked[15] sky130_fd_sc_hd__buf_2
Xoutput93 net93 VGND VGND VPWR VPWR out_clocked[9] sky130_fd_sc_hd__clkbuf_4
X_11147_ _01956_ _01957_ VGND VGND VPWR VPWR _01958_ sky130_fd_sc_hd__and2_1
XFILLER_0_128_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15955_ _07091_ _07092_ VGND VGND VPWR VPWR _07093_ sky130_fd_sc_hd__xnor2_1
X_11078_ _01840_ _01831_ _01838_ VGND VGND VPWR VPWR _01889_ sky130_fd_sc_hd__nand3_1
X_14906_ _05934_ _05928_ _05937_ VGND VGND VPWR VPWR _05939_ sky130_fd_sc_hd__or3_1
X_10029_ _00833_ _00838_ _00839_ VGND VGND VPWR VPWR _00840_ sky130_fd_sc_hd__and3_1
X_15886_ net274 net271 _06205_ _06348_ VGND VGND VPWR VPWR _07017_ sky130_fd_sc_hd__and4_1
X_14837_ _05850_ _05854_ VGND VGND VPWR VPWR _05863_ sky130_fd_sc_hd__nor2_2
XFILLER_0_144_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14768_ _05755_ _05769_ _05785_ VGND VGND VPWR VPWR _05787_ sky130_fd_sc_hd__nor3_1
XFILLER_0_86_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16507_ _05866_ _07553_ _05863_ VGND VGND VPWR VPWR _07700_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_74_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13719_ _04629_ _04631_ _04632_ VGND VGND VPWR VPWR _04633_ sky130_fd_sc_hd__nand3_4
X_17487_ clknet_4_4_0_clock _00047_ VGND VGND VPWR VPWR ki\[3\] sky130_fd_sc_hd__dfxtp_1
X_14699_ _05710_ VGND VGND VPWR VPWR _05711_ sky130_fd_sc_hd__buf_4
XFILLER_0_39_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16438_ _07238_ _07240_ _07484_ VGND VGND VPWR VPWR _07624_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_143_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16369_ _07542_ _07547_ VGND VGND VPWR VPWR _07548_ sky130_fd_sc_hd__xor2_1
XFILLER_0_6_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout305 ki\[1\] VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_10_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout316 kp\[16\] VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__clkbuf_2
X_09812_ _00620_ _00622_ VGND VGND VPWR VPWR _00623_ sky130_fd_sc_hd__or2b_1
Xfanout327 net328 VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__buf_2
Xfanout338 kp\[10\] VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__clkbuf_4
Xfanout349 net351 VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_94_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09743_ _00550_ _00552_ VGND VGND VPWR VPWR _00554_ sky130_fd_sc_hd__or2_1
XFILLER_0_118_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09674_ _00436_ _00435_ _00428_ VGND VGND VPWR VPWR _00485_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09108_ _07211_ _07222_ VGND VGND VPWR VPWR _07233_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_32_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10380_ _01141_ _01190_ VGND VGND VPWR VPWR _01191_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_103_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09039_ _05726_ _06463_ VGND VGND VPWR VPWR _06474_ sky130_fd_sc_hd__nand2_1
X_12050_ _02867_ _02868_ net442 net150 VGND VGND VPWR VPWR _02869_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_130_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11001_ _01809_ _01811_ VGND VGND VPWR VPWR _01812_ sky130_fd_sc_hd__and2_1
X_15740_ _06832_ _06833_ VGND VGND VPWR VPWR _06856_ sky130_fd_sc_hd__or2b_1
X_12952_ net182 net178 _03669_ net519 VGND VGND VPWR VPWR _03796_ sky130_fd_sc_hd__and4_1
XFILLER_0_59_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11903_ _02604_ _02636_ VGND VGND VPWR VPWR _02714_ sky130_fd_sc_hd__nor2_1
XFILLER_0_99_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15671_ _06770_ _06772_ _06778_ VGND VGND VPWR VPWR _06780_ sky130_fd_sc_hd__nor3_2
X_12883_ _03639_ _03722_ VGND VGND VPWR VPWR _03727_ sky130_fd_sc_hd__nor2_1
X_17410_ clknet_4_11_0_clock _00088_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dfxtp_1
X_14622_ _03177_ _05625_ _03218_ VGND VGND VPWR VPWR _05626_ sky130_fd_sc_hd__a21o_2
X_11834_ _02643_ _02644_ VGND VGND VPWR VPWR _02645_ sky130_fd_sc_hd__nor2_1
X_17341_ _08564_ _08170_ _08571_ net452 VGND VGND VPWR VPWR _00117_ sky130_fd_sc_hd__o211a_1
X_14553_ _05526_ _05549_ VGND VGND VPWR VPWR _05551_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_56_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11765_ _02509_ _02575_ VGND VGND VPWR VPWR _02576_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13504_ _04394_ _04393_ VGND VGND VPWR VPWR _04397_ sky130_fd_sc_hd__or2b_1
X_10716_ _01475_ _01526_ VGND VGND VPWR VPWR _01527_ sky130_fd_sc_hd__nor2_1
X_17272_ net468 net509 net456 VGND VGND VPWR VPWR _08528_ sky130_fd_sc_hd__o21ai_1
X_14484_ _06661_ _06771_ _06749_ VGND VGND VPWR VPWR _05475_ sky130_fd_sc_hd__a21o_1
X_11696_ net417 net422 net143 net148 VGND VGND VPWR VPWR _02507_ sky130_fd_sc_hd__and4_1
XFILLER_0_99_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16223_ net295 _06415_ _06015_ net310 VGND VGND VPWR VPWR _07388_ sky130_fd_sc_hd__a22o_1
X_13435_ _04320_ _04305_ VGND VGND VPWR VPWR _04321_ sky130_fd_sc_hd__nor2_1
X_10647_ net435 net439 net107 VGND VGND VPWR VPWR _01458_ sky130_fd_sc_hd__and3_1
XFILLER_0_3_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer4 net473 VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__clkbuf_1
X_16154_ net303 _06160_ VGND VGND VPWR VPWR _07312_ sky130_fd_sc_hd__nand2_1
X_13366_ _04239_ _04244_ VGND VGND VPWR VPWR _04245_ sky130_fd_sc_hd__nand2_1
XFILLER_0_141_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10578_ _01381_ _01380_ VGND VGND VPWR VPWR _01389_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15105_ _06157_ _06018_ VGND VGND VPWR VPWR _06158_ sky130_fd_sc_hd__xnor2_1
X_12317_ _02719_ _03147_ _03148_ VGND VGND VPWR VPWR _03149_ sky130_fd_sc_hd__o21ai_1
X_16085_ _07175_ _07177_ _07176_ VGND VGND VPWR VPWR _07236_ sky130_fd_sc_hd__a21o_1
X_13297_ net237 _03335_ _04167_ _04168_ VGND VGND VPWR VPWR _04169_ sky130_fd_sc_hd__a31o_1
X_15036_ _06076_ _06080_ _05959_ _06063_ VGND VGND VPWR VPWR _06082_ sky130_fd_sc_hd__a211o_1
X_12248_ _03073_ _03076_ VGND VGND VPWR VPWR _03078_ sky130_fd_sc_hd__or2_1
X_12179_ _03000_ _03003_ VGND VGND VPWR VPWR _03004_ sky130_fd_sc_hd__or2_1
X_16987_ _08207_ _08218_ VGND VGND VPWR VPWR _08228_ sky130_fd_sc_hd__nor2_1
X_15938_ _07052_ _07072_ _07071_ VGND VGND VPWR VPWR _07074_ sky130_fd_sc_hd__o21ai_1
X_15869_ net279 _06161_ VGND VGND VPWR VPWR _06998_ sky130_fd_sc_hd__nand2_1
XFILLER_0_149_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09390_ _00197_ _00200_ _00198_ VGND VGND VPWR VPWR _00201_ sky130_fd_sc_hd__o21a_1
XFILLER_0_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout113 kd_2\[15\] VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__clkbuf_4
Xfanout124 kd_2\[13\] VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__clkbuf_4
Xfanout135 net136 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__buf_2
Xfanout146 kd_2\[7\] VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__clkbuf_4
Xfanout157 kd_2\[5\] VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__clkbuf_4
Xfanout168 kd_2\[2\] VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__clkbuf_4
Xfanout179 kd_1\[16\] VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__buf_2
X_09726_ _00535_ _00536_ VGND VGND VPWR VPWR _00537_ sky130_fd_sc_hd__nor2_1
XFILLER_0_69_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09657_ _00406_ _00409_ VGND VGND VPWR VPWR _00468_ sky130_fd_sc_hd__xor2_1
XFILLER_0_97_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09588_ net333 _07343_ _00290_ VGND VGND VPWR VPWR _00399_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_148_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11550_ _02347_ _02353_ _02360_ VGND VGND VPWR VPWR _02361_ sky130_fd_sc_hd__o21a_1
XFILLER_0_135_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10501_ _01310_ _01311_ VGND VGND VPWR VPWR _01312_ sky130_fd_sc_hd__and2_1
X_11481_ _02143_ _02291_ VGND VGND VPWR VPWR _02292_ sky130_fd_sc_hd__nand2_2
XFILLER_0_107_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13220_ _04067_ _04082_ _04083_ VGND VGND VPWR VPWR _04084_ sky130_fd_sc_hd__o21a_1
X_10432_ _01236_ _01238_ VGND VGND VPWR VPWR _01243_ sky130_fd_sc_hd__nand2_1
XFILLER_0_123_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13151_ net194 net189 _03577_ _03668_ VGND VGND VPWR VPWR _04008_ sky130_fd_sc_hd__and4_1
XFILLER_0_21_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10363_ net346 _00518_ VGND VGND VPWR VPWR _01174_ sky130_fd_sc_hd__nand2_1
X_12102_ _02924_ _02925_ VGND VGND VPWR VPWR _02926_ sky130_fd_sc_hd__xnor2_1
X_13082_ _03930_ _03931_ VGND VGND VPWR VPWR _03932_ sky130_fd_sc_hd__xnor2_1
X_10294_ _01074_ _01103_ VGND VGND VPWR VPWR _01105_ sky130_fd_sc_hd__and2b_1
X_16910_ _08139_ _08142_ VGND VGND VPWR VPWR _08143_ sky130_fd_sc_hd__xnor2_1
X_12033_ _02847_ _02849_ VGND VGND VPWR VPWR _02851_ sky130_fd_sc_hd__and2_1
XFILLER_0_18_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16841_ _05441_ _08066_ VGND VGND VPWR VPWR _08067_ sky130_fd_sc_hd__xor2_1
X_16772_ _07990_ _07798_ _07764_ _07988_ VGND VGND VPWR VPWR _07991_ sky130_fd_sc_hd__o2bb2a_1
X_13984_ net210 _04315_ VGND VGND VPWR VPWR _04925_ sky130_fd_sc_hd__nand2_1
X_15723_ _06835_ _06827_ _06836_ VGND VGND VPWR VPWR _06838_ sky130_fd_sc_hd__or3_4
X_12935_ _03773_ _03772_ VGND VGND VPWR VPWR _03779_ sky130_fd_sc_hd__xor2_1
XFILLER_0_125_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15654_ _06681_ _06730_ _06759_ _06761_ VGND VGND VPWR VPWR _06762_ sky130_fd_sc_hd__a211oi_4
X_12866_ net218 net215 _03336_ _03328_ VGND VGND VPWR VPWR _03710_ sky130_fd_sc_hd__and4_1
X_14605_ _05585_ _05591_ _05607_ VGND VGND VPWR VPWR _05608_ sky130_fd_sc_hd__o21a_1
XFILLER_0_8_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11817_ _02519_ _02506_ _02518_ VGND VGND VPWR VPWR _02628_ sky130_fd_sc_hd__a21oi_1
X_15585_ net257 _06206_ _06349_ net253 VGND VGND VPWR VPWR _06686_ sky130_fd_sc_hd__a22o_1
XFILLER_0_68_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12797_ _03526_ _03635_ VGND VGND VPWR VPWR _03641_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17324_ net466 _08084_ _08085_ _08561_ VGND VGND VPWR VPWR _00109_ sky130_fd_sc_hd__a31oi_1
XFILLER_0_138_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14536_ _06793_ _05492_ _05490_ VGND VGND VPWR VPWR _05532_ sky130_fd_sc_hd__a21o_1
X_11748_ _02479_ _02453_ _02478_ VGND VGND VPWR VPWR _02559_ sky130_fd_sc_hd__and3_1
XFILLER_0_126_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17255_ _08498_ net92 VGND VGND VPWR VPWR _08515_ sky130_fd_sc_hd__and2_1
X_14467_ _00816_ _00896_ _01427_ _05455_ VGND VGND VPWR VPWR _05456_ sky130_fd_sc_hd__a31o_1
X_11679_ _02488_ _02489_ net443 net525 VGND VGND VPWR VPWR _02490_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_114_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16206_ _07362_ _07367_ _07368_ VGND VGND VPWR VPWR _07369_ sky130_fd_sc_hd__nor3_2
XFILLER_0_3_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13418_ net196 _03793_ _04301_ VGND VGND VPWR VPWR _04302_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_113_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17186_ _08380_ _08446_ VGND VGND VPWR VPWR _08447_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_141_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14398_ _03500_ _03505_ _03499_ VGND VGND VPWR VPWR _05380_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_106_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16137_ net311 _05665_ _06205_ net294 VGND VGND VPWR VPWR _07293_ sky130_fd_sc_hd__a22o_1
X_13349_ _04224_ _04225_ VGND VGND VPWR VPWR _04226_ sky130_fd_sc_hd__nand2_1
X_16068_ _07143_ _07144_ _07157_ VGND VGND VPWR VPWR _07217_ sky130_fd_sc_hd__o21a_1
X_15019_ _05955_ _05958_ VGND VGND VPWR VPWR _06063_ sky130_fd_sc_hd__nor2_1
XFILLER_0_20_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08890_ net7 net62 VGND VGND VPWR VPWR _04835_ sky130_fd_sc_hd__or2b_2
X_09511_ _00308_ _00321_ VGND VGND VPWR VPWR _00322_ sky130_fd_sc_hd__or2b_1
Xclone9 _05617_ _05624_ _03225_ _03179_ VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__a211o_2
XFILLER_0_79_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09442_ _00208_ _00209_ VGND VGND VPWR VPWR _00253_ sky130_fd_sc_hd__nor2_1
XFILLER_0_91_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09373_ _00182_ _00183_ VGND VGND VPWR VPWR _00184_ sky130_fd_sc_hd__nor2_1
XFILLER_0_115_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09709_ _00519_ VGND VGND VPWR VPWR _00520_ sky130_fd_sc_hd__clkbuf_4
X_10981_ net418 net114 net110 net421 VGND VGND VPWR VPWR _01792_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12720_ _03559_ _03560_ VGND VGND VPWR VPWR _03561_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12651_ _03478_ _03479_ _03488_ VGND VGND VPWR VPWR _03490_ sky130_fd_sc_hd__nor3_1
XFILLER_0_38_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11602_ _02402_ _02406_ _02407_ VGND VGND VPWR VPWR _02413_ sky130_fd_sc_hd__or3_1
XFILLER_0_148_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15370_ _06447_ _06448_ VGND VGND VPWR VPWR _06449_ sky130_fd_sc_hd__nor2_1
X_12582_ _03419_ _03420_ VGND VGND VPWR VPWR _03421_ sky130_fd_sc_hd__or2_2
XFILLER_0_108_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14321_ _05232_ _05234_ _05294_ VGND VGND VPWR VPWR _05295_ sky130_fd_sc_hd__o21bai_4
X_11533_ _02342_ _02343_ net404 net155 VGND VGND VPWR VPWR _02344_ sky130_fd_sc_hd__and4bb_1
X_17040_ _03452_ _08285_ VGND VGND VPWR VPWR _08286_ sky130_fd_sc_hd__xor2_1
X_11464_ _02251_ _02272_ _02274_ VGND VGND VPWR VPWR _02275_ sky130_fd_sc_hd__a21oi_1
X_14252_ _03993_ _05192_ VGND VGND VPWR VPWR _05219_ sky130_fd_sc_hd__xor2_4
XFILLER_0_135_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10415_ _01173_ _01225_ VGND VGND VPWR VPWR _01226_ sky130_fd_sc_hd__xor2_1
X_13203_ _04035_ _04034_ VGND VGND VPWR VPWR _04066_ sky130_fd_sc_hd__xnor2_2
X_14183_ _05079_ _05117_ _05141_ _05142_ VGND VGND VPWR VPWR _05144_ sky130_fd_sc_hd__a31o_1
X_11395_ _02203_ _02205_ VGND VGND VPWR VPWR _02206_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10346_ _01095_ _01153_ _01149_ _01152_ VGND VGND VPWR VPWR _01157_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_103_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13134_ _03948_ _03987_ _03989_ VGND VGND VPWR VPWR _03990_ sky130_fd_sc_hd__a21boi_1
X_13065_ _03898_ _03913_ VGND VGND VPWR VPWR _03914_ sky130_fd_sc_hd__and2_1
X_10277_ _01083_ _01087_ VGND VGND VPWR VPWR _01088_ sky130_fd_sc_hd__xor2_4
X_12016_ _02827_ _02830_ _02831_ VGND VGND VPWR VPWR _02832_ sky130_fd_sc_hd__nand3_1
X_16824_ _05421_ _08044_ VGND VGND VPWR VPWR _08049_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_136_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16755_ _07972_ VGND VGND VPWR VPWR _07973_ sky130_fd_sc_hd__inv_2
X_13967_ _04884_ _04905_ VGND VGND VPWR VPWR _04906_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_100_Left_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15706_ net308 _05581_ VGND VGND VPWR VPWR _06819_ sky130_fd_sc_hd__and2_1
X_12918_ _03674_ _03660_ _03673_ VGND VGND VPWR VPWR _03762_ sky130_fd_sc_hd__nor3_1
X_16686_ _07699_ _07700_ _07702_ VGND VGND VPWR VPWR _07897_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_88_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13898_ _04826_ _04829_ VGND VGND VPWR VPWR _04830_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15637_ _06741_ _06742_ VGND VGND VPWR VPWR _06743_ sky130_fd_sc_hd__xor2_1
XFILLER_0_61_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12849_ _03682_ _03692_ VGND VGND VPWR VPWR _03693_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15568_ net267 _05666_ VGND VGND VPWR VPWR _06667_ sky130_fd_sc_hd__nand2_1
X_17307_ _08549_ _04527_ _08550_ net451 VGND VGND VPWR VPWR _00101_ sky130_fd_sc_hd__o211a_1
XFILLER_0_126_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14519_ _05471_ _05512_ VGND VGND VPWR VPWR _05513_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_127_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15499_ _06589_ _06590_ VGND VGND VPWR VPWR _06591_ sky130_fd_sc_hd__and2_1
XFILLER_0_71_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17238_ net494 _08495_ _08482_ VGND VGND VPWR VPWR _08502_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_142_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17169_ _08319_ _08321_ _08427_ VGND VGND VPWR VPWR _08428_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09991_ net526 _00799_ _00801_ VGND VGND VPWR VPWR _00802_ sky130_fd_sc_hd__and3_1
XFILLER_0_12_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08942_ _05374_ VGND VGND VPWR VPWR _05407_ sky130_fd_sc_hd__buf_2
XFILLER_0_86_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08873_ _04461_ _04538_ VGND VGND VPWR VPWR _04648_ sky130_fd_sc_hd__xor2_1
XFILLER_0_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09425_ _08684_ _08683_ VGND VGND VPWR VPWR _00236_ sky130_fd_sc_hd__and2_1
XFILLER_0_137_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09356_ _08689_ _00166_ _00164_ VGND VGND VPWR VPWR _00167_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09287_ _08644_ _08650_ VGND VGND VPWR VPWR _08651_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10200_ _00936_ _01010_ VGND VGND VPWR VPWR _01011_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_120_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11180_ _01988_ _01990_ VGND VGND VPWR VPWR _01991_ sky130_fd_sc_hd__and2_1
XFILLER_0_101_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10131_ _00940_ _00941_ VGND VGND VPWR VPWR _00942_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_101_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10062_ _00867_ _00872_ VGND VGND VPWR VPWR _00873_ sky130_fd_sc_hd__xor2_1
XFILLER_0_100_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14870_ _05897_ _05898_ VGND VGND VPWR VPWR _05899_ sky130_fd_sc_hd__and2b_1
X_13821_ _04665_ _04742_ _04744_ VGND VGND VPWR VPWR _04745_ sky130_fd_sc_hd__o21ba_1
X_16540_ _07734_ _07735_ VGND VGND VPWR VPWR _07736_ sky130_fd_sc_hd__xor2_2
XFILLER_0_15_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13752_ _04597_ _04600_ VGND VGND VPWR VPWR _04669_ sky130_fd_sc_hd__xnor2_1
X_10964_ _01773_ _01774_ VGND VGND VPWR VPWR _01775_ sky130_fd_sc_hd__nand2_1
X_12703_ _03539_ _03541_ VGND VGND VPWR VPWR _03543_ sky130_fd_sc_hd__nor2_1
X_16471_ _07533_ _07557_ VGND VGND VPWR VPWR _07660_ sky130_fd_sc_hd__and2b_1
X_13683_ _04511_ _04514_ VGND VGND VPWR VPWR _04594_ sky130_fd_sc_hd__xor2_2
X_10895_ _01685_ _01705_ VGND VGND VPWR VPWR _01706_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15422_ net303 _05625_ _05635_ VGND VGND VPWR VPWR _06506_ sky130_fd_sc_hd__and3_1
XFILLER_0_66_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12634_ _03470_ _03472_ VGND VGND VPWR VPWR _03473_ sky130_fd_sc_hd__and2_1
XFILLER_0_53_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15353_ net288 _05630_ VGND VGND VPWR VPWR _06431_ sky130_fd_sc_hd__nand2_2
X_12565_ _03264_ _03234_ VGND VGND VPWR VPWR _03404_ sky130_fd_sc_hd__nor2_1
XFILLER_0_124_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14304_ _03144_ _02786_ VGND VGND VPWR VPWR _05277_ sky130_fd_sc_hd__and2b_1
XFILLER_0_80_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11516_ net425 net132 _02147_ _02245_ VGND VGND VPWR VPWR _02327_ sky130_fd_sc_hd__a31o_1
X_15284_ _06202_ _06346_ _06354_ VGND VGND VPWR VPWR _06355_ sky130_fd_sc_hd__o21ai_1
X_12496_ _03306_ _03331_ _03310_ VGND VGND VPWR VPWR _03333_ sky130_fd_sc_hd__nand3_4
XFILLER_0_22_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17023_ _05362_ _08265_ _08266_ VGND VGND VPWR VPWR _08268_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_150_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14235_ _01787_ _03173_ VGND VGND VPWR VPWR _05201_ sky130_fd_sc_hd__xnor2_1
X_11447_ _02162_ _02252_ _02256_ VGND VGND VPWR VPWR _02258_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_1_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14166_ _05122_ _05123_ _04904_ _05124_ VGND VGND VPWR VPWR _05125_ sky130_fd_sc_hd__a211o_1
X_11378_ net427 net123 _02144_ _02145_ VGND VGND VPWR VPWR _02189_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_21_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10329_ net372 net486 _08680_ net367 VGND VGND VPWR VPWR _01140_ sky130_fd_sc_hd__a22o_1
X_13117_ _03956_ _03970_ VGND VGND VPWR VPWR _03971_ sky130_fd_sc_hd__xnor2_2
X_14097_ _05021_ _05048_ VGND VGND VPWR VPWR _05049_ sky130_fd_sc_hd__xnor2_2
X_13048_ net212 _03217_ _03893_ _03894_ VGND VGND VPWR VPWR _03895_ sky130_fd_sc_hd__a31oi_1
XFILLER_0_56_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16807_ _07963_ _08029_ _08026_ net482 VGND VGND VPWR VPWR _08030_ sky130_fd_sc_hd__o22a_2
X_14999_ _06031_ _06039_ _06040_ VGND VGND VPWR VPWR _06041_ sky130_fd_sc_hd__o21ai_2
X_16738_ _07865_ _07876_ VGND VGND VPWR VPWR _07954_ sky130_fd_sc_hd__or2b_1
XFILLER_0_72_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16669_ _07864_ _07877_ VGND VGND VPWR VPWR _07878_ sky130_fd_sc_hd__xor2_2
XFILLER_0_48_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09210_ _06232_ _06276_ VGND VGND VPWR VPWR _08355_ sky130_fd_sc_hd__and2_1
XFILLER_0_57_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09141_ _07244_ _07266_ VGND VGND VPWR VPWR _07596_ sky130_fd_sc_hd__nand2_1
XFILLER_0_112_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09072_ _06606_ _06826_ VGND VGND VPWR VPWR _06837_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_115_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout4 _04316_ VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__buf_4
XFILLER_0_141_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09974_ _00773_ _00779_ VGND VGND VPWR VPWR _00785_ sky130_fd_sc_hd__and2b_1
XFILLER_0_0_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08925_ net329 _04934_ _04780_ net325 VGND VGND VPWR VPWR _05220_ sky130_fd_sc_hd__a22o_1
X_08856_ net317 _04450_ VGND VGND VPWR VPWR _04461_ sky130_fd_sc_hd__nand2_1
XFILLER_0_98_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08787_ net41 _03542_ _03575_ net331 VGND VGND VPWR VPWR _00057_ sky130_fd_sc_hd__a22o_1
XFILLER_0_79_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_868 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09408_ net322 _07420_ _08664_ VGND VGND VPWR VPWR _00219_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_109_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10680_ net108 _01489_ _01490_ VGND VGND VPWR VPWR _01491_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_35_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09339_ _08616_ _00149_ VGND VGND VPWR VPWR _00150_ sky130_fd_sc_hd__nor2_1
XFILLER_0_106_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_109_Right_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12350_ prev_error\[11\] _03181_ VGND VGND VPWR VPWR _03182_ sky130_fd_sc_hd__nand2_1
XFILLER_0_117_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11301_ _02110_ _02111_ VGND VGND VPWR VPWR _02112_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12281_ _03111_ _03112_ VGND VGND VPWR VPWR _03113_ sky130_fd_sc_hd__nor2_1
XFILLER_0_132_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14020_ net240 _03667_ VGND VGND VPWR VPWR _04964_ sky130_fd_sc_hd__nand2_1
X_11232_ net425 net119 _02040_ _02041_ VGND VGND VPWR VPWR _02043_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_120_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11163_ _01956_ _01970_ _01972_ VGND VGND VPWR VPWR _01974_ sky130_fd_sc_hd__a21oi_1
X_10114_ _00905_ _00913_ _00914_ VGND VGND VPWR VPWR _00925_ sky130_fd_sc_hd__or3_1
X_15971_ _07011_ _07031_ VGND VGND VPWR VPWR _07110_ sky130_fd_sc_hd__xor2_1
X_11094_ _01838_ _01904_ VGND VGND VPWR VPWR _01905_ sky130_fd_sc_hd__nand2_1
X_14922_ _05932_ _05931_ VGND VGND VPWR VPWR _05956_ sky130_fd_sc_hd__and2b_1
X_10045_ _00802_ _00855_ VGND VGND VPWR VPWR _00856_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14853_ _05878_ _05872_ _05873_ VGND VGND VPWR VPWR _05881_ sky130_fd_sc_hd__and3b_1
X_13804_ _04726_ VGND VGND VPWR VPWR _04727_ sky130_fd_sc_hd__inv_2
X_14784_ _05800_ _05804_ VGND VGND VPWR VPWR _05805_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_86_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11996_ _02808_ _02809_ VGND VGND VPWR VPWR _02810_ sky130_fd_sc_hd__and2_1
X_16523_ _07714_ _07716_ VGND VGND VPWR VPWR _07718_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_86_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13735_ _04570_ _04650_ VGND VGND VPWR VPWR _04651_ sky130_fd_sc_hd__xor2_4
XFILLER_0_133_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10947_ _01562_ net146 _01586_ VGND VGND VPWR VPWR _01758_ sky130_fd_sc_hd__o21a_1
X_16454_ _07605_ _07608_ _07638_ _07639_ _07641_ VGND VGND VPWR VPWR _07642_ sky130_fd_sc_hd__o41a_1
X_13666_ net246 _03241_ _03242_ VGND VGND VPWR VPWR _04575_ sky130_fd_sc_hd__and3_2
X_10878_ net393 net108 net105 net397 VGND VGND VPWR VPWR _01689_ sky130_fd_sc_hd__a22oi_1
X_15405_ _06429_ _06437_ VGND VGND VPWR VPWR _06488_ sky130_fd_sc_hd__xnor2_1
X_12617_ _03435_ _03455_ VGND VGND VPWR VPWR _03456_ sky130_fd_sc_hd__and2_1
X_16385_ _07565_ VGND VGND VPWR VPWR _07566_ sky130_fd_sc_hd__inv_2
XFILLER_0_6_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13597_ net212 _03577_ VGND VGND VPWR VPWR _04499_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15336_ _06410_ _06411_ VGND VGND VPWR VPWR _06412_ sky130_fd_sc_hd__or2b_1
X_12548_ _03364_ _03386_ VGND VGND VPWR VPWR _03387_ sky130_fd_sc_hd__and2b_1
X_15267_ _06193_ _06213_ VGND VGND VPWR VPWR _06336_ sky130_fd_sc_hd__xnor2_1
X_12479_ net520 prev_error\[17\] VGND VGND VPWR VPWR _03314_ sky130_fd_sc_hd__and2b_2
XANTENNA_2 _03371_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_124_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_17006_ _08247_ _08248_ VGND VGND VPWR VPWR _08249_ sky130_fd_sc_hd__nor2_1
X_14218_ _04453_ _04484_ _05181_ VGND VGND VPWR VPWR _05182_ sky130_fd_sc_hd__a21boi_4
XFILLER_0_112_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15198_ net300 _05701_ _06258_ VGND VGND VPWR VPWR _06260_ sky130_fd_sc_hd__and3_1
XFILLER_0_21_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14149_ _05096_ _05097_ VGND VGND VPWR VPWR _05106_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08710_ _02916_ VGND VGND VPWR VPWR _02927_ sky130_fd_sc_hd__buf_2
X_09690_ _00499_ _00500_ VGND VGND VPWR VPWR _00501_ sky130_fd_sc_hd__xnor2_1
Xrebuffer14 _01424_ VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__clkbuf_2
Xrebuffer25 _05301_ VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer36 _06867_ VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09124_ _07398_ VGND VGND VPWR VPWR _07409_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09055_ _04791_ _06056_ VGND VGND VPWR VPWR _06650_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09957_ _00761_ _00764_ _00767_ VGND VGND VPWR VPWR _00768_ sky130_fd_sc_hd__o21a_1
X_08908_ _05022_ VGND VGND VPWR VPWR _05033_ sky130_fd_sc_hd__buf_2
X_09888_ net370 net365 _04417_ _04747_ VGND VGND VPWR VPWR _00699_ sky130_fd_sc_hd__nand4_2
X_08839_ net17 VGND VGND VPWR VPWR _04274_ sky130_fd_sc_hd__inv_2
X_11850_ _02653_ _02660_ VGND VGND VPWR VPWR _02661_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10801_ _01559_ _01611_ VGND VGND VPWR VPWR _01612_ sky130_fd_sc_hd__nor2_1
X_11781_ _02524_ _02523_ VGND VGND VPWR VPWR _02592_ sky130_fd_sc_hd__nor2_1
X_13520_ _04409_ _04410_ VGND VGND VPWR VPWR _04414_ sky130_fd_sc_hd__xor2_1
X_10732_ net393 net125 net122 net399 VGND VGND VPWR VPWR _01543_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_27_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13451_ _04331_ _04337_ VGND VGND VPWR VPWR _04338_ sky130_fd_sc_hd__and2_2
XFILLER_0_137_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10663_ _01467_ _01472_ VGND VGND VPWR VPWR _01474_ sky130_fd_sc_hd__and2_1
X_12402_ _03233_ VGND VGND VPWR VPWR _03234_ sky130_fd_sc_hd__buf_2
X_16170_ _07325_ _07327_ _07328_ VGND VGND VPWR VPWR _07329_ sky130_fd_sc_hd__or3_1
XFILLER_0_35_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10594_ _01289_ _01320_ _01400_ _01401_ _01404_ VGND VGND VPWR VPWR _01405_ sky130_fd_sc_hd__o2111a_1
X_13382_ net191 _03793_ _04260_ _04261_ VGND VGND VPWR VPWR _04262_ sky130_fd_sc_hd__a31o_1
XFILLER_0_23_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15121_ _06027_ _06174_ VGND VGND VPWR VPWR _06175_ sky130_fd_sc_hd__nand2_1
X_12333_ _02218_ _03162_ _03164_ VGND VGND VPWR VPWR _03165_ sky130_fd_sc_hd__a21o_1
XFILLER_0_50_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15052_ _05702_ _05840_ VGND VGND VPWR VPWR _06099_ sky130_fd_sc_hd__and2_1
X_12264_ net440 VGND VGND VPWR VPWR _03096_ sky130_fd_sc_hd__inv_2
X_14003_ net210 _04317_ _04927_ _04944_ VGND VGND VPWR VPWR _04946_ sky130_fd_sc_hd__a31oi_2
X_11215_ _02010_ _02016_ _02014_ VGND VGND VPWR VPWR _02026_ sky130_fd_sc_hd__o21ai_1
X_12195_ _03013_ _03017_ _03019_ VGND VGND VPWR VPWR _03020_ sky130_fd_sc_hd__o21ai_1
Xoutput83 net83 VGND VGND VPWR VPWR out_clocked[16] sky130_fd_sc_hd__clkbuf_4
X_11146_ _01941_ _01942_ _01955_ VGND VGND VPWR VPWR _01957_ sky130_fd_sc_hd__or3_1
X_15954_ _07017_ _07016_ VGND VGND VPWR VPWR _07092_ sky130_fd_sc_hd__and2b_1
X_11077_ _01873_ _01887_ VGND VGND VPWR VPWR _01888_ sky130_fd_sc_hd__nor2_1
X_14905_ _05934_ _05928_ _05937_ VGND VGND VPWR VPWR _05938_ sky130_fd_sc_hd__o21ai_2
X_10028_ _00770_ _00772_ VGND VGND VPWR VPWR _00839_ sky130_fd_sc_hd__xnor2_1
X_15885_ net275 _06205_ _07015_ VGND VGND VPWR VPWR _07016_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_144_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14836_ _05857_ _05859_ _05861_ VGND VGND VPWR VPWR _05862_ sky130_fd_sc_hd__and3_1
XFILLER_0_86_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14767_ _05755_ _05769_ _05785_ VGND VGND VPWR VPWR _05786_ sky130_fd_sc_hd__o21a_1
X_11979_ net428 net446 net134 net150 VGND VGND VPWR VPWR _02791_ sky130_fd_sc_hd__and4_1
XFILLER_0_74_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16506_ _05866_ _07698_ VGND VGND VPWR VPWR _07699_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_46_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13718_ _04612_ _04613_ _04628_ VGND VGND VPWR VPWR _04632_ sky130_fd_sc_hd__a21o_1
XFILLER_0_46_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17486_ clknet_4_5_0_clock _00046_ VGND VGND VPWR VPWR ki\[2\] sky130_fd_sc_hd__dfxtp_1
X_14698_ _05709_ VGND VGND VPWR VPWR _05710_ sky130_fd_sc_hd__buf_4
X_16437_ _07183_ _07622_ VGND VGND VPWR VPWR _07623_ sky130_fd_sc_hd__or2_1
XFILLER_0_144_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13649_ _04520_ _04555_ VGND VGND VPWR VPWR _04556_ sky130_fd_sc_hd__or2_1
XFILLER_0_128_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16368_ _05874_ _07545_ _07546_ VGND VGND VPWR VPWR _07547_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_81_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15319_ _06390_ _06391_ _06392_ VGND VGND VPWR VPWR _06393_ sky130_fd_sc_hd__a21oi_2
X_16299_ _07445_ _07459_ _07470_ VGND VGND VPWR VPWR _07471_ sky130_fd_sc_hd__o21a_1
XFILLER_0_2_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout306 ki\[1\] VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__buf_2
X_09811_ _00488_ _00621_ VGND VGND VPWR VPWR _00622_ sky130_fd_sc_hd__xnor2_2
Xfanout317 net319 VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__buf_2
Xfanout328 kp\[13\] VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__clkbuf_4
Xfanout339 kp\[10\] VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__clkbuf_2
X_09742_ _00550_ _00552_ VGND VGND VPWR VPWR _00553_ sky130_fd_sc_hd__nand2_1
X_09673_ _00436_ _00428_ _00435_ VGND VGND VPWR VPWR _00484_ sky130_fd_sc_hd__nand3_1
XFILLER_0_27_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_138_Left_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09107_ _05231_ _05220_ VGND VGND VPWR VPWR _07222_ sky130_fd_sc_hd__and2b_1
XFILLER_0_72_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09038_ net329 net325 _05759_ VGND VGND VPWR VPWR _06463_ sky130_fd_sc_hd__and3_1
XFILLER_0_102_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11000_ _01757_ _01810_ VGND VGND VPWR VPWR _01811_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_147_Left_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12951_ net182 _03669_ net519 net178 VGND VGND VPWR VPWR _03795_ sky130_fd_sc_hd__a22o_1
X_11902_ _02710_ _02712_ VGND VGND VPWR VPWR _02713_ sky130_fd_sc_hd__and2b_1
X_15670_ _06770_ _06772_ _06778_ VGND VGND VPWR VPWR _06779_ sky130_fd_sc_hd__o21a_1
X_12882_ _03723_ _03724_ _03725_ VGND VGND VPWR VPWR _03726_ sky130_fd_sc_hd__o21ba_1
X_14621_ _05617_ _05624_ _03225_ _03179_ VGND VGND VPWR VPWR _05625_ sky130_fd_sc_hd__a211o_4
X_11833_ _02641_ _02640_ _02604_ VGND VGND VPWR VPWR _02644_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_114_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17340_ net463 i_error\[9\] VGND VGND VPWR VPWR _08571_ sky130_fd_sc_hd__or2_1
X_14552_ _05546_ _05548_ VGND VGND VPWR VPWR _05549_ sky130_fd_sc_hd__xnor2_1
X_11764_ net414 net152 _02507_ _02574_ VGND VGND VPWR VPWR _02575_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_56_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13503_ _04393_ _04394_ VGND VGND VPWR VPWR _04396_ sky130_fd_sc_hd__or2b_1
X_17271_ _08526_ VGND VGND VPWR VPWR _08527_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_82_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10715_ _01469_ _01525_ _01468_ VGND VGND VPWR VPWR _01526_ sky130_fd_sc_hd__o21ba_1
X_14483_ _06859_ _06936_ VGND VGND VPWR VPWR _05474_ sky130_fd_sc_hd__nand2_1
XFILLER_0_126_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11695_ _02495_ _02503_ _02505_ VGND VGND VPWR VPWR _02506_ sky130_fd_sc_hd__or3_1
X_16222_ net310 net295 _06415_ _06015_ VGND VGND VPWR VPWR _07386_ sky130_fd_sc_hd__nand4_1
X_13434_ net183 net518 VGND VGND VPWR VPWR _04320_ sky130_fd_sc_hd__nand2_1
X_10646_ _07772_ _01456_ VGND VGND VPWR VPWR _01457_ sky130_fd_sc_hd__xor2_4
XFILLER_0_63_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer5 net474 VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__clkbuf_1
X_16153_ _07263_ _07309_ VGND VGND VPWR VPWR _07311_ sky130_fd_sc_hd__xor2_1
XFILLER_0_140_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13365_ _04240_ _04243_ VGND VGND VPWR VPWR _04244_ sky130_fd_sc_hd__and2_1
XFILLER_0_2_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10577_ _01373_ _01384_ VGND VGND VPWR VPWR _01388_ sky130_fd_sc_hd__or2_1
X_15104_ _05595_ _06017_ VGND VGND VPWR VPWR _06157_ sky130_fd_sc_hd__nor2_1
XFILLER_0_140_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12316_ _02570_ _02642_ VGND VGND VPWR VPWR _03148_ sky130_fd_sc_hd__xor2_2
X_16084_ _07231_ _07234_ VGND VGND VPWR VPWR _07235_ sky130_fd_sc_hd__and2_1
X_13296_ net233 kd_1\[17\] _03283_ VGND VGND VPWR VPWR _04168_ sky130_fd_sc_hd__and3_1
X_15035_ _05959_ _06063_ _06076_ _06080_ VGND VGND VPWR VPWR _06081_ sky130_fd_sc_hd__o211ai_2
X_12247_ _03073_ _03076_ VGND VGND VPWR VPWR _03077_ sky130_fd_sc_hd__nand2_1
X_12178_ _02997_ _02998_ _02999_ VGND VGND VPWR VPWR _03003_ sky130_fd_sc_hd__o21ba_1
X_11129_ net430 net110 _01939_ VGND VGND VPWR VPWR _01940_ sky130_fd_sc_hd__a21oi_1
X_16986_ _08219_ _08224_ VGND VGND VPWR VPWR _08227_ sky130_fd_sc_hd__and2_1
X_15937_ _07052_ _07071_ _07072_ VGND VGND VPWR VPWR _07073_ sky130_fd_sc_hd__or3_4
XFILLER_0_64_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15868_ net282 _06016_ VGND VGND VPWR VPWR _06997_ sky130_fd_sc_hd__nand2_1
X_14819_ _05694_ _05842_ VGND VGND VPWR VPWR _05843_ sky130_fd_sc_hd__nor2_2
XFILLER_0_148_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15799_ _06917_ _06918_ _06920_ VGND VGND VPWR VPWR _06921_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_148_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17469_ clknet_4_0_0_clock _00065_ VGND VGND VPWR VPWR kp\[3\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_6_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_871 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout114 net115 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__buf_2
Xfanout125 net128 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__buf_2
Xfanout136 net137 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__clkbuf_4
Xfanout147 net149 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__clkbuf_4
Xfanout158 net161 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__buf_2
XFILLER_0_129_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout169 net172 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__clkbuf_4
X_09725_ _00503_ _00504_ VGND VGND VPWR VPWR _00536_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_97_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09656_ _00459_ _00465_ _00466_ VGND VGND VPWR VPWR _00467_ sky130_fd_sc_hd__a21oi_2
X_09587_ _00395_ _00396_ VGND VGND VPWR VPWR _00398_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10500_ _01307_ _01309_ VGND VGND VPWR VPWR _01311_ sky130_fd_sc_hd__or2_1
XFILLER_0_107_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11480_ _02142_ _02134_ _02140_ VGND VGND VPWR VPWR _02291_ sky130_fd_sc_hd__nand3_1
XFILLER_0_61_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10431_ _01235_ _01241_ VGND VGND VPWR VPWR _01242_ sky130_fd_sc_hd__nand2_1
XFILLER_0_135_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13150_ _03997_ _03998_ _04006_ VGND VGND VPWR VPWR _04007_ sky130_fd_sc_hd__o21a_1
X_10362_ net355 _00371_ VGND VGND VPWR VPWR _01173_ sky130_fd_sc_hd__nand2_2
XFILLER_0_60_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12101_ _02904_ _02907_ _02906_ VGND VGND VPWR VPWR _02925_ sky130_fd_sc_hd__o21ba_1
X_10293_ _01074_ _01103_ VGND VGND VPWR VPWR _01104_ sky130_fd_sc_hd__xnor2_1
X_13081_ _03194_ _00313_ VGND VGND VPWR VPWR _03931_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_130_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12032_ _02783_ _02848_ VGND VGND VPWR VPWR _02849_ sky130_fd_sc_hd__nand2_1
X_16840_ _08062_ _08065_ VGND VGND VPWR VPWR _08066_ sky130_fd_sc_hd__xnor2_2
X_16771_ _07800_ _07974_ VGND VGND VPWR VPWR _07990_ sky130_fd_sc_hd__or2_1
X_13983_ _04734_ _04918_ _04921_ _04922_ VGND VGND VPWR VPWR _04924_ sky130_fd_sc_hd__o22ai_2
X_15722_ _06543_ _06810_ _06825_ VGND VGND VPWR VPWR _06836_ sky130_fd_sc_hd__a21oi_1
X_12934_ _03776_ _03777_ VGND VGND VPWR VPWR _03778_ sky130_fd_sc_hd__nand2_2
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15653_ _06747_ _06748_ _06758_ VGND VGND VPWR VPWR _06761_ sky130_fd_sc_hd__and3_4
X_12865_ net215 _03336_ _03328_ net218 VGND VGND VPWR VPWR _03709_ sky130_fd_sc_hd__a22oi_2
X_14604_ net249 _05590_ _05584_ net252 VGND VGND VPWR VPWR _05607_ sky130_fd_sc_hd__a22o_1
X_11816_ _02519_ _02506_ _02518_ VGND VGND VPWR VPWR _02627_ sky130_fd_sc_hd__and3_1
X_15584_ _06346_ _06613_ VGND VGND VPWR VPWR _06685_ sky130_fd_sc_hd__or2_1
XFILLER_0_55_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12796_ _03636_ _03639_ VGND VGND VPWR VPWR _03640_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17323_ net466 net514 net456 VGND VGND VPWR VPWR _08561_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_138_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14535_ _05527_ _05530_ VGND VGND VPWR VPWR _05531_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_141_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11747_ _02543_ _02556_ _02557_ VGND VGND VPWR VPWR _02558_ sky130_fd_sc_hd__nand3_1
XFILLER_0_28_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17254_ _08512_ _08514_ net453 VGND VGND VPWR VPWR _00079_ sky130_fd_sc_hd__o21a_1
X_14466_ _00814_ VGND VGND VPWR VPWR _05455_ sky130_fd_sc_hd__inv_2
X_11678_ net434 net135 net131 net438 VGND VGND VPWR VPWR _02489_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_64_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16205_ _07345_ _07346_ _07361_ VGND VGND VPWR VPWR _07368_ sky130_fd_sc_hd__a21oi_1
X_13417_ net188 _03936_ VGND VGND VPWR VPWR _04301_ sky130_fd_sc_hd__nand2_1
X_17185_ _08401_ _08445_ VGND VGND VPWR VPWR _08446_ sky130_fd_sc_hd__xnor2_2
X_10629_ _00450_ _00360_ VGND VGND VPWR VPWR _01440_ sky130_fd_sc_hd__or2b_1
X_14397_ _03489_ _05378_ VGND VGND VPWR VPWR _05379_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16136_ _07290_ _07291_ VGND VGND VPWR VPWR _07292_ sky130_fd_sc_hd__nand2_1
X_13348_ _04223_ _04221_ VGND VGND VPWR VPWR _04225_ sky130_fd_sc_hd__or2b_1
XFILLER_0_12_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16067_ _07203_ _07215_ VGND VGND VPWR VPWR _07216_ sky130_fd_sc_hd__or2_1
XFILLER_0_121_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13279_ _04138_ _04144_ _04148_ VGND VGND VPWR VPWR _04149_ sky130_fd_sc_hd__a21oi_1
X_15018_ _06027_ _06061_ VGND VGND VPWR VPWR _06062_ sky130_fd_sc_hd__xor2_1
X_16969_ _05223_ _05298_ VGND VGND VPWR VPWR _08208_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09510_ _00309_ _00320_ VGND VGND VPWR VPWR _00321_ sky130_fd_sc_hd__nand2_1
X_09441_ _00250_ _00251_ VGND VGND VPWR VPWR _00252_ sky130_fd_sc_hd__and2b_1
X_09372_ _08653_ _00181_ _00177_ net97 VGND VGND VPWR VPWR _00183_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_47_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09708_ _00518_ VGND VGND VPWR VPWR _00519_ sky130_fd_sc_hd__clkbuf_4
X_10980_ net418 net421 net114 net110 VGND VGND VPWR VPWR _01791_ sky130_fd_sc_hd__and4_1
XFILLER_0_97_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09639_ _00417_ _00448_ _00449_ VGND VGND VPWR VPWR _00450_ sky130_fd_sc_hd__o21a_1
XFILLER_0_97_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12650_ _03478_ _03479_ _03488_ VGND VGND VPWR VPWR _03489_ sky130_fd_sc_hd__o21a_1
X_11601_ _02409_ _02410_ _02411_ VGND VGND VPWR VPWR _02412_ sky130_fd_sc_hd__o21ba_1
X_12581_ _03374_ _03377_ _03384_ VGND VGND VPWR VPWR _03420_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14320_ _05235_ _05293_ VGND VGND VPWR VPWR _05294_ sky130_fd_sc_hd__and2b_1
X_11532_ net413 net148 net151 net407 VGND VGND VPWR VPWR _02343_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_108_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14251_ _03168_ _05217_ VGND VGND VPWR VPWR _05218_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11463_ _02206_ _02273_ VGND VGND VPWR VPWR _02274_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13202_ _03953_ _03971_ VGND VGND VPWR VPWR _04064_ sky130_fd_sc_hd__xor2_2
XFILLER_0_150_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10414_ net351 _00518_ VGND VGND VPWR VPWR _01225_ sky130_fd_sc_hd__nand2_2
X_14182_ _05137_ _05138_ _05140_ VGND VGND VPWR VPWR _05142_ sky130_fd_sc_hd__o21a_1
X_11394_ _02204_ _02200_ VGND VGND VPWR VPWR _02205_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13133_ _03986_ _03950_ VGND VGND VPWR VPWR _03989_ sky130_fd_sc_hd__or2b_1
XFILLER_0_0_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10345_ _01130_ _01155_ VGND VGND VPWR VPWR _01156_ sky130_fd_sc_hd__xnor2_1
X_13064_ _03890_ _03896_ _03897_ VGND VGND VPWR VPWR _03913_ sky130_fd_sc_hd__nand3_1
X_10276_ _01084_ _01086_ VGND VGND VPWR VPWR _01087_ sky130_fd_sc_hd__nand2_2
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12015_ _02826_ _02819_ _02824_ VGND VGND VPWR VPWR _02831_ sky130_fd_sc_hd__nand3_1
X_16823_ _08037_ _08046_ VGND VGND VPWR VPWR _08048_ sky130_fd_sc_hd__xor2_1
X_16754_ _07722_ _07727_ _07971_ VGND VGND VPWR VPWR _07972_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13966_ _04900_ _04904_ VGND VGND VPWR VPWR _04905_ sky130_fd_sc_hd__nor2_1
X_15705_ net289 _05590_ VGND VGND VPWR VPWR _06818_ sky130_fd_sc_hd__nand2_1
X_12917_ _03719_ _03720_ VGND VGND VPWR VPWR _03761_ sky130_fd_sc_hd__nor2_1
X_16685_ _07879_ _07895_ VGND VGND VPWR VPWR _07896_ sky130_fd_sc_hd__xor2_2
X_13897_ net210 _04004_ _04827_ _04828_ VGND VGND VPWR VPWR _04829_ sky130_fd_sc_hd__a31o_1
X_12848_ _03680_ _03681_ VGND VGND VPWR VPWR _03692_ sky130_fd_sc_hd__or2_1
X_15636_ _06454_ _06457_ VGND VGND VPWR VPWR _06742_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15567_ _06582_ _06591_ VGND VGND VPWR VPWR _06666_ sky130_fd_sc_hd__nand2_1
X_12779_ _03370_ _03622_ VGND VGND VPWR VPWR _03623_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14518_ _05510_ _05511_ VGND VGND VPWR VPWR _05512_ sky130_fd_sc_hd__nor2_1
X_17306_ net462 prev_error\[11\] VGND VGND VPWR VPWR _08550_ sky130_fd_sc_hd__or2_1
XFILLER_0_124_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15498_ _06585_ _06588_ VGND VGND VPWR VPWR _06590_ sky130_fd_sc_hd__or2_1
XFILLER_0_71_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14449_ _00896_ _01427_ _00816_ VGND VGND VPWR VPWR _05436_ sky130_fd_sc_hd__a21oi_1
X_17237_ _08498_ net86 VGND VGND VPWR VPWR _08501_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17168_ _05312_ _08318_ VGND VGND VPWR VPWR _08427_ sky130_fd_sc_hd__nor2_1
XFILLER_0_141_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16119_ _07191_ _07192_ _07195_ _07196_ VGND VGND VPWR VPWR _07273_ sky130_fd_sc_hd__a2bb2o_1
X_17099_ _05347_ _08309_ _08349_ VGND VGND VPWR VPWR _08351_ sky130_fd_sc_hd__or3_1
XFILLER_0_40_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09990_ _00790_ _00800_ VGND VGND VPWR VPWR _00801_ sky130_fd_sc_hd__xnor2_1
X_08941_ net377 net360 _05385_ VGND VGND VPWR VPWR _05396_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_86_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08872_ _04560_ _04626_ VGND VGND VPWR VPWR _04637_ sky130_fd_sc_hd__or2_1
XFILLER_0_86_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09424_ net323 _07948_ _00234_ _00232_ VGND VGND VPWR VPWR _00235_ sky130_fd_sc_hd__a31o_1
XFILLER_0_94_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09355_ _00164_ _00165_ VGND VGND VPWR VPWR _00166_ sky130_fd_sc_hd__nor2_1
XFILLER_0_75_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09286_ _08648_ _08649_ VGND VGND VPWR VPWR _08650_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10130_ net356 _07409_ VGND VGND VPWR VPWR _00941_ sky130_fd_sc_hd__nand2_1
XFILLER_0_100_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10061_ _00868_ _00869_ _00871_ VGND VGND VPWR VPWR _00872_ sky130_fd_sc_hd__o21bai_1
X_13820_ net210 _03936_ _04743_ VGND VGND VPWR VPWR _04744_ sky130_fd_sc_hd__and3_1
XFILLER_0_106_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13751_ _04666_ _04667_ VGND VGND VPWR VPWR _04668_ sky130_fd_sc_hd__or2b_1
X_10963_ _01771_ _01747_ _01772_ VGND VGND VPWR VPWR _01774_ sky130_fd_sc_hd__or3b_1
XFILLER_0_85_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12702_ _03535_ _03540_ VGND VGND VPWR VPWR _03541_ sky130_fd_sc_hd__or2_1
X_16470_ _07510_ _07532_ _07529_ VGND VGND VPWR VPWR _07659_ sky130_fd_sc_hd__a21o_1
X_13682_ net197 _04003_ _04591_ VGND VGND VPWR VPWR _04592_ sky130_fd_sc_hd__and3_1
X_10894_ _01703_ _01704_ VGND VGND VPWR VPWR _01705_ sky130_fd_sc_hd__and2_1
XFILLER_0_38_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15421_ _06468_ _06503_ _06504_ VGND VGND VPWR VPWR _06505_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_128_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12633_ _03468_ _03471_ VGND VGND VPWR VPWR _03472_ sky130_fd_sc_hd__nor2_1
XFILLER_0_109_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15352_ net280 _05584_ _06427_ _06428_ VGND VGND VPWR VPWR _06429_ sky130_fd_sc_hd__a31o_1
XFILLER_0_65_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12564_ _03358_ _03361_ _03360_ VGND VGND VPWR VPWR _03403_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_31_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14303_ _04859_ _05166_ _05273_ _05170_ VGND VGND VPWR VPWR _05276_ sky130_fd_sc_hd__a22o_2
XFILLER_0_124_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11515_ net425 net132 _02317_ _02316_ VGND VGND VPWR VPWR _02326_ sky130_fd_sc_hd__a31oi_2
X_15283_ _06350_ _06352_ VGND VGND VPWR VPWR _06354_ sky130_fd_sc_hd__or2b_1
XFILLER_0_108_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12495_ _03306_ _03310_ _03331_ VGND VGND VPWR VPWR _03332_ sky130_fd_sc_hd__a21o_4
X_17022_ net178 _03337_ _03342_ net181 VGND VGND VPWR VPWR _08266_ sky130_fd_sc_hd__a22o_1
X_14234_ _05199_ VGND VGND VPWR VPWR _05200_ sky130_fd_sc_hd__inv_2
X_11446_ _02162_ _02252_ _02256_ VGND VGND VPWR VPWR _02257_ sky130_fd_sc_hd__or3_1
XFILLER_0_1_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14165_ _04899_ _04903_ _04902_ VGND VGND VPWR VPWR _05124_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_22_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11377_ _02185_ _02187_ VGND VGND VPWR VPWR _02188_ sky130_fd_sc_hd__and2b_1
XFILLER_0_150_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13116_ _03958_ _03968_ _03969_ VGND VGND VPWR VPWR _03970_ sky130_fd_sc_hd__o21ai_2
X_10328_ net376 _05132_ _07365_ VGND VGND VPWR VPWR _01139_ sky130_fd_sc_hd__and3_1
X_14096_ _05046_ _05047_ VGND VGND VPWR VPWR _05048_ sky130_fd_sc_hd__nor2_1
X_13047_ net220 net216 _03222_ _03283_ VGND VGND VPWR VPWR _03894_ sky130_fd_sc_hd__and4_1
X_10259_ _01057_ _01068_ _01069_ VGND VGND VPWR VPWR _01070_ sky130_fd_sc_hd__o21ai_2
X_16806_ _07914_ _07768_ _05468_ VGND VGND VPWR VPWR _08029_ sky130_fd_sc_hd__or3_1
X_14998_ _05949_ _05952_ VGND VGND VPWR VPWR _06040_ sky130_fd_sc_hd__xnor2_1
X_16737_ net248 _05711_ VGND VGND VPWR VPWR _07953_ sky130_fd_sc_hd__nand2_1
XFILLER_0_88_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13949_ _04815_ _04817_ _04885_ _04810_ VGND VGND VPWR VPWR _04886_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_88_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16668_ _07865_ _07876_ VGND VGND VPWR VPWR _07877_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_8_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15619_ _06689_ _06721_ _06720_ VGND VGND VPWR VPWR _06723_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_9_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16599_ _07725_ _07800_ VGND VGND VPWR VPWR _07801_ sky130_fd_sc_hd__or2_1
X_09140_ _05572_ _07255_ VGND VGND VPWR VPWR _07585_ sky130_fd_sc_hd__or2b_1
XFILLER_0_29_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09071_ _06628_ _06815_ VGND VGND VPWR VPWR _06826_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_21_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09973_ _00728_ _00782_ VGND VGND VPWR VPWR _00784_ sky130_fd_sc_hd__xor2_2
X_08924_ _05121_ _05198_ VGND VGND VPWR VPWR _05209_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08855_ _04439_ VGND VGND VPWR VPWR _04450_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08786_ net40 _03542_ _03575_ net334 VGND VGND VPWR VPWR _00056_ sky130_fd_sc_hd__a22o_1
XFILLER_0_67_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09407_ _00212_ _00217_ VGND VGND VPWR VPWR _00218_ sky130_fd_sc_hd__xnor2_1
X_09338_ net332 _04450_ _08615_ VGND VGND VPWR VPWR _00149_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_124_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09269_ _07959_ _08632_ VGND VGND VPWR VPWR _08633_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11300_ _02107_ _02109_ VGND VGND VPWR VPWR _02111_ sky130_fd_sc_hd__or2_1
XFILLER_0_16_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12280_ _02922_ _03108_ _03110_ VGND VGND VPWR VPWR _03112_ sky130_fd_sc_hd__and3_1
X_11231_ _02040_ _02041_ net425 net118 VGND VGND VPWR VPWR _02042_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_132_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11162_ _01956_ _01970_ _01972_ VGND VGND VPWR VPWR _01973_ sky130_fd_sc_hd__and3_1
X_10113_ _00916_ _00919_ _00923_ VGND VGND VPWR VPWR _00924_ sky130_fd_sc_hd__a21o_1
X_15970_ _07088_ _07108_ VGND VGND VPWR VPWR _07109_ sky130_fd_sc_hd__nand2_1
X_11093_ _01832_ _01835_ _01837_ VGND VGND VPWR VPWR _01904_ sky130_fd_sc_hd__or3_1
X_14921_ _05940_ _05954_ VGND VGND VPWR VPWR _05955_ sky130_fd_sc_hd__xnor2_1
X_10044_ kp\[17\] _00799_ _00801_ VGND VGND VPWR VPWR _00855_ sky130_fd_sc_hd__a21oi_1
X_14852_ _05872_ _05873_ _05878_ VGND VGND VPWR VPWR _05879_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_98_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13803_ _04722_ _04723_ _04724_ VGND VGND VPWR VPWR _04726_ sky130_fd_sc_hd__or3_2
X_14783_ net265 _05801_ _05730_ _05802_ VGND VGND VPWR VPWR _05804_ sky130_fd_sc_hd__a31o_1
X_11995_ net405 net410 net169 net173 VGND VGND VPWR VPWR _02809_ sky130_fd_sc_hd__and4_1
XFILLER_0_85_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16522_ _07565_ _07715_ VGND VGND VPWR VPWR _07716_ sky130_fd_sc_hd__nand2_1
X_13734_ _04609_ _04647_ _04649_ VGND VGND VPWR VPWR _04650_ sky130_fd_sc_hd__o21a_2
X_10946_ _01755_ _01756_ net391 net138 VGND VGND VPWR VPWR _01757_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_42_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16453_ i_error\[7\] _07601_ _07604_ i_error\[6\] VGND VGND VPWR VPWR _07641_ sky130_fd_sc_hd__o211ai_1
X_13665_ _03365_ _04573_ VGND VGND VPWR VPWR _04574_ sky130_fd_sc_hd__nor2_1
X_10877_ net393 net397 net105 VGND VGND VPWR VPWR _01688_ sky130_fd_sc_hd__and3_1
X_12616_ _03453_ _03454_ VGND VGND VPWR VPWR _03455_ sky130_fd_sc_hd__nor2_1
X_15404_ _06472_ _06484_ _06483_ VGND VGND VPWR VPWR _06487_ sky130_fd_sc_hd__a21oi_2
X_16384_ _07561_ _07562_ _07564_ VGND VGND VPWR VPWR _07565_ sky130_fd_sc_hd__nand3_1
X_13596_ _04412_ _04411_ VGND VGND VPWR VPWR _04498_ sky130_fd_sc_hd__and2b_1
XFILLER_0_143_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15335_ _06339_ _06409_ VGND VGND VPWR VPWR _06411_ sky130_fd_sc_hd__xor2_1
XFILLER_0_136_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12547_ _03380_ _03385_ VGND VGND VPWR VPWR _03386_ sky130_fd_sc_hd__or2_1
XFILLER_0_108_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15266_ _06332_ _06334_ VGND VGND VPWR VPWR _06335_ sky130_fd_sc_hd__and2b_1
XFILLER_0_13_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12478_ _03306_ _03308_ _03310_ _03311_ _03312_ VGND VGND VPWR VPWR _03313_ sky130_fd_sc_hd__a311o_2
XFILLER_0_41_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_3 net519 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_112_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17005_ _08244_ _08246_ VGND VGND VPWR VPWR _08248_ sky130_fd_sc_hd__and2_1
X_14217_ _04482_ _04455_ VGND VGND VPWR VPWR _05181_ sky130_fd_sc_hd__or2b_1
XFILLER_0_22_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11429_ _02227_ _02230_ _02239_ VGND VGND VPWR VPWR _02240_ sky130_fd_sc_hd__o21ai_2
X_15197_ net300 _05701_ _06258_ VGND VGND VPWR VPWR _06259_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_111_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14148_ _05092_ _05102_ _05104_ VGND VGND VPWR VPWR _05105_ sky130_fd_sc_hd__and3b_1
XFILLER_0_10_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14079_ _05025_ _05026_ _05028_ VGND VGND VPWR VPWR _05029_ sky130_fd_sc_hd__o21ba_1
Xrebuffer15 _05432_ VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__clkbuf_1
Xrebuffer26 _04252_ VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__clkbuf_1
Xrebuffer37 _06596_ VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__buf_1
XFILLER_0_88_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09123_ _07387_ VGND VGND VPWR VPWR _07398_ sky130_fd_sc_hd__buf_4
XFILLER_0_72_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09054_ _06034_ _06078_ VGND VGND VPWR VPWR _06639_ sky130_fd_sc_hd__nand2_1
XFILLER_0_103_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09956_ _00765_ _00766_ VGND VGND VPWR VPWR _00767_ sky130_fd_sc_hd__xor2_1
X_08907_ _05011_ VGND VGND VPWR VPWR _05022_ sky130_fd_sc_hd__clkbuf_4
X_09887_ _00573_ _00697_ VGND VGND VPWR VPWR _00698_ sky130_fd_sc_hd__xnor2_4
X_08838_ net16 VGND VGND VPWR VPWR _04263_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_142_Right_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08769_ net46 _03307_ _03340_ ki\[17\] VGND VGND VPWR VPWR _00044_ sky130_fd_sc_hd__a22o_1
X_10800_ _01558_ _01522_ VGND VGND VPWR VPWR _01611_ sky130_fd_sc_hd__and2b_1
X_11780_ _02588_ _02589_ _02590_ VGND VGND VPWR VPWR _02591_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_68_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10731_ net394 net399 net128 net122 VGND VGND VPWR VPWR _01542_ sky130_fd_sc_hd__and4_1
XFILLER_0_137_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_891 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13450_ _04325_ _04328_ _04330_ VGND VGND VPWR VPWR _04337_ sky130_fd_sc_hd__or3_1
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10662_ _01467_ _01472_ VGND VGND VPWR VPWR _01473_ sky130_fd_sc_hd__nor2_1
X_12401_ _03232_ VGND VGND VPWR VPWR _03233_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13381_ net197 net192 _03668_ _03751_ VGND VGND VPWR VPWR _04261_ sky130_fd_sc_hd__and4_1
X_10593_ _01320_ _01402_ _01403_ VGND VGND VPWR VPWR _01404_ sky130_fd_sc_hd__o21bai_1
X_15120_ _06026_ _06013_ _06024_ VGND VGND VPWR VPWR _06174_ sky130_fd_sc_hd__nand3_1
XFILLER_0_105_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12332_ _02126_ _03163_ VGND VGND VPWR VPWR _03164_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15051_ net300 _05691_ _05702_ net296 VGND VGND VPWR VPWR _06098_ sky130_fd_sc_hd__a22o_1
X_12263_ _03087_ _03066_ _03069_ _03093_ VGND VGND VPWR VPWR _03095_ sky130_fd_sc_hd__or4_1
X_14002_ _04874_ _04926_ VGND VGND VPWR VPWR _04944_ sky130_fd_sc_hd__nor2_1
XFILLER_0_120_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11214_ _02023_ _02024_ VGND VGND VPWR VPWR _02025_ sky130_fd_sc_hd__or2_1
X_12194_ _02982_ _03018_ VGND VGND VPWR VPWR _03019_ sky130_fd_sc_hd__nor2_1
X_11145_ _01941_ _01942_ _01955_ VGND VGND VPWR VPWR _01956_ sky130_fd_sc_hd__o21ai_1
Xoutput84 net84 VGND VGND VPWR VPWR out_clocked[17] sky130_fd_sc_hd__clkbuf_4
X_15953_ net267 _06416_ VGND VGND VPWR VPWR _07091_ sky130_fd_sc_hd__nand2_1
X_11076_ _01880_ _01884_ _01885_ _01886_ VGND VGND VPWR VPWR _01887_ sky130_fd_sc_hd__o211a_1
X_14904_ _05766_ _05936_ VGND VGND VPWR VPWR _05937_ sky130_fd_sc_hd__nor2_1
X_10027_ _00836_ _00837_ VGND VGND VPWR VPWR _00838_ sky130_fd_sc_hd__nand2_1
X_15884_ net271 _06348_ VGND VGND VPWR VPWR _07015_ sky130_fd_sc_hd__nand2_1
X_14835_ _05856_ _05860_ VGND VGND VPWR VPWR _05861_ sky130_fd_sc_hd__nor2_1
X_14766_ _05783_ _05784_ VGND VGND VPWR VPWR _05785_ sky130_fd_sc_hd__and2_1
X_11978_ net424 net154 VGND VGND VPWR VPWR _02790_ sky130_fd_sc_hd__nand2_1
X_16505_ _07682_ _07697_ VGND VGND VPWR VPWR _07698_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_58_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13717_ _04586_ _04630_ VGND VGND VPWR VPWR _04631_ sky130_fd_sc_hd__and2_1
X_10929_ net390 net137 _01579_ _01580_ VGND VGND VPWR VPWR _01740_ sky130_fd_sc_hd__o2bb2a_1
X_14697_ _03323_ _05684_ VGND VGND VPWR VPWR _05709_ sky130_fd_sc_hd__xnor2_2
X_17485_ clknet_4_4_0_clock _00045_ VGND VGND VPWR VPWR ki\[1\] sky130_fd_sc_hd__dfxtp_2
XFILLER_0_128_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16436_ _07124_ _07127_ _07182_ VGND VGND VPWR VPWR _07622_ sky130_fd_sc_hd__and3_1
XFILLER_0_129_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13648_ _04506_ _04519_ VGND VGND VPWR VPWR _04555_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16367_ net265 _05874_ VGND VGND VPWR VPWR _07546_ sky130_fd_sc_hd__nand2_2
X_13579_ _04437_ _04451_ VGND VGND VPWR VPWR _04479_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_109_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15318_ _06388_ _06389_ VGND VGND VPWR VPWR _06392_ sky130_fd_sc_hd__and2b_1
XFILLER_0_81_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16298_ _07460_ _07447_ _07458_ _07469_ VGND VGND VPWR VPWR _07470_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_112_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15249_ _06239_ _06241_ VGND VGND VPWR VPWR _06316_ sky130_fd_sc_hd__or2_1
XFILLER_0_111_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09810_ _00492_ _00493_ VGND VGND VPWR VPWR _00621_ sky130_fd_sc_hd__xnor2_1
Xfanout307 ki\[1\] VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__clkbuf_4
Xfanout318 net319 VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__clkbuf_4
Xfanout329 net330 VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__buf_2
XFILLER_0_10_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09741_ _00551_ _00521_ VGND VGND VPWR VPWR _00552_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_94_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09672_ _00459_ _00464_ VGND VGND VPWR VPWR _00483_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_27_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_59_Left_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09106_ net322 _04450_ VGND VGND VPWR VPWR _07211_ sky130_fd_sc_hd__nand2_1
XFILLER_0_150_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09037_ net329 _05759_ _05726_ net325 VGND VGND VPWR VPWR _06452_ sky130_fd_sc_hd__a22o_1
XFILLER_0_102_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09939_ net361 _00736_ net529 VGND VGND VPWR VPWR _00750_ sky130_fd_sc_hd__and3_1
X_12950_ _03263_ _03793_ VGND VGND VPWR VPWR _03794_ sky130_fd_sc_hd__nor2_1
X_11901_ _02681_ _02711_ VGND VGND VPWR VPWR _02712_ sky130_fd_sc_hd__nor2_1
X_12881_ net207 net204 _03217_ _03222_ VGND VGND VPWR VPWR _03725_ sky130_fd_sc_hd__and4_1
X_14620_ _03226_ _05610_ _05611_ VGND VGND VPWR VPWR _05624_ sky130_fd_sc_hd__and3b_1
XFILLER_0_68_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11832_ _02604_ _02641_ _02640_ VGND VGND VPWR VPWR _02643_ sky130_fd_sc_hd__and3_1
XFILLER_0_114_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14551_ _05547_ _05503_ _06309_ VGND VGND VPWR VPWR _05548_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_67_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11763_ _02508_ VGND VGND VPWR VPWR _02574_ sky130_fd_sc_hd__inv_2
XFILLER_0_55_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13502_ _04278_ _04279_ VGND VGND VPWR VPWR _04394_ sky130_fd_sc_hd__xnor2_1
X_10714_ net415 net111 VGND VGND VPWR VPWR _01525_ sky130_fd_sc_hd__nand2_1
X_14482_ _05572_ _06925_ VGND VGND VPWR VPWR _05472_ sky130_fd_sc_hd__or2_1
X_17270_ net464 _08453_ VGND VGND VPWR VPWR _08526_ sky130_fd_sc_hd__and2_1
X_11694_ _02463_ _02504_ VGND VGND VPWR VPWR _02505_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_71_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16221_ _07380_ _07382_ _07384_ VGND VGND VPWR VPWR _07385_ sky130_fd_sc_hd__o21a_1
X_13433_ _04317_ VGND VGND VPWR VPWR _04319_ sky130_fd_sc_hd__buf_1
XFILLER_0_125_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10645_ _08661_ _01449_ _01454_ _01455_ VGND VGND VPWR VPWR _01456_ sky130_fd_sc_hd__a31o_4
XFILLER_0_125_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16152_ net301 _06160_ _07184_ _07264_ VGND VGND VPWR VPWR _07309_ sky130_fd_sc_hd__a31o_1
X_13364_ net241 _03335_ _04240_ _04242_ VGND VGND VPWR VPWR _04243_ sky130_fd_sc_hd__nand4_1
Xrebuffer6 _07589_ VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__clkbuf_1
X_10576_ _01368_ _01348_ VGND VGND VPWR VPWR _01387_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_51_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15103_ _06006_ _06152_ _06154_ VGND VGND VPWR VPWR _06156_ sky130_fd_sc_hd__o21bai_1
X_12315_ _02720_ _03146_ VGND VGND VPWR VPWR _03147_ sky130_fd_sc_hd__nor2_1
XFILLER_0_134_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16083_ _07225_ _07231_ _07232_ VGND VGND VPWR VPWR _07234_ sky130_fd_sc_hd__nand3_1
X_13295_ net233 _03283_ kd_1\[17\] VGND VGND VPWR VPWR _04167_ sky130_fd_sc_hd__a21o_1
XFILLER_0_51_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15034_ _06077_ _06079_ VGND VGND VPWR VPWR _06080_ sky130_fd_sc_hd__nand2_2
X_12246_ _03074_ _03075_ VGND VGND VPWR VPWR _03076_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_121_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12177_ _02972_ _03001_ VGND VGND VPWR VPWR _03002_ sky130_fd_sc_hd__xnor2_1
X_11128_ _01938_ VGND VGND VPWR VPWR _01939_ sky130_fd_sc_hd__clkbuf_2
X_16985_ _08224_ _08225_ VGND VGND VPWR VPWR _08226_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15936_ _06992_ _06986_ _06990_ VGND VGND VPWR VPWR _07072_ sky130_fd_sc_hd__a21oi_1
X_11059_ _01867_ _01869_ VGND VGND VPWR VPWR _01870_ sky130_fd_sc_hd__or2b_1
X_15867_ _06946_ _06994_ _06993_ VGND VGND VPWR VPWR _06996_ sky130_fd_sc_hd__a21o_1
X_14818_ net288 _05697_ _05692_ VGND VGND VPWR VPWR _05842_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_99_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15798_ net267 _06348_ _06919_ VGND VGND VPWR VPWR _06920_ sky130_fd_sc_hd__and3_1
XFILLER_0_58_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17537_ clknet_4_7_0_clock _00026_ VGND VGND VPWR VPWR kd_2\[17\] sky130_fd_sc_hd__dfxtp_1
X_14749_ _05763_ _05765_ VGND VGND VPWR VPWR _05766_ sky130_fd_sc_hd__nor2_1
X_17468_ clknet_4_0_0_clock _00064_ VGND VGND VPWR VPWR kp\[2\] sky130_fd_sc_hd__dfxtp_1
XFILLER_0_129_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16419_ _06788_ _07589_ VGND VGND VPWR VPWR _07603_ sky130_fd_sc_hd__nand2_1
XFILLER_0_117_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17399_ clknet_4_11_0_clock _00077_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dfxtp_1
XFILLER_0_73_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout115 kd_2\[15\] VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__buf_2
Xfanout126 net525 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout137 kd_2\[10\] VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__clkbuf_4
Xfanout148 net149 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__buf_2
Xfanout159 net160 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__clkbuf_4
X_09724_ _00527_ _00534_ VGND VGND VPWR VPWR _00535_ sky130_fd_sc_hd__xnor2_1
X_09655_ _00457_ _00458_ VGND VGND VPWR VPWR _00466_ sky130_fd_sc_hd__nor2_1
XFILLER_0_145_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09586_ _00395_ _00396_ VGND VGND VPWR VPWR _00397_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10430_ _01235_ _01239_ _01240_ VGND VGND VPWR VPWR _01241_ sky130_fd_sc_hd__nand3_1
XFILLER_0_45_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10361_ _01167_ _01170_ VGND VGND VPWR VPWR _01172_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_103_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12100_ _02922_ _02923_ VGND VGND VPWR VPWR _02924_ sky130_fd_sc_hd__and2_1
XFILLER_0_20_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13080_ _03196_ _03200_ _03201_ VGND VGND VPWR VPWR _03930_ sky130_fd_sc_hd__a21o_1
XFILLER_0_131_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10292_ _01076_ _01101_ _01102_ VGND VGND VPWR VPWR _01103_ sky130_fd_sc_hd__a21o_1
XFILLER_0_103_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12031_ _02752_ _02782_ VGND VGND VPWR VPWR _02848_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16770_ _07753_ _07986_ _07988_ _07764_ VGND VGND VPWR VPWR _07989_ sky130_fd_sc_hd__a22o_1
X_13982_ net222 _04002_ VGND VGND VPWR VPWR _04922_ sky130_fd_sc_hd__nand2_1
X_15721_ _06831_ _06834_ VGND VGND VPWR VPWR _06835_ sky130_fd_sc_hd__xnor2_1
X_12933_ _03691_ _03775_ VGND VGND VPWR VPWR _03777_ sky130_fd_sc_hd__nand2_1
X_15652_ _06747_ _06748_ _06758_ VGND VGND VPWR VPWR _06759_ sky130_fd_sc_hd__a21oi_4
X_12864_ net211 _03284_ VGND VGND VPWR VPWR _03708_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14603_ net524 _05604_ VGND VGND VPWR VPWR _05606_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11815_ _02624_ _02623_ _02625_ VGND VGND VPWR VPWR _02626_ sky130_fd_sc_hd__nand3_1
X_15583_ net250 _06417_ VGND VGND VPWR VPWR _06684_ sky130_fd_sc_hd__nand2_1
X_12795_ net200 _03288_ _03638_ VGND VGND VPWR VPWR _03639_ sky130_fd_sc_hd__and3_1
XFILLER_0_139_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17322_ _08549_ _08558_ _08559_ net458 VGND VGND VPWR VPWR _00108_ sky130_fd_sc_hd__o211a_1
X_14534_ _05487_ _05529_ VGND VGND VPWR VPWR _05530_ sky130_fd_sc_hd__xnor2_1
X_11746_ _02477_ _02486_ _02542_ VGND VGND VPWR VPWR _02557_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_44_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_17253_ _08462_ _08495_ _08469_ VGND VGND VPWR VPWR _08514_ sky130_fd_sc_hd__a21oi_2
X_14465_ _00727_ _01428_ VGND VGND VPWR VPWR _05454_ sky130_fd_sc_hd__nand2_2
X_11677_ net434 net438 net135 net131 VGND VGND VPWR VPWR _02488_ sky130_fd_sc_hd__and4_1
XFILLER_0_126_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16204_ _07363_ _07366_ VGND VGND VPWR VPWR _07367_ sky130_fd_sc_hd__xnor2_1
X_10628_ _01437_ _01438_ VGND VGND VPWR VPWR _01439_ sky130_fd_sc_hd__and2b_2
X_13416_ net192 net188 _03792_ _03935_ VGND VGND VPWR VPWR _04300_ sky130_fd_sc_hd__and4_1
XFILLER_0_141_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14396_ _05376_ _05377_ VGND VGND VPWR VPWR _05378_ sky130_fd_sc_hd__nor2_1
X_17184_ _08402_ _08444_ VGND VGND VPWR VPWR _08445_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16135_ _07287_ _07289_ _07261_ VGND VGND VPWR VPWR _07291_ sky130_fd_sc_hd__o21ai_1
X_13347_ _04221_ _04223_ VGND VGND VPWR VPWR _04224_ sky130_fd_sc_hd__or2b_1
X_10559_ _01324_ _01346_ _01345_ VGND VGND VPWR VPWR _01370_ sky130_fd_sc_hd__a21o_1
XFILLER_0_11_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16066_ _07209_ _07214_ VGND VGND VPWR VPWR _07215_ sky130_fd_sc_hd__xnor2_1
X_13278_ _04145_ _04147_ VGND VGND VPWR VPWR _04148_ sky130_fd_sc_hd__and2_1
X_15017_ _06058_ _06060_ VGND VGND VPWR VPWR _06061_ sky130_fd_sc_hd__xnor2_1
X_12229_ _03048_ _03056_ VGND VGND VPWR VPWR _03057_ sky130_fd_sc_hd__and2_1
X_16968_ _05428_ _08206_ VGND VGND VPWR VPWR _08207_ sky130_fd_sc_hd__xnor2_1
X_15919_ net297 _05589_ _06983_ VGND VGND VPWR VPWR _07053_ sky130_fd_sc_hd__nand3_1
X_16899_ _08128_ _08130_ VGND VGND VPWR VPWR _08131_ sky130_fd_sc_hd__xor2_2
X_09440_ _08685_ _08671_ VGND VGND VPWR VPWR _00251_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_149_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09371_ _00177_ net97 _08653_ _00181_ VGND VGND VPWR VPWR _00182_ sky130_fd_sc_hd__o211a_1
XFILLER_0_47_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09707_ _00517_ VGND VGND VPWR VPWR _00518_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_69_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09638_ _00418_ _00447_ VGND VGND VPWR VPWR _00449_ sky130_fd_sc_hd__or2_1
X_09569_ _00366_ _00367_ _00379_ VGND VGND VPWR VPWR _00380_ sky130_fd_sc_hd__a21oi_1
X_11600_ net143 _02330_ VGND VGND VPWR VPWR _02411_ sky130_fd_sc_hd__and2_1
X_12580_ _03374_ _03377_ _03384_ VGND VGND VPWR VPWR _03419_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_93_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11531_ net407 net413 net149 net151 VGND VGND VPWR VPWR _02342_ sky130_fd_sc_hd__and4_1
XFILLER_0_136_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14250_ _03167_ _02126_ _03165_ VGND VGND VPWR VPWR _05217_ sky130_fd_sc_hd__and3_1
XFILLER_0_92_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11462_ _02203_ _02205_ VGND VGND VPWR VPWR _02273_ sky130_fd_sc_hd__or2_1
XFILLER_0_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13201_ _04053_ _04062_ VGND VGND VPWR VPWR _04063_ sky130_fd_sc_hd__nor2_1
X_10413_ _01222_ _01223_ VGND VGND VPWR VPWR _01224_ sky130_fd_sc_hd__xnor2_1
X_14181_ _05137_ _05138_ _05140_ VGND VGND VPWR VPWR _05141_ sky130_fd_sc_hd__or3_1
X_11393_ _02061_ _02181_ VGND VGND VPWR VPWR _02204_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13132_ _03950_ _03986_ VGND VGND VPWR VPWR _03987_ sky130_fd_sc_hd__xnor2_2
X_10344_ _01132_ _01133_ VGND VGND VPWR VPWR _01155_ sky130_fd_sc_hd__and2_1
XFILLER_0_131_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13063_ _03908_ _03910_ _03906_ VGND VGND VPWR VPWR _03912_ sky130_fd_sc_hd__a21oi_1
X_10275_ net376 _07321_ _01084_ _01085_ VGND VGND VPWR VPWR _01086_ sky130_fd_sc_hd__nand4_2
X_12014_ _02802_ _02829_ VGND VGND VPWR VPWR _02830_ sky130_fd_sc_hd__nor2_1
X_16822_ _05421_ _08044_ _08045_ VGND VGND VPWR VPWR _08046_ sky130_fd_sc_hd__a21oi_2
X_16753_ net504 VGND VGND VPWR VPWR _07971_ sky130_fd_sc_hd__clkbuf_4
X_13965_ _04899_ _04902_ _04903_ VGND VGND VPWR VPWR _04904_ sky130_fd_sc_hd__and3_1
X_15704_ _06814_ _06816_ VGND VGND VPWR VPWR _06817_ sky130_fd_sc_hd__xnor2_1
X_12916_ _03741_ _03759_ VGND VGND VPWR VPWR _03760_ sky130_fd_sc_hd__and2b_1
X_16684_ _07880_ _07894_ VGND VGND VPWR VPWR _07895_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_76_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13896_ net218 net214 _03791_ _03934_ VGND VGND VPWR VPWR _04828_ sky130_fd_sc_hd__and4_1
X_15635_ _06652_ _06659_ _06657_ VGND VGND VPWR VPWR _06741_ sky130_fd_sc_hd__a21o_1
X_12847_ _03685_ _03684_ VGND VGND VPWR VPWR _03691_ sky130_fd_sc_hd__xor2_1
XFILLER_0_56_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15566_ _06664_ _06636_ VGND VGND VPWR VPWR _06665_ sky130_fd_sc_hd__nor2_2
XFILLER_0_127_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12778_ _03536_ _03538_ VGND VGND VPWR VPWR _03622_ sky130_fd_sc_hd__xor2_1
X_17305_ _03878_ VGND VGND VPWR VPWR _08549_ sky130_fd_sc_hd__buf_4
X_14517_ _05509_ _06969_ _07002_ VGND VGND VPWR VPWR _05511_ sky130_fd_sc_hd__nor3_1
XFILLER_0_56_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11729_ _02521_ _02539_ VGND VGND VPWR VPWR _02540_ sky130_fd_sc_hd__nor2_1
X_15497_ _06585_ _06588_ VGND VGND VPWR VPWR _06589_ sky130_fd_sc_hd__nand2_1
X_17236_ _08499_ _08500_ net453 VGND VGND VPWR VPWR _00073_ sky130_fd_sc_hd__o21a_1
XFILLER_0_117_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14448_ _00816_ _00896_ _01427_ VGND VGND VPWR VPWR _05435_ sky130_fd_sc_hd__and3_1
XFILLER_0_4_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17167_ _01505_ _08336_ _08425_ VGND VGND VPWR VPWR _08426_ sky130_fd_sc_hd__a21oi_1
X_14379_ net187 _03337_ _03504_ _03503_ VGND VGND VPWR VPWR _05359_ sky130_fd_sc_hd__a31o_1
XFILLER_0_3_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16118_ _07268_ _07271_ VGND VGND VPWR VPWR _07272_ sky130_fd_sc_hd__or2b_1
XFILLER_0_110_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17098_ _05347_ _08309_ _08349_ VGND VGND VPWR VPWR _08350_ sky130_fd_sc_hd__o21a_1
XFILLER_0_122_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_23_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08940_ _05374_ VGND VGND VPWR VPWR _05385_ sky130_fd_sc_hd__clkbuf_4
X_16049_ net290 _06161_ _07193_ _07194_ VGND VGND VPWR VPWR _07196_ sky130_fd_sc_hd__a22o_1
X_08871_ _04615_ VGND VGND VPWR VPWR _04626_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_19_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09423_ _00232_ _00233_ VGND VGND VPWR VPWR _00234_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_32_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09354_ _00146_ _00162_ _00163_ VGND VGND VPWR VPWR _00165_ sky130_fd_sc_hd__nor3_1
XFILLER_0_136_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09285_ _08608_ _08645_ _08647_ VGND VGND VPWR VPWR _08649_ sky130_fd_sc_hd__and3_1
XFILLER_0_142_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_41_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10060_ net365 _04505_ _00870_ VGND VGND VPWR VPWR _00871_ sky130_fd_sc_hd__and3_1
XFILLER_0_97_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13750_ _04657_ _04661_ VGND VGND VPWR VPWR _04667_ sky130_fd_sc_hd__xor2_1
X_10962_ _01771_ _01747_ _01772_ VGND VGND VPWR VPWR _01773_ sky130_fd_sc_hd__o21bai_2
X_12701_ _03370_ _03534_ VGND VGND VPWR VPWR _03540_ sky130_fd_sc_hd__nor2_1
X_13681_ _04589_ _04590_ VGND VGND VPWR VPWR _04591_ sky130_fd_sc_hd__nor2_1
X_10893_ _01701_ _01702_ VGND VGND VPWR VPWR _01704_ sky130_fd_sc_hd__nand2_1
X_15420_ _06501_ _06502_ VGND VGND VPWR VPWR _06504_ sky130_fd_sc_hd__nor2_1
X_12632_ _03426_ _03466_ _03467_ VGND VGND VPWR VPWR _03471_ sky130_fd_sc_hd__nor3_1
XFILLER_0_38_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12563_ _03292_ _03293_ _03295_ VGND VGND VPWR VPWR _03402_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_38_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15351_ net283 _05620_ _06301_ VGND VGND VPWR VPWR _06428_ sky130_fd_sc_hd__and3_1
XFILLER_0_93_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14302_ _04859_ _05166_ _05273_ _05170_ VGND VGND VPWR VPWR _05274_ sky130_fd_sc_hd__nand4_4
X_11514_ _02315_ _02322_ _02324_ VGND VGND VPWR VPWR _02325_ sky130_fd_sc_hd__a21o_1
XFILLER_0_81_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12494_ prev_error\[15\] _05000_ VGND VGND VPWR VPWR _03331_ sky130_fd_sc_hd__xnor2_4
X_15282_ _06202_ _06346_ _06351_ VGND VGND VPWR VPWR _06352_ sky130_fd_sc_hd__o21a_1
XFILLER_0_124_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_17021_ net178 _03342_ VGND VGND VPWR VPWR _08265_ sky130_fd_sc_hd__nand2_1
XFILLER_0_150_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14233_ _03176_ _05197_ VGND VGND VPWR VPWR _05199_ sky130_fd_sc_hd__nor2_1
X_11445_ _02253_ _02255_ VGND VGND VPWR VPWR _02256_ sky130_fd_sc_hd__nor2_1
XFILLER_0_124_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14164_ _04947_ _04960_ VGND VGND VPWR VPWR _05123_ sky130_fd_sc_hd__or2_1
XFILLER_0_33_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11376_ _02036_ _02186_ VGND VGND VPWR VPWR _02187_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10327_ net376 _07321_ _01084_ _01085_ VGND VGND VPWR VPWR _01138_ sky130_fd_sc_hd__a22o_1
X_13115_ _03960_ _03967_ VGND VGND VPWR VPWR _03969_ sky130_fd_sc_hd__or2b_1
X_14095_ _05043_ _05045_ _05038_ _05042_ VGND VGND VPWR VPWR _05047_ sky130_fd_sc_hd__o211a_1
X_13046_ net219 _03283_ _03892_ VGND VGND VPWR VPWR _03893_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_147_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10258_ _00996_ _00818_ VGND VGND VPWR VPWR _01069_ sky130_fd_sc_hd__nor2_1
X_10189_ _00995_ _00998_ _00999_ VGND VGND VPWR VPWR _01000_ sky130_fd_sc_hd__a21oi_1
X_16805_ _08022_ _08023_ _08027_ VGND VGND VPWR VPWR _08028_ sky130_fd_sc_hd__a21o_2
X_14997_ _06032_ _06038_ VGND VGND VPWR VPWR _06039_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16736_ _07947_ _07951_ VGND VGND VPWR VPWR _07952_ sky130_fd_sc_hd__xnor2_1
X_13948_ _04768_ _04805_ _04809_ VGND VGND VPWR VPWR _04885_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_48_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16667_ _07866_ _07875_ VGND VGND VPWR VPWR _07876_ sky130_fd_sc_hd__xnor2_2
X_13879_ net241 _03269_ _04807_ _04808_ VGND VGND VPWR VPWR _04809_ sky130_fd_sc_hd__a31o_1
XFILLER_0_57_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15618_ _06720_ _06689_ _06721_ VGND VGND VPWR VPWR _06722_ sky130_fd_sc_hd__or3_2
X_16598_ _07754_ _07799_ VGND VGND VPWR VPWR _07800_ sky130_fd_sc_hd__or2_1
XFILLER_0_72_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15549_ _06567_ _06572_ _06575_ _06645_ VGND VGND VPWR VPWR _06646_ sky130_fd_sc_hd__a31o_1
XFILLER_0_127_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09070_ _06793_ _06804_ VGND VGND VPWR VPWR _06815_ sky130_fd_sc_hd__or2_1
XFILLER_0_142_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_17219_ _08090_ _08092_ VGND VGND VPWR VPWR _08483_ sky130_fd_sc_hd__nand2_1
XFILLER_0_71_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout6 _07926_ VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_130_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_889 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09972_ _00728_ _00782_ VGND VGND VPWR VPWR _00783_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_123_Right_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08923_ net526 _05165_ _05187_ VGND VGND VPWR VPWR _05198_ sky130_fd_sc_hd__and3_1
XFILLER_0_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08854_ _04428_ VGND VGND VPWR VPWR _04439_ sky130_fd_sc_hd__clkbuf_4
X_08785_ net39 _03542_ _03575_ net338 VGND VGND VPWR VPWR _00055_ sky130_fd_sc_hd__a22o_1
X_09406_ _00213_ _00214_ _00216_ VGND VGND VPWR VPWR _00217_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_149_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09337_ _00146_ _00147_ VGND VGND VPWR VPWR _00148_ sky130_fd_sc_hd__or2b_1
XFILLER_0_8_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09268_ _07981_ _07970_ VGND VGND VPWR VPWR _08632_ sky130_fd_sc_hd__nor2_1
XFILLER_0_106_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09199_ _08190_ _08212_ _08223_ VGND VGND VPWR VPWR _08234_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_90_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11230_ net431 net114 _01939_ VGND VGND VPWR VPWR _02041_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_31_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11161_ _01884_ _01971_ VGND VGND VPWR VPWR _01972_ sky130_fd_sc_hd__or2_1
X_10112_ _00920_ _00922_ VGND VGND VPWR VPWR _00923_ sky130_fd_sc_hd__and2_1
X_11092_ _01897_ _01900_ _01902_ VGND VGND VPWR VPWR _01903_ sky130_fd_sc_hd__o21ai_1
X_14920_ _05950_ _05952_ _05953_ VGND VGND VPWR VPWR _05954_ sky130_fd_sc_hd__a21oi_1
X_10043_ _00840_ _00852_ _00853_ VGND VGND VPWR VPWR _00854_ sky130_fd_sc_hd__o21bai_2
Xhold40 net84 VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_117_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14851_ _05876_ _05877_ VGND VGND VPWR VPWR _05878_ sky130_fd_sc_hd__xnor2_1
X_13802_ _04689_ _04691_ VGND VGND VPWR VPWR _04724_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14782_ _05727_ _05728_ VGND VGND VPWR VPWR _05802_ sky130_fd_sc_hd__nor2_1
XFILLER_0_98_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11994_ _02744_ _02807_ VGND VGND VPWR VPWR _02808_ sky130_fd_sc_hd__nor2_1
X_16521_ _06003_ _07505_ _07567_ VGND VGND VPWR VPWR _07715_ sky130_fd_sc_hd__or3_1
X_13733_ _04646_ _04610_ VGND VGND VPWR VPWR _04649_ sky130_fd_sc_hd__or2b_1
XFILLER_0_58_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10945_ net395 net137 net130 net398 VGND VGND VPWR VPWR _01756_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_97_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16452_ i_error\[7\] _07601_ VGND VGND VPWR VPWR _07639_ sky130_fd_sc_hd__xnor2_4
X_13664_ _03268_ VGND VGND VPWR VPWR _04573_ sky130_fd_sc_hd__inv_2
X_10876_ _01508_ _01641_ _01686_ VGND VGND VPWR VPWR _01687_ sky130_fd_sc_hd__a21o_2
XFILLER_0_128_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15403_ _06472_ _06483_ _06484_ VGND VGND VPWR VPWR _06486_ sky130_fd_sc_hd__and3_4
XFILLER_0_54_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12615_ _03452_ _03450_ VGND VGND VPWR VPWR _03454_ sky130_fd_sc_hd__and2b_1
XFILLER_0_26_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16383_ _05917_ _05789_ VGND VGND VPWR VPWR _07564_ sky130_fd_sc_hd__or2b_1
X_13595_ _04493_ _04495_ _04496_ VGND VGND VPWR VPWR _04497_ sky130_fd_sc_hd__a21bo_1
X_15334_ net256 _06162_ VGND VGND VPWR VPWR _06410_ sky130_fd_sc_hd__nand2_1
X_12546_ _03374_ _03382_ _03384_ VGND VGND VPWR VPWR _03385_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_54_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15265_ _06315_ _06333_ VGND VGND VPWR VPWR _06334_ sky130_fd_sc_hd__xnor2_1
X_12477_ prev_error\[15\] _06705_ VGND VGND VPWR VPWR _03312_ sky130_fd_sc_hd__nor2_1
X_17004_ _08244_ _08246_ VGND VGND VPWR VPWR _08247_ sky130_fd_sc_hd__nor2_2
XANTENNA_4 net521 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14216_ _04400_ _04398_ VGND VGND VPWR VPWR _05180_ sky130_fd_sc_hd__xor2_4
XFILLER_0_111_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11428_ _02151_ _02238_ VGND VGND VPWR VPWR _02239_ sky130_fd_sc_hd__xnor2_1
X_15196_ net296 _05709_ VGND VGND VPWR VPWR _06258_ sky130_fd_sc_hd__and2_4
XFILLER_0_10_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14147_ net244 _04004_ _05103_ VGND VGND VPWR VPWR _05104_ sky130_fd_sc_hd__and3_1
X_11359_ _02167_ _02169_ VGND VGND VPWR VPWR _02170_ sky130_fd_sc_hd__and2_1
XFILLER_0_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14078_ net240 _03934_ _05027_ VGND VGND VPWR VPWR _05028_ sky130_fd_sc_hd__and3_1
X_13029_ _03872_ _03870_ VGND VGND VPWR VPWR _03874_ sky130_fd_sc_hd__or2b_1
Xrebuffer16 net471 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer27 _06764_ VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__clkbuf_1
Xrebuffer38 _06737_ VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16719_ _07931_ _07932_ VGND VGND VPWR VPWR _07933_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09122_ _07376_ VGND VGND VPWR VPWR _07387_ sky130_fd_sc_hd__buf_6
XFILLER_0_32_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09053_ _05572_ _06507_ _06617_ VGND VGND VPWR VPWR _06628_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_114_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09955_ _00677_ _00676_ VGND VGND VPWR VPWR _00766_ sky130_fd_sc_hd__or2b_1
X_08906_ net529 VGND VGND VPWR VPWR _05011_ sky130_fd_sc_hd__clkbuf_4
X_09886_ _00663_ _00661_ VGND VGND VPWR VPWR _00697_ sky130_fd_sc_hd__and2b_1
XFILLER_0_99_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08837_ _04032_ _04131_ _04164_ _04241_ VGND VGND VPWR VPWR _04252_ sky130_fd_sc_hd__and4_4
X_08768_ net45 _03307_ _03340_ net250 VGND VGND VPWR VPWR _00043_ sky130_fd_sc_hd__a22o_1
X_08699_ net33 net32 net35 net34 VGND VGND VPWR VPWR _02806_ sky130_fd_sc_hd__or4_1
XFILLER_0_94_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10730_ _01539_ _01536_ VGND VGND VPWR VPWR _01541_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_67_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10661_ _01470_ _01471_ VGND VGND VPWR VPWR _01472_ sky130_fd_sc_hd__xor2_1
XFILLER_0_12_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12400_ _03229_ _03231_ VGND VGND VPWR VPWR _03232_ sky130_fd_sc_hd__nand2_2
X_13380_ net201 _03668_ _03751_ net192 VGND VGND VPWR VPWR _04260_ sky130_fd_sc_hd__a22o_1
X_10592_ _01369_ _01370_ VGND VGND VPWR VPWR _01403_ sky130_fd_sc_hd__and2_1
X_12331_ _02125_ _02120_ _02124_ VGND VGND VPWR VPWR _03163_ sky130_fd_sc_hd__or3_1
XFILLER_0_51_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15050_ net304 _05691_ VGND VGND VPWR VPWR _06097_ sky130_fd_sc_hd__and2_1
X_12262_ _03089_ _03090_ _03092_ _03080_ VGND VGND VPWR VPWR _03093_ sky130_fd_sc_hd__or4b_1
XFILLER_0_133_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14001_ _04940_ _04942_ VGND VGND VPWR VPWR _04943_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_121_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11213_ _02022_ _01994_ _02020_ VGND VGND VPWR VPWR _02024_ sky130_fd_sc_hd__nor3_1
X_12193_ net444 net158 _02980_ _02981_ VGND VGND VPWR VPWR _03018_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_120_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11144_ _01864_ _01954_ VGND VGND VPWR VPWR _01955_ sky130_fd_sc_hd__xnor2_1
Xoutput85 net85 VGND VGND VPWR VPWR out_clocked[1] sky130_fd_sc_hd__buf_2
XFILLER_0_128_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15952_ _07008_ _07087_ _07086_ _07073_ VGND VGND VPWR VPWR _07089_ sky130_fd_sc_hd__o211ai_1
X_11075_ _01863_ _01870_ _01872_ VGND VGND VPWR VPWR _01886_ sky130_fd_sc_hd__nand3_1
X_14903_ _05763_ _05765_ VGND VGND VPWR VPWR _05936_ sky130_fd_sc_hd__and2_1
X_10026_ _00830_ _00832_ VGND VGND VPWR VPWR _00837_ sky130_fd_sc_hd__xor2_1
X_15883_ _06920_ _07012_ VGND VGND VPWR VPWR _07014_ sky130_fd_sc_hd__nor2_1
X_14834_ _05855_ _05851_ VGND VGND VPWR VPWR _05860_ sky130_fd_sc_hd__and2b_1
XFILLER_0_53_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14765_ _05782_ _05648_ _05652_ VGND VGND VPWR VPWR _05784_ sky130_fd_sc_hd__nand3_1
XFILLER_0_59_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11977_ net446 net134 net150 net428 VGND VGND VPWR VPWR _02789_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_86_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16504_ _07694_ _07696_ VGND VGND VPWR VPWR _07697_ sky130_fd_sc_hd__nand2_1
X_13716_ _04580_ _04585_ VGND VGND VPWR VPWR _04630_ sky130_fd_sc_hd__or2_1
X_17484_ clknet_4_5_0_clock _00036_ VGND VGND VPWR VPWR ki\[0\] sky130_fd_sc_hd__dfxtp_1
X_10928_ _01737_ _01735_ VGND VGND VPWR VPWR _01739_ sky130_fd_sc_hd__xnor2_1
X_14696_ _05696_ _05707_ VGND VGND VPWR VPWR _05708_ sky130_fd_sc_hd__and2_1
XFILLER_0_74_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16435_ i_error\[2\] _07620_ VGND VGND VPWR VPWR _07621_ sky130_fd_sc_hd__xor2_1
XFILLER_0_39_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13647_ _04548_ _04552_ _04474_ _04553_ VGND VGND VPWR VPWR _04554_ sky130_fd_sc_hd__o211a_1
X_10859_ net125 _01668_ _01669_ prev_d_error\[17\] VGND VGND VPWR VPWR _01670_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_26_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16366_ _05874_ _05875_ _05877_ _07544_ VGND VGND VPWR VPWR _07545_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_6_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13578_ _04457_ _04476_ _04477_ VGND VGND VPWR VPWR _04478_ sky130_fd_sc_hd__a21o_1
XFILLER_0_26_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15317_ _06332_ _06334_ VGND VGND VPWR VPWR _06391_ sky130_fd_sc_hd__xnor2_1
X_12529_ net244 net225 _03345_ VGND VGND VPWR VPWR _03368_ sky130_fd_sc_hd__o21ai_1
X_16297_ _07455_ _07462_ _07463_ _07468_ VGND VGND VPWR VPWR _07469_ sky130_fd_sc_hd__a31o_1
XFILLER_0_124_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15248_ _06306_ _06313_ _06314_ VGND VGND VPWR VPWR _06315_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_124_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15179_ _06231_ _06238_ VGND VGND VPWR VPWR _06239_ sky130_fd_sc_hd__xor2_1
XFILLER_0_1_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout308 ki\[0\] VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__clkbuf_4
Xfanout319 net320 VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__buf_2
XFILLER_0_120_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09740_ _04549_ _00520_ VGND VGND VPWR VPWR _00551_ sky130_fd_sc_hd__nor2_1
XFILLER_0_94_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
.ends
