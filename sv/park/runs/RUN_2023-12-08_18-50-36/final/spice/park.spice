* NGSPICE file created from park.ext - technology: sky130A

.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.16 ps=1.32 w=1 l=0.15
X1 a_27_297# B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X2 VGND A2 a_373_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.114 ps=1 w=0.65 l=0.15
X3 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X4 a_27_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.253 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.253 ps=2.52 w=1 l=0.15
X6 a_373_47# A1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.96 w=0.65 l=0.15
X8 a_109_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
X0 a_377_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.365 ps=1.73 w=1 l=0.15
X1 a_47_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.3 ps=2.6 w=1 l=0.15
X2 a_129_47# B a_47_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_285_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 Y a_47_47# a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_129_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0683 ps=0.86 w=0.65 l=0.15
X6 VPWR A a_47_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.365 pd=1.73 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_47_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.165 ps=1.33 w=1 l=0.15
X8 Y B a_377_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_109_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.05
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.05
.ends

.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=2.89
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=2.89
.ends

.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_199_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_113_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.147 ps=1.29 w=1 l=0.15
X2 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X3 VPWR A1 a_113_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.29 as=0.14 ps=1.28 w=1 l=0.15
X4 a_113_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A2 a_199_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0959 ps=0.945 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_467_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_467_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_109_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A2 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_109_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 Y B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X1 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.135 ps=1.27 w=1 l=0.15
X3 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_381_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_109_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VGND A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0683 ps=0.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A a_113_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_113_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=0.59
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=0.59
.ends

.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X2 a_193_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y A a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X4 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 a_109_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
X0 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.157 ps=1.17 w=0.42 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.157 pd=1.17 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X6 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.97
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.97
.ends

.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
X0 VPWR B a_207_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.228 pd=1.74 as=0.0609 ps=0.71 w=0.42 l=0.15
X1 X a_207_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.228 ps=1.74 w=1 l=0.15
X2 a_297_47# a_27_413# a_207_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0504 pd=0.66 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_207_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.99 w=0.65 l=0.15
X4 a_207_413# a_27_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0609 pd=0.71 as=0.0714 ps=0.76 w=0.42 l=0.15
X5 VPWR A_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0714 pd=0.76 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VGND B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.99 as=0.0504 ps=0.66 w=0.42 l=0.15
X7 a_27_413# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0683 ps=0.86 w=0.65 l=0.15
X1 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=2.1 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A1 a_114_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
X3 a_114_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.185 ps=1.87 w=0.65 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.28 ps=2.56 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X10 a_285_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.091 ps=0.93 w=0.65 l=0.15
X11 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
X0 VPWR B a_59_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 X a_59_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.475 pd=2.95 as=0.167 ps=1.39 w=1 l=0.15
X2 VGND B a_145_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_59_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X4 X a_59_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.112 ps=1.04 w=0.65 l=0.15
X5 a_145_75# A a_59_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
X0 VGND C a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 a_277_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_47# B a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.135 ps=1.27 w=1 l=0.15
X8 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_277_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.35 as=0.265 ps=2.53 w=1 l=0.15
X1 a_209_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.172 ps=1.35 w=1 l=0.15
X2 a_303_47# A2 a_209_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.104 ps=0.97 w=0.65 l=0.15
X3 a_209_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.112 ps=0.995 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.172 ps=1.83 w=0.65 l=0.15
X5 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.107 ps=0.98 w=0.65 l=0.15
X6 a_80_21# A1 a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X7 VPWR A2 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.16 ps=1.32 w=1 l=0.15
X8 a_80_21# B1 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X9 a_209_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
X0 VPWR a_75_212# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 a_75_212# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 a_75_212# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND a_75_212# X VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VGND A1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
X1 a_510_47# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.143 ps=1.09 w=0.65 l=0.15
X2 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.175 ps=1.35 w=1 l=0.15
X3 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.22 ps=1.44 w=1 l=0.15
X4 a_79_21# A2 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.22 pd=1.44 as=0.162 ps=1.33 w=1 l=0.15
X5 a_297_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X6 a_79_21# C1 a_510_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.114 ps=1 w=0.65 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X8 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
X9 a_215_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.106 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_298_297# a_27_413# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.265 ps=2.53 w=1 l=0.15
X1 a_215_297# a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.136 ps=1.1 w=0.65 l=0.15
X2 a_298_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.258 ps=1.45 w=0.65 l=0.15
X4 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X6 a_382_47# A1 a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.136 pd=1.1 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VPWR A1 a_298_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND A2 a_382_47# VNB sky130_fd_pr__nfet_01v8 ad=0.258 pd=1.45 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VPWR C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 a_181_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VGND C a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.132 pd=1.14 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 a_27_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X6 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.132 ps=1.14 w=0.65 l=0.15
X7 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 a_81_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.257 ps=1.44 w=0.65 l=0.15
X1 a_299_297# B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_299_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 a_384_47# A1 a_81_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X3 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X4 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X5 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.301 ps=2.66 w=1 l=0.15
X7 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X8 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X10 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X12 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X13 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X14 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X15 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X16 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X17 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X18 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X20 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X21 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X22 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.209 ps=2.02 w=0.65 l=0.15
X23 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X24 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X25 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X26 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X27 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.42 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0703 pd=0.755 as=0.111 ps=1.37 w=0.42 l=0.15
X6 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.14 ps=1.28 w=1 l=0.15
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0703 ps=0.755 w=0.42 l=0.15
X8 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.165 ps=1.33 w=1 l=0.15
X9 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_286_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X2 a_286_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X3 Y A2 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 VGND A1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X6 VGND A2 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X7 a_487_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# B1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR A1 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_27_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X13 a_487_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X14 a_286_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
X0 X a_29_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.148 ps=1.34 w=1 l=0.15
X1 a_111_297# C a_29_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_29_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.102 ps=0.99 w=0.65 l=0.15
X3 a_183_297# B a_111_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 VPWR A a_183_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X5 a_29_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VGND C a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_806_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_47# B1 a_1314_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=2.09 as=0.104 ps=0.97 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X17 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.0943 ps=0.94 w=0.65 l=0.15
X19 Y C1 a_978_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_27_47# B1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 a_806_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.675 pd=3.35 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.091 ps=0.93 w=0.65 l=0.15
X27 a_978_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.091 ps=0.93 w=0.65 l=0.15
X28 a_1314_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X31 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2oi_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
X0 a_109_47# A2_N a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 a_397_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR B2 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A2_N a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.283 pd=1.52 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_397_297# a_109_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.34 ps=2.68 w=1 l=0.15
X5 a_481_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.283 ps=1.52 w=0.65 l=0.15
X7 VGND B1 a_481_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_109_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X9 a_109_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
X0 X a_35_297# a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.26 ps=2.52 w=1 l=0.15
X1 X B a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.25 pd=1.42 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_117_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 VPWR B a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.25 ps=1.42 w=0.65 l=0.15
X7 a_285_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A a_117_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
X0 a_27_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y A a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y A a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_445_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X12 a_445_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_445_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X17 a_445_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X23 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
X0 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X1 a_471_47# B a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.42 pd=2.84 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_47# C a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=1.67 w=1 l=0.15
X8 a_277_47# B a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X9 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.335 pd=1.67 as=0.135 ps=1.27 w=1 l=0.15
X10 Y A a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_277_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X13 a_471_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.745 as=0.111 ps=1.37 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.162 ps=1.33 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X7 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.38 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X11 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X18 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
X0 a_558_47# a_381_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X1 VGND X a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_841_47# a_664_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VPWR A a_62_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A a_62_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_558_47# a_381_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X6 X a_62_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR X a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_841_47# a_664_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X9 X a_62_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X10 VPWR a_558_47# a_664_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND a_558_47# a_664_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
X0 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.165 ps=1.33 w=1 l=0.15
X2 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_193_47# C a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_277_47# B a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
X0 VPWR a_505_21# a_535_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_505_21# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.0693 ps=0.75 w=0.42 l=0.15
X2 a_218_374# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0767 pd=0.785 as=0.158 ps=1.39 w=0.42 l=0.15
X3 VGND a_505_21# a_439_47# VNB sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.11 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 a_76_199# A0 a_218_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.193 pd=1.34 as=0.0767 ps=0.785 w=0.42 l=0.15
X5 a_505_21# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.145 ps=1.11 w=0.42 l=0.15
X6 a_439_47# A0 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0997 ps=0.895 w=0.42 l=0.15
X7 a_535_374# A1 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.193 ps=1.34 w=0.42 l=0.15
X8 a_76_199# A1 a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0997 pd=0.895 as=0.0693 ps=0.75 w=0.42 l=0.15
X9 a_218_47# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.113 ps=1.04 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.158 pd=1.39 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.04 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_382_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X1 a_297_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X2 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.327 pd=1.65 as=0.28 ps=2.56 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.327 ps=1.65 w=1 l=0.15
X6 a_382_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.195 ps=1.39 w=1 l=0.15
X7 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.149 ps=1.33 w=1 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.149 pd=1.33 as=0.166 ps=1.8 w=0.64 l=0.15
X3 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X4 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
X0 VPWR a_29_311# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_29_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.151 ps=1.35 w=1 l=0.15
X2 VPWR A a_29_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND a_29_311# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_184_53# B a_112_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X5 VPWR C a_29_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.151 pd=1.35 as=0.0744 ps=0.815 w=0.42 l=0.15
X6 X a_29_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.13 ps=1.11 w=0.65 l=0.15
X7 a_112_53# A a_29_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_29_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 VGND C a_184_53# VNB sky130_fd_pr__nfet_01v8 ad=0.13 pd=1.11 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
X0 a_27_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_560_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X2 VGND B a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0991 ps=0.955 w=0.65 l=0.15
X3 Y B a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_297# a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_474_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X7 VGND A a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# B a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X12 a_474_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_560_47# a_27_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X14 VPWR A a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X15 Y a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X16 VPWR a_27_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X17 a_560_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_222_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X1 VPWR A1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.105 ps=1.21 w=1 l=0.15
X2 VGND a_79_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_222_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.186 ps=1.41 w=0.42 l=0.15
X4 VGND A2 a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_448_47# a_222_93# a_79_199# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_79_199# a_222_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.3 ps=2.6 w=1 l=0.15
X7 a_544_297# A2 a_79_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X8 a_448_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.186 pd=1.41 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 Y A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.174 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.182 pd=1.92 as=0.174 ps=1.39 w=0.7 l=0.15
X2 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X3 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_197_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0798 pd=0.8 as=0.0609 ps=0.71 w=0.42 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.312 ps=1.68 w=1 l=0.15
X3 a_303_47# C a_197_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0798 ps=0.8 w=0.42 l=0.15
X4 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.68 as=0.0588 ps=0.7 w=0.42 l=0.15
X6 VGND D a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.196 pd=1.33 as=0.0693 ps=0.75 w=0.42 l=0.15
X7 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X8 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.196 ps=1.33 w=0.65 l=0.15
X9 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.117 ps=1.01 w=0.65 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.41 pd=1.82 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.175 ps=1.35 w=1 l=0.15
X4 a_277_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.41 ps=1.82 w=1 l=0.15
X10 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.18 ps=1.36 w=1 l=0.15
X11 a_277_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.114 ps=1 w=0.65 l=0.15
X13 Y A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.0975 ps=0.95 w=0.65 l=0.15
X14 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.091 ps=0.93 w=0.65 l=0.15
X1 Y B1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.175 ps=1.35 w=1 l=0.15
X4 a_29_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y A2 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND A1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 a_112_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X8 a_112_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.14 ps=1.28 w=1 l=0.15
X9 a_29_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X11 a_29_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_206_369# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.146 ps=1.34 w=0.42 l=0.15
X1 a_206_369# A2_N a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 VGND B2 a_489_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_585_369# B2 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0672 ps=0.74 w=0.42 l=0.15
X4 a_489_47# a_206_369# a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_489_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VPWR A2_N a_206_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.209 pd=1.35 as=0.129 ps=1.18 w=0.42 l=0.15
X7 a_76_199# a_206_369# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.74 as=0.209 ps=1.35 w=0.42 l=0.15
X8 a_205_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0662 pd=0.735 as=0.0986 ps=0.98 w=0.42 l=0.15
X9 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.26 ps=2.52 w=1 l=0.15
X10 VPWR B1 a_585_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0986 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_39_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=1 w=0.65 l=0.15
X2 VPWR a_39_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_39_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.156 ps=1.36 w=1 l=0.15
X4 VGND a_39_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.156 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VGND A a_39_297# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=1 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_39_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
X0 VPWR A a_49_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VGND a_285_47# a_391_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.5
X2 X a_391_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VGND A a_49_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR a_285_47# a_391_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.5
X5 a_285_47# a_49_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X6 a_285_47# a_49_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X7 X a_391_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
X0 VGND A a_68_297# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_68_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_68_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR A a_150_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 X a_68_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.34 pd=2.68 as=0.146 ps=1.34 w=1 l=0.15
X5 a_150_297# B a_68_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X1 a_80_21# C1 a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X2 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_300_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.26 ps=1.45 w=0.65 l=0.15
X6 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_80_21# A1 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 a_472_297# B1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X9 a_80_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
D0 VNB DIODE sky130_fd_pr__diode_pw2nd_05v5 pj=2.64e+06 area=4.347e+11
.ends

.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
X0 Y C a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 a_281_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X6 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X10 a_281_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_297# B a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
X0 X a_299_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X1 VPWR a_193_47# a_299_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 VGND a_193_47# a_299_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X6 X a_299_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_75_199# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.135 ps=1.07 w=0.65 l=0.15
X1 a_208_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.112 ps=0.995 w=0.65 l=0.15
X2 a_315_47# A2 a_208_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.17 as=0.125 ps=1.03 w=0.65 l=0.15
X3 VGND B1 a_75_199# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.07 as=0.106 ps=0.975 w=0.65 l=0.15
X4 a_75_199# A1 a_315_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.17 w=0.65 l=0.15
X5 a_75_199# C1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.207 ps=1.41 w=1 l=0.15
X6 a_544_297# B1 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.207 pd=1.41 as=0.162 ps=1.33 w=1 l=0.15
X7 VPWR a_75_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.285 ps=2.57 w=1 l=0.15
X8 a_201_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.142 ps=1.28 w=1 l=0.15
X9 VPWR A2 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.165 ps=1.33 w=1 l=0.15
X10 a_201_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.305 ps=1.61 w=1 l=0.15
X11 VGND a_75_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_470_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_470_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_470_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.106 ps=0.975 w=0.65 l=0.15
X6 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X8 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X10 a_470_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.162 ps=1.33 w=1 l=0.15
X11 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 VPWR B a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X13 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X16 X a_112_47# a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 a_470_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X18 X B a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
X0 X a_61_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.167 ps=1.39 w=1 l=0.15
X1 VPWR a_61_75# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.195 ps=1.39 w=1 l=0.15
X2 VPWR B a_61_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 VGND B a_147_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 X a_61_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.112 ps=1.04 w=0.65 l=0.15
X5 VGND a_61_75# X VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.127 ps=1.04 w=0.65 l=0.15
X6 a_61_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X7 a_147_75# A a_61_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_388_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.127 pd=1.25 as=0.153 ps=1.3 w=1 l=0.15
X1 a_105_352# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_297_47# a_105_352# Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A1 a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.127 ps=1.25 w=1 l=0.15
X5 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X6 VPWR B1_N a_105_352# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.178 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 Y a_105_352# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.178 ps=1.4 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311ai_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
X0 a_39_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR A1 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X4 a_125_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0943 ps=0.94 w=0.65 l=0.15
X5 a_125_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_125_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_1163_47# B1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_39_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_1163_47# B1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A3 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND A3 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_39_297# A2 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_125_47# B1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X17 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 a_125_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X19 VGND A2 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_125_47# B1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VGND A2 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y C1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y C1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_461_297# A2 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 Y A3 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X26 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 Y A3 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 a_125_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 VPWR A1 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X31 a_461_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 a_461_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X33 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 a_125_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X35 a_1163_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X36 a_1163_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X37 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X38 a_39_297# A2 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X39 a_461_297# A2 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 X a_79_204# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A1 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_473_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.195 ps=1.39 w=1 l=0.15
X3 X a_79_204# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X4 VGND C1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.104 ps=0.97 w=0.65 l=0.15
X5 a_79_204# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0926 ps=0.935 w=0.65 l=0.15
X6 VPWR a_79_204# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X7 a_473_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X8 a_473_297# B1 a_727_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.16 ps=1.32 w=1 l=0.15
X9 X a_79_204# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X10 VGND B1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.127 ps=1.04 w=0.65 l=0.15
X11 a_79_204# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.109 ps=0.985 w=0.65 l=0.15
X12 VGND a_79_204# X VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.0959 ps=0.945 w=0.65 l=0.15
X13 a_1123_47# A1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_555_297# B1 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X15 VPWR A2 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X16 VGND A2 a_1123_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.091 ps=0.93 w=0.65 l=0.15
X17 a_951_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.14 ps=1.08 w=0.65 l=0.15
X18 VPWR a_79_204# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_79_204# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X20 a_79_204# A1 a_951_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 a_79_204# C1 a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 a_727_297# C1 a_79_204# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X23 X a_79_204# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 a_79_21# A1 a_348_47# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.133 ps=1.06 w=0.65 l=0.15
X1 a_79_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X2 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.2 pd=1.26 as=0.091 ps=0.93 w=0.65 l=0.15
X3 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 a_79_21# C1 a_585_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X5 VPWR A2 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.26 ps=2.52 w=1 l=0.15
X6 a_299_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.195 ps=1.39 w=1 l=0.15
X7 a_585_297# B1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X8 a_348_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.2 ps=1.26 w=0.65 l=0.15
X9 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.115 ps=1 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4bb_2 A_N B_N C D VGND VNB VPB VPWR X
X0 a_174_21# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X1 a_174_21# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.74 as=0.331 ps=1.71 w=0.42 l=0.15
X2 a_476_47# a_27_47# a_174_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VPWR a_174_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.331 pd=1.71 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_174_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.141 ps=1.33 w=1 l=0.15
X5 a_548_47# a_505_280# a_476_47# VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X7 X a_174_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X8 VPWR D a_174_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0924 pd=0.86 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 VGND D a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0924 pd=0.86 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 VPWR a_505_280# a_174_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0672 ps=0.74 w=0.42 l=0.15
X11 a_505_280# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0924 ps=0.86 w=0.42 l=0.15
X12 VGND a_174_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_505_280# B_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0924 ps=0.86 w=0.42 l=0.15
X14 a_639_47# C a_548_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.064 ps=0.725 w=0.42 l=0.15
X15 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_93_21# A1 a_346_47# VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.146 ps=1.1 w=0.65 l=0.15
X1 a_93_21# B1 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.185 ps=1.37 w=1 l=0.15
X2 a_584_47# B1 a_93_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.143 ps=1.09 w=0.65 l=0.15
X3 VPWR a_93_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.243 pd=1.49 as=0.33 ps=2.66 w=1 l=0.15
X4 VGND B2 a_584_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 a_256_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.167 ps=1.16 w=0.65 l=0.15
X6 a_250_297# B2 a_93_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 VGND a_93_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.167 pd=1.16 as=0.214 ps=1.96 w=0.65 l=0.15
X8 a_250_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.243 ps=1.49 w=1 l=0.15
X9 VPWR A2 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.225 pd=1.45 as=0.165 ps=1.33 w=1 l=0.15
X10 a_250_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.225 ps=1.45 w=1 l=0.15
X11 a_346_47# A2 a_256_47# VNB sky130_fd_pr__nfet_01v8 ad=0.146 pd=1.1 as=0.0975 ps=0.95 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
X0 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X5 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X7 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
X0 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.107 ps=0.98 w=0.65 l=0.15
X1 VGND D a_304_47# VNB sky130_fd_pr__nfet_01v8 ad=0.175 pd=1.26 as=0.0693 ps=0.75 w=0.42 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.28 ps=1.62 w=1 l=0.15
X3 a_198_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0798 pd=0.8 as=0.0619 ps=0.715 w=0.42 l=0.15
X4 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0777 ps=0.79 w=0.42 l=0.15
X5 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.165 ps=1.33 w=1 l=0.15
X6 a_304_47# C a_198_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0798 ps=0.8 w=0.42 l=0.15
X7 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0746 pd=0.775 as=0.109 ps=1.36 w=0.42 l=0.15
X8 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=1.62 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.175 ps=1.26 w=0.65 l=0.15
X10 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0746 ps=0.775 w=0.42 l=0.15
X11 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0619 pd=0.715 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.26 ps=1.45 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.4 ps=1.8 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.205 pd=1.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.135 ps=1.27 w=1 l=0.15
X5 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_109_297# C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y A3 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_449_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 Y A3 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y B1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_449_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.263 ps=2.57 w=1 l=0.15
X8 Y B1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_31_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_297# A2 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.261 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 a_31_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 a_31_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_31_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_449_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X20 VGND A2 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 VGND A2 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VGND A3 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.223 pd=1.34 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_31_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.223 ps=1.34 w=0.65 l=0.15
X25 a_27_297# A2 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND A3 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 a_31_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X28 a_449_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 a_31_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 a_31_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
X0 a_297_47# a_27_47# a_193_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_369_47# B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0441 ps=0.63 w=0.42 l=0.15
X2 VPWR D a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.0662 ps=0.735 w=0.42 l=0.15
X3 X a_193_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.103 ps=1 w=0.65 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND D a_469_47# VNB sky130_fd_pr__nfet_01v8 ad=0.103 pd=1 as=0.0609 ps=0.71 w=0.42 l=0.15
X6 X a_193_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR B a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.128 pd=1.03 as=0.0987 ps=0.89 w=0.42 l=0.15
X8 a_193_413# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.128 ps=1.03 w=0.42 l=0.15
X9 a_193_413# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0987 pd=0.89 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 a_469_47# C a_369_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.0735 ps=0.77 w=0.42 l=0.15
X11 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_277_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_277_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_277_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X5 a_277_47# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X6 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND a_277_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND a_277_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_193_47# A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_361_47# A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 X a_277_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A3 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X15 X a_277_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X16 a_277_47# A1 a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_445_47# A2 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND B1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_27_297# B1 a_277_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X21 VPWR a_277_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.5 pd=3 as=0.135 ps=1.27 w=1 l=0.15
X22 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X23 a_277_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_585_47# B1 a_266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.119 ps=1.01 w=0.65 l=0.15
X1 VGND A2 a_266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.137 pd=1.07 as=0.117 ps=1.01 w=0.65 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.62 as=0.26 ps=2.52 w=1 l=0.15
X3 a_81_21# C1 a_585_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.203 pd=1.27 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_266_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.312 ps=1.62 w=1 l=0.15
X6 a_368_297# A2 a_266_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.21 pd=1.42 as=0.18 ps=1.36 w=1 l=0.15
X7 a_266_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.137 ps=1.07 w=0.65 l=0.15
X8 a_266_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.203 ps=1.27 w=0.65 l=0.15
X9 a_81_21# A3 a_368_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.21 ps=1.42 w=1 l=0.15
X10 a_81_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.15 ps=1.3 w=1 l=0.15
X11 VPWR B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.138 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X6 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X11 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
X0 a_109_93# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_215_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 VGND a_109_93# a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND A a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 VPWR A a_369_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_369_297# B a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_215_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X7 a_297_297# a_109_93# a_215_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_109_93# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 X a_215_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.1 ps=0.985 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
X0 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_161_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X2 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_161_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A a_161_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_161_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311oi_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
X0 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.159 ps=1.14 w=0.65 l=0.15
X3 a_1139_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.245 pd=1.49 as=0.135 ps=1.27 w=1 l=0.15
X4 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A3 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_109_297# B1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_1139_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X13 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_109_297# B1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X16 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VPWR A3 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 a_1139_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 Y C1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_1139_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.159 pd=1.14 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X32 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y C1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.245 ps=1.49 w=1 l=0.15
X35 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X36 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X38 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X39 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VGND A2 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR A1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_37_297# B1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_485_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_292_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VPWR A2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X8 a_485_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X11 a_37_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 Y A1 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X13 Y C1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_292_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X15 a_292_297# B1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_465_47# A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.157 ps=1.32 w=1 l=0.15
X2 a_109_297# B1 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 a_193_297# B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.102 ps=0.965 w=0.65 l=0.15
X5 a_205_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X6 VPWR A2 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.165 ps=1.33 w=1 l=0.15
X7 a_193_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X8 a_27_47# B1 a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X9 a_109_297# C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 VGND C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND A2 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
X0 VPWR D a_343_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.46 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_223_47# B_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.5 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 a_515_93# a_223_47# a_429_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 a_223_47# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.134 pd=1.48 as=0.0588 ps=0.7 w=0.42 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.168 ps=1.64 w=0.42 l=0.15
X5 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.168 ps=1.64 w=0.42 l=0.15
X6 X a_343_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.172 ps=1.46 w=1 l=0.15
X7 a_429_93# a_27_47# a_343_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.118 ps=1.4 w=0.42 l=0.15
X8 VGND D a_615_93# VNB sky130_fd_pr__nfet_01v8 ad=0.126 pd=1.11 as=0.0777 ps=0.79 w=0.42 l=0.15
X9 a_343_93# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X10 a_343_93# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.122 ps=1.42 w=0.42 l=0.15
X11 a_615_93# C a_515_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X12 X a_343_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.82 as=0.126 ps=1.11 w=0.65 l=0.15
X13 VPWR a_223_47# a_343_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_56_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A2 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_139_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.266 ps=2.12 w=0.65 l=0.15
X4 a_311_297# B1 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X5 Y C1 a_311_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X7 Y A1 a_139_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
X0 VGND A a_311_413# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 VPWR A a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0598 ps=0.705 w=0.42 l=0.15
X2 a_393_413# a_205_93# a_311_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.122 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND C_N a_27_410# VNB sky130_fd_pr__nfet_01v8 ad=0.0619 pd=0.715 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR C_N a_27_410# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.123 pd=1.32 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_311_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X6 VGND a_27_410# a_311_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0598 ps=0.705 w=0.42 l=0.15
X7 a_561_297# B a_489_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0598 pd=0.705 as=0.0441 ps=0.63 w=0.42 l=0.15
X8 a_205_93# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0619 ps=0.715 w=0.42 l=0.15
X9 a_205_93# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.123 ps=1.32 w=0.42 l=0.15
X10 a_489_297# a_27_410# a_393_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.122 ps=1.33 w=0.42 l=0.15
X11 a_311_413# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X12 a_311_413# a_205_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0598 pd=0.705 as=0.109 ps=1.36 w=0.42 l=0.15
X13 X a_311_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.102 ps=0.99 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X7 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X11 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X12 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X14 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X15 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X16 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.155 ps=1.31 w=1 l=0.15
X20 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 a_676_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.213 ps=1.42 w=1 l=0.15
X1 a_512_47# B1 a_409_47# VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.119 ps=1.01 w=0.65 l=0.15
X2 a_306_47# D1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.198 ps=1.91 w=0.65 l=0.15
X3 VGND A2 a_512_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.198 ps=1.26 w=0.65 l=0.15
X4 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.218 ps=1.43 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.305 ps=1.61 w=1 l=0.15
X6 VPWR A1 a_676_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.105 ps=1.21 w=1 l=0.15
X7 a_512_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_409_47# C1 a_306_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.119 ps=1.01 w=0.65 l=0.15
X9 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.382 pd=1.76 as=0.26 ps=2.52 w=1 l=0.15
X10 a_79_21# D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.218 pd=1.43 as=0.382 ps=1.76 w=1 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 Y a_61_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.183 ps=1.24 w=0.65 l=0.15
X1 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_217_297# a_61_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_479_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X4 a_217_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X5 Y a_61_47# a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 VPWR A1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_61_47# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VGND A2 a_637_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_61_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A1 a_479_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0683 ps=0.86 w=0.65 l=0.15
X11 VGND B1_N a_61_47# VNB sky130_fd_pr__nfet_01v8 ad=0.183 pd=1.24 as=0.126 ps=1.44 w=0.42 l=0.15
X12 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X13 a_637_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_300_297# a_27_413# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X3 Y a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.102 ps=0.99 w=0.65 l=0.15
X4 VPWR A1 a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 a_384_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.143 ps=1.09 w=0.65 l=0.15
X6 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.111 ps=1.37 w=0.42 l=0.15
X7 a_300_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 a_27_47# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.368 pd=1.74 as=0.14 ps=1.28 w=1 l=0.15
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.231 pd=2.01 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VPWR A1 a_373_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X4 a_182_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.165 ps=1.82 w=0.65 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.195 ps=1.39 w=1 l=0.15
X6 a_182_47# B1 a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X8 a_373_297# A2 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.368 ps=1.74 w=1 l=0.15
X9 a_110_47# C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X10 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X11 VGND A1 a_182_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
X0 a_27_47# C a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# C a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_445_47# B a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_445_47# B a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y A a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X14 Y A a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_803_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X17 a_803_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_445_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 a_803_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X23 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X24 a_445_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_803_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X30 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X31 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 Y A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.109 ps=0.985 w=0.65 l=0.15
X4 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_949_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 Y C1 a_949_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.15 ps=1.3 w=1 l=0.15
X10 a_781_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_27_297# B1 a_781_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_781_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_1301_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.15 ps=1.3 w=1 l=0.15
X16 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 Y C1 a_781_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.14 ps=1.28 w=1 l=0.15
X18 a_109_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_109_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_109_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.091 ps=0.93 w=0.65 l=0.15
X27 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X28 a_27_297# B1 a_1301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X29 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0894 ps=0.925 w=0.65 l=0.15
X30 a_109_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X31 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
X0 a_109_93# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_209_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X2 a_109_93# A_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_296_53# a_109_93# a_209_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.108 ps=1.36 w=0.42 l=0.15
X4 VPWR C a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0744 ps=0.815 w=0.42 l=0.15
X5 a_368_53# B a_296_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_209_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.122 ps=1.08 w=0.65 l=0.15
X7 a_209_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VPWR a_109_93# a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.108 ps=1.36 w=0.42 l=0.15
X9 VGND C a_368_53# VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.08 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
X0 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=1.67 w=1 l=0.15
X1 VGND A_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0.194 pd=1.95 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VGND B a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y a_27_93# a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 a_229_47# a_27_93# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.147 ps=1.34 w=1 l=0.15
X6 VPWR a_27_93# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.335 pd=1.67 as=0.165 ps=1.33 w=1 l=0.15
X7 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.135 ps=1.27 w=1 l=0.15
X8 a_229_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR A_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.221 pd=1.98 as=0.198 ps=1.26 w=0.65 l=0.15
X1 Y A3 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.393 pd=1.78 as=0.135 ps=1.27 w=1 l=0.15
X2 a_193_297# A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.393 ps=1.78 w=1 l=0.15
X5 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
X0 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X1 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND B a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
X0 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND a_215_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR a_215_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_109_93# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X4 a_215_297# a_109_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.165 ps=1.82 w=0.65 l=0.15
X5 VGND C a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X6 VGND A a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X8 a_215_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_109_93# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X10 VPWR A a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND a_215_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_487_297# B a_403_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_403_297# C a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X14 VPWR a_215_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X15 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X16 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_297_297# a_109_93# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 a_78_199# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 VPWR A1 a_493_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X2 a_493_297# A2 a_78_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.235 ps=1.47 w=1 l=0.15
X3 VPWR a_78_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.373 pd=1.75 as=0.28 ps=2.56 w=1 l=0.15
X4 VGND A2 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X5 a_78_199# B2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.235 pd=1.47 as=0.117 ps=1.24 w=1 l=0.15
X6 a_215_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_215_47# B2 a_78_199# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_292_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.117 pd=1.24 as=0.373 ps=1.75 w=1 l=0.15
X9 VGND a_78_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_77_199# B2 a_227_47# VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.127 ps=1.04 w=0.65 l=0.15
X1 a_323_297# A2 a_227_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.165 ps=1.33 w=1 l=0.15
X2 a_227_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_227_47# B1 a_77_199# VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.133 ps=1.06 w=0.65 l=0.15
X4 VGND a_77_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR B1 a_539_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.205 ps=1.41 w=1 l=0.15
X6 a_227_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X7 VPWR a_77_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=2.67 w=1 l=0.15
X8 a_77_199# A3 a_323_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X9 VGND A2 a_227_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 a_227_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_539_297# B2 a_77_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=1.41 as=0.195 ps=1.39 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 VGND A2 a_660_47# VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.0829 ps=0.905 w=0.65 l=0.15
X1 VGND C1 a_85_193# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.101 ps=0.96 w=0.65 l=0.15
X2 a_414_297# C1 a_334_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.125 ps=1.25 w=1 l=0.15
X3 VGND a_85_193# X VNB sky130_fd_pr__nfet_01v8 ad=0.275 pd=1.5 as=0.214 ps=1.96 w=0.65 l=0.15
X4 a_334_297# D1 a_85_193# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.125 pd=1.25 as=0.385 ps=2.77 w=1 l=0.15
X5 a_516_297# B1 a_414_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=1.56 as=0.18 ps=1.36 w=1 l=0.15
X6 a_516_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.135 ps=1.27 w=1 l=0.15
X7 a_660_47# A1 a_85_193# VNB sky130_fd_pr__nfet_01v8 ad=0.0829 pd=0.905 as=0.185 ps=1.22 w=0.65 l=0.15
X8 a_85_193# D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.275 ps=1.5 w=0.65 l=0.15
X9 VPWR A1 a_516_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=1.56 w=1 l=0.15
X10 a_85_193# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.22 as=0.117 ps=1.01 w=0.65 l=0.15
X11 VPWR a_85_193# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.29 ps=2.58 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.172 ps=1.83 w=0.65 l=0.15
X2 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X3 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X5 a_326_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.127 ps=1.04 w=0.65 l=0.15
X6 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.635 pd=3.27 as=0.195 ps=1.39 w=1 l=0.15
X7 Y C1 a_326_47# VNB sky130_fd_pr__nfet_01v8 ad=0.393 pd=2.51 as=0.0683 ps=0.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
X0 Y a_251_21# a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y a_251_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X5 VGND a_251_21# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X7 VPWR B_N a_251_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X8 VGND B_N a_251_21# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_27_297# a_251_21# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4b_2 A B C D_N VGND VNB VPB VPWR X
X0 a_176_21# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 VGND D_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X4 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.168 pd=1.5 as=0.135 ps=1.27 w=1 l=0.15
X5 a_555_297# C a_483_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 a_176_21# a_27_53# a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0693 ps=0.75 w=0.42 l=0.15
X7 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.169 ps=1.5 w=1 l=0.15
X8 a_387_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.168 ps=1.5 w=0.42 l=0.15
X9 a_483_297# B a_387_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X10 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0693 ps=0.75 w=0.42 l=0.15
X11 VGND a_27_53# a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X12 VPWR D_N a_27_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.169 pd=1.5 as=0.109 ps=1.36 w=0.42 l=0.15
X13 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.1 ps=0.985 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
X0 a_281_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND a_531_21# Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR C_N a_531_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X7 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X9 a_281_297# a_531_21# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X10 Y a_531_21# a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X11 VGND C_N a_531_21# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X12 a_27_297# B a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X13 Y a_531_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X21 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
X0 VGND B1 a_84_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_741_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.101 ps=0.96 w=0.65 l=0.15
X2 a_84_21# A1 a_741_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0747 ps=0.88 w=0.65 l=0.15
X3 VGND A2 a_901_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR a_84_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR A2 a_483_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_483_297# B1 a_84_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_84_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X8 a_84_21# B1 a_483_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 VGND a_84_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.265 pd=1.47 as=0.091 ps=0.93 w=0.65 l=0.15
X10 VPWR a_84_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_483_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=2.79 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR A1 a_483_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 VGND a_84_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 X a_84_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.285 ps=2.57 w=1 l=0.15
X15 a_84_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.265 ps=1.47 w=0.65 l=0.15
X16 a_483_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 X a_84_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 a_901_47# A1 a_84_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_84_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X4 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X5 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X6 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X8 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.301 ps=2.66 w=1 l=0.15
X9 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X10 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X11 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X12 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X13 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X14 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X15 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X16 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X17 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X18 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X19 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X20 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X21 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X22 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X23 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X24 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.209 ps=2.02 w=0.65 l=0.15
X25 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X26 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X27 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X28 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X29 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_475_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A1 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X9 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.27 pd=1.48 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X12 a_475_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 Y A2 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X14 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.27 ps=1.48 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VGND A1 a_474_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.104 ps=0.97 w=0.65 l=0.15
X1 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 VPWR A1 a_1122_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.252 pd=1.5 as=0.14 ps=1.28 w=1 l=0.15
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.192 pd=1.89 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.252 ps=1.5 w=1 l=0.15
X8 a_950_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X9 a_557_47# B1 a_474_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X10 a_474_47# B1 a_748_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X11 VGND A2 a_474_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_79_21# C1 a_557_47# VNB sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.1 as=0.0683 ps=0.86 w=0.65 l=0.15
X15 a_474_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X16 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.14 ps=1.28 w=1 l=0.15
X17 a_748_47# C1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.145 ps=1.1 w=0.65 l=0.15
X18 a_474_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
X19 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.195 ps=1.39 w=1 l=0.15
X20 a_79_21# A2 a_950_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X21 a_1122_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X23 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X8 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X11 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=1.37 as=0.0588 ps=0.7 w=0.42 l=0.15
X18 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X20 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X21 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X22 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X23 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X25 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X26 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X27 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X28 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X29 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X30 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X31 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X32 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X33 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X34 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X35 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X36 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X37 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X38 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X39 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0578 ps=0.695 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.135 ps=1.27 w=1 l=0.15
X3 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X17 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_803_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_803_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 VGND A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X30 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X31 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X1 X a_80_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 VGND a_80_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=0.99 as=0.091 ps=0.93 w=0.65 l=0.15
X3 a_386_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.157 ps=1.32 w=1 l=0.15
X4 X a_80_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_80_199# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.162 pd=1.15 as=0.111 ps=0.99 w=0.65 l=0.15
X6 a_386_297# B1 a_80_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_458_47# A1 a_80_199# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.162 ps=1.15 w=0.65 l=0.15
X8 VPWR A1 a_386_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X9 VGND A2 a_458_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.123 ps=1.03 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 a_465_47# A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND A4 a_561_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X2 VPWR A3 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X3 a_297_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X4 a_297_297# A4 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X5 VPWR A1 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_381_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.184 ps=1.22 w=0.65 l=0.15
X7 a_297_297# B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X8 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X9 a_79_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.184 pd=1.22 as=0.161 ps=1.14 w=0.65 l=0.15
X10 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.161 pd=1.14 as=0.169 ps=1.82 w=0.65 l=0.15
X11 a_561_47# A3 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111a_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 VGND A1 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.965 w=0.65 l=0.15
X1 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_297# A2 a_852_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.177 ps=1.36 w=1 l=0.15
X3 VPWR a_27_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND a_27_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.115 ps=1 w=0.65 l=0.15
X5 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_852_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X7 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_361_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.02 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR C1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND A2 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.1 as=0.12 ps=1.02 w=0.65 l=0.15
X11 a_27_297# D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.145 ps=1.1 w=0.65 l=0.15
X13 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X14 a_27_47# D1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_361_47# B1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_361_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.169 ps=1.82 w=0.65 l=0.15
X17 a_277_47# C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_445_47# B1 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.0926 ps=0.935 w=0.65 l=0.15
X20 a_27_297# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.135 ps=1.27 w=1 l=0.15
X21 a_681_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.305 ps=1.61 w=1 l=0.15
X22 a_27_47# C1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X23 VGND a_27_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0959 ps=0.945 w=0.65 l=0.15
X24 VPWR D1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X25 VPWR a_27_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X26 VPWR A1 a_681_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X27 a_27_297# D1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
X0 VPWR A a_94_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.198 pd=1.39 as=0.305 ps=2.61 w=1 l=0.15
X1 a_294_47# B a_185_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.128 ps=1.04 w=0.65 l=0.15
X2 a_185_47# A a_94_47# VNB sky130_fd_pr__nfet_01v8 ad=0.128 pd=1.04 as=0.198 ps=1.91 w=0.65 l=0.15
X3 VPWR a_94_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND C a_294_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 a_94_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.198 ps=1.39 w=1 l=0.15
X6 X a_94_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X7 X a_94_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 VPWR C a_94_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X9 X a_94_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X10 VGND a_94_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X11 VPWR a_94_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND a_94_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 X a_94_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3b_4 A B C_N VGND VNB VPB VPWR Y
X0 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VPWR A a_197_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_555_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_197_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_197_297# B a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X8 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X12 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y a_27_47# a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y a_27_47# a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X16 a_555_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_555_297# B a_197_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 a_197_297# B a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_555_297# B a_197_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 VPWR A a_197_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X23 a_197_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X25 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
X0 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 a_103_199# B1 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.107 ps=0.98 w=0.65 l=0.15
X1 VPWR a_103_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.36 ps=2.72 w=1 l=0.15
X2 a_337_297# A2 a_253_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_103_199# A3 a_337_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.165 ps=1.33 w=1 l=0.15
X4 a_253_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.195 ps=1.39 w=1 l=0.15
X5 VPWR B1 a_103_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.345 pd=2.69 as=0.213 ps=1.42 w=1 l=0.15
X6 VGND a_103_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.234 ps=2.02 w=0.65 l=0.15
X7 a_253_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X8 a_253_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X9 VGND A2 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.16 ps=1.32 w=1 l=0.15
X1 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.4 ps=1.8 w=1 l=0.15
X2 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0894 ps=0.925 w=0.65 l=0.15
X3 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_470_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.138 ps=1.27 w=1 l=0.15
X6 a_384_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 a_384_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.104 ps=0.97 w=0.65 l=0.15
X8 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
X0 VPWR A a_304_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X1 a_304_297# B a_220_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND C a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X3 a_220_297# C a_114_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X4 a_32_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_32_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X11 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X13 a_114_297# D a_32_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.26 ps=2.52 w=1 l=0.15
X14 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2b_4 A B_N VGND VNB VPB VPWR Y
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# a_419_21# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X6 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_419_21# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND a_419_21# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 Y a_419_21# a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X11 Y a_419_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VGND B_N a_419_21# VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.182 ps=1.86 w=0.65 l=0.15
X13 Y a_419_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VPWR B_N a_419_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.27 ps=2.54 w=1 l=0.15
X15 a_27_297# a_419_21# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 Y a_419_21# a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.272 ps=2.56 w=1 l=0.15
X15 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X17 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X19 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X24 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.257 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X30 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X38 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
X0 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X5 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X17 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X21 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X23 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X36 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X39 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X1 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0926 ps=0.935 w=0.65 l=0.15
X2 VPWR A1 a_307_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.105 ps=1.21 w=1 l=0.15
X3 a_307_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.233 ps=1.47 w=1 l=0.15
X4 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.233 pd=1.47 as=0.112 ps=1.23 w=1 l=0.15
X6 a_109_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.112 pd=1.23 as=0.26 ps=2.52 w=1 l=0.15
X7 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.385 pd=1.77 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X9 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.385 ps=1.77 w=1 l=0.15
X14 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X21 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X31 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_223_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 Y A1 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X3 a_223_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X4 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 VGND A2 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_223_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X7 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.123 ps=1.03 w=0.65 l=0.15
X8 VPWR A2 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 a_658_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.201 ps=1.27 w=0.65 l=0.15
X10 VPWR A1 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_223_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 a_658_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 Y a_27_47# a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_223_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X15 VPWR A2 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.155 ps=1.31 w=1 l=0.15
X16 VPWR A1 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 a_658_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VGND B1_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.27 ps=2.13 w=0.65 l=0.15
X19 a_223_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X20 a_658_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 VGND A2 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.27 as=0.091 ps=0.93 w=0.65 l=0.15
X23 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X24 Y A1 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X25 Y a_27_47# a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_240_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_51_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A1 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_51_297# B2 a_245_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.412 pd=1.83 as=0.105 ps=1.21 w=1 l=0.15
X4 a_149_47# C1 a_51_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.201 ps=1.92 w=0.65 l=0.15
X5 a_240_47# B1 a_149_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0991 ps=0.955 w=0.65 l=0.15
X6 VPWR A1 a_512_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X7 X a_51_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.165 ps=1.33 w=1 l=0.15
X8 a_149_47# B2 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_245_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X10 VPWR C1 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.34 ps=2.68 w=1 l=0.15
X11 a_512_297# A2 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.412 ps=1.83 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_226_47# A2_N a_226_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_489_413# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_226_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.167 ps=1.43 w=0.42 l=0.15
X3 VPWR B2 a_489_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_489_413# a_226_47# a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_76_199# a_226_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.139 ps=1.08 w=0.42 l=0.15
X6 VGND B1 a_556_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_556_47# B2 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VGND A2_N a_226_47# VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.08 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_226_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.12 ps=1.09 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.43 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.09 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor4_4 A B C D VGND VNB VPB VPWR Y
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_807_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y D a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X9 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X13 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 a_807_297# C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 VGND D Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 VGND D Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_807_297# C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X22 a_449_297# C a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_449_297# C a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X26 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_807_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X28 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 Y D a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_449_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 Y C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_449_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X10 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X15 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
X0 VGND a_91_199# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.221 ps=1.98 w=0.65 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A a_245_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.135 ps=1.27 w=1 l=0.15
X3 a_91_199# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_245_297# B a_161_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_91_199# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.146 ps=1.34 w=0.42 l=0.15
X7 a_161_297# a_91_199# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.32 ps=2.64 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.28 ps=2.56 w=1 l=0.15
X1 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X4 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.177 ps=1.36 w=1 l=0.15
X7 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.105 ps=1.21 w=1 l=0.15
X9 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2111o_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 a_30_297# C1 a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X1 VGND C1 a_44_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.091 ps=0.93 w=0.65 l=0.15
X2 a_44_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.266 ps=1.47 w=0.65 l=0.15
X3 VGND a_44_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VPWR A1 a_477_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.257 ps=1.51 w=1 l=0.15
X5 VPWR a_44_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 X a_44_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VGND B1 a_44_47# VNB sky130_fd_pr__nfet_01v8 ad=0.266 pd=1.47 as=0.109 ps=0.985 w=0.65 l=0.15
X8 X a_44_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 a_477_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X10 a_285_297# B1 a_477_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND D1 a_44_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X12 a_770_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.182 ps=1.86 w=0.65 l=0.15
X13 X a_44_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X14 a_30_297# D1 a_44_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 VGND A2 a_770_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X16 a_44_47# D1 a_30_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X17 a_477_297# B1 a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.257 pd=1.51 as=0.14 ps=1.28 w=1 l=0.15
X18 a_770_47# A1 a_44_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0926 ps=0.935 w=0.65 l=0.15
X19 a_477_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X20 VPWR a_44_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X21 a_285_297# C1 a_30_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 a_44_47# D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_44_47# A1 a_770_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.091 ps=0.93 w=0.65 l=0.15
X24 VGND a_44_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X25 VPWR A2 a_477_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X26 X a_44_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X27 a_44_47# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.102 ps=0.965 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
X0 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0894 ps=0.925 w=0.65 l=0.15
X1 a_191_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.13 ps=1.26 w=1 l=0.15
X2 VPWR A a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.119 ps=1.01 w=0.65 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_297_297# B a_191_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X6 a_109_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.13 pd=1.26 as=0.26 ps=2.52 w=1 l=0.15
X7 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311a_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.305 ps=1.61 w=1 l=0.15
X1 a_467_47# C1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_467_47# B1 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND A1 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.135 ps=1.27 w=1 l=0.15
X6 a_79_21# C1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_717_47# B1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VGND A3 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.27 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_1147_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR A1 a_1147_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_1147_297# A2 a_875_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X18 a_79_21# A3 a_875_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X19 a_875_297# A3 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 a_875_297# A2 a_1147_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 a_717_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.201 ps=1.27 w=0.65 l=0.15
X23 a_717_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_717_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X26 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
X0 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X1 a_109_53# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_215_297# a_109_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_392_297# C a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0452 pd=0.635 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_465_297# B a_392_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.064 pd=0.725 as=0.0452 ps=0.635 w=0.42 l=0.15
X6 a_215_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 VPWR A a_465_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.064 ps=0.725 w=0.42 l=0.15
X8 a_297_297# a_109_53# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_109_53# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X10 VGND C a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.064 ps=0.725 w=0.42 l=0.15
X11 VGND A a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
X0 VPWR a_30_53# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.315 pd=2.63 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND a_30_53# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_30_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X3 a_112_297# C a_30_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_30_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 VGND A a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 a_30_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 VGND C a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_184_297# B a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X9 VPWR A a_184_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
X0 Y a_53_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.192 ps=1.38 w=1 l=0.15
X1 a_232_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.192 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A_N a_53_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A_N a_53_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_316_47# B a_232_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y a_53_93# a_316_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.125 ps=1.03 w=0.65 l=0.15
X7 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
X0 Y B1 a_383_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_301_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_301_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND B2 a_383_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A1 a_735_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_27_297# B2 a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 VPWR A1 a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A2 a_735_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_301_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 Y C1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.27 ps=2.54 w=1 l=0.15
X10 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.176 ps=1.84 w=0.65 l=0.15
X12 VPWR A2 a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.175 ps=1.35 w=1 l=0.15
X13 a_383_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X14 a_383_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_735_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X16 a_27_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X17 a_301_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.135 ps=1.27 w=1 l=0.15
X18 a_735_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_27_297# B1 a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 VGND A4 a_321_47# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_321_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.123 ps=1.03 w=0.65 l=0.15
X2 a_103_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=1.52 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR a_103_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.425 ps=2.85 w=1 l=0.15
X4 VGND a_103_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.247 ps=2.06 w=0.65 l=0.15
X5 VGND A2 a_321_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X6 a_321_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.127 ps=1.04 w=0.65 l=0.15
X7 a_511_297# A3 a_393_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.22 ps=1.44 w=1 l=0.15
X8 a_619_297# A2 a_511_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X9 a_321_47# B1 a_103_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X10 a_393_297# A4 a_103_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.22 pd=1.44 as=0.26 ps=1.52 w=1 l=0.15
X11 VPWR A1 a_619_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.195 ps=1.39 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_397_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR B1_N a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X2 Y A2 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VGND A2 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND A1 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_28_297# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X6 Y a_28_297# a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VPWR a_28_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_397_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X9 a_229_47# a_28_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y a_28_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X11 a_229_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_229_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A1 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X3 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X4 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X5 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=2.61 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X8 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X9 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X12 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X14 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X15 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X16 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X17 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X18 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X19 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X20 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X21 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X23 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X24 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X25 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X28 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X29 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X30 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X31 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X32 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
X33 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o221ai_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
X0 Y A2 a_734_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_300_47# B2 a_28_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 a_300_47# B1 a_28_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_300_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_300_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_734_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.175 ps=1.35 w=1 l=0.15
X7 a_28_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C1 a_28_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR B1 a_382_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.135 ps=1.27 w=1 l=0.15
X11 a_382_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_28_47# B1 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_28_47# B2 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A1 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X15 Y B2 a_382_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 VPWR A1 a_734_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND A2 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_382_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X19 a_734_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
X0 a_176_21# a_27_47# a_626_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X1 a_626_297# B a_542_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_542_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X8 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X12 a_176_21# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X13 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 a_281_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X1 a_281_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X6 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X7 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X9 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.127 ps=1.04 w=0.65 l=0.15
X10 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.198 ps=1.26 w=0.65 l=0.15
X11 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.127 ps=1.04 w=0.65 l=0.15
X12 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y A3 a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.195 ps=1.39 w=1 l=0.15
X15 a_27_297# A2 a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
X0 VPWR a_219_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.295 pd=2.59 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.202 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.17 pd=1.34 as=0.105 ps=1.21 w=1 l=0.15
X3 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.111 ps=0.99 w=0.65 l=0.15
X5 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X6 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=0.99 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_219_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND a_219_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.17 ps=1.34 w=1 l=0.15
X11 VGND a_219_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.214 pd=1.96 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.202 ps=1.4 w=0.65 l=0.15
X13 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
X0 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR A a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_109_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 VPWR A a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VGND A a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 a_109_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.135 ps=1.27 w=1 l=0.15
X24 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_109_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X29 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 a_109_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X31 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_27_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_277_297# B a_205_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VPWR A a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X5 a_205_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X6 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X7 VGND C a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0693 ps=0.75 w=0.42 l=0.15
X8 a_109_297# D a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X9 VGND A a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X16 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X17 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X20 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
X0 VGND A_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X1 Y a_27_93# a_206_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_206_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR a_27_93# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X5 VPWR A_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o221ai_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
X0 a_471_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_471_47# B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_471_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A1 a_1241_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.295 pd=2.59 as=0.135 ps=1.27 w=1 l=0.15
X5 a_471_47# B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_471_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_1241_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.175 ps=1.35 w=1 l=0.15
X10 a_27_47# B2 a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B1 a_553_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A2 a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_553_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X14 a_27_47# B2 a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND A2 a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND A1 a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X19 a_27_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_1241_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VPWR B1 a_553_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.135 ps=1.27 w=1 l=0.15
X22 VPWR A1 a_1241_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 Y B2 a_553_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 a_1241_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X26 a_553_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_471_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 Y A2 a_1241_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 a_553_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 a_27_47# B1 a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X31 VGND A1 a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X32 Y B2 a_553_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 a_1241_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 a_27_47# B1 a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X35 a_553_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 Y A2 a_1241_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X38 a_471_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 a_471_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2bb2a_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_294_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0662 pd=0.735 as=0.0986 ps=0.98 w=0.42 l=0.15
X1 VPWR A2_N a_295_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.227 pd=1.35 as=0.173 ps=1.4 w=0.64 l=0.15
X2 VPWR B1 a_665_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X3 VGND a_84_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0986 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 X a_84_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.185 ps=1.87 w=0.65 l=0.15
X5 a_581_47# a_295_369# a_84_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VPWR a_84_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.154 pd=1.34 as=0.135 ps=1.27 w=1 l=0.15
X7 a_665_369# B2 a_84_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.0928 ps=0.93 w=0.64 l=0.15
X8 VGND B2 a_581_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_295_369# A2_N a_294_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0662 ps=0.735 w=0.42 l=0.15
X10 X a_84_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.285 ps=2.57 w=1 l=0.15
X11 a_84_21# a_295_369# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0928 pd=0.93 as=0.227 ps=1.35 w=0.64 l=0.15
X12 a_295_369# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.173 pd=1.4 as=0.154 ps=1.34 w=0.64 l=0.15
X13 a_581_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 Y a_33_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_225_47# a_33_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR a_33_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_33_297# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.182 ps=1.86 w=0.65 l=0.15
X4 Y a_33_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A2 a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 Y a_33_297# a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 Y a_33_297# a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND A2 a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND A2 a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_561_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X11 a_225_47# a_33_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR A1 a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_225_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_225_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_225_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_225_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VPWR A1 a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 a_561_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR B1_N a_33_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X20 a_561_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VGND A1 a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y A2 a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VGND A1 a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_561_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 VPWR a_33_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
X0 a_408_47# B a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_408_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y a_27_47# a_408_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.176 pd=1.39 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND C a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X6 a_218_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.12 ps=1.04 w=0.65 l=0.15
X7 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_218_47# B a_408_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X11 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.176 ps=1.39 w=1 l=0.15
X12 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.04 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt park D[0] D[10] D[11] D[12] D[13] D[14] D[15] D[16] D[17] D[1] D[2] D[3] D[4]
+ D[5] D[6] D[7] D[8] D[9] Q[0] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] Q[16] Q[17] Q[1]
+ Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] VGND VPWR alpha[0] alpha[10] alpha[11] alpha[12]
+ alpha[13] alpha[14] alpha[15] alpha[16] alpha[17] alpha[1] alpha[2] alpha[3] alpha[4]
+ alpha[5] alpha[6] alpha[7] alpha[8] alpha[9] beta[0] beta[10] beta[11] beta[12]
+ beta[13] beta[14] beta[15] beta[16] beta[17] beta[1] beta[2] beta[3] beta[4] beta[5]
+ beta[6] beta[7] beta[8] beta[9] clk cos[0] cos[10] cos[11] cos[12] cos[13] cos[14]
+ cos[15] cos[16] cos[17] cos[1] cos[2] cos[3] cos[4] cos[5] cos[6] cos[7] cos[8]
+ cos[9] done rstb sin[0] sin[10] sin[11] sin[12] sin[13] sin[14] sin[15] sin[16]
+ sin[17] sin[1] sin[2] sin[3] sin[4] sin[5] sin[6] sin[7] sin[8] sin[9] start
X_09671_ net673 net486 net408 net682 VGND VGND VPWR VPWR _01672_ sky130_fd_sc_hd__a22o_1
X_08622_ _00661_ _00668_ VGND VGND VPWR VPWR _00669_ sky130_fd_sc_hd__xnor2_1
X_08553_ _00599_ _00600_ VGND VGND VPWR VPWR _00601_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08484_ _00456_ _00457_ _00532_ VGND VGND VPWR VPWR _00533_ sky130_fd_sc_hd__a21oi_1
X_07504_ net149 net534 net540 net297 VGND VGND VPWR VPWR _03682_ sky130_fd_sc_hd__a22oi_2
X_07435_ net147 net566 net575 net295 VGND VGND VPWR VPWR _02929_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_64_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07366_ net211 net804 net514 net202 VGND VGND VPWR VPWR _02179_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_91_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09105_ net253 net583 VGND VGND VPWR VPWR _01144_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09036_ _01027_ _01028_ VGND VGND VPWR VPWR _01077_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09938_ _01931_ _01937_ VGND VGND VPWR VPWR _01938_ sky130_fd_sc_hd__nand2_1
X_09869_ _01811_ _01809_ _01810_ VGND VGND VPWR VPWR _01870_ sky130_fd_sc_hd__nand3_1
X_11900_ net723 net248 net240 net732 VGND VGND VPWR VPWR _04070_ sky130_fd_sc_hd__a22oi_1
X_12880_ _05058_ _05080_ VGND VGND VPWR VPWR _05135_ sky130_fd_sc_hd__or2b_1
XFILLER_0_87_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11831_ _03992_ _03993_ _03994_ VGND VGND VPWR VPWR _03995_ sky130_fd_sc_hd__nand3_1
XFILLER_0_68_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14550_ _06891_ _06955_ VGND VGND VPWR VPWR _06956_ sky130_fd_sc_hd__nand2_1
X_11762_ net375 net213 net206 net461 VGND VGND VPWR VPWR _03920_ sky130_fd_sc_hd__a22o_1
XFILLER_0_138_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13501_ _05736_ _05735_ VGND VGND VPWR VPWR _05815_ sky130_fd_sc_hd__and2b_1
X_11693_ _03842_ _03843_ _03823_ VGND VGND VPWR VPWR _03845_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_82_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10713_ _02715_ _02708_ VGND VGND VPWR VPWR _02775_ sky130_fd_sc_hd__or2b_1
X_14481_ _00945_ net417 VGND VGND VPWR VPWR _06881_ sky130_fd_sc_hd__and2_1
XFILLER_0_70_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10644_ _02698_ _02699_ VGND VGND VPWR VPWR _02700_ sky130_fd_sc_hd__xnor2_1
X_13432_ _05723_ _05724_ _05738_ VGND VGND VPWR VPWR _05740_ sky130_fd_sc_hd__nand3_2
XFILLER_0_91_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10575_ _02623_ _02624_ VGND VGND VPWR VPWR _02626_ sky130_fd_sc_hd__xnor2_1
X_13363_ net570 net400 _05662_ _05663_ VGND VGND VPWR VPWR _05664_ sky130_fd_sc_hd__a31o_1
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12314_ _04519_ _04520_ VGND VGND VPWR VPWR _04521_ sky130_fd_sc_hd__nor2_1
Xrebuffer7 _04826_ VGND VGND VPWR VPWR net752 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13294_ _05583_ _05587_ net657 net355 VGND VGND VPWR VPWR _05588_ sky130_fd_sc_hd__o211a_1
XFILLER_0_121_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12245_ _04438_ _04434_ _04436_ VGND VGND VPWR VPWR _04446_ sky130_fd_sc_hd__a21bo_1
X_12176_ _04354_ _04370_ VGND VGND VPWR VPWR _04371_ sky130_fd_sc_hd__xnor2_1
X_11127_ _03057_ _03114_ VGND VGND VPWR VPWR _03224_ sky130_fd_sc_hd__nor2_1
X_11058_ _03069_ _03094_ _03149_ VGND VGND VPWR VPWR _03150_ sky130_fd_sc_hd__and3_1
X_10009_ _02008_ _02009_ _01929_ VGND VGND VPWR VPWR _02011_ sky130_fd_sc_hd__a21o_1
XFILLER_0_99_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14748_ clknet_3_7_0_clk _00049_ net322 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14679_ _07061_ _07094_ VGND VGND VPWR VPWR _07095_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_120_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout138 net9 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__buf_4
Xfanout149 net73 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__clkbuf_4
X_07984_ _07276_ _07277_ _07188_ _07190_ VGND VGND VPWR VPWR _07279_ sky130_fd_sc_hd__o211ai_2
X_09723_ _01688_ _01722_ _01723_ VGND VGND VPWR VPWR _01724_ sky130_fd_sc_hd__or3_1
X_09654_ _01652_ _01653_ _01549_ _01622_ VGND VGND VPWR VPWR _01655_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_97_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08605_ _00589_ _00629_ _00630_ VGND VGND VPWR VPWR _00652_ sky130_fd_sc_hd__nor3_1
XFILLER_0_139_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09585_ _01562_ _01563_ _01583_ _01584_ VGND VGND VPWR VPWR _01586_ sky130_fd_sc_hd__a2bb2oi_1
XFILLER_0_54_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08536_ _00494_ _00499_ VGND VGND VPWR VPWR _00584_ sky130_fd_sc_hd__and2b_1
X_08467_ _00514_ _00515_ VGND VGND VPWR VPWR _00516_ sky130_fd_sc_hd__xor2_1
XFILLER_0_65_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08398_ net181 net599 net608 net171 VGND VGND VPWR VPWR _00448_ sky130_fd_sc_hd__a22o_1
X_07418_ _02571_ _02723_ _02734_ VGND VGND VPWR VPWR _02745_ sky130_fd_sc_hd__nand3_4
XFILLER_0_92_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07349_ net128 VGND VGND VPWR VPWR _01995_ sky130_fd_sc_hd__inv_2
XFILLER_0_18_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10360_ _02293_ _02294_ VGND VGND VPWR VPWR _02392_ sky130_fd_sc_hd__nor2_1
XFILLER_0_131_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09019_ _01056_ _01057_ _01058_ VGND VGND VPWR VPWR _01060_ sky130_fd_sc_hd__nor3_1
XFILLER_0_103_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10291_ _02314_ _02315_ VGND VGND VPWR VPWR _02316_ sky130_fd_sc_hd__xor2_1
XFILLER_0_14_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12030_ net557 net160 _04209_ _04210_ VGND VGND VPWR VPWR _04212_ sky130_fd_sc_hd__nand4_2
Xfanout650 net655 VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout694 net698 VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__clkbuf_4
Xfanout672 net18 VGND VGND VPWR VPWR net672 sky130_fd_sc_hd__clkbuf_8
Xfanout661 net663 VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout683 net689 VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__clkbuf_2
X_13981_ net577 net394 net385 VGND VGND VPWR VPWR _06338_ sky130_fd_sc_hd__and3_1
X_12932_ net629 net638 net484 net406 VGND VGND VPWR VPWR _05190_ sky130_fd_sc_hd__nand4_1
XFILLER_0_125_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12863_ net253 net146 net245 net191 VGND VGND VPWR VPWR _05116_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_96_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14602_ _06995_ _07011_ VGND VGND VPWR VPWR _07012_ sky130_fd_sc_hd__xnor2_1
X_11814_ _03964_ _03975_ VGND VGND VPWR VPWR _03976_ sky130_fd_sc_hd__xor2_1
XFILLER_0_96_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12794_ a_sin\[14\] _05041_ _04160_ VGND VGND VPWR VPWR _05042_ sky130_fd_sc_hd__mux2_1
X_11745_ _03898_ _03899_ _03883_ VGND VGND VPWR VPWR _03902_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14533_ _06935_ _06936_ VGND VGND VPWR VPWR _06937_ sky130_fd_sc_hd__and2b_1
XFILLER_0_126_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14464_ net579 net470 _06805_ VGND VGND VPWR VPWR _06862_ sky130_fd_sc_hd__a21o_1
X_11676_ net461 net213 net206 net556 VGND VGND VPWR VPWR _03827_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_119_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13415_ _05407_ _05412_ VGND VGND VPWR VPWR _05722_ sky130_fd_sc_hd__and2_1
XFILLER_0_36_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10627_ _02595_ _02612_ _02613_ VGND VGND VPWR VPWR _02682_ sky130_fd_sc_hd__o21a_1
XFILLER_0_52_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14395_ _06786_ VGND VGND VPWR VPWR _06788_ sky130_fd_sc_hd__buf_2
X_10558_ _02514_ _02515_ _02513_ VGND VGND VPWR VPWR _02607_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_12_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13346_ _05639_ _05643_ _05645_ VGND VGND VPWR VPWR _05646_ sky130_fd_sc_hd__nand3_1
XFILLER_0_122_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13277_ _05569_ VGND VGND VPWR VPWR _05570_ sky130_fd_sc_hd__inv_2
X_12228_ _04372_ _04427_ VGND VGND VPWR VPWR _04428_ sky130_fd_sc_hd__xor2_1
X_10489_ net649 net454 net447 net666 VGND VGND VPWR VPWR _02532_ sky130_fd_sc_hd__a22oi_1
X_12159_ _04274_ _04291_ VGND VGND VPWR VPWR _04352_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09370_ _01371_ VGND VGND VPWR VPWR _00054_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_129_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08321_ _00368_ _00369_ _00371_ VGND VGND VPWR VPWR _00372_ sky130_fd_sc_hd__nand3_1
XFILLER_0_24_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08252_ _00184_ _00217_ _00216_ VGND VGND VPWR VPWR _00304_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_86_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08183_ _00232_ _00235_ VGND VGND VPWR VPWR _00236_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_61_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07967_ _07259_ _07260_ _07261_ VGND VGND VPWR VPWR _07262_ sky130_fd_sc_hd__or3_1
X_09706_ _01698_ _01699_ _01706_ VGND VGND VPWR VPWR _01707_ sky130_fd_sc_hd__nand3_1
XFILLER_0_4_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07898_ _07134_ _07192_ _07193_ VGND VGND VPWR VPWR _07194_ sky130_fd_sc_hd__and3_2
XFILLER_0_65_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09637_ _01634_ _01637_ VGND VGND VPWR VPWR _01638_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_84_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09568_ net718 net467 VGND VGND VPWR VPWR _01569_ sky130_fd_sc_hd__nand2_1
X_08519_ _00506_ _00493_ VGND VGND VPWR VPWR _00567_ sky130_fd_sc_hd__or2b_1
XFILLER_0_65_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11530_ _03608_ _03613_ VGND VGND VPWR VPWR _03666_ sky130_fd_sc_hd__or2b_1
XFILLER_0_108_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09499_ _01489_ _01490_ _01499_ VGND VGND VPWR VPWR _01500_ sky130_fd_sc_hd__and3_1
XFILLER_0_37_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_137_Right_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11461_ _03587_ _03588_ _03571_ VGND VGND VPWR VPWR _03590_ sky130_fd_sc_hd__a21o_1
XFILLER_0_61_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11392_ _03512_ _03513_ VGND VGND VPWR VPWR _03514_ sky130_fd_sc_hd__nor2_1
X_10412_ _02445_ _02446_ _02437_ VGND VGND VPWR VPWR _02448_ sky130_fd_sc_hd__a21o_1
X_14180_ _06496_ _06503_ VGND VGND VPWR VPWR _06554_ sky130_fd_sc_hd__and2_1
X_13200_ _05480_ _05482_ VGND VGND VPWR VPWR _05485_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10343_ _02275_ _02276_ _02280_ _02372_ VGND VGND VPWR VPWR _02373_ sky130_fd_sc_hd__a31o_1
XFILLER_0_0_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13131_ net564 net450 net441 net572 VGND VGND VPWR VPWR _05409_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_131_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10274_ _02217_ _02296_ VGND VGND VPWR VPWR _02298_ sky130_fd_sc_hd__nand2_1
X_13062_ _05258_ _05266_ VGND VGND VPWR VPWR _05333_ sky130_fd_sc_hd__nand2_1
X_12013_ net653 net151 net299 net670 VGND VGND VPWR VPWR _04193_ sky130_fd_sc_hd__a22o_1
XFILLER_0_136_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout480 net482 VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__clkbuf_4
Xfanout491 net492 VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__buf_2
XFILLER_0_45_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13964_ _06303_ _06317_ _06318_ VGND VGND VPWR VPWR _06319_ sky130_fd_sc_hd__nand3_1
X_12915_ _05105_ _05171_ VGND VGND VPWR VPWR _05173_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_100_Left_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13895_ _06240_ _06241_ _06243_ VGND VGND VPWR VPWR _06245_ sky130_fd_sc_hd__nand3_1
X_12846_ _04987_ _05055_ _04856_ VGND VGND VPWR VPWR _05098_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12777_ _05008_ _05023_ VGND VGND VPWR VPWR _05024_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_28_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14516_ _06906_ _06908_ VGND VGND VPWR VPWR _06919_ sky130_fd_sc_hd__and2b_1
XFILLER_0_138_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11728_ _03812_ _03821_ _03820_ VGND VGND VPWR VPWR _03883_ sky130_fd_sc_hd__a21o_1
XFILLER_0_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11659_ _03790_ _03791_ _03806_ VGND VGND VPWR VPWR _03808_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_104_Right_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14447_ _06767_ _06785_ _06843_ _06844_ VGND VGND VPWR VPWR _06845_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_126_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14378_ _06746_ _06747_ _06769_ VGND VGND VPWR VPWR _06770_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_12_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13329_ _05608_ _05605_ _05607_ VGND VGND VPWR VPWR _05627_ sky130_fd_sc_hd__nand3_1
Xclkbuf_3_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_1_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08870_ _00852_ _00853_ VGND VGND VPWR VPWR _00914_ sky130_fd_sc_hd__and2b_1
XFILLER_0_20_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07821_ _05172_ _05479_ _05468_ VGND VGND VPWR VPWR _07117_ sky130_fd_sc_hd__a21bo_1
X_07752_ _06091_ _06081_ _06070_ VGND VGND VPWR VPWR _06385_ sky130_fd_sc_hd__a21o_1
X_07683_ _05589_ _05622_ VGND VGND VPWR VPWR _05633_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_126_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09422_ net647 net401 VGND VGND VPWR VPWR _01423_ sky130_fd_sc_hd__and2_1
X_09353_ _01356_ _01357_ VGND VGND VPWR VPWR _01358_ sky130_fd_sc_hd__nor2_1
X_08304_ _00287_ _00289_ _00288_ VGND VGND VPWR VPWR _00355_ sky130_fd_sc_hd__a21bo_1
X_09284_ b_cos\[6\] a_sin\[6\] VGND VGND VPWR VPWR _01298_ sky130_fd_sc_hd__or2b_1
XFILLER_0_7_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08235_ net204 net597 net588 net214 VGND VGND VPWR VPWR _00287_ sky130_fd_sc_hd__a22o_1
XFILLER_0_51_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08166_ _00216_ _00217_ _00184_ VGND VGND VPWR VPWR _00219_ sky130_fd_sc_hd__a21o_1
XFILLER_0_31_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08097_ _00148_ _00149_ VGND VGND VPWR VPWR _00150_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08999_ net285 net267 net582 VGND VGND VPWR VPWR _01040_ sky130_fd_sc_hd__o21ai_1
X_10961_ _02911_ _02981_ VGND VGND VPWR VPWR _03045_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12700_ _04937_ _04938_ VGND VGND VPWR VPWR _04940_ sky130_fd_sc_hd__nand2_1
X_13680_ _05805_ _05973_ _05971_ VGND VGND VPWR VPWR _06010_ sky130_fd_sc_hd__a21bo_1
X_12631_ net189 net276 net285 net267 VGND VGND VPWR VPWR _04865_ sky130_fd_sc_hd__and4_1
XFILLER_0_78_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10892_ _02968_ _02969_ VGND VGND VPWR VPWR _02970_ sky130_fd_sc_hd__and2_1
XFILLER_0_66_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12562_ net275 net378 net285 net267 VGND VGND VPWR VPWR _04790_ sky130_fd_sc_hd__and4_1
XFILLER_0_81_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11513_ _03640_ _03641_ _03646_ VGND VGND VPWR VPWR _03647_ sky130_fd_sc_hd__nand3_2
X_12493_ _04713_ _04714_ VGND VGND VPWR VPWR _04715_ sky130_fd_sc_hd__nor2_1
XFILLER_0_108_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14301_ _06601_ _06602_ _06600_ VGND VGND VPWR VPWR _06686_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11444_ _03355_ _03360_ _03354_ VGND VGND VPWR VPWR _03571_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_124_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14232_ _06476_ _06610_ VGND VGND VPWR VPWR _06611_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11375_ net306 net226 net721 net729 VGND VGND VPWR VPWR _03496_ sky130_fd_sc_hd__and4_1
XFILLER_0_61_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14163_ _06464_ _06465_ _06534_ _06535_ VGND VGND VPWR VPWR _06536_ sky130_fd_sc_hd__o211a_1
XFILLER_0_21_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14094_ b_cos\[7\] _06460_ _05794_ VGND VGND VPWR VPWR _06461_ sky130_fd_sc_hd__mux2_1
X_10326_ net459 net344 _02352_ _02354_ VGND VGND VPWR VPWR _02355_ sky130_fd_sc_hd__a22o_1
X_13114_ _05382_ _05389_ VGND VGND VPWR VPWR _05390_ sky130_fd_sc_hd__xnor2_1
X_13045_ _05311_ _05312_ _05296_ VGND VGND VPWR VPWR _05315_ sky130_fd_sc_hd__a21o_1
X_10257_ net403 _02182_ _02278_ _02279_ VGND VGND VPWR VPWR _02280_ sky130_fd_sc_hd__a31oi_2
X_10188_ _02202_ _02203_ _02141_ VGND VGND VPWR VPWR _02205_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_88_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13947_ _06280_ _06300_ VGND VGND VPWR VPWR _06301_ sky130_fd_sc_hd__xor2_1
XFILLER_0_72_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13878_ net621 net343 _06224_ _06225_ VGND VGND VPWR VPWR _06226_ sky130_fd_sc_hd__a22o_1
X_12829_ _05059_ _05079_ VGND VGND VPWR VPWR _05080_ sky130_fd_sc_hd__xor2_1
XFILLER_0_57_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08020_ net261 net540 _07312_ _07313_ VGND VGND VPWR VPWR _07314_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09971_ net648 net665 net362 net352 VGND VGND VPWR VPWR _01971_ sky130_fd_sc_hd__nand4_2
X_08922_ _00887_ _00905_ _00964_ VGND VGND VPWR VPWR _00965_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08853_ _00769_ _00829_ VGND VGND VPWR VPWR _00897_ sky130_fd_sc_hd__nor2_1
X_07804_ net218 _06863_ _06939_ VGND VGND VPWR VPWR _06950_ sky130_fd_sc_hd__o21ai_1
X_08784_ net243 net634 VGND VGND VPWR VPWR _00829_ sky130_fd_sc_hd__nand2_1
X_07735_ _06015_ _05983_ VGND VGND VPWR VPWR _06200_ sky130_fd_sc_hd__and2b_1
XFILLER_0_79_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07666_ _04902_ _04913_ _04934_ VGND VGND VPWR VPWR _05446_ sky130_fd_sc_hd__a21oi_1
X_09405_ net708 net716 net357 net347 VGND VGND VPWR VPWR _01406_ sky130_fd_sc_hd__and4_1
XFILLER_0_137_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07597_ _04293_ net746 _04282_ VGND VGND VPWR VPWR _04696_ sky130_fd_sc_hd__nand3_2
X_09336_ b_cos\[13\] a_sin\[13\] VGND VGND VPWR VPWR _01343_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_63_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09267_ _01280_ _01283_ VGND VGND VPWR VPWR _01284_ sky130_fd_sc_hd__nor2_1
XFILLER_0_117_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08218_ _00266_ _00267_ _00268_ VGND VGND VPWR VPWR _00270_ sky130_fd_sc_hd__a21o_1
XFILLER_0_90_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09198_ _01225_ VGND VGND VPWR VPWR _00028_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_120_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08149_ net311 net231 VGND VGND VPWR VPWR _00202_ sky130_fd_sc_hd__or2_2
X_11160_ _03252_ _03257_ _03258_ VGND VGND VPWR VPWR _03259_ sky130_fd_sc_hd__or3_1
X_10111_ _01938_ _02100_ _02119_ VGND VGND VPWR VPWR _02120_ sky130_fd_sc_hd__o21ai_1
X_11091_ net141 net432 net424 net187 VGND VGND VPWR VPWR _03185_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10042_ _01985_ _02039_ _02043_ _02044_ VGND VGND VPWR VPWR _02045_ sky130_fd_sc_hd__o211ai_2
Xhold41 b_sin\[16\] VGND VGND VPWR VPWR net786 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14781_ clknet_3_6_0_clk _00082_ net319 VGND VGND VPWR VPWR a_sin\[9\] sky130_fd_sc_hd__dfrtp_1
X_13801_ _06137_ _06140_ _06141_ VGND VGND VPWR VPWR _06142_ sky130_fd_sc_hd__and3_1
X_11993_ _04169_ _04170_ VGND VGND VPWR VPWR _04171_ sky130_fd_sc_hd__xor2_1
X_13732_ _06049_ _06065_ _06066_ VGND VGND VPWR VPWR _06067_ sky130_fd_sc_hd__and3_1
XFILLER_0_133_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10944_ _03022_ _03024_ VGND VGND VPWR VPWR _03026_ sky130_fd_sc_hd__nand2_1
XFILLER_0_42_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13663_ b_cos\[2\] _05991_ _05794_ VGND VGND VPWR VPWR _05992_ sky130_fd_sc_hd__mux2_1
X_10875_ _02865_ _02872_ VGND VGND VPWR VPWR _02952_ sky130_fd_sc_hd__or2_1
XFILLER_0_38_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12614_ _04773_ _04775_ VGND VGND VPWR VPWR _04847_ sky130_fd_sc_hd__or2b_1
XFILLER_0_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13594_ _05858_ _05859_ _05860_ VGND VGND VPWR VPWR _05916_ sky130_fd_sc_hd__nor3_1
XFILLER_0_136_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12545_ _04667_ _04708_ _04770_ _04771_ VGND VGND VPWR VPWR _04773_ sky130_fd_sc_hd__o211a_1
XFILLER_0_108_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12476_ _04444_ _04618_ _04620_ _04697_ VGND VGND VPWR VPWR _04698_ sky130_fd_sc_hd__a211o_1
XFILLER_0_101_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_5 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11427_ _03549_ _03551_ _03512_ VGND VGND VPWR VPWR _03553_ sky130_fd_sc_hd__a21o_1
XFILLER_0_112_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14215_ _06590_ _06574_ _06575_ VGND VGND VPWR VPWR _06593_ sky130_fd_sc_hd__nor3_2
X_11358_ _03469_ _03474_ _03470_ VGND VGND VPWR VPWR _03477_ sky130_fd_sc_hd__nand3_1
XFILLER_0_1_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14146_ net577 net361 net351 VGND VGND VPWR VPWR _06518_ sky130_fd_sc_hd__and3_1
X_10309_ net554 net335 net480 net649 VGND VGND VPWR VPWR _02336_ sky130_fd_sc_hd__a22o_1
XFILLER_0_21_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11289_ _03399_ _03398_ _03345_ _03340_ VGND VGND VPWR VPWR _03401_ sky130_fd_sc_hd__o211ai_2
X_14077_ _06441_ _06442_ VGND VGND VPWR VPWR _06443_ sky130_fd_sc_hd__or2_1
X_13028_ _05247_ _05253_ _05246_ VGND VGND VPWR VPWR _05296_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_83_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer17 net761 VGND VGND VPWR VPWR net762 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_83_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer39 _03953_ VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_107_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07520_ _03583_ _03594_ _03825_ _03836_ VGND VGND VPWR VPWR _03858_ sky130_fd_sc_hd__a2bb2oi_1
Xrebuffer28 _05435_ VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07451_ net149 net797 net540 net550 VGND VGND VPWR VPWR _03103_ sky130_fd_sc_hd__and4_1
XFILLER_0_88_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07382_ _02331_ _02342_ VGND VGND VPWR VPWR _02353_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09121_ _01084_ _01080_ _01124_ _01126_ _01159_ VGND VGND VPWR VPWR _01160_ sky130_fd_sc_hd__a311o_1
XFILLER_0_32_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09052_ _00864_ _01091_ VGND VGND VPWR VPWR _01092_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_114_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08003_ net255 net549 net567 net247 VGND VGND VPWR VPWR _07297_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_40_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09954_ net686 net692 net332 net476 VGND VGND VPWR VPWR _01954_ sky130_fd_sc_hd__and4_1
X_08905_ _00870_ _00873_ _00947_ VGND VGND VPWR VPWR _00948_ sky130_fd_sc_hd__or3_1
X_09885_ _01882_ _01884_ VGND VGND VPWR VPWR _01886_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08836_ _00876_ _00879_ VGND VGND VPWR VPWR _00880_ sky130_fd_sc_hd__xnor2_1
X_08767_ _00810_ _00811_ VGND VGND VPWR VPWR _00812_ sky130_fd_sc_hd__xor2_2
X_08698_ _00742_ _00743_ VGND VGND VPWR VPWR _00744_ sky130_fd_sc_hd__xnor2_1
X_07718_ net193 net573 _05993_ _06004_ VGND VGND VPWR VPWR _06015_ sky130_fd_sc_hd__a31o_1
XFILLER_0_95_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07649_ _05193_ _05204_ _05248_ VGND VGND VPWR VPWR _05259_ sky130_fd_sc_hd__a21o_1
XFILLER_0_67_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10660_ _02372_ _02556_ VGND VGND VPWR VPWR _02718_ sky130_fd_sc_hd__nand2_1
XFILLER_0_137_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09319_ a_sin\[11\] b_cos\[11\] VGND VGND VPWR VPWR _01328_ sky130_fd_sc_hd__and2b_1
XFILLER_0_48_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10591_ _02640_ _02642_ VGND VGND VPWR VPWR _02643_ sky130_fd_sc_hd__or2_1
XFILLER_0_36_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12330_ _04490_ _04492_ VGND VGND VPWR VPWR _04538_ sky130_fd_sc_hd__nand2_1
XFILLER_0_106_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12261_ _04460_ _04461_ VGND VGND VPWR VPWR _04463_ sky130_fd_sc_hd__and2_1
X_11212_ _03312_ _03314_ _03313_ VGND VGND VPWR VPWR _03316_ sky130_fd_sc_hd__a21o_1
X_14000_ _06252_ _06254_ VGND VGND VPWR VPWR _06359_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12192_ _04384_ _04385_ _04386_ VGND VGND VPWR VPWR _04388_ sky130_fd_sc_hd__a21o_1
XFILLER_0_128_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput75 net75 VGND VGND VPWR VPWR D[0] sky130_fd_sc_hd__clkbuf_4
X_11143_ _03222_ _03240_ VGND VGND VPWR VPWR _03241_ sky130_fd_sc_hd__xnor2_1
Xoutput97 net97 VGND VGND VPWR VPWR Q[13] sky130_fd_sc_hd__buf_2
Xoutput86 net86 VGND VGND VPWR VPWR D[3] sky130_fd_sc_hd__clkbuf_4
X_11074_ net134 net439 _03112_ VGND VGND VPWR VPWR _03166_ sky130_fd_sc_hd__a21oi_1
X_10025_ net648 net352 _02025_ _02026_ VGND VGND VPWR VPWR _02028_ sky130_fd_sc_hd__a22o_1
X_11976_ _04061_ _04049_ _04153_ VGND VGND VPWR VPWR _04154_ sky130_fd_sc_hd__o21a_1
X_14764_ clknet_3_4_0_clk _00065_ net320 VGND VGND VPWR VPWR a_cos\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_74_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10927_ _03004_ _03006_ VGND VGND VPWR VPWR _03008_ sky130_fd_sc_hd__nand2_1
X_13715_ _06040_ _06047_ VGND VGND VPWR VPWR _06049_ sky130_fd_sc_hd__xor2_2
X_14695_ _07021_ _07074_ _07081_ VGND VGND VPWR VPWR _07113_ sky130_fd_sc_hd__o21a_1
XFILLER_0_85_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13646_ _05971_ _05973_ VGND VGND VPWR VPWR _05974_ sky130_fd_sc_hd__nand2_1
XFILLER_0_128_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10858_ _02930_ _02931_ _02932_ VGND VGND VPWR VPWR _02933_ sky130_fd_sc_hd__o21a_1
X_10789_ _02646_ _02798_ VGND VGND VPWR VPWR _02858_ sky130_fd_sc_hd__and2_2
X_13577_ _05837_ _05838_ _05875_ _05876_ VGND VGND VPWR VPWR _05898_ sky130_fd_sc_hd__nand4_2
XFILLER_0_26_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12528_ _04752_ _04753_ VGND VGND VPWR VPWR _04754_ sky130_fd_sc_hd__nor2_1
X_12459_ _04677_ _04678_ VGND VGND VPWR VPWR _04679_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout309 net313 VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__buf_2
X_14129_ _06497_ _06498_ VGND VGND VPWR VPWR _06499_ sky130_fd_sc_hd__nor2_1
X_09670_ net690 net399 VGND VGND VPWR VPWR _01671_ sky130_fd_sc_hd__and2_1
X_08621_ _00666_ _00667_ VGND VGND VPWR VPWR _00668_ sky130_fd_sc_hd__xnor2_1
X_08552_ net153 net301 net608 net617 VGND VGND VPWR VPWR _00600_ sky130_fd_sc_hd__and4_1
XFILLER_0_76_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08483_ net196 net583 VGND VGND VPWR VPWR _00532_ sky130_fd_sc_hd__and2_1
X_07503_ net149 net797 net534 net540 VGND VGND VPWR VPWR _03671_ sky130_fd_sc_hd__and4_1
X_07434_ net147 net295 net566 net574 VGND VGND VPWR VPWR _02919_ sky130_fd_sc_hd__and4_1
XFILLER_0_85_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07365_ net211 net202 net804 net514 VGND VGND VPWR VPWR _02168_ sky130_fd_sc_hd__and4_1
XFILLER_0_18_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09104_ _01103_ _01105_ _01102_ VGND VGND VPWR VPWR _01143_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_72_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09035_ _01073_ _01075_ VGND VGND VPWR VPWR _01076_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_60_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09937_ _01932_ _01936_ VGND VGND VPWR VPWR _01937_ sky130_fd_sc_hd__xnor2_1
X_09868_ _01819_ _01813_ _01818_ VGND VGND VPWR VPWR _01869_ sky130_fd_sc_hd__a21o_1
X_08819_ _00612_ _00819_ VGND VGND VPWR VPWR _00863_ sky130_fd_sc_hd__and2_2
X_09799_ _01793_ _01794_ _01799_ VGND VGND VPWR VPWR _01800_ sky130_fd_sc_hd__nor3_1
X_11830_ _03889_ _03891_ _03892_ VGND VGND VPWR VPWR _03994_ sky130_fd_sc_hd__o21bai_1
X_11761_ net375 net461 net206 VGND VGND VPWR VPWR _03919_ sky130_fd_sc_hd__and3_1
XFILLER_0_95_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10712_ _02646_ _02714_ VGND VGND VPWR VPWR _02774_ sky130_fd_sc_hd__nand2_1
X_13500_ _05812_ _05813_ VGND VGND VPWR VPWR _05814_ sky130_fd_sc_hd__nor2_1
X_11692_ _03823_ _03842_ _03843_ VGND VGND VPWR VPWR _03844_ sky130_fd_sc_hd__and3_1
XFILLER_0_76_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14480_ _06878_ _06879_ VGND VGND VPWR VPWR _06880_ sky130_fd_sc_hd__nor2_1
XFILLER_0_138_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10643_ _02627_ _02630_ _02628_ VGND VGND VPWR VPWR _02699_ sky130_fd_sc_hd__o21ba_1
X_13431_ _05723_ _05724_ _05738_ VGND VGND VPWR VPWR _05739_ sky130_fd_sc_hd__a21o_1
XFILLER_0_118_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10574_ net666 net439 VGND VGND VPWR VPWR _02624_ sky130_fd_sc_hd__nand2_1
X_13362_ net546 net562 net485 net407 VGND VGND VPWR VPWR _05663_ sky130_fd_sc_hd__and4_1
XFILLER_0_36_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12313_ _04470_ _04518_ VGND VGND VPWR VPWR _04520_ sky130_fd_sc_hd__and2_1
Xrebuffer8 _06527_ VGND VGND VPWR VPWR net753 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13293_ _05584_ _05586_ VGND VGND VPWR VPWR _05587_ sky130_fd_sc_hd__nor2_1
X_12244_ _04057_ _04060_ _04341_ _04342_ _04443_ VGND VGND VPWR VPWR _04444_ sky130_fd_sc_hd__o311ai_4
XFILLER_0_31_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12175_ _04366_ _04368_ VGND VGND VPWR VPWR _04370_ sky130_fd_sc_hd__xnor2_1
X_11126_ _03184_ _03191_ _03193_ VGND VGND VPWR VPWR _03223_ sky130_fd_sc_hd__a21oi_1
X_11057_ _03126_ _03148_ VGND VGND VPWR VPWR _03149_ sky130_fd_sc_hd__xnor2_1
X_10008_ _01929_ _02008_ _02009_ VGND VGND VPWR VPWR _02010_ sky130_fd_sc_hd__nand3_2
XFILLER_0_64_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11959_ _04009_ _04018_ _04017_ VGND VGND VPWR VPWR _04135_ sky130_fd_sc_hd__a21bo_1
X_14747_ clknet_3_7_0_clk _00048_ net326 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_117_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14678_ _07092_ _07093_ VGND VGND VPWR VPWR _07094_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_117_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13629_ _05952_ _05953_ _05936_ VGND VGND VPWR VPWR _05955_ sky130_fd_sc_hd__a21o_1
XFILLER_0_15_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout128 state VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__buf_4
X_07983_ _07188_ _07190_ _07276_ _07277_ VGND VGND VPWR VPWR _07278_ sky130_fd_sc_hd__a211o_4
X_09722_ net734 net339 _01686_ _01687_ VGND VGND VPWR VPWR _01723_ sky130_fd_sc_hd__o2bb2a_1
Xfanout139 net8 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__clkbuf_4
X_09653_ _01549_ _01622_ _01652_ _01653_ VGND VGND VPWR VPWR _01654_ sky130_fd_sc_hd__a211o_2
X_08604_ _00571_ _00588_ _00650_ VGND VGND VPWR VPWR _00651_ sky130_fd_sc_hd__o21a_1
X_09584_ _01562_ _01563_ _01583_ _01584_ VGND VGND VPWR VPWR _01585_ sky130_fd_sc_hd__and4bb_2
XPHY_EDGE_ROW_118_Right_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08535_ _00581_ _00582_ VGND VGND VPWR VPWR _00583_ sky130_fd_sc_hd__xor2_1
XFILLER_0_49_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08466_ net257 net509 VGND VGND VPWR VPWR _00515_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08397_ _00365_ _00367_ _00366_ VGND VGND VPWR VPWR _00447_ sky130_fd_sc_hd__a21bo_1
X_07417_ _02647_ _02658_ _02712_ VGND VGND VPWR VPWR _02734_ sky130_fd_sc_hd__a21o_1
XFILLER_0_107_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09018_ _01056_ _01057_ _01058_ VGND VGND VPWR VPWR _01059_ sky130_fd_sc_hd__o21a_1
X_10290_ net719 net416 VGND VGND VPWR VPWR _02315_ sky130_fd_sc_hd__and2b_1
XFILLER_0_41_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout651 net652 VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__clkbuf_4
Xfanout640 net748 VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_18_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout684 net689 VGND VGND VPWR VPWR net684 sky130_fd_sc_hd__clkbuf_4
Xfanout662 net663 VGND VGND VPWR VPWR net662 sky130_fd_sc_hd__buf_2
Xfanout673 net674 VGND VGND VPWR VPWR net673 sky130_fd_sc_hd__clkbuf_4
X_13980_ net577 _02467_ _06336_ net369 net584 VGND VGND VPWR VPWR _06337_ sky130_fd_sc_hd__a32o_1
Xfanout695 net698 VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__buf_2
X_12931_ net493 net398 VGND VGND VPWR VPWR _05189_ sky130_fd_sc_hd__and2_1
X_12862_ net259 net144 _05049_ _05047_ VGND VGND VPWR VPWR _05115_ sky130_fd_sc_hd__a31o_1
X_11813_ _03973_ _03974_ VGND VGND VPWR VPWR _03975_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_68_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14601_ _07009_ _07010_ VGND VGND VPWR VPWR _07011_ sky130_fd_sc_hd__nand2_1
X_12793_ _05039_ _05040_ VGND VGND VPWR VPWR _05041_ sky130_fd_sc_hd__xor2_1
XFILLER_0_141_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11744_ _03883_ _03898_ _03899_ VGND VGND VPWR VPWR _03900_ sky130_fd_sc_hd__nand3_2
XFILLER_0_95_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14532_ _06788_ _06869_ _06934_ VGND VGND VPWR VPWR _06936_ sky130_fd_sc_hd__a21o_1
X_11675_ net461 net213 net206 net556 VGND VGND VPWR VPWR _03826_ sky130_fd_sc_hd__and4_1
XFILLER_0_83_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14463_ _06804_ _06805_ _06731_ VGND VGND VPWR VPWR _06861_ sky130_fd_sc_hd__a21o_1
XFILLER_0_83_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10626_ _02681_ VGND VGND VPWR VPWR _00063_ sky130_fd_sc_hd__clkbuf_1
X_13414_ _05400_ _05406_ VGND VGND VPWR VPWR _05720_ sky130_fd_sc_hd__and2b_1
XFILLER_0_141_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14394_ _06586_ _06715_ VGND VGND VPWR VPWR _06786_ sky130_fd_sc_hd__or2_1
XFILLER_0_36_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10557_ _02604_ _02605_ VGND VGND VPWR VPWR _02606_ sky130_fd_sc_hd__nor2_1
XFILLER_0_51_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13345_ _05642_ _05641_ _05614_ _05640_ VGND VGND VPWR VPWR _05645_ sky130_fd_sc_hd__a211o_1
X_10488_ _02455_ _02463_ _02461_ VGND VGND VPWR VPWR _02531_ sky130_fd_sc_hd__a21bo_1
X_13276_ _05558_ _05566_ _05568_ _05525_ VGND VGND VPWR VPWR _05569_ sky130_fd_sc_hd__o211a_1
X_12227_ _04423_ _04426_ VGND VGND VPWR VPWR _04427_ sky130_fd_sc_hd__xnor2_1
X_12158_ _04266_ _04268_ VGND VGND VPWR VPWR _04351_ sky130_fd_sc_hd__or2_1
XFILLER_0_75_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12089_ net679 net687 net282 net264 VGND VGND VPWR VPWR _04276_ sky130_fd_sc_hd__and4_1
X_11109_ _03126_ _03148_ _03125_ VGND VGND VPWR VPWR _03205_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_91_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08320_ _00293_ _00370_ VGND VGND VPWR VPWR _00371_ sky130_fd_sc_hd__nor2_2
XFILLER_0_87_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08251_ _00276_ _00302_ VGND VGND VPWR VPWR _00303_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_62_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08182_ _07290_ _00136_ _00234_ VGND VGND VPWR VPWR _00235_ sky130_fd_sc_hd__o21a_1
XFILLER_0_54_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07966_ net311 net231 net597 net588 VGND VGND VPWR VPWR _07261_ sky130_fd_sc_hd__and4_2
X_09705_ _01704_ _01705_ VGND VGND VPWR VPWR _01706_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07897_ _07190_ _07191_ _03583_ _03847_ VGND VGND VPWR VPWR _07193_ sky130_fd_sc_hd__a211o_1
XFILLER_0_69_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09636_ _01635_ _01636_ VGND VGND VPWR VPWR _01637_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09567_ _01509_ _01511_ _01510_ VGND VGND VPWR VPWR _01568_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_93_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08518_ _00566_ VGND VGND VPWR VPWR _00007_ sky130_fd_sc_hd__clkbuf_1
X_09498_ _01491_ _01498_ VGND VGND VPWR VPWR _01499_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_136_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08449_ net534 net236 VGND VGND VPWR VPWR _00498_ sky130_fd_sc_hd__and2b_1
XFILLER_0_65_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11460_ _03571_ _03587_ _03588_ VGND VGND VPWR VPWR _03589_ sky130_fd_sc_hd__nand3_4
XFILLER_0_80_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11391_ _03511_ _03510_ VGND VGND VPWR VPWR _03513_ sky130_fd_sc_hd__and2b_1
X_10411_ _02437_ _02445_ _02446_ VGND VGND VPWR VPWR _02447_ sky130_fd_sc_hd__nand3_1
XFILLER_0_21_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13130_ net659 net437 VGND VGND VPWR VPWR _05408_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10342_ net133 _02368_ VGND VGND VPWR VPWR _02372_ sky130_fd_sc_hd__and2_1
X_13061_ _05260_ _05265_ VGND VGND VPWR VPWR _05332_ sky130_fd_sc_hd__or2b_1
X_12012_ _04190_ _04191_ VGND VGND VPWR VPWR _04192_ sky130_fd_sc_hd__xnor2_2
X_10273_ _02217_ _02296_ VGND VGND VPWR VPWR _02297_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout492 net37 VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__buf_4
Xfanout481 net482 VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__clkbuf_2
Xfanout470 net472 VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__clkbuf_2
X_13963_ _06315_ _06316_ _06308_ VGND VGND VPWR VPWR _06318_ sky130_fd_sc_hd__a21o_1
X_12914_ _05165_ _05170_ VGND VGND VPWR VPWR _05171_ sky130_fd_sc_hd__xnor2_1
X_13894_ _06150_ _06151_ _06154_ _06242_ VGND VGND VPWR VPWR _06243_ sky130_fd_sc_hd__a31o_1
X_12845_ _05084_ _05085_ VGND VGND VPWR VPWR _05097_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12776_ _05020_ _05022_ VGND VGND VPWR VPWR _05023_ sky130_fd_sc_hd__xor2_1
XFILLER_0_69_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11727_ _03797_ _03805_ VGND VGND VPWR VPWR _03882_ sky130_fd_sc_hd__and2_1
X_14515_ net791 next_state _06917_ VGND VGND VPWR VPWR _00104_ sky130_fd_sc_hd__o21a_1
XFILLER_0_29_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11658_ _03790_ _03791_ _03806_ VGND VGND VPWR VPWR _03807_ sky130_fd_sc_hd__a21o_1
X_14446_ _06747_ _06841_ _06839_ _06840_ VGND VGND VPWR VPWR _06844_ sky130_fd_sc_hd__o211ai_2
X_11589_ _03724_ _03730_ VGND VGND VPWR VPWR _03731_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_107_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10609_ _02661_ _02638_ _02639_ VGND VGND VPWR VPWR _02663_ sky130_fd_sc_hd__or3_4
XFILLER_0_4_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14377_ _06748_ _06768_ VGND VGND VPWR VPWR _06769_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13328_ _05623_ _05624_ _05625_ VGND VGND VPWR VPWR _05626_ sky130_fd_sc_hd__a21o_1
XFILLER_0_24_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13259_ net535 net388 net379 net543 VGND VGND VPWR VPWR _05550_ sky130_fd_sc_hd__a22oi_1
X_07820_ _04674_ _04967_ _04956_ VGND VGND VPWR VPWR _07116_ sky130_fd_sc_hd__nand3_1
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07751_ _06091_ _06070_ _06081_ VGND VGND VPWR VPWR _06374_ sky130_fd_sc_hd__nand3_1
XFILLER_0_79_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07682_ _05600_ _05611_ VGND VGND VPWR VPWR _05622_ sky130_fd_sc_hd__and2b_1
XFILLER_0_79_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09421_ _01376_ _01378_ _01377_ VGND VGND VPWR VPWR _01422_ sky130_fd_sc_hd__a21bo_1
X_09352_ b_cos\[15\] a_sin\[15\] VGND VGND VPWR VPWR _01357_ sky130_fd_sc_hd__and2b_1
XFILLER_0_59_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08303_ _00280_ _00282_ VGND VGND VPWR VPWR _00354_ sky130_fd_sc_hd__nand2_1
XFILLER_0_142_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09283_ _01297_ VGND VGND VPWR VPWR _00041_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_117_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08234_ _00277_ _00285_ VGND VGND VPWR VPWR _00286_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_74_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08165_ _00184_ _00216_ _00217_ VGND VGND VPWR VPWR _00218_ sky130_fd_sc_hd__nand3_1
XFILLER_0_43_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08096_ net247 net239 net549 net567 VGND VGND VPWR VPWR _00149_ sky130_fd_sc_hd__and4_1
XFILLER_0_3_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08998_ net285 net267 net582 VGND VGND VPWR VPWR _01039_ sky130_fd_sc_hd__and3_1
X_07949_ _07168_ _07170_ _07169_ VGND VGND VPWR VPWR _07244_ sky130_fd_sc_hd__o21bai_1
X_10960_ _02913_ _02983_ VGND VGND VPWR VPWR _03044_ sky130_fd_sc_hd__or2_1
X_10891_ _02965_ _02967_ VGND VGND VPWR VPWR _02969_ sky130_fd_sc_hd__nand2_1
X_09619_ _01601_ _01602_ _01618_ _01619_ VGND VGND VPWR VPWR _01620_ sky130_fd_sc_hd__o211ai_4
X_12630_ net189 net285 net267 net276 VGND VGND VPWR VPWR _04864_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_97_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12561_ net276 net285 net267 net377 VGND VGND VPWR VPWR _04789_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_93_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11512_ _03642_ _03645_ VGND VGND VPWR VPWR _03646_ sky130_fd_sc_hd__xnor2_2
X_12492_ net377 net465 net286 net268 VGND VGND VPWR VPWR _04714_ sky130_fd_sc_hd__and4_1
XFILLER_0_93_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14300_ _06678_ _06684_ VGND VGND VPWR VPWR _06685_ sky130_fd_sc_hd__xnor2_1
Xwire112 _06626_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__buf_1
XFILLER_0_135_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11443_ _03365_ _03366_ _03378_ VGND VGND VPWR VPWR _03570_ sky130_fd_sc_hd__nand3_2
X_14231_ _06478_ _06477_ VGND VGND VPWR VPWR _06610_ sky130_fd_sc_hd__and2b_1
X_14162_ _06532_ _06533_ _06487_ VGND VGND VPWR VPWR _06535_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_34_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11374_ net306 net720 net730 net226 VGND VGND VPWR VPWR _03494_ sky130_fd_sc_hd__a22o_1
X_13113_ _05383_ _05388_ VGND VGND VPWR VPWR _05389_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10325_ net271 net372 net362 net352 VGND VGND VPWR VPWR _02354_ sky130_fd_sc_hd__nand4_2
XFILLER_0_21_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14093_ _06455_ _06459_ VGND VGND VPWR VPWR _06460_ sky130_fd_sc_hd__xnor2_1
X_13044_ _05296_ _05311_ _05312_ VGND VGND VPWR VPWR _05313_ sky130_fd_sc_hd__nand3_2
X_10256_ net490 net413 net403 net133 VGND VGND VPWR VPWR _02279_ sky130_fd_sc_hd__o31ai_4
X_10187_ _02141_ _02202_ _02203_ VGND VGND VPWR VPWR _02204_ sky130_fd_sc_hd__or3_4
X_13946_ _06283_ _06299_ VGND VGND VPWR VPWR _06300_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13877_ net603 net612 net361 net350 VGND VGND VPWR VPWR _06225_ sky130_fd_sc_hd__nand4_2
X_12828_ _05061_ _05078_ VGND VGND VPWR VPWR _05079_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_57_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12759_ _04856_ _04989_ _05003_ VGND VGND VPWR VPWR _05004_ sky130_fd_sc_hd__or3_1
XFILLER_0_142_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14429_ _06823_ _06824_ VGND VGND VPWR VPWR _06825_ sky130_fd_sc_hd__xor2_1
XFILLER_0_142_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09970_ net648 net362 net352 net665 VGND VGND VPWR VPWR _01970_ sky130_fd_sc_hd__a22o_1
XFILLER_0_40_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08921_ _00885_ _00886_ VGND VGND VPWR VPWR _00964_ sky130_fd_sc_hd__and2b_1
X_08852_ _00890_ _00895_ VGND VGND VPWR VPWR _00896_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07803_ _06874_ _06928_ net574 net660 VGND VGND VPWR VPWR _06939_ sky130_fd_sc_hd__and4b_1
XFILLER_0_137_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08783_ _00733_ _00736_ _00734_ VGND VGND VPWR VPWR _00828_ sky130_fd_sc_hd__o21ba_1
X_07734_ _06037_ _06168_ _06178_ VGND VGND VPWR VPWR _06189_ sky130_fd_sc_hd__nand3_2
XFILLER_0_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07665_ net757 _05402_ _05424_ VGND VGND VPWR VPWR _05435_ sky130_fd_sc_hd__nand3_2
X_09404_ _01388_ _01403_ _01402_ VGND VGND VPWR VPWR _01405_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07596_ _04391_ _04402_ _04413_ VGND VGND VPWR VPWR _04685_ sky130_fd_sc_hd__o21a_1
XFILLER_0_47_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09335_ _01328_ _01338_ _01337_ VGND VGND VPWR VPWR _01342_ sky130_fd_sc_hd__o21ba_1
X_09266_ b_cos\[2\] _01281_ _01282_ VGND VGND VPWR VPWR _01283_ sky130_fd_sc_hd__o21a_1
XFILLER_0_62_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08217_ _00266_ _00267_ _00268_ VGND VGND VPWR VPWR _00269_ sky130_fd_sc_hd__nand3_1
XFILLER_0_28_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09197_ net76 _01224_ net131 VGND VGND VPWR VPWR _01225_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08148_ net308 net229 VGND VGND VPWR VPWR _00201_ sky130_fd_sc_hd__nand2_2
XFILLER_0_43_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08079_ _00130_ _00131_ _07217_ VGND VGND VPWR VPWR _00133_ sky130_fd_sc_hd__a21oi_1
X_10110_ _02086_ _02099_ VGND VGND VPWR VPWR _02119_ sky130_fd_sc_hd__nand2_1
X_11090_ net141 net440 _03112_ _03057_ VGND VGND VPWR VPWR _03184_ sky130_fd_sc_hd__a31o_1
X_10041_ _02041_ _02042_ _02040_ VGND VGND VPWR VPWR _02044_ sky130_fd_sc_hd__o21ai_1
Xhold31 a_cos\[13\] VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 net100 VGND VGND VPWR VPWR net787 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11992_ net732 net235 VGND VGND VPWR VPWR _04170_ sky130_fd_sc_hd__and2b_1
X_14780_ clknet_3_3_0_clk _00081_ net319 VGND VGND VPWR VPWR a_sin\[8\] sky130_fd_sc_hd__dfrtp_1
X_13800_ net630 net343 _06138_ _06139_ VGND VGND VPWR VPWR _06141_ sky130_fd_sc_hd__nand4_1
XFILLER_0_98_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10943_ _03022_ _03024_ VGND VGND VPWR VPWR _03025_ sky130_fd_sc_hd__or2_1
X_13731_ _06062_ _06063_ _06064_ VGND VGND VPWR VPWR _06066_ sky130_fd_sc_hd__a21o_1
Xclkbuf_3_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_0_0_clk sky130_fd_sc_hd__clkbuf_8
X_10874_ _02895_ _02898_ VGND VGND VPWR VPWR _02950_ sky130_fd_sc_hd__or2_1
XFILLER_0_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13662_ _05988_ _05990_ VGND VGND VPWR VPWR _05991_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12613_ _04844_ _04845_ VGND VGND VPWR VPWR _04846_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13593_ _05911_ _05914_ VGND VGND VPWR VPWR _05915_ sky130_fd_sc_hd__xnor2_1
X_12544_ _04746_ _04747_ _04769_ VGND VGND VPWR VPWR _04771_ sky130_fd_sc_hd__or3_1
X_12475_ _04694_ _04695_ VGND VGND VPWR VPWR _04697_ sky130_fd_sc_hd__xor2_1
XFILLER_0_108_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11426_ _03512_ _03549_ _03551_ VGND VGND VPWR VPWR _03552_ sky130_fd_sc_hd__nand3_1
XANTENNA_6 net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14214_ _06574_ _06575_ _06590_ VGND VGND VPWR VPWR _06591_ sky130_fd_sc_hd__o21a_1
X_11357_ _03446_ _03448_ VGND VGND VPWR VPWR _03476_ sky130_fd_sc_hd__xor2_1
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14145_ net577 net369 _02467_ _06338_ VGND VGND VPWR VPWR _06517_ sky130_fd_sc_hd__a31o_4
XFILLER_0_67_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10308_ _02333_ _02334_ VGND VGND VPWR VPWR _02335_ sky130_fd_sc_hd__xnor2_2
X_14076_ _06438_ _06439_ VGND VGND VPWR VPWR _06442_ sky130_fd_sc_hd__nor2_1
X_11288_ _03340_ _03345_ _03398_ _03399_ VGND VGND VPWR VPWR _03400_ sky130_fd_sc_hd__a211o_1
X_13027_ _05256_ _05257_ _05267_ VGND VGND VPWR VPWR _05295_ sky130_fd_sc_hd__nand3_1
X_10239_ _02239_ _02259_ VGND VGND VPWR VPWR _02260_ sky130_fd_sc_hd__xor2_2
Xrebuffer18 _05347_ VGND VGND VPWR VPWR net763 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_89_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer29 net643 VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_16_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13929_ _06201_ _06218_ VGND VGND VPWR VPWR _06281_ sky130_fd_sc_hd__nand2_1
X_07450_ net288 net568 VGND VGND VPWR VPWR _03092_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07381_ net211 net497 net804 net202 VGND VGND VPWR VPWR _02342_ sky130_fd_sc_hd__a22oi_2
X_09120_ _01133_ _01158_ VGND VGND VPWR VPWR _01159_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_127_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09051_ _01086_ _01090_ VGND VGND VPWR VPWR _01091_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08002_ _07225_ _07226_ VGND VGND VPWR VPWR _07296_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09953_ net686 net332 net476 net692 VGND VGND VPWR VPWR _01953_ sky130_fd_sc_hd__a22oi_2
X_08904_ _00944_ _00946_ VGND VGND VPWR VPWR _00947_ sky130_fd_sc_hd__xor2_1
X_09884_ _01836_ _01837_ _01838_ _01833_ VGND VGND VPWR VPWR _01885_ sky130_fd_sc_hd__a22o_1
X_08835_ _00877_ _00878_ VGND VGND VPWR VPWR _00879_ sky130_fd_sc_hd__and2b_1
X_08766_ net292 net607 _00740_ _00739_ VGND VGND VPWR VPWR _00811_ sky130_fd_sc_hd__a31o_1
X_07717_ net208 net199 net547 net565 VGND VGND VPWR VPWR _06004_ sky130_fd_sc_hd__and4_1
XFILLER_0_79_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08697_ _00662_ _00665_ _00663_ VGND VGND VPWR VPWR _00743_ sky130_fd_sc_hd__o21ba_1
X_07648_ _05215_ _05226_ _05237_ VGND VGND VPWR VPWR _05248_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_95_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07579_ _04445_ _04152_ _04435_ VGND VGND VPWR VPWR _04500_ sky130_fd_sc_hd__nand3_1
XFILLER_0_94_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09318_ net796 net793 _01325_ _01327_ VGND VGND VPWR VPWR _00046_ sky130_fd_sc_hd__a22o_1
XFILLER_0_133_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10590_ _02641_ _02556_ VGND VGND VPWR VPWR _02642_ sky130_fd_sc_hd__nor2_1
XFILLER_0_35_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09249_ _01266_ _01268_ net128 net792 VGND VGND VPWR VPWR _00036_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_50_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12260_ _04460_ _04461_ VGND VGND VPWR VPWR _04462_ sky130_fd_sc_hd__nor2_1
X_11211_ _03312_ _03313_ _03314_ VGND VGND VPWR VPWR _03315_ sky130_fd_sc_hd__nand3_1
X_12191_ _04384_ _04385_ _04386_ VGND VGND VPWR VPWR _04387_ sky130_fd_sc_hd__nand3_2
XFILLER_0_31_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11142_ _03238_ _03239_ VGND VGND VPWR VPWR _03240_ sky130_fd_sc_hd__xnor2_1
Xoutput76 net76 VGND VGND VPWR VPWR D[10] sky130_fd_sc_hd__clkbuf_4
Xoutput87 net87 VGND VGND VPWR VPWR D[4] sky130_fd_sc_hd__clkbuf_4
Xoutput98 net98 VGND VGND VPWR VPWR Q[14] sky130_fd_sc_hd__buf_2
X_11073_ _03063_ _03116_ _03055_ VGND VGND VPWR VPWR _03165_ sky130_fd_sc_hd__o21ai_1
X_10024_ net459 net553 net369 net362 VGND VGND VPWR VPWR _02026_ sky130_fd_sc_hd__nand4_1
X_11975_ _04063_ _04151_ VGND VGND VPWR VPWR _04153_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14763_ clknet_3_6_0_clk _00064_ net319 VGND VGND VPWR VPWR a_cos\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_85_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10926_ _03004_ _03006_ VGND VGND VPWR VPWR _03007_ sky130_fd_sc_hd__or2_1
X_14694_ _07021_ _07024_ _07074_ _07081_ _07110_ VGND VGND VPWR VPWR _07111_ sky130_fd_sc_hd__o311a_1
X_13714_ _06041_ _06046_ VGND VGND VPWR VPWR _06047_ sky130_fd_sc_hd__xor2_2
X_10857_ net373 net439 VGND VGND VPWR VPWR _02932_ sky130_fd_sc_hd__nand2_1
X_13645_ _05820_ _05966_ _05970_ VGND VGND VPWR VPWR _05973_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_73_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10788_ _02646_ _02798_ VGND VGND VPWR VPWR _02857_ sky130_fd_sc_hd__or2_1
X_13576_ _05883_ _05886_ VGND VGND VPWR VPWR _05897_ sky130_fd_sc_hd__nand2_1
XFILLER_0_124_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12527_ net654 net671 net251 net243 VGND VGND VPWR VPWR _04753_ sky130_fd_sc_hd__and4_1
XFILLER_0_81_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12458_ _04542_ _04544_ _04541_ VGND VGND VPWR VPWR _04678_ sky130_fd_sc_hd__a21o_1
XFILLER_0_112_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11409_ _03531_ _03532_ VGND VGND VPWR VPWR _03533_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12389_ _04600_ _04601_ _04556_ VGND VGND VPWR VPWR _04603_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_78_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14128_ net604 net615 net333 net478 VGND VGND VPWR VPWR _06498_ sky130_fd_sc_hd__and4_1
X_14059_ net577 _02467_ _06336_ VGND VGND VPWR VPWR _06423_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08620_ _00599_ _00602_ _00600_ VGND VGND VPWR VPWR _00667_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_27_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08551_ net153 net608 net617 net301 VGND VGND VPWR VPWR _00599_ sky130_fd_sc_hd__a22oi_2
XPHY_EDGE_ROW_59_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08482_ _00371_ _00458_ _00459_ _00370_ VGND VGND VPWR VPWR _00531_ sky130_fd_sc_hd__a31o_1
X_07502_ net289 net550 VGND VGND VPWR VPWR _03660_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07433_ _02864_ _02875_ _02397_ _02560_ VGND VGND VPWR VPWR _02908_ sky130_fd_sc_hd__o211a_1
XFILLER_0_43_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07364_ net195 net522 VGND VGND VPWR VPWR _02157_ sky130_fd_sc_hd__nand2_1
XFILLER_0_91_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09103_ _01140_ _01141_ VGND VGND VPWR VPWR _01142_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_57_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09034_ _01003_ _01021_ _01074_ VGND VGND VPWR VPWR _01075_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_68_Left_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09936_ _01933_ _01935_ VGND VGND VPWR VPWR _01936_ sky130_fd_sc_hd__nand2_1
X_09867_ _01819_ _01813_ _01818_ VGND VGND VPWR VPWR _01868_ sky130_fd_sc_hd__nand3_1
X_08818_ _00683_ _00819_ VGND VGND VPWR VPWR _00862_ sky130_fd_sc_hd__nor2_4
XPHY_EDGE_ROW_77_Left_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09798_ _01797_ _01798_ VGND VGND VPWR VPWR _01799_ sky130_fd_sc_hd__or2_1
X_08749_ b_sin\[10\] _00794_ _00486_ VGND VGND VPWR VPWR _00795_ sky130_fd_sc_hd__mux2_1
X_11760_ net556 net197 VGND VGND VPWR VPWR _03918_ sky130_fd_sc_hd__and2_1
XFILLER_0_67_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10711_ _02693_ _02700_ VGND VGND VPWR VPWR _02773_ sky130_fd_sc_hd__and2_1
X_11691_ _03839_ _03840_ _03841_ VGND VGND VPWR VPWR _03843_ sky130_fd_sc_hd__a21o_1
XFILLER_0_83_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10642_ _02696_ _02697_ VGND VGND VPWR VPWR _02698_ sky130_fd_sc_hd__xnor2_1
X_13430_ _05729_ _05737_ VGND VGND VPWR VPWR _05738_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_36_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10573_ _02621_ _02622_ VGND VGND VPWR VPWR _02623_ sky130_fd_sc_hd__nor2_1
X_13361_ net546 net485 net407 net562 VGND VGND VPWR VPWR _05662_ sky130_fd_sc_hd__a22o_1
X_12312_ _04470_ _04518_ VGND VGND VPWR VPWR _04519_ sky130_fd_sc_hd__nor2_1
Xrebuffer9 _02124_ VGND VGND VPWR VPWR net754 sky130_fd_sc_hd__buf_1
XFILLER_0_90_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13292_ _05585_ _05583_ VGND VGND VPWR VPWR _05586_ sky130_fd_sc_hd__or2_1
X_12243_ _04340_ _04437_ VGND VGND VPWR VPWR _04443_ sky130_fd_sc_hd__nor2_1
XFILLER_0_139_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12174_ _04367_ _04265_ VGND VGND VPWR VPWR _04368_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11125_ _03165_ _03172_ _03170_ VGND VGND VPWR VPWR _03222_ sky130_fd_sc_hd__a21oi_1
X_11056_ _03127_ _03147_ VGND VGND VPWR VPWR _03148_ sky130_fd_sc_hd__xor2_1
XFILLER_0_3_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10007_ _02005_ _02007_ _01930_ _01660_ VGND VGND VPWR VPWR _02009_ sky130_fd_sc_hd__a211o_1
X_14746_ clknet_3_7_0_clk _00047_ net326 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11958_ _04131_ _04132_ _04125_ VGND VGND VPWR VPWR _04134_ sky130_fd_sc_hd__a21o_1
XFILLER_0_104_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11889_ _04051_ _03962_ VGND VGND VPWR VPWR _04058_ sky130_fd_sc_hd__or2b_1
XFILLER_0_86_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10909_ _02937_ _02942_ VGND VGND VPWR VPWR _02988_ sky130_fd_sc_hd__and2b_1
X_14677_ _07050_ _07055_ _07057_ VGND VGND VPWR VPWR _07093_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_117_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13628_ _05936_ _05952_ _05953_ VGND VGND VPWR VPWR _05954_ sky130_fd_sc_hd__nand3_1
XFILLER_0_109_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13559_ _05779_ _05781_ _05877_ _05878_ VGND VGND VPWR VPWR _05879_ sky130_fd_sc_hd__a211o_1
XFILLER_0_89_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07982_ _07240_ _07241_ _07274_ _07275_ VGND VGND VPWR VPWR _07277_ sky130_fd_sc_hd__a22oi_2
Xfanout129 net130 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__clkbuf_4
X_09721_ _01719_ _01721_ VGND VGND VPWR VPWR _01722_ sky130_fd_sc_hd__nor2_1
X_09652_ _01650_ _01651_ _01633_ VGND VGND VPWR VPWR _01653_ sky130_fd_sc_hd__a21oi_2
X_08603_ _00572_ _00587_ VGND VGND VPWR VPWR _00650_ sky130_fd_sc_hd__nand2_1
X_09583_ _01581_ _01582_ _01564_ _01565_ VGND VGND VPWR VPWR _01584_ sky130_fd_sc_hd__a211o_1
X_08534_ _00497_ _00498_ _00496_ VGND VGND VPWR VPWR _00582_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_92_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08465_ _00512_ _00513_ VGND VGND VPWR VPWR _00514_ sky130_fd_sc_hd__or2_1
XFILLER_0_58_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08396_ _00357_ _00359_ VGND VGND VPWR VPWR _00446_ sky130_fd_sc_hd__nand2_1
X_07416_ _02647_ _02658_ _02712_ VGND VGND VPWR VPWR _02723_ sky130_fd_sc_hd__nand3_2
XFILLER_0_64_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09017_ net618 net237 VGND VGND VPWR VPWR _01058_ sky130_fd_sc_hd__or2b_1
XFILLER_0_103_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout641 net748 VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__clkbuf_2
Xfanout630 net637 VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__buf_2
Xfanout652 net655 VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__clkbuf_2
Xfanout685 net689 VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout663 net19 VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__buf_2
X_09919_ _01765_ _01766_ _01919_ VGND VGND VPWR VPWR _01920_ sky130_fd_sc_hd__and3_1
Xfanout674 net676 VGND VGND VPWR VPWR net674 sky130_fd_sc_hd__clkbuf_4
Xfanout696 net697 VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__clkbuf_4
X_12930_ _05185_ _05186_ _05187_ VGND VGND VPWR VPWR _05188_ sky130_fd_sc_hd__a21bo_1
X_12861_ net189 net277 net254 net245 VGND VGND VPWR VPWR _05114_ sky130_fd_sc_hd__and4_1
X_11812_ _03867_ _03869_ _03871_ VGND VGND VPWR VPWR _03974_ sky130_fd_sc_hd__a21bo_1
X_14600_ _06948_ _06996_ _07008_ VGND VGND VPWR VPWR _07010_ sky130_fd_sc_hd__or3b_1
XFILLER_0_139_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12792_ _04971_ _04981_ VGND VGND VPWR VPWR _05040_ sky130_fd_sc_hd__nand2_1
X_11743_ _03896_ _03897_ _03888_ VGND VGND VPWR VPWR _03899_ sky130_fd_sc_hd__a21o_1
XFILLER_0_56_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14531_ _06788_ _06869_ _06934_ VGND VGND VPWR VPWR _06935_ sky130_fd_sc_hd__and3_1
X_11674_ net198 net651 VGND VGND VPWR VPWR _03824_ sky130_fd_sc_hd__nand2_1
XFILLER_0_138_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14462_ _06858_ _06859_ VGND VGND VPWR VPWR _06860_ sky130_fd_sc_hd__xor2_1
XFILLER_0_71_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10625_ a_cos\[8\] _02679_ _02303_ VGND VGND VPWR VPWR _02681_ sky130_fd_sc_hd__mux2_1
XFILLER_0_64_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13413_ _05715_ _05718_ VGND VGND VPWR VPWR _05719_ sky130_fd_sc_hd__xnor2_1
X_14393_ _06748_ _06768_ VGND VGND VPWR VPWR _06785_ sky130_fd_sc_hd__nor2_1
XFILLER_0_107_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10556_ _02533_ _02597_ _02602_ VGND VGND VPWR VPWR _02605_ sky130_fd_sc_hd__o21a_1
XFILLER_0_3_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13344_ _05640_ _05614_ _05641_ _05642_ VGND VGND VPWR VPWR _05643_ sky130_fd_sc_hd__o211ai_2
X_10487_ _02437_ _02445_ _02446_ VGND VGND VPWR VPWR _02530_ sky130_fd_sc_hd__and3_1
X_13275_ _05521_ _05522_ _05524_ VGND VGND VPWR VPWR _05568_ sky130_fd_sc_hd__a21o_1
X_12226_ _04294_ _04325_ _04425_ VGND VGND VPWR VPWR _04426_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_20_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12157_ _04252_ _04270_ _04349_ VGND VGND VPWR VPWR _04350_ sky130_fd_sc_hd__o21ai_1
X_11108_ _03177_ _03203_ VGND VGND VPWR VPWR _03204_ sky130_fd_sc_hd__xnor2_1
X_12088_ net679 net282 net264 net687 VGND VGND VPWR VPWR _04275_ sky130_fd_sc_hd__a22oi_2
X_11039_ _03056_ _03065_ _03128_ VGND VGND VPWR VPWR _03129_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_115_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14729_ clknet_3_5_0_clk _00030_ net324 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_47_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08250_ _00300_ _00301_ VGND VGND VPWR VPWR _00302_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_46_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08181_ _00137_ _00134_ _00233_ VGND VGND VPWR VPWR _00234_ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07965_ net231 net597 net588 net311 VGND VGND VPWR VPWR _07260_ sky130_fd_sc_hd__a22oi_2
X_09704_ _01700_ _01701_ _01703_ VGND VGND VPWR VPWR _01705_ sky130_fd_sc_hd__and3_1
X_07896_ _03583_ _03847_ _07190_ _07191_ VGND VGND VPWR VPWR _07192_ sky130_fd_sc_hd__o211ai_2
X_09635_ net460 net396 net387 net552 VGND VGND VPWR VPWR _01636_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_139_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09566_ _01491_ _01498_ VGND VGND VPWR VPWR _01567_ sky130_fd_sc_hd__or2b_1
XFILLER_0_93_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08517_ b_sin\[7\] _00565_ _00486_ VGND VGND VPWR VPWR _00566_ sky130_fd_sc_hd__mux2_1
X_09497_ _01492_ _01497_ VGND VGND VPWR VPWR _01498_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_135_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08448_ _00495_ _00496_ VGND VGND VPWR VPWR _00497_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08379_ net257 net517 VGND VGND VPWR VPWR _00429_ sky130_fd_sc_hd__nand2_1
XFILLER_0_92_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10410_ _02442_ _02443_ _02444_ VGND VGND VPWR VPWR _02446_ sky130_fd_sc_hd__a21o_1
X_11390_ _03510_ _03511_ VGND VGND VPWR VPWR _03512_ sky130_fd_sc_hd__and2b_1
XFILLER_0_61_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10341_ _02366_ _02367_ _02369_ VGND VGND VPWR VPWR _02371_ sky130_fd_sc_hd__a21o_1
X_10272_ _02218_ _02295_ VGND VGND VPWR VPWR _02296_ sky130_fd_sc_hd__xnor2_1
X_13060_ _05282_ _05289_ VGND VGND VPWR VPWR _05331_ sky130_fd_sc_hd__or2b_1
XFILLER_0_131_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12011_ net706 net257 VGND VGND VPWR VPWR _04191_ sky130_fd_sc_hd__nand2_1
Xfanout471 net472 VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__clkbuf_4
Xfanout460 net4 VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__clkbuf_4
Xfanout493 net496 VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__clkbuf_4
X_13962_ _06308_ _06315_ _06316_ VGND VGND VPWR VPWR _06317_ sky130_fd_sc_hd__nand3_1
Xfanout482 net38 VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__buf_6
X_12913_ _05168_ _05169_ VGND VGND VPWR VPWR _05170_ sky130_fd_sc_hd__xnor2_1
X_13893_ net578 _02368_ VGND VGND VPWR VPWR _06242_ sky130_fd_sc_hd__and2_1
X_12844_ _04971_ _04981_ _05036_ _05038_ _05094_ VGND VGND VPWR VPWR _05095_ sky130_fd_sc_hd__a311oi_4
XFILLER_0_139_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12775_ _04950_ _04953_ _04951_ VGND VGND VPWR VPWR _05022_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_96_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11726_ _03804_ _03802_ VGND VGND VPWR VPWR _03881_ sky130_fd_sc_hd__and2b_1
X_14514_ _06915_ _06916_ _01926_ VGND VGND VPWR VPWR _06917_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_71_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11657_ _03797_ _03805_ VGND VGND VPWR VPWR _03806_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14445_ _06839_ _06840_ _06747_ _06841_ VGND VGND VPWR VPWR _06843_ sky130_fd_sc_hd__a211o_1
XFILLER_0_141_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11588_ _03725_ _03729_ VGND VGND VPWR VPWR _03730_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_101_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10608_ _02638_ _02639_ _02661_ VGND VGND VPWR VPWR _02662_ sky130_fd_sc_hd__o21ai_1
X_14376_ _06765_ _06767_ VGND VGND VPWR VPWR _06768_ sky130_fd_sc_hd__or2_1
X_10539_ _02401_ _02585_ _02586_ VGND VGND VPWR VPWR _02587_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_3_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13327_ _05621_ _05616_ _05617_ VGND VGND VPWR VPWR _05625_ sky130_fd_sc_hd__and3_1
XFILLER_0_101_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_23_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13258_ net561 net365 VGND VGND VPWR VPWR _05549_ sky130_fd_sc_hd__nand2_1
X_12209_ _04404_ _04405_ _04397_ VGND VGND VPWR VPWR _04407_ sky130_fd_sc_hd__a21o_1
XFILLER_0_86_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13189_ _05471_ _05472_ VGND VGND VPWR VPWR _05473_ sky130_fd_sc_hd__nor2_1
X_07750_ _06157_ _06113_ _06146_ VGND VGND VPWR VPWR _06364_ sky130_fd_sc_hd__nand3_2
XFILLER_0_126_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07681_ net208 net538 net547 net199 VGND VGND VPWR VPWR _05611_ sky130_fd_sc_hd__a22o_1
X_09420_ _01382_ _01387_ _01381_ VGND VGND VPWR VPWR _01421_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_32_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09351_ a_sin\[15\] b_cos\[15\] VGND VGND VPWR VPWR _01356_ sky130_fd_sc_hd__and2b_1
X_08302_ _00334_ _00352_ VGND VGND VPWR VPWR _00353_ sky130_fd_sc_hd__xnor2_2
X_09282_ net106 _01296_ state VGND VGND VPWR VPWR _01297_ sky130_fd_sc_hd__mux2_1
XFILLER_0_142_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08233_ _00283_ _00284_ VGND VGND VPWR VPWR _00285_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08164_ _00214_ _00215_ _07348_ _00120_ VGND VGND VPWR VPWR _00217_ sky130_fd_sc_hd__a211o_1
X_08095_ net247 net549 net567 net239 VGND VGND VPWR VPWR _00148_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_30_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_41_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08997_ _00991_ _00993_ _00984_ VGND VGND VPWR VPWR _01038_ sky130_fd_sc_hd__o21ai_1
X_07948_ _07161_ _07162_ VGND VGND VPWR VPWR _07243_ sky130_fd_sc_hd__nand2_1
X_07879_ net310 net597 net606 net232 VGND VGND VPWR VPWR _07175_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_97_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_50_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10890_ _02965_ _02967_ VGND VGND VPWR VPWR _02968_ sky130_fd_sc_hd__or2_1
X_09618_ _01603_ _01604_ _01617_ VGND VGND VPWR VPWR _01619_ sky130_fd_sc_hd__nand3_2
XFILLER_0_78_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09549_ _01547_ _01548_ _01533_ VGND VGND VPWR VPWR _01550_ sky130_fd_sc_hd__a21o_1
XFILLER_0_65_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12560_ _04732_ _04786_ _04787_ VGND VGND VPWR VPWR _04788_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_65_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11511_ _03643_ _03644_ VGND VGND VPWR VPWR _03645_ sky130_fd_sc_hd__nor2_1
X_12491_ net377 net286 net268 net464 VGND VGND VPWR VPWR _04713_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_108_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11442_ _03381_ _03382_ _03397_ VGND VGND VPWR VPWR _03569_ sky130_fd_sc_hd__nand3_1
XFILLER_0_80_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14230_ _06607_ _06608_ VGND VGND VPWR VPWR _06609_ sky130_fd_sc_hd__or2_1
X_11373_ _03492_ _03471_ _03490_ VGND VGND VPWR VPWR _03493_ sky130_fd_sc_hd__a21bo_1
X_14161_ _06487_ _06532_ _06533_ VGND VGND VPWR VPWR _06534_ sky130_fd_sc_hd__or3_1
XFILLER_0_21_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10324_ net271 net362 net352 net372 VGND VGND VPWR VPWR _02352_ sky130_fd_sc_hd__a22o_1
X_13112_ _05384_ _05387_ VGND VGND VPWR VPWR _05388_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_21_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14092_ _06457_ _06458_ VGND VGND VPWR VPWR _06459_ sky130_fd_sc_hd__nand2_1
X_13043_ _05304_ _05305_ _05310_ VGND VGND VPWR VPWR _05312_ sky130_fd_sc_hd__a21o_1
X_10255_ net490 net413 net139 VGND VGND VPWR VPWR _02278_ sky130_fd_sc_hd__a21bo_1
X_10186_ _02199_ _02200_ _02055_ _02082_ VGND VGND VPWR VPWR _02203_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_56_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout290 net294 VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__clkbuf_4
X_13945_ _06295_ _06297_ VGND VGND VPWR VPWR _06299_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_88_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13876_ net603 net360 net350 net612 VGND VGND VPWR VPWR _06224_ sky130_fd_sc_hd__a22o_1
X_12827_ _05076_ _05077_ VGND VGND VPWR VPWR _05078_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12758_ _04859_ _05002_ VGND VGND VPWR VPWR _05003_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_17_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12689_ _04926_ _04927_ VGND VGND VPWR VPWR _04928_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_112_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11709_ _03777_ _03860_ _03862_ VGND VGND VPWR VPWR _03863_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_72_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14428_ net641 net417 VGND VGND VPWR VPWR _06824_ sky130_fd_sc_hd__and2b_1
XFILLER_0_142_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14359_ _06656_ VGND VGND VPWR VPWR _06749_ sky130_fd_sc_hd__inv_2
XFILLER_0_24_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08920_ _00938_ _00962_ VGND VGND VPWR VPWR _00963_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08851_ _00893_ _00894_ VGND VGND VPWR VPWR _00895_ sky130_fd_sc_hd__xor2_1
X_07802_ net305 net226 VGND VGND VPWR VPWR _06928_ sky130_fd_sc_hd__and2_2
X_08782_ _00729_ _00730_ _00746_ _00747_ VGND VGND VPWR VPWR _00827_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_46_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07733_ _05644_ _05578_ _05633_ VGND VGND VPWR VPWR _06178_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07664_ _05172_ _05413_ VGND VGND VPWR VPWR _05424_ sky130_fd_sc_hd__nor2_1
XFILLER_0_95_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09403_ _01388_ _01402_ _01403_ VGND VGND VPWR VPWR _01404_ sky130_fd_sc_hd__nand3_2
X_07595_ _04576_ _04641_ _04663_ VGND VGND VPWR VPWR _04674_ sky130_fd_sc_hd__a21oi_2
X_09334_ _01341_ VGND VGND VPWR VPWR _00048_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09265_ b_cos\[2\] _01281_ _01266_ _01270_ _01269_ VGND VGND VPWR VPWR _01282_ sky130_fd_sc_hd__a221o_1
XFILLER_0_35_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08216_ _00171_ _00173_ _00172_ VGND VGND VPWR VPWR _00268_ sky130_fd_sc_hd__a21bo_1
X_09196_ _01222_ _01223_ VGND VGND VPWR VPWR _01224_ sky130_fd_sc_hd__xor2_1
XFILLER_0_133_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08147_ _07338_ _07339_ _07340_ VGND VGND VPWR VPWR _00200_ sky130_fd_sc_hd__o21bai_1
X_08078_ _07217_ _00130_ _00131_ VGND VGND VPWR VPWR _00132_ sky130_fd_sc_hd__and3_1
XFILLER_0_31_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10040_ _02040_ _02041_ _02042_ VGND VGND VPWR VPWR _02043_ sky130_fd_sc_hd__or3_1
Xhold32 a_sin\[1\] VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 b_sin\[13\] VGND VGND VPWR VPWR net788 sky130_fd_sc_hd__dlygate4sd3_1
X_11991_ _04167_ _04168_ VGND VGND VPWR VPWR _04169_ sky130_fd_sc_hd__nor2_1
XFILLER_0_97_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10942_ _03023_ _02964_ VGND VGND VPWR VPWR _03024_ sky130_fd_sc_hd__nor2_1
X_13730_ _06062_ _06063_ _06064_ VGND VGND VPWR VPWR _06065_ sky130_fd_sc_hd__nand3_1
XFILLER_0_97_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10873_ _02947_ _02948_ VGND VGND VPWR VPWR _02949_ sky130_fd_sc_hd__xor2_1
XFILLER_0_39_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13661_ _05989_ _05893_ VGND VGND VPWR VPWR _05990_ sky130_fd_sc_hd__nand2_1
X_12612_ _04842_ _04843_ _04767_ _04783_ VGND VGND VPWR VPWR _04845_ sky130_fd_sc_hd__a211o_1
XFILLER_0_39_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13592_ net394 _05912_ _05913_ VGND VGND VPWR VPWR _05914_ sky130_fd_sc_hd__a21bo_1
X_12543_ _04746_ _04747_ _04769_ VGND VGND VPWR VPWR _04770_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_93_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12474_ _04604_ _04606_ VGND VGND VPWR VPWR _04695_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14213_ _06588_ _06589_ VGND VGND VPWR VPWR _06590_ sky130_fd_sc_hd__or2_1
X_11425_ _03548_ _03547_ _03516_ _03546_ VGND VGND VPWR VPWR _03551_ sky130_fd_sc_hd__a211o_1
XANTENNA_7 net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11356_ _03469_ _03470_ _03474_ VGND VGND VPWR VPWR _03475_ sky130_fd_sc_hd__a21o_1
XFILLER_0_61_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14144_ net604 net342 _06433_ _06432_ VGND VGND VPWR VPWR _06515_ sky130_fd_sc_hd__a31o_1
X_10307_ net693 net440 VGND VGND VPWR VPWR _02334_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14075_ _06438_ _06439_ VGND VGND VPWR VPWR _06441_ sky130_fd_sc_hd__and2_1
X_11287_ _03381_ _03382_ _03397_ VGND VGND VPWR VPWR _03399_ sky130_fd_sc_hd__and3_1
X_13026_ _05271_ _05272_ _05293_ VGND VGND VPWR VPWR _05294_ sky130_fd_sc_hd__nor3_1
X_10238_ _02241_ _02258_ VGND VGND VPWR VPWR _02259_ sky130_fd_sc_hd__xnor2_2
X_10169_ net133 _01897_ _02182_ _02183_ VGND VGND VPWR VPWR _02184_ sky130_fd_sc_hd__nand4_1
XFILLER_0_107_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer19 _06494_ VGND VGND VPWR VPWR net764 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13928_ _06193_ _06195_ VGND VGND VPWR VPWR _06280_ sky130_fd_sc_hd__or2_1
XFILLER_0_107_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13859_ net520 net437 VGND VGND VPWR VPWR _06205_ sky130_fd_sc_hd__nand2_1
XFILLER_0_123_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07380_ net211 net202 net497 net804 VGND VGND VPWR VPWR _02331_ sky130_fd_sc_hd__and4_1
XFILLER_0_57_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09050_ _00868_ _01089_ VGND VGND VPWR VPWR _01090_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_84_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08001_ net662 net236 VGND VGND VPWR VPWR _07295_ sky130_fd_sc_hd__and2b_1
XFILLER_0_4_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09952_ net701 net467 VGND VGND VPWR VPWR _01952_ sky130_fd_sc_hd__nand2_1
X_08903_ net237 _00945_ VGND VGND VPWR VPWR _00946_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09883_ _01867_ _01882_ _01883_ VGND VGND VPWR VPWR _01884_ sky130_fd_sc_hd__nand3_1
X_08834_ net154 net301 net581 VGND VGND VPWR VPWR _00878_ sky130_fd_sc_hd__o21a_1
X_08765_ _00808_ _00809_ VGND VGND VPWR VPWR _00810_ sky130_fd_sc_hd__nor2_1
X_07716_ net208 net547 net565 net199 VGND VGND VPWR VPWR _05993_ sky130_fd_sc_hd__a22o_1
X_08696_ _00740_ _00741_ VGND VGND VPWR VPWR _00742_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_73_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07647_ net306 net226 net514 net522 VGND VGND VPWR VPWR _05237_ sky130_fd_sc_hd__nand4_2
XFILLER_0_48_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07578_ _04467_ _04478_ VGND VGND VPWR VPWR _04489_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09317_ net796 _01326_ VGND VGND VPWR VPWR _01327_ sky130_fd_sc_hd__nor2_1
XFILLER_0_63_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09248_ b_cos\[0\] _01267_ net796 VGND VGND VPWR VPWR _01268_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_63_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09179_ a_cos\[8\] b_sin\[8\] VGND VGND VPWR VPWR _01209_ sky130_fd_sc_hd__nand2_1
X_11210_ net221 net677 _03309_ _03311_ VGND VGND VPWR VPWR _03314_ sky130_fd_sc_hd__a22o_1
X_12190_ _04280_ _04283_ _04281_ VGND VGND VPWR VPWR _04386_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_120_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11141_ _02923_ _03173_ _03164_ VGND VGND VPWR VPWR _03239_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput88 net88 VGND VGND VPWR VPWR D[5] sky130_fd_sc_hd__clkbuf_4
Xoutput99 net99 VGND VGND VPWR VPWR Q[15] sky130_fd_sc_hd__buf_2
Xoutput77 net77 VGND VGND VPWR VPWR D[11] sky130_fd_sc_hd__clkbuf_4
X_11072_ _02922_ VGND VGND VPWR VPWR _03164_ sky130_fd_sc_hd__inv_2
X_10023_ net459 net369 net362 net553 VGND VGND VPWR VPWR _02025_ sky130_fd_sc_hd__a22o_1
X_11974_ _04149_ _04150_ VGND VGND VPWR VPWR _04151_ sky130_fd_sc_hd__or2_1
XFILLER_0_86_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14762_ clknet_3_1_0_clk _00063_ net319 VGND VGND VPWR VPWR a_cos\[8\] sky130_fd_sc_hd__dfrtp_1
X_10925_ _02924_ _02946_ _02922_ VGND VGND VPWR VPWR _03006_ sky130_fd_sc_hd__o21ai_1
X_13713_ _06044_ _06045_ VGND VGND VPWR VPWR _06046_ sky130_fd_sc_hd__xor2_2
X_14693_ _07083_ _07109_ VGND VGND VPWR VPWR _07110_ sky130_fd_sc_hd__xnor2_1
X_10856_ net186 net272 net457 net448 VGND VGND VPWR VPWR _02931_ sky130_fd_sc_hd__and4_1
X_13644_ _05820_ _05966_ _05970_ VGND VGND VPWR VPWR _05971_ sky130_fd_sc_hd__or3_1
XFILLER_0_109_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13575_ _01926_ _05894_ _05895_ VGND VGND VPWR VPWR _00092_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_54_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10787_ _02781_ _02789_ VGND VGND VPWR VPWR _02856_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12526_ net654 net251 net243 net671 VGND VGND VPWR VPWR _04752_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_109_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12457_ _04670_ _04676_ VGND VGND VPWR VPWR _04677_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_124_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11408_ _03496_ _03494_ VGND VGND VPWR VPWR _03532_ sky130_fd_sc_hd__and2b_1
XFILLER_0_78_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12388_ _04556_ _04600_ _04601_ VGND VGND VPWR VPWR _04602_ sky130_fd_sc_hd__or3_1
X_14127_ net604 net333 net478 net615 VGND VGND VPWR VPWR _06497_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_120_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11339_ net305 net703 net711 net227 VGND VGND VPWR VPWR _03456_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14058_ _06239_ _06337_ _06340_ _06242_ VGND VGND VPWR VPWR _06422_ sky130_fd_sc_hd__a31o_1
XFILLER_0_94_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13009_ _05273_ _05274_ net658 net467 VGND VGND VPWR VPWR _05275_ sky130_fd_sc_hd__and4bb_1
X_08550_ _00596_ _00597_ VGND VGND VPWR VPWR _00598_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_6_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08481_ _00528_ _00529_ VGND VGND VPWR VPWR _00530_ sky130_fd_sc_hd__nand2_1
X_07501_ net288 net568 _03113_ _03103_ VGND VGND VPWR VPWR _03649_ sky130_fd_sc_hd__a31o_1
XFILLER_0_76_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07432_ _02397_ _02560_ net803 _02875_ VGND VGND VPWR VPWR _02897_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_64_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07363_ _02081_ _02092_ _02135_ VGND VGND VPWR VPWR _02146_ sky130_fd_sc_hd__a21o_1
X_09102_ net598 net237 VGND VGND VPWR VPWR _01141_ sky130_fd_sc_hd__or2b_1
XFILLER_0_57_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09033_ _00956_ _01022_ VGND VGND VPWR VPWR _01074_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09935_ _01598_ _01934_ VGND VGND VPWR VPWR _01935_ sky130_fd_sc_hd__or2_1
X_09866_ net733 net740 net390 net382 VGND VGND VPWR VPWR _01867_ sky130_fd_sc_hd__and4_1
X_08817_ _00825_ VGND VGND VPWR VPWR _00861_ sky130_fd_sc_hd__inv_2
X_09797_ net740 net331 _01795_ _01796_ VGND VGND VPWR VPWR _01798_ sky130_fd_sc_hd__a211oi_1
X_08748_ _00724_ _00793_ VGND VGND VPWR VPWR _00794_ sky130_fd_sc_hd__xnor2_1
X_08679_ _00651_ _00711_ _00712_ VGND VGND VPWR VPWR _00725_ sky130_fd_sc_hd__nor3_1
XFILLER_0_95_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10710_ _02699_ _02698_ VGND VGND VPWR VPWR _02772_ sky130_fd_sc_hd__and2b_1
X_11690_ _03839_ _03840_ _03841_ VGND VGND VPWR VPWR _03842_ sky130_fd_sc_hd__nand3_4
XFILLER_0_82_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10641_ net373 net471 VGND VGND VPWR VPWR _02697_ sky130_fd_sc_hd__nand2_1
XFILLER_0_91_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10572_ net554 net649 net455 net447 VGND VGND VPWR VPWR _02622_ sky130_fd_sc_hd__and4_1
X_13360_ _05620_ _05619_ _05618_ VGND VGND VPWR VPWR _05661_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_24_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12311_ _04516_ _04517_ VGND VGND VPWR VPWR _04518_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13291_ net561 net388 net379 net569 VGND VGND VPWR VPWR _05585_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_134_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12242_ _04442_ VGND VGND VPWR VPWR _00079_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12173_ _04255_ _04261_ VGND VGND VPWR VPWR _04367_ sky130_fd_sc_hd__and2b_1
X_11124_ _03177_ _03203_ _03176_ VGND VGND VPWR VPWR _03220_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_101_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11055_ _03129_ _03145_ VGND VGND VPWR VPWR _03147_ sky130_fd_sc_hd__xnor2_1
X_10006_ _01930_ _01660_ _02005_ _02007_ VGND VGND VPWR VPWR _02008_ sky130_fd_sc_hd__o211ai_4
X_11957_ _04125_ _04131_ _04132_ VGND VGND VPWR VPWR _04133_ sky130_fd_sc_hd__nand3_1
X_14745_ clknet_3_6_0_clk _00046_ net323 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_129_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10908_ _02987_ VGND VGND VPWR VPWR _00067_ sky130_fd_sc_hd__clkbuf_1
X_11888_ _03959_ _04052_ VGND VGND VPWR VPWR _04057_ sky130_fd_sc_hd__and2_2
XFILLER_0_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14676_ _07089_ _07091_ VGND VGND VPWR VPWR _07092_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_104_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10839_ _02911_ _02912_ VGND VGND VPWR VPWR _02913_ sky130_fd_sc_hd__or2_1
X_13627_ _05949_ _05951_ _05942_ VGND VGND VPWR VPWR _05953_ sky130_fd_sc_hd__a21o_1
XFILLER_0_13_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13558_ _05837_ _05838_ _05875_ _05876_ VGND VGND VPWR VPWR _05878_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_140_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12509_ net162 net136 VGND VGND VPWR VPWR _04733_ sky130_fd_sc_hd__nand2_2
XPHY_EDGE_ROW_132_Right_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13489_ net572 net437 _05727_ _05726_ VGND VGND VPWR VPWR _05802_ sky130_fd_sc_hd__a31o_1
XFILLER_0_2_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07981_ _07240_ _07241_ _07274_ _07275_ VGND VGND VPWR VPWR _07276_ sky130_fd_sc_hd__and4_2
XFILLER_0_1_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09720_ _01719_ _01720_ net716 net366 VGND VGND VPWR VPWR _01721_ sky130_fd_sc_hd__and4bb_1
X_09651_ _01633_ _01650_ _01651_ VGND VGND VPWR VPWR _01652_ sky130_fd_sc_hd__and3_1
X_08602_ _00563_ _00646_ _00648_ VGND VGND VPWR VPWR _00649_ sky130_fd_sc_hd__o21a_1
X_09582_ _01564_ _01565_ _01581_ _01582_ VGND VGND VPWR VPWR _01583_ sky130_fd_sc_hd__o211ai_2
X_08533_ _00579_ _00580_ VGND VGND VPWR VPWR _00581_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08464_ net283 net265 net644 net499 VGND VGND VPWR VPWR _00513_ sky130_fd_sc_hd__and4_1
XFILLER_0_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07415_ _02669_ _02701_ VGND VGND VPWR VPWR _02712_ sky130_fd_sc_hd__xnor2_2
X_08395_ _00362_ _00363_ _00375_ _00376_ VGND VGND VPWR VPWR _00445_ sky130_fd_sc_hd__or4bb_1
XFILLER_0_92_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09016_ net252 net244 net599 net608 VGND VGND VPWR VPWR _01057_ sky130_fd_sc_hd__and4_1
XFILLER_0_131_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout642 net643 VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__clkbuf_1
X_09918_ _01797_ _01915_ _01802_ VGND VGND VPWR VPWR _01919_ sky130_fd_sc_hd__a21o_1
Xfanout631 net637 VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__clkbuf_4
Xfanout620 net628 VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__clkbuf_4
Xfanout653 net655 VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__clkbuf_4
Xfanout675 net676 VGND VGND VPWR VPWR net675 sky130_fd_sc_hd__clkbuf_4
Xfanout664 net672 VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__clkbuf_4
Xfanout697 net698 VGND VGND VPWR VPWR net697 sky130_fd_sc_hd__buf_2
X_09849_ _01847_ _01848_ _01843_ VGND VGND VPWR VPWR _01850_ sky130_fd_sc_hd__a21oi_1
Xfanout686 net688 VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__clkbuf_4
X_12860_ _05071_ _05112_ VGND VGND VPWR VPWR _05113_ sky130_fd_sc_hd__nand2_1
X_11811_ _03971_ _03972_ VGND VGND VPWR VPWR _03973_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12791_ _05037_ _05038_ VGND VGND VPWR VPWR _05039_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14530_ _06790_ _06933_ VGND VGND VPWR VPWR _06934_ sky130_fd_sc_hd__xnor2_1
X_11742_ _03888_ _03896_ _03897_ VGND VGND VPWR VPWR _03898_ sky130_fd_sc_hd__nand3_1
XFILLER_0_138_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11673_ _03812_ _03822_ VGND VGND VPWR VPWR _03823_ sky130_fd_sc_hd__xor2_2
X_14461_ net605 net438 VGND VGND VPWR VPWR _06859_ sky130_fd_sc_hd__nand2_1
XFILLER_0_138_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14392_ _01926_ _06783_ _06784_ VGND VGND VPWR VPWR _00102_ sky130_fd_sc_hd__a21oi_1
X_10624_ _02677_ _02678_ VGND VGND VPWR VPWR _02679_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_52_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13412_ _05716_ _05717_ VGND VGND VPWR VPWR _05718_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_36_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13343_ _05558_ _05559_ _05565_ VGND VGND VPWR VPWR _05642_ sky130_fd_sc_hd__or3_1
XFILLER_0_122_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10555_ _02533_ _02597_ _02602_ VGND VGND VPWR VPWR _02604_ sky130_fd_sc_hd__nor3_1
XFILLER_0_51_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10486_ _02445_ VGND VGND VPWR VPWR _02529_ sky130_fd_sc_hd__inv_2
X_13274_ _05558_ _05559_ _05565_ VGND VGND VPWR VPWR _05566_ sky130_fd_sc_hd__nor3_1
X_12225_ _04322_ _04324_ VGND VGND VPWR VPWR _04425_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12156_ _04254_ _04269_ VGND VGND VPWR VPWR _04349_ sky130_fd_sc_hd__or2_1
X_11107_ _03201_ _03202_ VGND VGND VPWR VPWR _03203_ sky130_fd_sc_hd__nor2_1
X_12087_ _04207_ _04215_ _04213_ VGND VGND VPWR VPWR _04274_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_75_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11038_ _02858_ _02927_ _03064_ VGND VGND VPWR VPWR _03128_ sky130_fd_sc_hd__o21a_1
XFILLER_0_115_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12989_ _05249_ _05252_ VGND VGND VPWR VPWR _05253_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_96_Left_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14728_ clknet_3_5_0_clk _00029_ net324 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_24_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14659_ _07017_ _07029_ _07073_ VGND VGND VPWR VPWR _07074_ sky130_fd_sc_hd__o21a_1
XFILLER_0_129_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08180_ _00132_ _00133_ _07293_ VGND VGND VPWR VPWR _00233_ sky130_fd_sc_hd__o21a_1
XFILLER_0_55_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07964_ net222 net606 VGND VGND VPWR VPWR _07259_ sky130_fd_sc_hd__nand2_1
X_07895_ _07154_ _07155_ _07188_ _07189_ VGND VGND VPWR VPWR _07191_ sky130_fd_sc_hd__a22o_1
X_09703_ _01700_ _01701_ _01703_ VGND VGND VPWR VPWR _01704_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09634_ net460 net552 net396 net387 VGND VGND VPWR VPWR _01635_ sky130_fd_sc_hd__and4_1
XFILLER_0_78_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09565_ _01492_ _01497_ VGND VGND VPWR VPWR _01566_ sky130_fd_sc_hd__or2b_1
XFILLER_0_81_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08516_ _00560_ _00564_ VGND VGND VPWR VPWR _00565_ sky130_fd_sc_hd__xnor2_1
X_09496_ _01493_ _01496_ VGND VGND VPWR VPWR _01497_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_108_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08447_ net249 net241 net517 net525 VGND VGND VPWR VPWR _00496_ sky130_fd_sc_hd__and4_1
XFILLER_0_136_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08378_ _00426_ _00427_ VGND VGND VPWR VPWR _00428_ sky130_fd_sc_hd__nor2_1
XFILLER_0_61_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10340_ _02366_ _02367_ _02369_ VGND VGND VPWR VPWR _02370_ sky130_fd_sc_hd__nand3_1
X_10271_ _02293_ _02294_ VGND VGND VPWR VPWR _02295_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12010_ _04188_ _04189_ VGND VGND VPWR VPWR _04190_ sky130_fd_sc_hd__nor2_1
Xfanout450 net458 VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__clkbuf_4
Xfanout461 net4 VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__clkbuf_4
Xfanout472 net473 VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__clkbuf_4
X_13961_ _06312_ _06313_ _06314_ VGND VGND VPWR VPWR _06316_ sky130_fd_sc_hd__a21o_1
Xfanout483 net492 VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__clkbuf_4
X_12912_ net253 net138 VGND VGND VPWR VPWR _05169_ sky130_fd_sc_hd__nand2_1
Xfanout494 net496 VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__buf_2
XFILLER_0_88_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13892_ _06237_ _06238_ _06239_ VGND VGND VPWR VPWR _06241_ sky130_fd_sc_hd__a21o_1
X_12843_ _05090_ VGND VGND VPWR VPWR _05094_ sky130_fd_sc_hd__inv_2
XFILLER_0_69_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12774_ _05018_ _05019_ VGND VGND VPWR VPWR _05020_ sky130_fd_sc_hd__or2_1
XFILLER_0_84_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11725_ _03877_ _03878_ VGND VGND VPWR VPWR _03880_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14513_ _06912_ _06914_ _06909_ VGND VGND VPWR VPWR _06916_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_139_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14444_ _06746_ _06747_ _06769_ VGND VGND VPWR VPWR _06841_ sky130_fd_sc_hd__nor3_1
X_11656_ _03802_ _03804_ VGND VGND VPWR VPWR _03805_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_83_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11587_ _03727_ _03728_ VGND VGND VPWR VPWR _03729_ sky130_fd_sc_hd__nor2_1
XFILLER_0_107_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10607_ _02659_ _02660_ VGND VGND VPWR VPWR _02661_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14375_ _06749_ _06659_ _06764_ VGND VGND VPWR VPWR _06767_ sky130_fd_sc_hd__o21a_1
XFILLER_0_101_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10538_ _02500_ _02496_ _02497_ VGND VGND VPWR VPWR _02586_ sky130_fd_sc_hd__a21bo_1
X_13326_ _05584_ _05586_ VGND VGND VPWR VPWR _05624_ sky130_fd_sc_hd__xor2_1
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13257_ _05541_ _05542_ _05547_ VGND VGND VPWR VPWR _05548_ sky130_fd_sc_hd__a21o_1
X_12208_ _04397_ _04404_ _04405_ VGND VGND VPWR VPWR _04406_ sky130_fd_sc_hd__nand3_1
XFILLER_0_122_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10469_ _02431_ _02452_ _02449_ VGND VGND VPWR VPWR _02510_ sky130_fd_sc_hd__o21ai_1
X_13188_ _05466_ _05467_ _05470_ VGND VGND VPWR VPWR _05472_ sky130_fd_sc_hd__and3_1
X_12139_ _04272_ _04330_ VGND VGND VPWR VPWR _04331_ sky130_fd_sc_hd__xor2_2
XFILLER_0_19_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07680_ net208 net199 net538 net547 VGND VGND VPWR VPWR _05600_ sky130_fd_sc_hd__and4_1
X_09350_ _01347_ _01348_ _01351_ VGND VGND VPWR VPWR _01355_ sky130_fd_sc_hd__and3_1
X_08301_ _00335_ _00351_ VGND VGND VPWR VPWR _00352_ sky130_fd_sc_hd__xnor2_1
X_09281_ _01294_ _01295_ VGND VGND VPWR VPWR _01296_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08232_ _00281_ _00282_ _00278_ VGND VGND VPWR VPWR _00284_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_75_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08163_ _07348_ _00120_ _00214_ _00215_ VGND VGND VPWR VPWR _00216_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_42_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08094_ _07313_ _07315_ VGND VGND VPWR VPWR _00147_ sky130_fd_sc_hd__or2_1
XFILLER_0_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08996_ _00864_ VGND VGND VPWR VPWR _01037_ sky130_fd_sc_hd__inv_2
X_07947_ _07167_ _07184_ _07185_ VGND VGND VPWR VPWR _07242_ sky130_fd_sc_hd__nand3_2
X_07878_ net310 net232 net597 net606 VGND VGND VPWR VPWR _07174_ sky130_fd_sc_hd__and4_1
XFILLER_0_98_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09617_ _01603_ _01604_ _01617_ VGND VGND VPWR VPWR _01618_ sky130_fd_sc_hd__a21o_1
X_09548_ _01533_ _01547_ _01548_ VGND VGND VPWR VPWR _01549_ sky130_fd_sc_hd__nand3_4
XFILLER_0_93_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11510_ net212 net651 net668 net203 VGND VGND VPWR VPWR _03644_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_108_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09479_ _01474_ _01478_ _01479_ VGND VGND VPWR VPWR _01480_ sky130_fd_sc_hd__nand3_1
XFILLER_0_136_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12490_ _04647_ net800 VGND VGND VPWR VPWR _04712_ sky130_fd_sc_hd__nand2_1
XFILLER_0_124_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11441_ _03556_ _03562_ _03565_ _03566_ _03567_ VGND VGND VPWR VPWR _03568_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_80_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11372_ _03472_ VGND VGND VPWR VPWR _03492_ sky130_fd_sc_hd__inv_2
X_14160_ _06530_ _06531_ _06441_ _06488_ VGND VGND VPWR VPWR _06533_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_33_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13111_ _05385_ _05386_ VGND VGND VPWR VPWR _05387_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10323_ _02272_ _02274_ _02273_ VGND VGND VPWR VPWR _02351_ sky130_fd_sc_hd__a21bo_1
X_14091_ _06367_ _06363_ _06365_ VGND VGND VPWR VPWR _06458_ sky130_fd_sc_hd__a21bo_1
X_13042_ _05304_ _05305_ _05310_ VGND VGND VPWR VPWR _05311_ sky130_fd_sc_hd__nand3_1
X_10254_ _02272_ _02273_ _02274_ VGND VGND VPWR VPWR _02276_ sky130_fd_sc_hd__nand3_1
X_10185_ _02055_ _02082_ _02199_ _02200_ VGND VGND VPWR VPWR _02202_ sky130_fd_sc_hd__o211a_1
Xfanout291 net294 VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__buf_2
Xfanout280 net287 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__buf_2
XFILLER_0_89_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13944_ _06296_ _06192_ VGND VGND VPWR VPWR _06297_ sky130_fd_sc_hd__nor2_1
XFILLER_0_88_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13875_ _06147_ _06149_ _06148_ VGND VGND VPWR VPWR _06223_ sky130_fd_sc_hd__a21bo_1
X_12826_ _05062_ _05019_ _05074_ VGND VGND VPWR VPWR _05077_ sky130_fd_sc_hd__or3b_1
XFILLER_0_69_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12757_ _04991_ _05001_ VGND VGND VPWR VPWR _05002_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_84_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12688_ net276 net259 VGND VGND VPWR VPWR _04927_ sky130_fd_sc_hd__nand2_1
X_11708_ _03777_ _03861_ VGND VGND VPWR VPWR _03862_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11639_ _03757_ _03760_ _03784_ VGND VGND VPWR VPWR _03786_ sky130_fd_sc_hd__and3_1
X_14427_ _06821_ _06822_ VGND VGND VPWR VPWR _06823_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14358_ _06689_ _06692_ VGND VGND VPWR VPWR _06748_ sky130_fd_sc_hd__or2_1
XFILLER_0_141_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13309_ _05598_ _05599_ _05604_ VGND VGND VPWR VPWR _05605_ sky130_fd_sc_hd__a21o_1
X_14289_ _06671_ _06672_ VGND VGND VPWR VPWR _06673_ sky130_fd_sc_hd__and2_1
XFILLER_0_122_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08850_ net645 net237 VGND VGND VPWR VPWR _00894_ sky130_fd_sc_hd__and2b_1
X_07801_ _06842_ _06874_ _06907_ VGND VGND VPWR VPWR _06918_ sky130_fd_sc_hd__o21ai_1
X_08781_ _00776_ _00779_ VGND VGND VPWR VPWR _00826_ sky130_fd_sc_hd__or2_1
XFILLER_0_137_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07732_ net772 _06146_ _06157_ VGND VGND VPWR VPWR _06168_ sky130_fd_sc_hd__a21bo_1
X_07663_ _05064_ _05140_ _05161_ VGND VGND VPWR VPWR _05413_ sky130_fd_sc_hd__and3_1
XFILLER_0_79_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09402_ _01381_ _01382_ _01387_ VGND VGND VPWR VPWR _01403_ sky130_fd_sc_hd__a21o_1
XFILLER_0_137_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07594_ _03977_ _04652_ VGND VGND VPWR VPWR _04663_ sky130_fd_sc_hd__or2_1
X_09333_ net96 _01340_ net129 VGND VGND VPWR VPWR _01341_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09264_ a_sin\[2\] VGND VGND VPWR VPWR _01281_ sky130_fd_sc_hd__inv_2
X_08215_ _00263_ _00264_ _00265_ VGND VGND VPWR VPWR _00267_ sky130_fd_sc_hd__nand3_1
XFILLER_0_90_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09195_ _01214_ _01217_ _01215_ VGND VGND VPWR VPWR _01223_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_63_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08146_ _00195_ _00198_ VGND VGND VPWR VPWR _00199_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_120_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08077_ _00128_ _00129_ _07278_ _07280_ VGND VGND VPWR VPWR _00131_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_30_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08979_ _01019_ _01020_ VGND VGND VPWR VPWR _01021_ sky130_fd_sc_hd__nor2_1
Xhold33 b_cos\[11\] VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 net101 VGND VGND VPWR VPWR net789 sky130_fd_sc_hd__dlygate4sd3_1
X_11990_ net714 net723 net248 net240 VGND VGND VPWR VPWR _04168_ sky130_fd_sc_hd__and4_1
XFILLER_0_98_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10941_ _02954_ _02959_ VGND VGND VPWR VPWR _03023_ sky130_fd_sc_hd__and2b_1
X_13660_ _05796_ _05798_ _05886_ _05887_ VGND VGND VPWR VPWR _05989_ sky130_fd_sc_hd__o211ai_2
X_12611_ _04767_ _04783_ _04842_ _04843_ VGND VGND VPWR VPWR _04844_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_85_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10872_ _02854_ _02878_ _02851_ VGND VGND VPWR VPWR _02948_ sky130_fd_sc_hd__o21a_1
XFILLER_0_39_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13591_ net593 net402 net394 net602 VGND VGND VPWR VPWR _05913_ sky130_fd_sc_hd__a22o_1
X_12542_ _04748_ _04768_ VGND VGND VPWR VPWR _04769_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12473_ _04692_ _04693_ VGND VGND VPWR VPWR _04694_ sky130_fd_sc_hd__or2b_1
XFILLER_0_108_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11424_ _03546_ _03516_ _03547_ _03548_ VGND VGND VPWR VPWR _03549_ sky130_fd_sc_hd__o211ai_2
X_14212_ _06585_ _06587_ VGND VGND VPWR VPWR _06589_ sky130_fd_sc_hd__and2_1
XFILLER_0_123_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_8 net287 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11355_ net218 net730 _03471_ _03472_ VGND VGND VPWR VPWR _03474_ sky130_fd_sc_hd__a31o_1
XFILLER_0_1_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14143_ _06513_ VGND VGND VPWR VPWR _06514_ sky130_fd_sc_hd__clkbuf_2
X_11286_ _03381_ _03382_ _03397_ VGND VGND VPWR VPWR _03398_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_104_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10306_ _02330_ _02332_ VGND VGND VPWR VPWR _02333_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14074_ _06345_ _06347_ VGND VGND VPWR VPWR _06439_ sky130_fd_sc_hd__or2_1
X_10237_ _02247_ _02257_ VGND VGND VPWR VPWR _02258_ sky130_fd_sc_hd__xor2_2
X_13025_ _05279_ _05291_ VGND VGND VPWR VPWR _05293_ sky130_fd_sc_hd__xnor2_1
X_10168_ net139 net403 VGND VGND VPWR VPWR _02183_ sky130_fd_sc_hd__nand2_1
XFILLER_0_83_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10099_ _02105_ VGND VGND VPWR VPWR _02108_ sky130_fd_sc_hd__inv_2
XFILLER_0_89_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13927_ _06179_ _06197_ _06278_ VGND VGND VPWR VPWR _06279_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_88_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13858_ _06202_ _06203_ VGND VGND VPWR VPWR _06204_ sky130_fd_sc_hd__nor2_1
X_12809_ _05056_ _05057_ VGND VGND VPWR VPWR _05058_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13789_ _06126_ _06127_ _06128_ VGND VGND VPWR VPWR _06129_ sky130_fd_sc_hd__nand3_1
XFILLER_0_44_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08000_ _07238_ _07240_ VGND VGND VPWR VPWR _07294_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09951_ _01949_ _01950_ VGND VGND VPWR VPWR _01951_ sky130_fd_sc_hd__xor2_1
XFILLER_0_110_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08902_ net635 VGND VGND VPWR VPWR _00945_ sky130_fd_sc_hd__inv_2
X_09882_ _01868_ _01869_ _01881_ VGND VGND VPWR VPWR _01883_ sky130_fd_sc_hd__a21o_1
X_08833_ net154 net301 net581 VGND VGND VPWR VPWR _00877_ sky130_fd_sc_hd__and3_1
X_08764_ _00806_ _00807_ net292 net598 VGND VGND VPWR VPWR _00809_ sky130_fd_sc_hd__and4bb_1
X_07715_ _05710_ _05972_ VGND VGND VPWR VPWR _05983_ sky130_fd_sc_hd__or2_1
X_08695_ net292 net607 VGND VGND VPWR VPWR _00741_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07646_ net306 net514 net522 net226 VGND VGND VPWR VPWR _05226_ sky130_fd_sc_hd__a22o_1
XFILLER_0_94_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07577_ _03923_ _03934_ _04456_ VGND VGND VPWR VPWR _04478_ sky130_fd_sc_hd__a21o_1
XFILLER_0_75_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09316_ _01322_ _01323_ _01324_ VGND VGND VPWR VPWR _01326_ sky130_fd_sc_hd__and3_1
XFILLER_0_36_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09247_ a_sin\[0\] VGND VGND VPWR VPWR _01267_ sky130_fd_sc_hd__inv_2
XFILLER_0_90_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09178_ a_cos\[8\] b_sin\[8\] VGND VGND VPWR VPWR _01208_ sky130_fd_sc_hd__nor2_1
X_08129_ _00179_ _00180_ _00165_ VGND VGND VPWR VPWR _00182_ sky130_fd_sc_hd__a21oi_2
X_11140_ _03236_ _03237_ VGND VGND VPWR VPWR _03238_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_101_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput89 net89 VGND VGND VPWR VPWR D[6] sky130_fd_sc_hd__clkbuf_4
Xoutput78 net78 VGND VGND VPWR VPWR D[12] sky130_fd_sc_hd__buf_2
X_11071_ _03152_ _03153_ VGND VGND VPWR VPWR _03163_ sky130_fd_sc_hd__and2b_1
X_10022_ _01978_ _01980_ _01979_ net396 VGND VGND VPWR VPWR _02024_ sky130_fd_sc_hd__a22o_1
XFILLER_0_98_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11973_ _04147_ _04148_ _04042_ _04065_ VGND VGND VPWR VPWR _04150_ sky130_fd_sc_hd__o211a_1
X_14761_ clknet_3_1_0_clk _00062_ net319 VGND VGND VPWR VPWR a_cos\[7\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_113_Right_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10924_ _03002_ _03003_ VGND VGND VPWR VPWR _03004_ sky130_fd_sc_hd__and2_1
X_13712_ net640 net343 VGND VGND VPWR VPWR _06045_ sky130_fd_sc_hd__nand2_1
X_14692_ _07084_ _07108_ VGND VGND VPWR VPWR _07109_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_129_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10855_ net186 net457 net448 net272 VGND VGND VPWR VPWR _02930_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_39_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13643_ _05804_ _05969_ VGND VGND VPWR VPWR _05970_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_128_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13574_ net785 _02027_ VGND VGND VPWR VPWR _05895_ sky130_fd_sc_hd__nor2_1
X_12525_ _04628_ _04632_ _04629_ VGND VGND VPWR VPWR _04751_ sky130_fd_sc_hd__o21ba_1
X_10786_ _02787_ _02786_ VGND VGND VPWR VPWR _02855_ sky130_fd_sc_hd__and2b_1
XFILLER_0_136_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12456_ _04673_ _04675_ VGND VGND VPWR VPWR _04676_ sky130_fd_sc_hd__xor2_1
XFILLER_0_2_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12387_ _04597_ net119 _04557_ _04558_ VGND VGND VPWR VPWR _04601_ sky130_fd_sc_hd__o211a_1
X_11407_ net219 net736 VGND VGND VPWR VPWR _03531_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11338_ net219 net720 VGND VGND VPWR VPWR _03455_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14126_ _06493_ _06495_ VGND VGND VPWR VPWR _06496_ sky130_fd_sc_hd__xnor2_1
X_11269_ _03365_ _03366_ _03378_ VGND VGND VPWR VPWR _03379_ sky130_fd_sc_hd__a21oi_1
X_14057_ _06419_ _06420_ VGND VGND VPWR VPWR _06421_ sky130_fd_sc_hd__nand2_1
XFILLER_0_118_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13008_ net563 net330 net475 net571 VGND VGND VPWR VPWR _05274_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_118_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07500_ _02766_ _02843_ VGND VGND VPWR VPWR _03638_ sky130_fd_sc_hd__nand2_1
X_08480_ _00526_ _00527_ _00509_ _00510_ VGND VGND VPWR VPWR _00529_ sky130_fd_sc_hd__a211o_1
XFILLER_0_89_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07431_ _02397_ _02560_ _02864_ _02875_ VGND VGND VPWR VPWR _02886_ sky130_fd_sc_hd__a211o_1
X_07362_ _02103_ _02114_ net755 VGND VGND VPWR VPWR _02135_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_43_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09101_ net245 net591 VGND VGND VPWR VPWR _01140_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09032_ _01071_ _01072_ VGND VGND VPWR VPWR _01073_ sky130_fd_sc_hd__and2b_1
XFILLER_0_60_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09934_ net739 net421 VGND VGND VPWR VPWR _01934_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09865_ _01851_ _01861_ _01836_ VGND VGND VPWR VPWR _01866_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_99_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08816_ _00826_ _00843_ VGND VGND VPWR VPWR _00860_ sky130_fd_sc_hd__or2_1
X_09796_ _01795_ _01796_ net740 net331 VGND VGND VPWR VPWR _01797_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_116_Left_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08747_ _00791_ _00792_ VGND VGND VPWR VPWR _00793_ sky130_fd_sc_hd__nor2_1
X_08678_ _00716_ _00720_ VGND VGND VPWR VPWR _00724_ sky130_fd_sc_hd__nor2_1
X_07629_ _05010_ _05021_ _05032_ VGND VGND VPWR VPWR _05043_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_95_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10640_ _02694_ _02695_ VGND VGND VPWR VPWR _02696_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10571_ net554 net454 net447 net649 VGND VGND VPWR VPWR _02621_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_36_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12310_ _04395_ _04421_ _04420_ VGND VGND VPWR VPWR _04517_ sky130_fd_sc_hd__o21bai_1
XPHY_EDGE_ROW_125_Left_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13290_ net657 net365 VGND VGND VPWR VPWR _05584_ sky130_fd_sc_hd__nand2_1
XFILLER_0_133_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12241_ a_sin\[6\] _04441_ _04160_ VGND VGND VPWR VPWR _04442_ sky130_fd_sc_hd__mux2_1
XFILLER_0_133_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12172_ _04364_ _04365_ VGND VGND VPWR VPWR _04366_ sky130_fd_sc_hd__or2_1
XFILLER_0_101_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11123_ _03180_ _03198_ _03202_ VGND VGND VPWR VPWR _03219_ sky130_fd_sc_hd__a21o_1
X_11054_ _03143_ _03144_ VGND VGND VPWR VPWR _03145_ sky130_fd_sc_hd__nand2_1
X_10005_ _02003_ _02004_ _01943_ VGND VGND VPWR VPWR _02007_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_134_Left_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11956_ _04127_ _04129_ _04126_ VGND VGND VPWR VPWR _04132_ sky130_fd_sc_hd__a21o_1
X_14744_ clknet_3_7_0_clk _00045_ net326 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__dfrtp_1
X_10907_ a_cos\[12\] _02986_ _02303_ VGND VGND VPWR VPWR _02987_ sky130_fd_sc_hd__mux2_1
X_11887_ next_state _04053_ _04055_ _04056_ VGND VGND VPWR VPWR _00075_ sky130_fd_sc_hd__a31o_1
XFILLER_0_39_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14675_ _06930_ _07033_ _06922_ VGND VGND VPWR VPWR _07091_ sky130_fd_sc_hd__o21a_1
XFILLER_0_73_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10838_ _02909_ _02910_ _02835_ _02837_ VGND VGND VPWR VPWR _02912_ sky130_fd_sc_hd__o211a_1
X_13626_ _05942_ _05949_ _05951_ VGND VGND VPWR VPWR _05952_ sky130_fd_sc_hd__nand3_1
XFILLER_0_137_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10769_ _02769_ _02770_ _02835_ _02836_ VGND VGND VPWR VPWR _02837_ sky130_fd_sc_hd__o211ai_4
X_13557_ _05837_ _05838_ _05875_ _05876_ VGND VGND VPWR VPWR _05877_ sky130_fd_sc_hd__and4_1
X_12508_ net162 net145 _04649_ _04648_ VGND VGND VPWR VPWR _04732_ sky130_fd_sc_hd__a31o_1
X_13488_ _05716_ _05717_ VGND VGND VPWR VPWR _05801_ sky130_fd_sc_hd__nor2_1
X_12439_ _04580_ VGND VGND VPWR VPWR _04657_ sky130_fd_sc_hd__inv_2
XFILLER_0_2_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07980_ _07272_ _07273_ _07184_ _07242_ VGND VGND VPWR VPWR _07275_ sky130_fd_sc_hd__o211ai_2
X_14109_ _06475_ _06476_ VGND VGND VPWR VPWR _06477_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09650_ _01647_ _01648_ _01649_ VGND VGND VPWR VPWR _01651_ sky130_fd_sc_hd__a21o_1
X_08601_ _00641_ _00638_ _00639_ VGND VGND VPWR VPWR _00648_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_89_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09581_ _01566_ _01567_ _01580_ VGND VGND VPWR VPWR _01582_ sky130_fd_sc_hd__nand3_1
X_08532_ _00513_ _00573_ _00578_ VGND VGND VPWR VPWR _00580_ sky130_fd_sc_hd__o21a_1
XFILLER_0_77_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08463_ net283 net644 net499 net265 VGND VGND VPWR VPWR _00512_ sky130_fd_sc_hd__a22oi_1
X_07414_ _02680_ _02690_ VGND VGND VPWR VPWR _02701_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08394_ _00424_ _00443_ VGND VGND VPWR VPWR _00444_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_116_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09015_ net252 net600 net607 net244 VGND VGND VPWR VPWR _01056_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_60_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09917_ _01711_ _01763_ _01718_ VGND VGND VPWR VPWR _01918_ sky130_fd_sc_hd__and3_1
Xfanout621 net628 VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__clkbuf_4
Xfanout632 net637 VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout610 net24 VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__clkbuf_4
Xfanout654 net655 VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__buf_1
Xfanout643 net646 VGND VGND VPWR VPWR net643 sky130_fd_sc_hd__clkbuf_1
Xfanout676 net681 VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__buf_4
Xfanout665 net672 VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__buf_2
Xfanout687 net688 VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__clkbuf_4
Xfanout698 net15 VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__buf_4
X_09848_ _01843_ _01847_ _01848_ VGND VGND VPWR VPWR _01849_ sky130_fd_sc_hd__and3_1
X_09779_ _01768_ _01773_ _01769_ VGND VGND VPWR VPWR _01780_ sky130_fd_sc_hd__nand3_1
X_11810_ _03885_ _03965_ _03970_ VGND VGND VPWR VPWR _03972_ sky130_fd_sc_hd__o21ai_1
X_12790_ _04983_ _04984_ _05035_ VGND VGND VPWR VPWR _05038_ sky130_fd_sc_hd__nor3_2
X_11741_ _03893_ _03894_ _03895_ VGND VGND VPWR VPWR _03897_ sky130_fd_sc_hd__a21o_1
XFILLER_0_138_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11672_ _03820_ _03821_ VGND VGND VPWR VPWR _03822_ sky130_fd_sc_hd__and2b_1
XFILLER_0_83_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14460_ _06856_ _06857_ VGND VGND VPWR VPWR _06858_ sky130_fd_sc_hd__or2_1
X_14391_ net778 _02027_ VGND VGND VPWR VPWR _06784_ sky130_fd_sc_hd__nor2_1
X_10623_ _02583_ _02587_ _02581_ VGND VGND VPWR VPWR _02678_ sky130_fd_sc_hd__a21boi_1
X_13411_ net659 net427 VGND VGND VPWR VPWR _05717_ sky130_fd_sc_hd__nand2_1
X_10554_ _02600_ _02601_ VGND VGND VPWR VPWR _02602_ sky130_fd_sc_hd__xor2_1
XFILLER_0_51_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13342_ _05558_ _05559_ _05565_ VGND VGND VPWR VPWR _05641_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10485_ _02509_ _02526_ VGND VGND VPWR VPWR _02528_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_32_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13273_ _05560_ _05564_ VGND VGND VPWR VPWR _05565_ sky130_fd_sc_hd__xnor2_1
X_12224_ _04395_ _04422_ VGND VGND VPWR VPWR _04423_ sky130_fd_sc_hd__xnor2_1
X_12155_ _04251_ _04334_ VGND VGND VPWR VPWR _04348_ sky130_fd_sc_hd__and2b_1
XFILLER_0_75_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11106_ _03143_ _03199_ VGND VGND VPWR VPWR _03202_ sky130_fd_sc_hd__nor2_1
XFILLER_0_20_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12086_ _04192_ _04201_ _04200_ VGND VGND VPWR VPWR _04273_ sky130_fd_sc_hd__a21bo_1
X_11037_ _03085_ _03086_ VGND VGND VPWR VPWR _03127_ sky130_fd_sc_hd__or2_1
XFILLER_0_91_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12988_ _05250_ _05251_ VGND VGND VPWR VPWR _05252_ sky130_fd_sc_hd__nor2_1
X_11939_ net462 net180 net170 net559 VGND VGND VPWR VPWR _04113_ sky130_fd_sc_hd__a22o_1
XFILLER_0_115_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14727_ clknet_3_5_0_clk _00028_ net326 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_138_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14658_ _07071_ _07072_ VGND VGND VPWR VPWR _07073_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_131_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13609_ _05899_ _05872_ _05931_ _05932_ VGND VGND VPWR VPWR _05933_ sky130_fd_sc_hd__o211a_2
XFILLER_0_27_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14589_ _06925_ _06927_ _06997_ VGND VGND VPWR VPWR _06998_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_27_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07963_ _07254_ _07257_ VGND VGND VPWR VPWR _07258_ sky130_fd_sc_hd__xnor2_2
X_07894_ _07154_ _07155_ _07188_ _07189_ VGND VGND VPWR VPWR _07190_ sky130_fd_sc_hd__nand4_4
X_09702_ _01458_ _01702_ VGND VGND VPWR VPWR _01703_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09633_ net647 net369 VGND VGND VPWR VPWR _01634_ sky130_fd_sc_hd__nand2_1
X_09564_ _01514_ _01517_ VGND VGND VPWR VPWR _01565_ sky130_fd_sc_hd__nor2_1
X_08515_ _00562_ _00563_ VGND VGND VPWR VPWR _00564_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09495_ _01494_ _01495_ VGND VGND VPWR VPWR _01496_ sky130_fd_sc_hd__nor2_1
XFILLER_0_136_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08446_ net249 net517 net525 net241 VGND VGND VPWR VPWR _00495_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_65_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08377_ net281 net263 net499 net508 VGND VGND VPWR VPWR _00427_ sky130_fd_sc_hd__and4_1
XFILLER_0_18_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10270_ _02141_ _02203_ _02202_ VGND VGND VPWR VPWR _02294_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_14_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout440 net42 VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__buf_4
Xfanout462 net4 VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__clkbuf_2
X_13960_ _06312_ _06313_ _06314_ VGND VGND VPWR VPWR _06315_ sky130_fd_sc_hd__nand3_2
Xfanout484 net492 VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__clkbuf_2
Xfanout473 net39 VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__clkbuf_4
Xfanout451 net458 VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__buf_2
X_12911_ _05166_ _05167_ VGND VGND VPWR VPWR _05168_ sky130_fd_sc_hd__xnor2_1
Xfanout495 net496 VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__clkbuf_4
X_13891_ _06237_ _06238_ _06239_ VGND VGND VPWR VPWR _06240_ sky130_fd_sc_hd__nand3_1
X_12842_ _05093_ VGND VGND VPWR VPWR _00088_ sky130_fd_sc_hd__clkbuf_1
X_12773_ _05016_ _05017_ VGND VGND VPWR VPWR _05019_ sky130_fd_sc_hd__and2_1
XFILLER_0_139_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11724_ _03807_ _03809_ _03876_ VGND VGND VPWR VPWR _03878_ sky130_fd_sc_hd__and3_1
X_14512_ _06909_ _06912_ _06914_ VGND VGND VPWR VPWR _06915_ sky130_fd_sc_hd__and3_1
XFILLER_0_127_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11655_ _03743_ _03745_ _03744_ VGND VGND VPWR VPWR _03804_ sky130_fd_sc_hd__o21ba_1
X_14443_ _06815_ _06838_ VGND VGND VPWR VPWR _06840_ sky130_fd_sc_hd__nand2_1
XFILLER_0_138_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11586_ net178 net168 net678 net685 VGND VGND VPWR VPWR _03728_ sky130_fd_sc_hd__and4_1
XFILLER_0_52_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10606_ _02655_ _02657_ VGND VGND VPWR VPWR _02660_ sky130_fd_sc_hd__or2_1
X_14374_ _06749_ _06659_ _06764_ VGND VGND VPWR VPWR _06765_ sky130_fd_sc_hd__nor3_1
XFILLER_0_24_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10537_ _02395_ _02498_ VGND VGND VPWR VPWR _02585_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13325_ _05616_ _05617_ _05621_ VGND VGND VPWR VPWR _05623_ sky130_fd_sc_hd__a21o_1
X_10468_ _02424_ _02426_ VGND VGND VPWR VPWR _02509_ sky130_fd_sc_hd__or2_1
X_13256_ _05543_ _05544_ _05546_ VGND VGND VPWR VPWR _05547_ sky130_fd_sc_hd__o21bai_1
X_12207_ _04401_ _04403_ _04398_ VGND VGND VPWR VPWR _04405_ sky130_fd_sc_hd__a21o_1
X_10399_ net666 net675 net453 net444 VGND VGND VPWR VPWR _02434_ sky130_fd_sc_hd__and4_1
X_13187_ _05466_ _05467_ _05470_ VGND VGND VPWR VPWR _05471_ sky130_fd_sc_hd__a21oi_1
X_12138_ _04327_ _04329_ VGND VGND VPWR VPWR _04330_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_19_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12069_ _04185_ _04204_ _04253_ VGND VGND VPWR VPWR _04254_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_126_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08300_ _00349_ _00350_ VGND VGND VPWR VPWR _00351_ sky130_fd_sc_hd__or2_1
XFILLER_0_87_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09280_ _01286_ _01289_ _01287_ VGND VGND VPWR VPWR _01295_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_142_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08231_ _00278_ _00281_ _00282_ VGND VGND VPWR VPWR _00283_ sky130_fd_sc_hd__and3_1
XFILLER_0_75_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08162_ _00212_ _00213_ _00194_ VGND VGND VPWR VPWR _00215_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08093_ _07327_ _07329_ VGND VGND VPWR VPWR _00146_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08995_ _01001_ _01023_ VGND VGND VPWR VPWR _01036_ sky130_fd_sc_hd__or2b_1
X_07946_ _07238_ _07239_ _07220_ _07221_ VGND VGND VPWR VPWR _07241_ sky130_fd_sc_hd__a211o_1
XFILLER_0_76_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07877_ net224 net613 VGND VGND VPWR VPWR _07173_ sky130_fd_sc_hd__nand2_1
XFILLER_0_92_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09616_ _01609_ _01616_ VGND VGND VPWR VPWR _01617_ sky130_fd_sc_hd__xnor2_1
X_09547_ _01540_ _01541_ _01546_ VGND VGND VPWR VPWR _01548_ sky130_fd_sc_hd__a21o_1
XFILLER_0_136_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09478_ _01476_ _01477_ _01475_ VGND VGND VPWR VPWR _01479_ sky130_fd_sc_hd__a21o_1
X_08429_ _00405_ _00478_ VGND VGND VPWR VPWR _00479_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_80_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11440_ _03557_ _03559_ VGND VGND VPWR VPWR _03567_ sky130_fd_sc_hd__or2_1
XFILLER_0_33_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11371_ _03472_ _03490_ _03471_ VGND VGND VPWR VPWR _03491_ sky130_fd_sc_hd__or3b_1
XFILLER_0_34_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10322_ _02264_ _02267_ VGND VGND VPWR VPWR _02350_ sky130_fd_sc_hd__nand2_1
X_13110_ net503 net511 net356 net346 VGND VGND VPWR VPWR _05386_ sky130_fd_sc_hd__and4_1
XFILLER_0_21_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14090_ _06268_ _06271_ _06456_ VGND VGND VPWR VPWR _06457_ sky130_fd_sc_hd__a21o_1
X_13041_ _05306_ _05309_ VGND VGND VPWR VPWR _05310_ sky130_fd_sc_hd__xnor2_1
X_10253_ _02272_ _02273_ _02274_ VGND VGND VPWR VPWR _02275_ sky130_fd_sc_hd__a21o_1
X_10184_ _02197_ _02198_ _02164_ VGND VGND VPWR VPWR _02200_ sky130_fd_sc_hd__a21o_1
Xfanout292 net293 VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__buf_2
Xfanout281 net287 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__buf_2
Xfanout270 net278 VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__clkbuf_4
X_13943_ _06182_ _06187_ VGND VGND VPWR VPWR _06296_ sky130_fd_sc_hd__and2b_1
XFILLER_0_72_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13874_ _06139_ _06141_ VGND VGND VPWR VPWR _06221_ sky130_fd_sc_hd__nand2_1
X_12825_ _05062_ _05019_ _05074_ VGND VGND VPWR VPWR _05076_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_84_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12756_ _04863_ _05000_ VGND VGND VPWR VPWR _05001_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_29_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12687_ _04924_ _04925_ VGND VGND VPWR VPWR _04926_ sky130_fd_sc_hd__nor2_1
X_11707_ _03773_ _03860_ VGND VGND VPWR VPWR _03861_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_21_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11638_ _03757_ _03760_ _03784_ VGND VGND VPWR VPWR _03785_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_112_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14426_ net623 net632 net431 net423 VGND VGND VPWR VPWR _06822_ sky130_fd_sc_hd__and4_1
XFILLER_0_123_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14357_ _06712_ _06672_ _06745_ VGND VGND VPWR VPWR _06747_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_25_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11569_ _03706_ _03707_ _03708_ VGND VGND VPWR VPWR _03709_ sky130_fd_sc_hd__or3_1
XFILLER_0_40_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13308_ _05601_ _05602_ _05603_ VGND VGND VPWR VPWR _05604_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_25_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14288_ _06670_ _06659_ _06660_ VGND VGND VPWR VPWR _06672_ sky130_fd_sc_hd__or3_1
X_13239_ _05521_ _05525_ _05526_ _05527_ VGND VGND VPWR VPWR _05528_ sky130_fd_sc_hd__a211o_1
XFILLER_0_110_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07800_ _06885_ _06896_ VGND VGND VPWR VPWR _06907_ sky130_fd_sc_hd__xnor2_1
X_08780_ _00758_ _00761_ _00822_ net122 VGND VGND VPWR VPWR _00825_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_137_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_127_Right_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07731_ _06048_ _06102_ _06059_ VGND VGND VPWR VPWR _06157_ sky130_fd_sc_hd__nand3_1
X_07662_ _05380_ _05369_ _05358_ _05325_ VGND VGND VPWR VPWR _05402_ sky130_fd_sc_hd__o211ai_2
X_07593_ _03956_ _03966_ VGND VGND VPWR VPWR _04652_ sky130_fd_sc_hd__nor2_1
X_09401_ _01395_ _01400_ _01401_ VGND VGND VPWR VPWR _01402_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_1_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09332_ _01337_ _01339_ VGND VGND VPWR VPWR _01340_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09263_ _01278_ _01279_ VGND VGND VPWR VPWR _01280_ sky130_fd_sc_hd__nand2_1
XFILLER_0_62_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08214_ _00263_ _00264_ _00265_ VGND VGND VPWR VPWR _00266_ sky130_fd_sc_hd__a21o_1
X_09194_ _01220_ _01221_ VGND VGND VPWR VPWR _01222_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08145_ _00196_ _00197_ VGND VGND VPWR VPWR _00198_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08076_ _07278_ _07280_ _00128_ _00129_ VGND VGND VPWR VPWR _00130_ sky130_fd_sc_hd__a211o_1
XFILLER_0_140_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08978_ _00949_ _01017_ _01016_ VGND VGND VPWR VPWR _01020_ sky130_fd_sc_hd__and3_1
Xhold45 a_sin\[17\] VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 a_cos\[17\] VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__dlygate4sd3_1
X_07929_ net279 net261 net540 net549 VGND VGND VPWR VPWR _07224_ sky130_fd_sc_hd__and4_1
XFILLER_0_97_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10940_ _03020_ _03021_ VGND VGND VPWR VPWR _03022_ sky130_fd_sc_hd__xor2_1
X_12610_ _04747_ net113 _04839_ _04840_ VGND VGND VPWR VPWR _04843_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_94_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10871_ _02924_ _02946_ VGND VGND VPWR VPWR _02947_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_66_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13590_ net593 net602 net402 VGND VGND VPWR VPWR _05912_ sky130_fd_sc_hd__and3_1
XFILLER_0_136_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12541_ _04766_ _04767_ VGND VGND VPWR VPWR _04768_ sky130_fd_sc_hd__or2_1
XFILLER_0_54_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12472_ _04690_ _04691_ _04621_ _04622_ VGND VGND VPWR VPWR _04693_ sky130_fd_sc_hd__a211o_1
XFILLER_0_93_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11423_ _03422_ _03423_ _03430_ VGND VGND VPWR VPWR _03548_ sky130_fd_sc_hd__or3_1
X_14211_ _06585_ _06587_ VGND VGND VPWR VPWR _06588_ sky130_fd_sc_hd__nor2_1
XANTENNA_9 net797 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11354_ net306 net226 net715 net720 VGND VGND VPWR VPWR _03472_ sky130_fd_sc_hd__and4_1
XFILLER_0_22_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14142_ _06510_ _06512_ VGND VGND VPWR VPWR _06513_ sky130_fd_sc_hd__or2_1
X_11285_ _03394_ _03395_ VGND VGND VPWR VPWR _03397_ sky130_fd_sc_hd__nor2_1
X_10305_ net675 net686 net453 net444 VGND VGND VPWR VPWR _02332_ sky130_fd_sc_hd__and4_1
X_14073_ _06427_ _06437_ VGND VGND VPWR VPWR _06438_ sky130_fd_sc_hd__xor2_1
X_10236_ _02254_ _02256_ VGND VGND VPWR VPWR _02257_ sky130_fd_sc_hd__nand2_1
X_13024_ _05280_ _05290_ VGND VGND VPWR VPWR _05291_ sky130_fd_sc_hd__xnor2_1
X_10167_ _02181_ VGND VGND VPWR VPWR _02182_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_107_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10098_ _02105_ _02106_ _01941_ VGND VGND VPWR VPWR _02107_ sky130_fd_sc_hd__and3b_1
XFILLER_0_16_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13926_ _06181_ _06196_ VGND VGND VPWR VPWR _06278_ sky130_fd_sc_hd__or2_1
XFILLER_0_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13857_ net504 net512 net452 net442 VGND VGND VPWR VPWR _06203_ sky130_fd_sc_hd__and4_1
X_12808_ _04987_ _05002_ _04856_ VGND VGND VPWR VPWR _05057_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_57_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13788_ _06024_ _06027_ _06025_ VGND VGND VPWR VPWR _06128_ sky130_fd_sc_hd__a21bo_1
X_12739_ _01926_ _04980_ _04981_ _04982_ VGND VGND VPWR VPWR _00086_ sky130_fd_sc_hd__a31o_1
XFILLER_0_72_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14409_ _06734_ _06735_ _06802_ VGND VGND VPWR VPWR _06803_ sky130_fd_sc_hd__o21a_1
XFILLER_0_25_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09950_ net727 net436 VGND VGND VPWR VPWR _01950_ sky130_fd_sc_hd__nand2_1
XFILLER_0_40_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08901_ _00891_ _00942_ _00943_ VGND VGND VPWR VPWR _00944_ sky130_fd_sc_hd__o21a_1
XFILLER_0_40_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09881_ _01868_ _01869_ _01881_ VGND VGND VPWR VPWR _01882_ sky130_fd_sc_hd__nand3_1
XFILLER_0_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08832_ net292 net590 VGND VGND VPWR VPWR _00876_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_29_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08763_ net292 net598 _00806_ _00807_ VGND VGND VPWR VPWR _00808_ sky130_fd_sc_hd__o2bb2a_1
X_07714_ net174 net573 net660 net164 VGND VGND VPWR VPWR _05972_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08694_ _00738_ _00739_ VGND VGND VPWR VPWR _00740_ sky130_fd_sc_hd__nor2_1
X_07645_ net219 net531 VGND VGND VPWR VPWR _05215_ sky130_fd_sc_hd__and2_1
XFILLER_0_95_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07576_ _03923_ _03934_ _04456_ VGND VGND VPWR VPWR _04467_ sky130_fd_sc_hd__nand3_2
XFILLER_0_118_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09315_ _01322_ _01323_ _01324_ VGND VGND VPWR VPWR _01325_ sky130_fd_sc_hd__a21o_1
X_09246_ b_cos\[0\] a_sin\[0\] VGND VGND VPWR VPWR _01266_ sky130_fd_sc_hd__nand2b_2
XFILLER_0_8_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_38_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09177_ _01207_ VGND VGND VPWR VPWR _00025_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08128_ _00165_ _00179_ _00180_ VGND VGND VPWR VPWR _00181_ sky130_fd_sc_hd__and3_1
XFILLER_0_16_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08059_ net197 net179 net627 net636 VGND VGND VPWR VPWR _00113_ sky130_fd_sc_hd__nand4_1
X_11070_ _00919_ _03159_ _03161_ _03162_ VGND VGND VPWR VPWR _00070_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_31_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput79 net79 VGND VGND VPWR VPWR D[13] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_47_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10021_ _01971_ _01972_ VGND VGND VPWR VPWR _02023_ sky130_fd_sc_hd__nand2_1
X_14760_ clknet_3_3_0_clk _00061_ net318 VGND VGND VPWR VPWR a_cos\[6\] sky130_fd_sc_hd__dfrtp_1
X_11972_ _04042_ _04065_ _04147_ _04148_ VGND VGND VPWR VPWR _04149_ sky130_fd_sc_hd__a211oi_1
X_13711_ _06042_ _06043_ VGND VGND VPWR VPWR _06044_ sky130_fd_sc_hd__nand2_2
XFILLER_0_98_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10923_ _02924_ _03001_ VGND VGND VPWR VPWR _03003_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14691_ _07086_ _07107_ VGND VGND VPWR VPWR _07108_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_79_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10854_ _02858_ _02927_ VGND VGND VPWR VPWR _02928_ sky130_fd_sc_hd__nor2_4
X_13642_ _05967_ _05968_ VGND VGND VPWR VPWR _05969_ sky130_fd_sc_hd__nor2_1
XFILLER_0_39_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13573_ _05892_ _05893_ VGND VGND VPWR VPWR _05894_ sky130_fd_sc_hd__or2b_1
X_12524_ _04624_ _04625_ _04643_ _04644_ VGND VGND VPWR VPWR _04749_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_109_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10785_ _02851_ _02852_ VGND VGND VPWR VPWR _02854_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12455_ net688 net236 VGND VGND VPWR VPWR _04675_ sky130_fd_sc_hd__and2b_1
XFILLER_0_81_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12386_ _04557_ _04558_ _04597_ net119 VGND VGND VPWR VPWR _04600_ sky130_fd_sc_hd__a211oi_4
X_11406_ net219 net743 _03529_ VGND VGND VPWR VPWR _03530_ sky130_fd_sc_hd__and3_1
XFILLER_0_50_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11337_ _03410_ _03408_ _03409_ VGND VGND VPWR VPWR _03454_ sky130_fd_sc_hd__or3_1
X_14125_ net495 net438 VGND VGND VPWR VPWR _06495_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11268_ _03367_ _03377_ VGND VGND VPWR VPWR _03378_ sky130_fd_sc_hd__xor2_2
X_14056_ _06416_ _06417_ _06398_ _06399_ VGND VGND VPWR VPWR _06420_ sky130_fd_sc_hd__a211o_1
X_11199_ _03298_ _03300_ _03301_ VGND VGND VPWR VPWR _03302_ sky130_fd_sc_hd__a21bo_1
X_10219_ _02137_ _02237_ VGND VGND VPWR VPWR _02238_ sky130_fd_sc_hd__xor2_1
X_13007_ net563 net571 net330 net475 VGND VGND VPWR VPWR _05273_ sky130_fd_sc_hd__and4_1
XFILLER_0_134_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13909_ _06257_ _06259_ VGND VGND VPWR VPWR _06260_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_134_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07430_ _02745_ _02756_ _02853_ VGND VGND VPWR VPWR _02875_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_43_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07361_ net308 net229 net642 net497 VGND VGND VPWR VPWR _02124_ sky130_fd_sc_hd__and4_1
XFILLER_0_91_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09100_ _01111_ _01138_ VGND VGND VPWR VPWR _01139_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_45_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09031_ _01000_ _01036_ _01070_ VGND VGND VPWR VPWR _01072_ sky130_fd_sc_hd__a21o_1
XFILLER_0_45_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09933_ net739 net429 net421 net742 VGND VGND VPWR VPWR _01933_ sky130_fd_sc_hd__a22o_1
XFILLER_0_7_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09864_ _01851_ _01859_ VGND VGND VPWR VPWR _01865_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08815_ _00859_ VGND VGND VPWR VPWR _00011_ sky130_fd_sc_hd__clkbuf_1
X_09795_ _01785_ _01789_ VGND VGND VPWR VPWR _01796_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08746_ _00789_ _00790_ _00711_ _00725_ VGND VGND VPWR VPWR _00792_ sky130_fd_sc_hd__a211oi_2
X_08677_ _00723_ VGND VGND VPWR VPWR _00009_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07628_ net209 net200 net531 net539 VGND VGND VPWR VPWR _05032_ sky130_fd_sc_hd__and4_1
XFILLER_0_49_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07559_ _04260_ _04271_ VGND VGND VPWR VPWR _04282_ sky130_fd_sc_hd__xor2_1
XFILLER_0_75_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10570_ _02559_ _02567_ VGND VGND VPWR VPWR _02620_ sky130_fd_sc_hd__nand2_1
XFILLER_0_91_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09229_ _01250_ _01251_ VGND VGND VPWR VPWR _01252_ sky130_fd_sc_hd__nand2_1
XFILLER_0_17_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12240_ _04437_ _04440_ VGND VGND VPWR VPWR _04441_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_121_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12171_ _04362_ _04363_ VGND VGND VPWR VPWR _04365_ sky130_fd_sc_hd__and2_1
XFILLER_0_31_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11122_ _03204_ _03205_ _03217_ VGND VGND VPWR VPWR _03218_ sky130_fd_sc_hd__o21ai_1
X_11053_ _03082_ _03130_ _03142_ VGND VGND VPWR VPWR _03144_ sky130_fd_sc_hd__or3b_1
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10004_ _01943_ _02003_ _02004_ VGND VGND VPWR VPWR _02005_ sky130_fd_sc_hd__nand3_4
X_11955_ _04126_ _04127_ _04129_ VGND VGND VPWR VPWR _04131_ sky130_fd_sc_hd__nand3_1
XFILLER_0_99_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14743_ clknet_3_7_0_clk _00044_ net326 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10906_ _02983_ _02985_ VGND VGND VPWR VPWR _02986_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14674_ _06924_ _06979_ VGND VGND VPWR VPWR _07089_ sky130_fd_sc_hd__or2_1
XFILLER_0_129_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11886_ _01281_ _01926_ VGND VGND VPWR VPWR _04056_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13625_ _05946_ _05947_ _05948_ VGND VGND VPWR VPWR _05951_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10837_ _02835_ _02837_ _02909_ _02910_ VGND VGND VPWR VPWR _02911_ sky130_fd_sc_hd__a211oi_1
X_10768_ _02833_ _02834_ _02771_ _02748_ VGND VGND VPWR VPWR _02836_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_54_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13556_ _05872_ _05873_ _05774_ _05839_ VGND VGND VPWR VPWR _05876_ sky130_fd_sc_hd__o211ai_4
X_12507_ _04727_ _04729_ _04709_ _04710_ VGND VGND VPWR VPWR _04731_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_89_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13487_ _05783_ VGND VGND VPWR VPWR _05800_ sky130_fd_sc_hd__inv_2
XFILLER_0_140_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12438_ _04582_ _04655_ VGND VGND VPWR VPWR _04656_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_120_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10699_ _02758_ _02760_ VGND VGND VPWR VPWR _02761_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12369_ _04225_ _04499_ VGND VGND VPWR VPWR _04581_ sky130_fd_sc_hd__and2_4
XFILLER_0_2_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14108_ _06402_ _06468_ _06474_ VGND VGND VPWR VPWR _06476_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14039_ net640 net454 net445 net495 VGND VGND VPWR VPWR _06401_ sky130_fd_sc_hd__a22oi_1
X_08600_ _00395_ _00561_ _00646_ _00397_ VGND VGND VPWR VPWR _00647_ sky130_fd_sc_hd__or4b_4
X_09580_ _01566_ _01567_ _01580_ VGND VGND VPWR VPWR _01581_ sky130_fd_sc_hd__a21o_1
XFILLER_0_89_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08531_ _00513_ _00573_ _00578_ VGND VGND VPWR VPWR _00579_ sky130_fd_sc_hd__nor3_1
XFILLER_0_54_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08462_ _00446_ _00453_ _00452_ VGND VGND VPWR VPWR _00511_ sky130_fd_sc_hd__a21bo_1
X_07413_ net211 net768 net497 net202 VGND VGND VPWR VPWR _02690_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_92_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08393_ _00441_ _00442_ VGND VGND VPWR VPWR _00443_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09014_ _00987_ _00990_ VGND VGND VPWR VPWR _01055_ sky130_fd_sc_hd__nor2_1
XFILLER_0_103_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout633 net636 VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__clkbuf_4
Xfanout600 net601 VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__clkbuf_2
X_09916_ _01910_ _01912_ _01916_ _01797_ VGND VGND VPWR VPWR _01917_ sky130_fd_sc_hd__o22a_1
Xfanout611 net614 VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__clkbuf_4
Xfanout622 net628 VGND VGND VPWR VPWR net622 sky130_fd_sc_hd__clkbuf_4
Xfanout655 net2 VGND VGND VPWR VPWR net655 sky130_fd_sc_hd__buf_4
Xfanout644 net749 VGND VGND VPWR VPWR net644 sky130_fd_sc_hd__clkbuf_4
Xfanout666 net672 VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__clkbuf_4
Xfanout688 net689 VGND VGND VPWR VPWR net688 sky130_fd_sc_hd__buf_4
Xfanout677 net681 VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__clkbuf_4
X_09847_ _01844_ _01846_ _01845_ VGND VGND VPWR VPWR _01848_ sky130_fd_sc_hd__a21o_1
Xfanout699 net700 VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__clkbuf_4
X_09778_ _01775_ _01778_ VGND VGND VPWR VPWR _01779_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_96_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08729_ _00698_ _00699_ _00697_ VGND VGND VPWR VPWR _00775_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_139_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11740_ _03893_ _03894_ _03895_ VGND VGND VPWR VPWR _03896_ sky130_fd_sc_hd__nand3_1
XFILLER_0_96_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11671_ _03818_ _03819_ _03813_ VGND VGND VPWR VPWR _03821_ sky130_fd_sc_hd__a21o_1
XFILLER_0_37_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10622_ _02675_ _02676_ VGND VGND VPWR VPWR _02677_ sky130_fd_sc_hd__nor2_1
X_13410_ _05408_ _05409_ _05410_ VGND VGND VPWR VPWR _05716_ sky130_fd_sc_hd__o21ba_1
X_14390_ _06779_ _06782_ VGND VGND VPWR VPWR _06783_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_134_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10553_ net693 net416 VGND VGND VPWR VPWR _02601_ sky130_fd_sc_hd__and2b_1
XFILLER_0_24_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13341_ _05612_ VGND VGND VPWR VPWR _05640_ sky130_fd_sc_hd__inv_2
XFILLER_0_63_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10484_ _02510_ _02525_ VGND VGND VPWR VPWR _02526_ sky130_fd_sc_hd__xor2_1
X_13272_ _05561_ _05563_ VGND VGND VPWR VPWR _05564_ sky130_fd_sc_hd__xor2_1
X_12223_ _04420_ _04421_ VGND VGND VPWR VPWR _04422_ sky130_fd_sc_hd__nor2_1
XFILLER_0_20_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12154_ _04331_ _04333_ VGND VGND VPWR VPWR _04346_ sky130_fd_sc_hd__and2b_1
X_11105_ _03143_ _03199_ VGND VGND VPWR VPWR _03201_ sky130_fd_sc_hd__and2_1
X_12085_ _04252_ _04270_ VGND VGND VPWR VPWR _04272_ sky130_fd_sc_hd__xor2_2
X_11036_ _03123_ _03125_ VGND VGND VPWR VPWR _03126_ sky130_fd_sc_hd__nor2_1
XFILLER_0_99_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14726_ clknet_3_5_0_clk _00027_ net324 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dfrtp_1
X_12987_ net493 net389 net380 net502 VGND VGND VPWR VPWR _05251_ sky130_fd_sc_hd__a22oi_2
X_11938_ _04005_ _04007_ _04006_ net216 VGND VGND VPWR VPWR _04112_ sky130_fd_sc_hd__a22o_1
XFILLER_0_115_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11869_ _04023_ _04024_ _04035_ VGND VGND VPWR VPWR _04037_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_46_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14657_ _06952_ _06953_ _07012_ _07011_ _06995_ VGND VGND VPWR VPWR _07072_ sky130_fd_sc_hd__o32a_1
XFILLER_0_39_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13608_ _05929_ _05930_ _05910_ VGND VGND VPWR VPWR _05932_ sky130_fd_sc_hd__a21o_1
X_14588_ net586 _06924_ VGND VGND VPWR VPWR _06997_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13539_ _05853_ _05856_ VGND VGND VPWR VPWR _05857_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_131_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07962_ net613 _07255_ _07256_ VGND VGND VPWR VPWR _07257_ sky130_fd_sc_hd__a21bo_1
X_09701_ _01456_ _01457_ VGND VGND VPWR VPWR _01702_ sky130_fd_sc_hd__nor2_1
X_07893_ _07186_ _07187_ _03440_ _07156_ VGND VGND VPWR VPWR _07189_ sky130_fd_sc_hd__o211ai_4
X_09632_ _01623_ _01632_ VGND VGND VPWR VPWR _01633_ sky130_fd_sc_hd__xor2_2
X_09563_ _01508_ _01513_ VGND VGND VPWR VPWR _01564_ sky130_fd_sc_hd__and2_1
X_08514_ _00483_ _00480_ _00481_ VGND VGND VPWR VPWR _00563_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_78_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09494_ net683 net359 net349 net691 VGND VGND VPWR VPWR _01495_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_19_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08445_ _00426_ _00429_ _00427_ VGND VGND VPWR VPWR _00494_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_92_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08376_ net281 net499 net508 net263 VGND VGND VPWR VPWR _00426_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_45_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout430 net435 VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__clkbuf_2
Xfanout441 net449 VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__clkbuf_4
Xfanout463 net466 VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__clkbuf_4
Xfanout452 net458 VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__clkbuf_4
Xfanout474 net477 VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__clkbuf_4
X_12910_ net191 net238 VGND VGND VPWR VPWR _05167_ sky130_fd_sc_hd__and2b_1
Xfanout485 net486 VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__buf_2
Xfanout496 net501 VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__clkbuf_4
X_13890_ _02368_ _06153_ VGND VGND VPWR VPWR _06239_ sky130_fd_sc_hd__nor2_2
X_12841_ a_sin\[15\] _05092_ _04160_ VGND VGND VPWR VPWR _05093_ sky130_fd_sc_hd__mux2_1
XFILLER_0_139_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12772_ _05016_ _05017_ VGND VGND VPWR VPWR _05018_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11723_ _03807_ _03809_ _03876_ VGND VGND VPWR VPWR _03877_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_96_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14511_ _06457_ net112 _06627_ _06913_ _06910_ VGND VGND VPWR VPWR _06914_ sky130_fd_sc_hd__a2111o_1
X_11654_ _03798_ _03801_ VGND VGND VPWR VPWR _03802_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_126_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14442_ _06815_ _06838_ VGND VGND VPWR VPWR _06839_ sky130_fd_sc_hd__or2_1
XFILLER_0_142_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10605_ _02655_ _02657_ VGND VGND VPWR VPWR _02659_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11585_ net178 net678 net685 net167 VGND VGND VPWR VPWR _03727_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_101_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14373_ _06761_ _06763_ VGND VGND VPWR VPWR _06764_ sky130_fd_sc_hd__xor2_1
XFILLER_0_24_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10536_ _02581_ _02583_ VGND VGND VPWR VPWR _02584_ sky130_fd_sc_hd__nand2_1
XFILLER_0_40_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13324_ _05618_ _05619_ _05620_ VGND VGND VPWR VPWR _05621_ sky130_fd_sc_hd__o21bai_1
XPHY_EDGE_ROW_108_Right_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10467_ _02409_ _02428_ _02507_ VGND VGND VPWR VPWR _02508_ sky130_fd_sc_hd__o21ai_1
X_13255_ net518 net527 net483 net405 VGND VGND VPWR VPWR _05546_ sky130_fd_sc_hd__and4_1
X_12206_ _04398_ _04401_ _04403_ VGND VGND VPWR VPWR _04404_ sky130_fd_sc_hd__nand3_1
XFILLER_0_20_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10398_ net666 net453 net444 net675 VGND VGND VPWR VPWR _02433_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_19_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13186_ _05279_ _05469_ VGND VGND VPWR VPWR _05470_ sky130_fd_sc_hd__or2_1
X_12137_ _04205_ _04233_ _04328_ VGND VGND VPWR VPWR _04329_ sky130_fd_sc_hd__a21oi_2
X_12068_ _04187_ _04203_ VGND VGND VPWR VPWR _04253_ sky130_fd_sc_hd__nor2_1
X_11019_ next_state _03105_ _03106_ _03107_ VGND VGND VPWR VPWR _00069_ sky130_fd_sc_hd__a31o_1
XFILLER_0_142_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14709_ clknet_3_6_0_clk _00010_ net320 VGND VGND VPWR VPWR b_sin\[10\] sky130_fd_sc_hd__dfrtp_1
X_08230_ net160 net635 _00279_ _00280_ VGND VGND VPWR VPWR _00282_ sky130_fd_sc_hd__nand4_1
XFILLER_0_62_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08161_ _00194_ _00212_ _00213_ VGND VGND VPWR VPWR _00214_ sky130_fd_sc_hd__nand3_1
XFILLER_0_16_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08092_ _00144_ _07301_ _07302_ _07305_ _07295_ VGND VGND VPWR VPWR _00145_ sky130_fd_sc_hd__a32o_1
XFILLER_0_125_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08994_ next_state _01033_ _01034_ _01035_ VGND VGND VPWR VPWR _00014_ sky130_fd_sc_hd__a31o_1
XFILLER_0_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_10_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07945_ _07220_ _07221_ _07238_ _07239_ VGND VGND VPWR VPWR _07240_ sky130_fd_sc_hd__o211ai_2
X_07876_ _07168_ _07171_ VGND VGND VPWR VPWR _07172_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_97_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09615_ _01614_ _01615_ VGND VGND VPWR VPWR _01616_ sky130_fd_sc_hd__xnor2_1
X_09546_ _01540_ _01541_ _01546_ VGND VGND VPWR VPWR _01547_ sky130_fd_sc_hd__nand3_2
XFILLER_0_78_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09477_ _01475_ _01476_ _01477_ VGND VGND VPWR VPWR _01478_ sky130_fd_sc_hd__nand3_1
XFILLER_0_38_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08428_ _00474_ _00477_ VGND VGND VPWR VPWR _00478_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08359_ _00334_ _00407_ _00408_ VGND VGND VPWR VPWR _00409_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_74_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11370_ net219 net730 VGND VGND VPWR VPWR _03490_ sky130_fd_sc_hd__nand2_1
XFILLER_0_104_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10321_ _02328_ _02348_ VGND VGND VPWR VPWR _02349_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_22_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13040_ _05307_ _05308_ VGND VGND VPWR VPWR _05309_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10252_ net270 net368 VGND VGND VPWR VPWR _02274_ sky130_fd_sc_hd__and2_1
X_10183_ _02164_ _02197_ _02198_ VGND VGND VPWR VPWR _02199_ sky130_fd_sc_hd__nand3_1
Xfanout260 net61 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__buf_4
Xfanout282 net287 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__clkbuf_4
Xfanout271 net278 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__clkbuf_2
X_13942_ _06293_ _06294_ VGND VGND VPWR VPWR _06295_ sky130_fd_sc_hd__or2_1
Xfanout293 net294 VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__buf_4
X_13873_ _06199_ _06219_ VGND VGND VPWR VPWR _06220_ sky130_fd_sc_hd__xnor2_2
X_12824_ _05072_ _05073_ VGND VGND VPWR VPWR _05074_ sky130_fd_sc_hd__xor2_1
X_12755_ _04997_ _04998_ VGND VGND VPWR VPWR _05000_ sky130_fd_sc_hd__xor2_2
XFILLER_0_139_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11706_ _03857_ _03859_ VGND VGND VPWR VPWR _03860_ sky130_fd_sc_hd__nor2_2
XFILLER_0_122_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12686_ net189 net285 net267 net144 VGND VGND VPWR VPWR _04925_ sky130_fd_sc_hd__and4_1
XFILLER_0_84_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11637_ _03780_ _03783_ VGND VGND VPWR VPWR _03784_ sky130_fd_sc_hd__or2_1
X_14425_ net623 net431 net423 net632 VGND VGND VPWR VPWR _06821_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_141_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11568_ net310 net274 net375 net232 VGND VGND VPWR VPWR _03708_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_4_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14356_ _06712_ _06672_ _06745_ VGND VGND VPWR VPWR _06746_ sky130_fd_sc_hd__and3_1
XFILLER_0_97_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10519_ net271 net344 VGND VGND VPWR VPWR _02565_ sky130_fd_sc_hd__nand2_1
X_13307_ net527 net535 net483 net405 VGND VGND VPWR VPWR _05603_ sky130_fd_sc_hd__and4_1
X_11499_ _03580_ _03586_ _03579_ VGND VGND VPWR VPWR _03632_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_0_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14287_ _06659_ _06660_ _06670_ VGND VGND VPWR VPWR _06671_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_110_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13238_ _05449_ _05450_ _05460_ VGND VGND VPWR VPWR _05527_ sky130_fd_sc_hd__and3_1
XFILLER_0_20_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13169_ net543 net561 net355 net345 VGND VGND VPWR VPWR _05451_ sky130_fd_sc_hd__and4_1
XFILLER_0_137_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07730_ _06124_ _06135_ VGND VGND VPWR VPWR _06146_ sky130_fd_sc_hd__xnor2_1
X_07661_ _05325_ _05358_ _05369_ _05380_ VGND VGND VPWR VPWR _05391_ sky130_fd_sc_hd__a211o_1
XFILLER_0_1_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07592_ _04619_ _04630_ VGND VGND VPWR VPWR _04641_ sky130_fd_sc_hd__or2b_1
XFILLER_0_94_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09400_ _01389_ _01394_ _01390_ VGND VGND VPWR VPWR _01401_ sky130_fd_sc_hd__nand3_1
X_09331_ _01328_ _01338_ VGND VGND VPWR VPWR _01339_ sky130_fd_sc_hd__or2_1
XFILLER_0_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09262_ a_sin\[3\] b_cos\[3\] VGND VGND VPWR VPWR _01279_ sky130_fd_sc_hd__or2b_1
XFILLER_0_47_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08213_ net290 net508 VGND VGND VPWR VPWR _00265_ sky130_fd_sc_hd__and2_1
X_09193_ a_cos\[10\] b_sin\[10\] VGND VGND VPWR VPWR _01221_ sky130_fd_sc_hd__or2_1
XFILLER_0_16_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08144_ net214 net204 net597 net606 VGND VGND VPWR VPWR _00197_ sky130_fd_sc_hd__and4_1
XFILLER_0_71_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08075_ _00126_ _00127_ _07308_ VGND VGND VPWR VPWR _00129_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_3_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08977_ _01016_ _01018_ VGND VGND VPWR VPWR _01019_ sky130_fd_sc_hd__nor2_1
Xhold46 b_cos\[13\] VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 a_cos\[15\] VGND VGND VPWR VPWR net780 sky130_fd_sc_hd__dlygate4sd3_1
X_07928_ net279 net540 net549 net261 VGND VGND VPWR VPWR _07223_ sky130_fd_sc_hd__a22oi_1
X_07859_ _07152_ _07153_ _07135_ _07136_ VGND VGND VPWR VPWR _07155_ sky130_fd_sc_hd__a211o_1
X_10870_ _02926_ _02945_ VGND VGND VPWR VPWR _02946_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_97_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09529_ _01527_ _01528_ _01525_ _01529_ VGND VGND VPWR VPWR _01530_ sky130_fd_sc_hd__a211o_1
XFILLER_0_39_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12540_ _04643_ _04749_ _04765_ VGND VGND VPWR VPWR _04767_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_93_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12471_ _04621_ _04622_ _04690_ _04691_ VGND VGND VPWR VPWR _04692_ sky130_fd_sc_hd__o211a_1
XFILLER_0_19_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11422_ _03422_ _03423_ _03430_ VGND VGND VPWR VPWR _03547_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_62_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14210_ _06514_ _06524_ _06586_ VGND VGND VPWR VPWR _06587_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_34_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14141_ _06511_ _06425_ VGND VGND VPWR VPWR _06512_ sky130_fd_sc_hd__nor2_1
XFILLER_0_120_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11353_ net306 net711 net720 net226 VGND VGND VPWR VPWR _03471_ sky130_fd_sc_hd__a22o_1
X_11284_ _03383_ _03384_ _03393_ VGND VGND VPWR VPWR _03395_ sky130_fd_sc_hd__and3_1
X_10304_ net675 net453 net444 net686 VGND VGND VPWR VPWR _02330_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14072_ _06428_ _06436_ VGND VGND VPWR VPWR _06437_ sky130_fd_sc_hd__xnor2_1
X_10235_ _02251_ _02252_ _02253_ VGND VGND VPWR VPWR _02256_ sky130_fd_sc_hd__a21o_1
XFILLER_0_30_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13023_ _05282_ _05289_ VGND VGND VPWR VPWR _05290_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10166_ net490 net411 VGND VGND VPWR VPWR _02181_ sky130_fd_sc_hd__or2_1
X_10097_ _02102_ _02104_ _02003_ _02005_ VGND VGND VPWR VPWR _02106_ sky130_fd_sc_hd__o211ai_1
X_13925_ _06177_ _06260_ VGND VGND VPWR VPWR _06277_ sky130_fd_sc_hd__and2b_1
XFILLER_0_107_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13856_ net504 net452 net442 net512 VGND VGND VPWR VPWR _06202_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_16_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12807_ _04987_ _05055_ VGND VGND VPWR VPWR _05056_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10999_ _03018_ _03021_ _03019_ VGND VGND VPWR VPWR _03086_ sky130_fd_sc_hd__o21ba_1
X_13787_ _06122_ _06123_ _06125_ VGND VGND VPWR VPWR _06127_ sky130_fd_sc_hd__nand3_1
XFILLER_0_32_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12738_ _01350_ _02027_ VGND VGND VPWR VPWR _04982_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12669_ _04884_ _04906_ VGND VGND VPWR VPWR _04907_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_84_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14408_ net587 _06731_ VGND VGND VPWR VPWR _06802_ sky130_fd_sc_hd__nand2_1
XFILLER_0_107_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14339_ net604 net615 net456 net445 VGND VGND VPWR VPWR _06727_ sky130_fd_sc_hd__and4_1
XFILLER_0_111_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08900_ net253 net618 net626 net245 VGND VGND VPWR VPWR _00943_ sky130_fd_sc_hd__a22o_1
X_09880_ _01877_ _01880_ VGND VGND VPWR VPWR _01881_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08831_ _00807_ _00809_ VGND VGND VPWR VPWR _00875_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08762_ net153 net301 net589 net581 VGND VGND VPWR VPWR _00807_ sky130_fd_sc_hd__and4_1
X_08693_ net153 net301 net598 net589 VGND VGND VPWR VPWR _00739_ sky130_fd_sc_hd__and4_1
X_07713_ _05797_ _05808_ _05863_ VGND VGND VPWR VPWR _05961_ sky130_fd_sc_hd__o21a_1
X_07644_ net219 net522 _04750_ _04739_ VGND VGND VPWR VPWR _05204_ sky130_fd_sc_hd__a22o_1
XFILLER_0_73_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07575_ _04152_ _04435_ _04445_ VGND VGND VPWR VPWR _04456_ sky130_fd_sc_hd__a21bo_1
X_09314_ _01316_ _01319_ _01317_ VGND VGND VPWR VPWR _01324_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_36_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09245_ _01265_ VGND VGND VPWR VPWR _00035_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09176_ net90 _01206_ net129 VGND VGND VPWR VPWR _01207_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08127_ _00177_ _00178_ _00170_ VGND VGND VPWR VPWR _00180_ sky130_fd_sc_hd__a21o_1
X_08058_ net197 net624 net636 net179 VGND VGND VPWR VPWR _00112_ sky130_fd_sc_hd__a22o_1
XFILLER_0_31_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10020_ _01991_ _01992_ _01993_ VGND VGND VPWR VPWR _02022_ sky130_fd_sc_hd__and3_1
X_11971_ _04145_ _04146_ _04084_ VGND VGND VPWR VPWR _04148_ sky130_fd_sc_hd__o21a_1
X_10922_ _02924_ _03001_ VGND VGND VPWR VPWR _03002_ sky130_fd_sc_hd__nand2_1
X_13710_ net621 net630 net360 net350 VGND VGND VPWR VPWR _06043_ sky130_fd_sc_hd__nand4_2
XFILLER_0_39_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14690_ _07087_ _07106_ VGND VGND VPWR VPWR _07107_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10853_ _02800_ _02848_ VGND VGND VPWR VPWR _02927_ sky130_fd_sc_hd__nor2b_2
X_13641_ net545 net564 net436 net427 VGND VGND VPWR VPWR _05968_ sky130_fd_sc_hd__and4_1
XFILLER_0_82_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10784_ _02847_ _02850_ VGND VGND VPWR VPWR _02852_ sky130_fd_sc_hd__or2_1
X_13572_ _05712_ _05890_ _05889_ _05888_ _05791_ VGND VGND VPWR VPWR _05893_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_137_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12523_ _04681_ _04683_ VGND VGND VPWR VPWR _04748_ sky130_fd_sc_hd__or2_1
XFILLER_0_109_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12454_ _04671_ _04672_ VGND VGND VPWR VPWR _04673_ sky130_fd_sc_hd__nor2_1
XFILLER_0_81_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_124_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12385_ _04596_ _04578_ _04579_ VGND VGND VPWR VPWR _04599_ sky130_fd_sc_hd__nor3_2
X_11405_ _03526_ _03527_ VGND VGND VPWR VPWR _03529_ sky130_fd_sc_hd__nor2_1
XFILLER_0_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11336_ _03450_ _03452_ VGND VGND VPWR VPWR _03453_ sky130_fd_sc_hd__or2_1
X_14124_ _06491_ _06492_ VGND VGND VPWR VPWR _06493_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14055_ _06398_ _06399_ _06416_ _06417_ VGND VGND VPWR VPWR _06419_ sky130_fd_sc_hd__o211ai_2
X_11267_ _03375_ _03376_ VGND VGND VPWR VPWR _03377_ sky130_fd_sc_hd__nor2_1
X_13006_ _05269_ _05268_ _05238_ _05220_ VGND VGND VPWR VPWR _05272_ sky130_fd_sc_hd__o211a_1
X_11198_ _03291_ _03296_ _03292_ VGND VGND VPWR VPWR _03301_ sky130_fd_sc_hd__nand3_1
X_10218_ _02219_ _02236_ VGND VGND VPWR VPWR _02237_ sky130_fd_sc_hd__xnor2_1
X_10149_ _02159_ _02160_ _02143_ VGND VGND VPWR VPWR _02162_ sky130_fd_sc_hd__a21o_1
XFILLER_0_27_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13908_ _06112_ _06166_ _06258_ VGND VGND VPWR VPWR _06259_ sky130_fd_sc_hd__a21o_1
XFILLER_0_76_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13839_ net529 net427 net419 net542 VGND VGND VPWR VPWR _06183_ sky130_fd_sc_hd__a22oi_1
X_07360_ net308 net767 net497 net229 VGND VGND VPWR VPWR _02114_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_85_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09030_ _01000_ _01036_ _01070_ VGND VGND VPWR VPWR _01071_ sky130_fd_sc_hd__and3_1
XFILLER_0_72_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09932_ net735 net436 _01607_ _01606_ VGND VGND VPWR VPWR _01932_ sky130_fd_sc_hd__a31o_1
XFILLER_0_7_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09863_ _01851_ _01860_ _01863_ VGND VGND VPWR VPWR _01864_ sky130_fd_sc_hd__a21o_1
X_08814_ b_sin\[11\] _00858_ _00486_ VGND VGND VPWR VPWR _00859_ sky130_fd_sc_hd__mux2_1
X_09794_ _01786_ _01788_ VGND VGND VPWR VPWR _01795_ sky130_fd_sc_hd__and2_1
XFILLER_0_84_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08745_ _00711_ _00725_ _00789_ _00790_ VGND VGND VPWR VPWR _00791_ sky130_fd_sc_hd__o211a_1
X_08676_ b_sin\[9\] _00722_ _00486_ VGND VGND VPWR VPWR _00723_ sky130_fd_sc_hd__mux2_1
X_07627_ net209 net531 net539 net200 VGND VGND VPWR VPWR _05021_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_95_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07558_ net523 _04043_ _04032_ VGND VGND VPWR VPWR _04271_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_82_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07489_ _03495_ _03506_ VGND VGND VPWR VPWR _03517_ sky130_fd_sc_hd__nor2_1
XFILLER_0_91_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09228_ a_cos\[15\] b_sin\[15\] VGND VGND VPWR VPWR _01251_ sky130_fd_sc_hd__or2_1
XFILLER_0_23_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09159_ _01190_ _01191_ VGND VGND VPWR VPWR _01192_ sky130_fd_sc_hd__nand2_1
XFILLER_0_16_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12170_ _04362_ _04363_ VGND VGND VPWR VPWR _04364_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_2_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11121_ _03207_ _03206_ VGND VGND VPWR VPWR _03217_ sky130_fd_sc_hd__or2b_1
XFILLER_0_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11052_ _03082_ _03130_ _03142_ VGND VGND VPWR VPWR _03143_ sky130_fd_sc_hd__o21bai_1
X_10003_ _02001_ _02002_ _01654_ _01656_ VGND VGND VPWR VPWR _02004_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_99_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11954_ _06928_ _00205_ _04128_ net135 VGND VGND VPWR VPWR _04129_ sky130_fd_sc_hd__or4b_2
X_14742_ clknet_3_7_0_clk _00043_ net326 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_86_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11885_ _03961_ _03959_ _04052_ VGND VGND VPWR VPWR _04055_ sky130_fd_sc_hd__or3_1
XFILLER_0_80_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10905_ _02913_ _02916_ _02911_ VGND VGND VPWR VPWR _02985_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_58_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14673_ _07031_ _07038_ _07035_ VGND VGND VPWR VPWR _07088_ sky130_fd_sc_hd__a21o_1
X_10836_ _02906_ _02907_ _02829_ _02845_ VGND VGND VPWR VPWR _02910_ sky130_fd_sc_hd__o211a_1
X_13624_ _05946_ _05947_ _05948_ VGND VGND VPWR VPWR _05949_ sky130_fd_sc_hd__nand3_1
XFILLER_0_104_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10767_ _02771_ _02748_ _02833_ _02834_ VGND VGND VPWR VPWR _02835_ sky130_fd_sc_hd__a211o_2
X_13555_ _05774_ _05839_ _05872_ _05873_ VGND VGND VPWR VPWR _05875_ sky130_fd_sc_hd__a211o_2
X_12506_ _04709_ _04710_ _04727_ _04729_ VGND VGND VPWR VPWR _04730_ sky130_fd_sc_hd__o211a_1
XFILLER_0_125_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10698_ _02586_ _02757_ _02759_ VGND VGND VPWR VPWR _02760_ sky130_fd_sc_hd__o21a_1
XFILLER_0_54_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13486_ _05415_ _05417_ _05718_ VGND VGND VPWR VPWR _05799_ sky130_fd_sc_hd__a21oi_1
X_12437_ _04647_ _04654_ VGND VGND VPWR VPWR _04655_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_112_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12368_ _04317_ _04499_ VGND VGND VPWR VPWR _04580_ sky130_fd_sc_hd__nor2_2
XFILLER_0_50_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14107_ _06402_ _06468_ _06474_ VGND VGND VPWR VPWR _06475_ sky130_fd_sc_hd__nor3_1
XFILLER_0_10_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12299_ net190 net172 net146 net182 VGND VGND VPWR VPWR _04505_ sky130_fd_sc_hd__a22oi_1
X_11319_ _03307_ _03432_ _03431_ _03422_ VGND VGND VPWR VPWR _03434_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14038_ _06326_ _06329_ _06330_ _06334_ VGND VGND VPWR VPWR _06400_ sky130_fd_sc_hd__a31o_1
XFILLER_0_38_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08530_ _00576_ _00577_ VGND VGND VPWR VPWR _00578_ sky130_fd_sc_hd__xor2_1
X_08461_ _00430_ _00437_ _00438_ VGND VGND VPWR VPWR _00510_ sky130_fd_sc_hd__and3_1
X_07412_ net211 net202 net768 net497 VGND VGND VPWR VPWR _02680_ sky130_fd_sc_hd__and4_1
XFILLER_0_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08392_ _00439_ _00440_ _00425_ VGND VGND VPWR VPWR _00442_ sky130_fd_sc_hd__a21o_1
XFILLER_0_92_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09013_ _01052_ _00994_ _01053_ VGND VGND VPWR VPWR _01054_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_85_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09915_ _01802_ _01915_ VGND VGND VPWR VPWR _01916_ sky130_fd_sc_hd__and2b_1
XFILLER_0_1_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout623 net628 VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout612 net614 VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__buf_2
Xfanout601 net25 VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__buf_4
Xfanout645 net749 VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__clkbuf_2
Xfanout634 net635 VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__clkbuf_4
Xfanout667 net672 VGND VGND VPWR VPWR net667 sky130_fd_sc_hd__dlymetal6s2s_1
X_09846_ _01844_ _01845_ _01846_ VGND VGND VPWR VPWR _01847_ sky130_fd_sc_hd__nand3_2
Xfanout656 net657 VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__buf_2
Xfanout678 net681 VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__clkbuf_2
Xfanout689 net16 VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__buf_4
X_09777_ _01776_ _01777_ VGND VGND VPWR VPWR _01778_ sky130_fd_sc_hd__nor2_1
X_08728_ _00767_ _00773_ VGND VGND VPWR VPWR _00774_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_96_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08659_ _00703_ _00705_ VGND VGND VPWR VPWR _00706_ sky130_fd_sc_hd__xor2_1
XFILLER_0_49_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11670_ _03813_ _03818_ _03819_ VGND VGND VPWR VPWR _03820_ sky130_fd_sc_hd__and3_1
XFILLER_0_49_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10621_ _02673_ _02674_ _02671_ _02672_ VGND VGND VPWR VPWR _02676_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_36_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10552_ _02598_ _02599_ VGND VGND VPWR VPWR _02600_ sky130_fd_sc_hd__nor2_1
X_13340_ _05595_ _05593_ VGND VGND VPWR VPWR _05639_ sky130_fd_sc_hd__and2b_1
XFILLER_0_107_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13271_ _05496_ _05562_ VGND VGND VPWR VPWR _05563_ sky130_fd_sc_hd__nor2_1
X_12222_ _04418_ _04419_ _04319_ _04396_ VGND VGND VPWR VPWR _04421_ sky130_fd_sc_hd__o211a_1
X_10483_ _02522_ _02524_ VGND VGND VPWR VPWR _02525_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_20_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12153_ _04345_ VGND VGND VPWR VPWR _00078_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12084_ _04254_ _04269_ VGND VGND VPWR VPWR _04270_ sky130_fd_sc_hd__xnor2_2
X_11104_ _03180_ _03198_ VGND VGND VPWR VPWR _03199_ sky130_fd_sc_hd__xnor2_1
X_11035_ _02922_ _03109_ _03122_ VGND VGND VPWR VPWR _03125_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_99_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12986_ net493 net502 net389 net380 VGND VGND VPWR VPWR _05250_ sky130_fd_sc_hd__and4_1
XFILLER_0_87_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14725_ clknet_3_5_0_clk _00026_ net324 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dfrtp_1
X_11937_ _04028_ _04030_ VGND VGND VPWR VPWR _04111_ sky130_fd_sc_hd__nand2_2
XFILLER_0_24_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11868_ _04023_ _04024_ _04035_ VGND VGND VPWR VPWR _04036_ sky130_fd_sc_hd__nor3b_2
XFILLER_0_28_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14656_ _07068_ _07070_ VGND VGND VPWR VPWR _07071_ sky130_fd_sc_hd__xor2_1
X_11799_ _00919_ _03958_ _03959_ _03960_ VGND VGND VPWR VPWR _00074_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_67_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10819_ _02884_ _02890_ VGND VGND VPWR VPWR _02891_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13607_ _05910_ _05929_ _05930_ VGND VGND VPWR VPWR _05931_ sky130_fd_sc_hd__nand3_2
X_14587_ _06951_ _06949_ VGND VGND VPWR VPWR _06996_ sky130_fd_sc_hd__and2b_1
XFILLER_0_131_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13538_ net395 _05854_ _05855_ VGND VGND VPWR VPWR _05856_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_27_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_65_Left_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13469_ _05741_ _05742_ _05779_ _05780_ VGND VGND VPWR VPWR _05781_ sky130_fd_sc_hd__nand4_4
XFILLER_0_71_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07961_ net213 net613 net624 net206 VGND VGND VPWR VPWR _07256_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09700_ _01689_ _01693_ VGND VGND VPWR VPWR _01701_ sky130_fd_sc_hd__or2b_1
XFILLER_0_4_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07892_ _03440_ _07156_ _07186_ _07187_ VGND VGND VPWR VPWR _07188_ sky130_fd_sc_hd__a211o_4
XPHY_EDGE_ROW_74_Left_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09631_ _01630_ _01631_ VGND VGND VPWR VPWR _01632_ sky130_fd_sc_hd__and2b_1
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09562_ _01560_ _01561_ _01489_ _01532_ VGND VGND VPWR VPWR _01563_ sky130_fd_sc_hd__o211a_1
X_08513_ _00398_ _00561_ VGND VGND VPWR VPWR _00562_ sky130_fd_sc_hd__or2_1
XFILLER_0_81_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09493_ net683 net691 net359 net349 VGND VGND VPWR VPWR _01494_ sky130_fd_sc_hd__and4_1
X_08444_ _00424_ _00443_ _00441_ VGND VGND VPWR VPWR _00493_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_92_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08375_ _00354_ _00361_ _00360_ VGND VGND VPWR VPWR _00425_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_58_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_83_Left_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_92_Left_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout420 net422 VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__clkbuf_2
Xfanout431 net434 VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__clkbuf_4
Xfanout464 net466 VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__clkbuf_4
Xfanout453 net458 VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__clkbuf_4
Xfanout475 net476 VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__buf_4
Xfanout442 net449 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__buf_2
Xfanout497 net501 VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__buf_8
X_09829_ _01826_ _01829_ VGND VGND VPWR VPWR _01830_ sky130_fd_sc_hd__xnor2_2
Xfanout486 net487 VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__clkbuf_4
X_12840_ _05090_ _05091_ VGND VGND VPWR VPWR _05092_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_68_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12771_ _04947_ _04948_ _04946_ VGND VGND VPWR VPWR _05017_ sky130_fd_sc_hd__a21o_1
XFILLER_0_138_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11722_ _03874_ _03875_ VGND VGND VPWR VPWR _03876_ sky130_fd_sc_hd__nand2_1
X_14510_ _06623_ _06707_ VGND VGND VPWR VPWR _06913_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11653_ _03799_ _03800_ VGND VGND VPWR VPWR _03801_ sky130_fd_sc_hd__nor2_1
X_14441_ _06816_ _06837_ VGND VGND VPWR VPWR _06838_ sky130_fd_sc_hd__xor2_1
X_10604_ _02558_ _02568_ _02656_ VGND VGND VPWR VPWR _02657_ sky130_fd_sc_hd__o21a_1
X_14372_ _06762_ _06688_ VGND VGND VPWR VPWR _06763_ sky130_fd_sc_hd__nor2_1
X_11584_ net158 net695 VGND VGND VPWR VPWR _03725_ sky130_fd_sc_hd__nand2_1
XFILLER_0_64_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13323_ net537 net544 net487 net409 VGND VGND VPWR VPWR _05620_ sky130_fd_sc_hd__and4_1
XFILLER_0_3_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10535_ _02504_ _02506_ _02580_ VGND VGND VPWR VPWR _02583_ sky130_fd_sc_hd__or3_1
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10466_ _02412_ _02427_ VGND VGND VPWR VPWR _02507_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13254_ net518 net483 net405 net527 VGND VGND VPWR VPWR _05544_ sky130_fd_sc_hd__a22oi_2
X_12205_ net377 net162 _04399_ _04400_ VGND VGND VPWR VPWR _04403_ sky130_fd_sc_hd__nand4_2
XFILLER_0_122_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13185_ _05277_ _05278_ VGND VGND VPWR VPWR _05469_ sky130_fd_sc_hd__nor2_1
X_12136_ _04231_ _04232_ VGND VGND VPWR VPWR _04328_ sky130_fd_sc_hd__and2b_1
XFILLER_0_102_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10397_ _02350_ _02358_ _02357_ VGND VGND VPWR VPWR _02432_ sky130_fd_sc_hd__a21bo_1
X_12067_ _04177_ _04180_ VGND VGND VPWR VPWR _04252_ sky130_fd_sc_hd__or2_1
X_11018_ a_cos\[14\] _00918_ VGND VGND VPWR VPWR _03107_ sky130_fd_sc_hd__and2_1
XFILLER_0_87_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12969_ _05211_ _05212_ _05213_ VGND VGND VPWR VPWR _05231_ sky130_fd_sc_hd__o21bai_1
X_14708_ clknet_3_6_0_clk _00009_ net320 VGND VGND VPWR VPWR b_sin\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_59_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14639_ net595 net586 net432 net424 VGND VGND VPWR VPWR _07052_ sky130_fd_sc_hd__and4_1
X_08160_ _00209_ _00210_ _00211_ VGND VGND VPWR VPWR _00213_ sky130_fd_sc_hd__a21o_1
XFILLER_0_16_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08091_ _07208_ _07209_ _07211_ VGND VGND VPWR VPWR _00144_ sky130_fd_sc_hd__and3_1
XFILLER_0_3_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08993_ b_sin\[14\] _07291_ VGND VGND VPWR VPWR _01035_ sky130_fd_sc_hd__and2_1
X_07944_ _07236_ _07237_ _07222_ VGND VGND VPWR VPWR _07239_ sky130_fd_sc_hd__a21o_1
X_07875_ _07169_ _07170_ VGND VGND VPWR VPWR _07171_ sky130_fd_sc_hd__nor2_1
XFILLER_0_98_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09614_ _01569_ _01571_ _01570_ VGND VGND VPWR VPWR _01615_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_78_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09545_ _01542_ _01545_ VGND VGND VPWR VPWR _01546_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_116_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09476_ net371 net491 net411 net460 VGND VGND VPWR VPWR _01477_ sky130_fd_sc_hd__a22o_1
XFILLER_0_38_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08427_ _00333_ _00475_ _00476_ VGND VGND VPWR VPWR _00477_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08358_ _00335_ _00351_ VGND VGND VPWR VPWR _00408_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08289_ _00338_ _00339_ VGND VGND VPWR VPWR _00340_ sky130_fd_sc_hd__xor2_1
XFILLER_0_33_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10320_ _02329_ _02347_ VGND VGND VPWR VPWR _02348_ sky130_fd_sc_hd__xnor2_1
X_10251_ net184 net139 net393 net384 VGND VGND VPWR VPWR _02273_ sky130_fd_sc_hd__nand4_1
XFILLER_0_100_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10182_ _02195_ _02196_ _02051_ _02053_ VGND VGND VPWR VPWR _02198_ sky130_fd_sc_hd__o211ai_2
Xfanout250 net62 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__clkbuf_4
Xfanout261 net269 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__clkbuf_4
Xfanout283 net286 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__clkbuf_4
Xfanout272 net278 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__clkbuf_4
X_13941_ _06291_ _06292_ VGND VGND VPWR VPWR _06294_ sky130_fd_sc_hd__and2_1
Xfanout294 net58 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__buf_2
XFILLER_0_89_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13872_ _06201_ _06218_ VGND VGND VPWR VPWR _06219_ sky130_fd_sc_hd__xnor2_1
X_12823_ _05013_ _05014_ _05012_ VGND VGND VPWR VPWR _05073_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_141_Right_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12754_ _04873_ _04929_ _04990_ VGND VGND VPWR VPWR _04998_ sky130_fd_sc_hd__a21o_4
XFILLER_0_96_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11705_ _03855_ _03856_ _03778_ VGND VGND VPWR VPWR _03859_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_69_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12685_ net189 net267 net144 net285 VGND VGND VPWR VPWR _04924_ sky130_fd_sc_hd__a22oi_2
X_11636_ _03779_ _03782_ VGND VGND VPWR VPWR _03783_ sky130_fd_sc_hd__and2b_1
X_14424_ _06726_ _06729_ _06727_ VGND VGND VPWR VPWR _06819_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_21_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11567_ net310 net232 net274 net375 VGND VGND VPWR VPWR _03707_ sky130_fd_sc_hd__and4_1
XFILLER_0_80_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14355_ _06719_ _06743_ VGND VGND VPWR VPWR _06745_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_52_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10518_ _02562_ _02563_ VGND VGND VPWR VPWR _02564_ sky130_fd_sc_hd__nor2_1
X_13306_ net527 net483 net405 net535 VGND VGND VPWR VPWR _05602_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_24_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14286_ _06667_ _06669_ VGND VGND VPWR VPWR _06670_ sky130_fd_sc_hd__xnor2_1
X_11498_ _03589_ _03590_ _03600_ VGND VGND VPWR VPWR _03631_ sky130_fd_sc_hd__nand3_1
XFILLER_0_12_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13237_ _05449_ _05450_ _05460_ VGND VGND VPWR VPWR _05526_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_122_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10449_ _02430_ _02488_ VGND VGND VPWR VPWR _02489_ sky130_fd_sc_hd__xor2_1
XFILLER_0_0_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13168_ _05431_ _05448_ _05447_ VGND VGND VPWR VPWR _05450_ sky130_fd_sc_hd__a21o_1
X_12119_ net191 net196 VGND VGND VPWR VPWR _04309_ sky130_fd_sc_hd__and2_1
X_13099_ net629 net397 net49 net638 VGND VGND VPWR VPWR _05374_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_137_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07660_ _04837_ _04848_ _04858_ VGND VGND VPWR VPWR _05380_ sky130_fd_sc_hd__and3_1
XFILLER_0_79_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07591_ _04543_ _04565_ VGND VGND VPWR VPWR _04630_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09330_ _01331_ _01326_ _01330_ VGND VGND VPWR VPWR _01338_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_1_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09261_ b_cos\[3\] a_sin\[3\] VGND VGND VPWR VPWR _01278_ sky130_fd_sc_hd__or2b_1
XFILLER_0_62_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08212_ net151 net299 net644 net499 VGND VGND VPWR VPWR _00264_ sky130_fd_sc_hd__nand4_1
XFILLER_0_90_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09192_ a_cos\[10\] b_sin\[10\] VGND VGND VPWR VPWR _01220_ sky130_fd_sc_hd__nand2_1
XFILLER_0_62_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08143_ net214 net597 net606 net204 VGND VGND VPWR VPWR _00196_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_43_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08074_ _07308_ _00126_ _00127_ VGND VGND VPWR VPWR _00128_ sky130_fd_sc_hd__and3_1
XFILLER_0_70_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08976_ _00949_ _01017_ VGND VGND VPWR VPWR _01018_ sky130_fd_sc_hd__and2_1
Xhold47 net93 VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 b_cos\[15\] VGND VGND VPWR VPWR net781 sky130_fd_sc_hd__dlygate4sd3_1
X_07927_ _07157_ _07165_ _07164_ VGND VGND VPWR VPWR _07222_ sky130_fd_sc_hd__a21o_1
X_07858_ _07135_ _07136_ _07152_ _07153_ VGND VGND VPWR VPWR _07154_ sky130_fd_sc_hd__o211ai_4
X_07789_ _06603_ _06766_ VGND VGND VPWR VPWR _06787_ sky130_fd_sc_hd__nand2_1
X_09528_ _01524_ _01523_ net121 _01450_ VGND VGND VPWR VPWR _01529_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_109_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09459_ net741 net450 VGND VGND VPWR VPWR _01460_ sky130_fd_sc_hd__nand2_1
X_12470_ _04688_ _04689_ _04600_ _04623_ VGND VGND VPWR VPWR _04691_ sky130_fd_sc_hd__a211o_1
XFILLER_0_108_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11421_ _03504_ _03505_ _03507_ VGND VGND VPWR VPWR _03546_ sky130_fd_sc_hd__and3_1
XFILLER_0_123_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11352_ _03457_ _03456_ _03455_ VGND VGND VPWR VPWR _03470_ sky130_fd_sc_hd__a21o_1
XFILLER_0_22_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14140_ _06153_ VGND VGND VPWR VPWR _06511_ sky130_fd_sc_hd__inv_2
XFILLER_0_34_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10303_ _02261_ _02270_ _02268_ VGND VGND VPWR VPWR _02329_ sky130_fd_sc_hd__a21oi_2
X_11283_ _03383_ _03384_ _03393_ VGND VGND VPWR VPWR _03394_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_104_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14071_ _06430_ _06435_ VGND VGND VPWR VPWR _06436_ sky130_fd_sc_hd__xnor2_2
X_10234_ _02251_ _02252_ _02253_ VGND VGND VPWR VPWR _02254_ sky130_fd_sc_hd__nand3_1
X_13022_ _05283_ _05288_ VGND VGND VPWR VPWR _05289_ sky130_fd_sc_hd__xnor2_1
X_10165_ _02175_ _02178_ VGND VGND VPWR VPWR _02180_ sky130_fd_sc_hd__xor2_1
XFILLER_0_83_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10096_ _02003_ _02005_ _02102_ _02104_ VGND VGND VPWR VPWR _02105_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_89_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13924_ _06257_ _06259_ VGND VGND VPWR VPWR _06275_ sky130_fd_sc_hd__and2b_1
XFILLER_0_88_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13855_ _06136_ _06144_ _06142_ VGND VGND VPWR VPWR _06201_ sky130_fd_sc_hd__a21oi_2
X_12806_ _05046_ _05054_ VGND VGND VPWR VPWR _05055_ sky130_fd_sc_hd__xnor2_2
X_10998_ _03083_ _03084_ VGND VGND VPWR VPWR _03085_ sky130_fd_sc_hd__xor2_2
XFILLER_0_8_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13786_ _06122_ _06123_ _06125_ VGND VGND VPWR VPWR _06126_ sky130_fd_sc_hd__a21o_1
X_12737_ _04975_ _04979_ _04973_ VGND VGND VPWR VPWR _04981_ sky130_fd_sc_hd__a21o_4
XFILLER_0_84_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12668_ _04885_ _04905_ VGND VGND VPWR VPWR _04906_ sky130_fd_sc_hd__xor2_2
X_11619_ _03701_ _03688_ _03762_ _03763_ VGND VGND VPWR VPWR _03764_ sky130_fd_sc_hd__a211o_2
X_14407_ _06799_ _06800_ VGND VGND VPWR VPWR _06801_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12599_ _04751_ _04756_ VGND VGND VPWR VPWR _04831_ sky130_fd_sc_hd__and2b_1
XFILLER_0_106_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14338_ net604 net456 net445 net615 VGND VGND VPWR VPWR _06726_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_25_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14269_ net604 net469 VGND VGND VPWR VPWR _06651_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08830_ _00872_ _00873_ VGND VGND VPWR VPWR _00874_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08761_ net301 net589 net581 net153 VGND VGND VPWR VPWR _00806_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_32_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08692_ net301 net598 net589 net153 VGND VGND VPWR VPWR _00738_ sky130_fd_sc_hd__a22oi_1
X_07712_ _05917_ net756 _05841_ VGND VGND VPWR VPWR _05950_ sky130_fd_sc_hd__a21oi_1
X_07643_ _04750_ _04728_ net766 VGND VGND VPWR VPWR _05193_ sky130_fd_sc_hd__nand3_1
XFILLER_0_79_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07574_ _04391_ _04424_ _04162_ _03243_ VGND VGND VPWR VPWR _04445_ sky130_fd_sc_hd__o211ai_2
X_09313_ b_cos\[10\] a_sin\[10\] VGND VGND VPWR VPWR _01323_ sky130_fd_sc_hd__or2b_1
XFILLER_0_75_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09244_ net83 _01264_ net130 VGND VGND VPWR VPWR _01265_ sky130_fd_sc_hd__mux2_1
XFILLER_0_113_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09175_ _01204_ _01205_ VGND VGND VPWR VPWR _01206_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_7_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08126_ _00170_ _00177_ _00178_ VGND VGND VPWR VPWR _00179_ sky130_fd_sc_hd__nand3_1
XFILLER_0_114_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08057_ _07254_ _07256_ _07255_ net613 VGND VGND VPWR VPWR _00111_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08959_ _00999_ _01000_ VGND VGND VPWR VPWR _01001_ sky130_fd_sc_hd__nand2_1
X_11970_ _04084_ _04145_ _04146_ VGND VGND VPWR VPWR _04147_ sky130_fd_sc_hd__nor3_1
X_10921_ _02989_ _03000_ VGND VGND VPWR VPWR _03001_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10852_ _02870_ _02871_ _02925_ VGND VGND VPWR VPWR _02926_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_39_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13640_ net545 net436 net427 net564 VGND VGND VPWR VPWR _05967_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_109_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10783_ _02847_ _02850_ VGND VGND VPWR VPWR _02851_ sky130_fd_sc_hd__nand2_1
X_13571_ _05888_ _05889_ _05891_ VGND VGND VPWR VPWR _05892_ sky130_fd_sc_hd__o21a_1
X_12522_ _04660_ _04745_ _04743_ _04744_ VGND VGND VPWR VPWR _04747_ sky130_fd_sc_hd__o211a_2
XFILLER_0_94_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12453_ net671 net680 net251 net242 VGND VGND VPWR VPWR _04672_ sky130_fd_sc_hd__and4_1
XFILLER_0_35_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12384_ _04578_ _04579_ _04596_ VGND VGND VPWR VPWR _04597_ sky130_fd_sc_hd__o21a_1
X_11404_ net307 net729 net736 net227 VGND VGND VPWR VPWR _03527_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_78_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11335_ net174 net744 _03445_ _03449_ VGND VGND VPWR VPWR _03452_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_105_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14123_ net631 net641 net454 net445 VGND VGND VPWR VPWR _06492_ sky130_fd_sc_hd__and4_1
X_11266_ _03371_ _03373_ _03372_ VGND VGND VPWR VPWR _03376_ sky130_fd_sc_hd__a21oi_1
X_14054_ _06414_ _06415_ _06400_ VGND VGND VPWR VPWR _06417_ sky130_fd_sc_hd__a21o_1
X_10217_ _02231_ _02235_ VGND VGND VPWR VPWR _02236_ sky130_fd_sc_hd__xor2_1
X_13005_ _05220_ _05238_ _05268_ _05269_ VGND VGND VPWR VPWR _05271_ sky130_fd_sc_hd__a211oi_2
X_11197_ _03254_ _03299_ VGND VGND VPWR VPWR _03300_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_94_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10148_ _02143_ _02159_ _02160_ VGND VGND VPWR VPWR _02161_ sky130_fd_sc_hd__and3_1
X_10079_ _01962_ _01964_ VGND VGND VPWR VPWR _02086_ sky130_fd_sc_hd__nand2_1
X_13907_ _06164_ _06165_ VGND VGND VPWR VPWR _06258_ sky130_fd_sc_hd__and2b_1
XFILLER_0_9_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13838_ _06117_ _06120_ _06118_ VGND VGND VPWR VPWR _06182_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_128_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13769_ _06000_ _06006_ VGND VGND VPWR VPWR _06107_ sky130_fd_sc_hd__and2b_1
XFILLER_0_85_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09931_ _01597_ _01598_ VGND VGND VPWR VPWR _01931_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09862_ _01862_ _01858_ VGND VGND VPWR VPWR _01863_ sky130_fd_sc_hd__and2b_1
X_08813_ _00855_ _00857_ VGND VGND VPWR VPWR _00858_ sky130_fd_sc_hd__xnor2_1
X_09793_ _01753_ _01792_ _01791_ _01783_ VGND VGND VPWR VPWR _01794_ sky130_fd_sc_hd__a211oi_1
X_08744_ _00787_ _00788_ _00726_ _00727_ VGND VGND VPWR VPWR _00790_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08675_ _00720_ _00721_ VGND VGND VPWR VPWR _00722_ sky130_fd_sc_hd__nor2_1
X_07626_ net193 net548 VGND VGND VPWR VPWR _05010_ sky130_fd_sc_hd__nand2_1
XFILLER_0_95_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07557_ net193 net532 VGND VGND VPWR VPWR _04260_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07488_ net177 net167 net507 net515 VGND VGND VPWR VPWR _03506_ sky130_fd_sc_hd__and4_1
XFILLER_0_91_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09227_ a_cos\[15\] b_sin\[15\] VGND VGND VPWR VPWR _01250_ sky130_fd_sc_hd__nand2_1
XFILLER_0_63_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09158_ a_cos\[5\] b_sin\[5\] VGND VGND VPWR VPWR _01191_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08109_ _00122_ VGND VGND VPWR VPWR _00162_ sky130_fd_sc_hd__inv_2
X_09089_ _01084_ _01080_ _01128_ VGND VGND VPWR VPWR _01129_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_32_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11120_ _03210_ VGND VGND VPWR VPWR _03216_ sky130_fd_sc_hd__inv_2
XFILLER_0_31_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11051_ _03140_ _03141_ VGND VGND VPWR VPWR _03142_ sky130_fd_sc_hd__xor2_1
X_10002_ _01654_ _01656_ _02001_ _02002_ VGND VGND VPWR VPWR _02003_ sky130_fd_sc_hd__a211o_2
X_11953_ net222 net146 VGND VGND VPWR VPWR _04128_ sky130_fd_sc_hd__nand2_1
XFILLER_0_98_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14741_ clknet_3_3_0_clk _00042_ net318 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__dfrtp_2
XPHY_EDGE_ROW_103_Left_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11884_ _03961_ _03959_ _04052_ VGND VGND VPWR VPWR _04053_ sky130_fd_sc_hd__o21ai_1
X_10904_ _02981_ _02982_ VGND VGND VPWR VPWR _02983_ sky130_fd_sc_hd__nand2_1
X_14672_ _07045_ _07063_ _07066_ VGND VGND VPWR VPWR _07087_ sky130_fd_sc_hd__a21oi_1
X_10835_ _02829_ _02845_ _02906_ _02907_ VGND VGND VPWR VPWR _02909_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_39_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13623_ _05824_ _05825_ _05826_ VGND VGND VPWR VPWR _05948_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_66_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10766_ _02808_ _02809_ _02831_ VGND VGND VPWR VPWR _02834_ sky130_fd_sc_hd__nor3_2
X_13554_ _05870_ _05871_ _05851_ VGND VGND VPWR VPWR _05873_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_137_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12505_ _04711_ _04712_ _04726_ VGND VGND VPWR VPWR _04729_ sky130_fd_sc_hd__nand3_2
XFILLER_0_109_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10697_ _02581_ _02675_ _02676_ VGND VGND VPWR VPWR _02759_ sky130_fd_sc_hd__o21ba_1
X_13485_ _05421_ _05788_ _05796_ _05423_ VGND VGND VPWR VPWR _05798_ sky130_fd_sc_hd__a211oi_2
X_12436_ _04584_ _04653_ VGND VGND VPWR VPWR _04654_ sky130_fd_sc_hd__xor2_1
XFILLER_0_124_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12367_ _04575_ _04577_ _04485_ _04487_ VGND VGND VPWR VPWR _04579_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_112_Left_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14106_ _06471_ _06473_ VGND VGND VPWR VPWR _06474_ sky130_fd_sc_hd__xor2_1
X_12298_ _04408_ _04411_ VGND VGND VPWR VPWR _04504_ sky130_fd_sc_hd__nand2_1
X_11318_ _03422_ _03431_ _03432_ _03307_ VGND VGND VPWR VPWR _03433_ sky130_fd_sc_hd__o211a_1
XFILLER_0_22_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11249_ net212 net203 net677 net684 VGND VGND VPWR VPWR _03357_ sky130_fd_sc_hd__and4_1
XFILLER_0_129_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14037_ _06308_ _06315_ _06316_ VGND VGND VPWR VPWR _06399_ sky130_fd_sc_hd__and3_1
XFILLER_0_38_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_121_Left_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08460_ _00437_ VGND VGND VPWR VPWR _00509_ sky130_fd_sc_hd__inv_2
XFILLER_0_89_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07411_ net195 net805 VGND VGND VPWR VPWR _02669_ sky130_fd_sc_hd__nand2_1
X_08391_ _00425_ _00439_ _00440_ VGND VGND VPWR VPWR _00441_ sky130_fd_sc_hd__nand3_1
XFILLER_0_9_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_130_Left_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09012_ _00995_ _00985_ VGND VGND VPWR VPWR _01053_ sky130_fd_sc_hd__and2b_1
XFILLER_0_60_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout624 net627 VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__clkbuf_4
Xfanout613 net614 VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__clkbuf_4
X_09914_ _01760_ _01801_ _01800_ _01793_ VGND VGND VPWR VPWR _01915_ sky130_fd_sc_hd__a211o_1
XFILLER_0_0_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout602 net603 VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__clkbuf_4
Xfanout635 net636 VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__buf_4
X_09845_ _01780_ _01774_ _01779_ VGND VGND VPWR VPWR _01846_ sky130_fd_sc_hd__a21o_1
Xfanout657 net658 VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout646 net20 VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__buf_6
Xfanout668 net672 VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__clkbuf_4
Xfanout679 net681 VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__clkbuf_4
X_09776_ net709 net717 net390 net381 VGND VGND VPWR VPWR _01777_ sky130_fd_sc_hd__and4_1
X_08727_ _00771_ _00772_ VGND VGND VPWR VPWR _00773_ sky130_fd_sc_hd__xor2_1
X_08658_ _00580_ _00704_ VGND VGND VPWR VPWR _00705_ sky130_fd_sc_hd__nor2_1
X_07609_ _04293_ _04249_ _04282_ VGND VGND VPWR VPWR _04826_ sky130_fd_sc_hd__a21o_1
XFILLER_0_95_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08589_ _00556_ _00489_ VGND VGND VPWR VPWR _00637_ sky130_fd_sc_hd__and2b_1
XFILLER_0_76_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10620_ _02671_ _02672_ _02673_ _02674_ VGND VGND VPWR VPWR _02675_ sky130_fd_sc_hd__o211a_1
X_10551_ net675 net688 net430 net422 VGND VGND VPWR VPWR _02599_ sky130_fd_sc_hd__and4_1
XFILLER_0_9_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10482_ _02523_ _02423_ VGND VGND VPWR VPWR _02524_ sky130_fd_sc_hd__nor2_1
X_13270_ net658 net339 _05494_ _05495_ VGND VGND VPWR VPWR _05562_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_17_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12221_ _04319_ _04396_ _04418_ _04419_ VGND VGND VPWR VPWR _04420_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_106_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12152_ a_sin\[5\] _04344_ _04160_ VGND VGND VPWR VPWR _04345_ sky130_fd_sc_hd__mux2_1
X_12083_ _04266_ _04268_ VGND VGND VPWR VPWR _04269_ sky130_fd_sc_hd__xnor2_2
X_11103_ _03196_ _03197_ VGND VGND VPWR VPWR _03198_ sky130_fd_sc_hd__and2_1
X_11034_ _02922_ _03109_ _03122_ VGND VGND VPWR VPWR _03123_ sky130_fd_sc_hd__and3_1
XFILLER_0_91_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12985_ net511 net367 VGND VGND VPWR VPWR _05249_ sky130_fd_sc_hd__nand2_1
X_11936_ _04088_ _04109_ VGND VGND VPWR VPWR _04110_ sky130_fd_sc_hd__xor2_1
XFILLER_0_99_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14724_ clknet_3_7_0_clk _00025_ net325 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_86_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11867_ _04025_ _04034_ VGND VGND VPWR VPWR _04035_ sky130_fd_sc_hd__xor2_1
XFILLER_0_67_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14655_ _06991_ _07013_ _06990_ VGND VGND VPWR VPWR _07070_ sky130_fd_sc_hd__a21oi_1
X_11798_ net777 _07291_ VGND VGND VPWR VPWR _03960_ sky130_fd_sc_hd__nand2_1
X_10818_ _02888_ _02889_ VGND VGND VPWR VPWR _02890_ sky130_fd_sc_hd__xor2_1
X_13606_ _05925_ _05926_ _05927_ VGND VGND VPWR VPWR _05930_ sky130_fd_sc_hd__a21o_1
X_14586_ _06923_ _06932_ _06994_ VGND VGND VPWR VPWR _06995_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_82_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10749_ net650 net667 net433 net425 VGND VGND VPWR VPWR _02815_ sky130_fd_sc_hd__and4_1
XFILLER_0_40_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13537_ net611 net395 net386 net620 VGND VGND VPWR VPWR _05855_ sky130_fd_sc_hd__a22o_1
XFILLER_0_113_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13468_ _05777_ _05778_ _05379_ _05744_ VGND VGND VPWR VPWR _05780_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_140_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12419_ net190 net275 net154 net302 VGND VGND VPWR VPWR _04635_ sky130_fd_sc_hd__and4_1
X_13399_ _05580_ _05579_ _05577_ _05570_ VGND VGND VPWR VPWR _05704_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_50_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07960_ net213 net206 net624 VGND VGND VPWR VPWR _07255_ sky130_fd_sc_hd__and3_1
XFILLER_0_11_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07891_ _07184_ _07185_ _07167_ VGND VGND VPWR VPWR _07187_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_4_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09630_ _01628_ _01629_ _01624_ VGND VGND VPWR VPWR _01631_ sky130_fd_sc_hd__a21o_1
X_09561_ _01489_ _01532_ _01560_ _01561_ VGND VGND VPWR VPWR _01562_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_78_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08512_ _00393_ _00482_ VGND VGND VPWR VPWR _00561_ sky130_fd_sc_hd__or2_1
XFILLER_0_77_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09492_ net700 net339 VGND VGND VPWR VPWR _01493_ sky130_fd_sc_hd__nand2_1
X_08443_ _00418_ _00420_ VGND VGND VPWR VPWR _00492_ sky130_fd_sc_hd__or2_1
XFILLER_0_19_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08374_ _00340_ _00348_ _00347_ VGND VGND VPWR VPWR _00424_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_46_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout421 net422 VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__buf_2
Xfanout410 net414 VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__clkbuf_4
Xfanout432 net434 VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__buf_2
Xfanout465 net466 VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__clkbuf_2
Xfanout443 net449 VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__clkbuf_4
Xfanout454 net458 VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_122_Right_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout498 net501 VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__clkbuf_2
X_09828_ _01827_ _01828_ VGND VGND VPWR VPWR _01829_ sky130_fd_sc_hd__nor2_1
Xfanout487 net488 VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__clkbuf_4
Xfanout476 net477 VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__buf_6
X_09759_ _01756_ _01757_ _01759_ VGND VGND VPWR VPWR _01760_ sky130_fd_sc_hd__nand3_2
XFILLER_0_138_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12770_ _05009_ _05015_ VGND VGND VPWR VPWR _05016_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_139_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11721_ _03780_ _03873_ VGND VGND VPWR VPWR _03875_ sky130_fd_sc_hd__or2_1
X_11652_ net696 net705 net150 net298 VGND VGND VPWR VPWR _03800_ sky130_fd_sc_hd__and4_1
XFILLER_0_127_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14440_ _06818_ _06836_ VGND VGND VPWR VPWR _06837_ sky130_fd_sc_hd__xnor2_1
X_10603_ _02553_ _02557_ VGND VGND VPWR VPWR _02656_ sky130_fd_sc_hd__nand2_1
X_14371_ _06678_ _06684_ VGND VGND VPWR VPWR _06762_ sky130_fd_sc_hd__and2b_1
XFILLER_0_36_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11583_ _03642_ _03644_ _03643_ VGND VGND VPWR VPWR _03724_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_107_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13322_ net537 net487 net409 net543 VGND VGND VPWR VPWR _05619_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_9_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10534_ _02504_ _02506_ _02580_ VGND VGND VPWR VPWR _02581_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_10_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10465_ _02493_ _02408_ VGND VGND VPWR VPWR _02506_ sky130_fd_sc_hd__and2b_1
X_13253_ net535 net398 VGND VGND VPWR VPWR _05543_ sky130_fd_sc_hd__nand2_1
X_12204_ net377 net162 _04399_ _04400_ VGND VGND VPWR VPWR _04401_ sky130_fd_sc_hd__a22o_1
XFILLER_0_122_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10396_ _02335_ _02344_ _02343_ VGND VGND VPWR VPWR _02431_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_20_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13184_ _05454_ _05459_ VGND VGND VPWR VPWR _05467_ sky130_fd_sc_hd__or2b_1
X_12135_ _04294_ _04325_ VGND VGND VPWR VPWR _04327_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_19_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12066_ _04080_ _04182_ _04250_ VGND VGND VPWR VPWR _04251_ sky130_fd_sc_hd__o21a_1
XFILLER_0_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11017_ _03052_ _03050_ _03104_ VGND VGND VPWR VPWR _03106_ sky130_fd_sc_hd__or3_1
XFILLER_0_126_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12968_ _05227_ _05228_ _05229_ VGND VGND VPWR VPWR _05230_ sky130_fd_sc_hd__or3_1
X_11919_ net696 net705 net282 net264 VGND VGND VPWR VPWR _04091_ sky130_fd_sc_hd__and4_1
X_12899_ _04857_ _05154_ _04856_ VGND VGND VPWR VPWR _05155_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_87_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14707_ clknet_3_6_0_clk _00008_ net319 VGND VGND VPWR VPWR b_sin\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_47_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14638_ net586 net432 net424 net595 VGND VGND VPWR VPWR _07051_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_129_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14569_ _06790_ _06933_ VGND VGND VPWR VPWR _06976_ sky130_fd_sc_hd__or2_1
X_08090_ _07308_ _00126_ _00127_ VGND VGND VPWR VPWR _00143_ sky130_fd_sc_hd__nand3_2
XFILLER_0_141_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08992_ _00970_ _00979_ _01032_ VGND VGND VPWR VPWR _01034_ sky130_fd_sc_hd__or3_1
X_07943_ _07222_ _07236_ _07237_ VGND VGND VPWR VPWR _07238_ sky130_fd_sc_hd__nand3_2
XFILLER_0_76_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07874_ net213 net624 net633 net206 VGND VGND VPWR VPWR _07170_ sky130_fd_sc_hd__a22oi_2
X_09613_ _01610_ _01613_ VGND VGND VPWR VPWR _01614_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_92_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09544_ _01543_ _01544_ VGND VGND VPWR VPWR _01545_ sky130_fd_sc_hd__nor2_1
X_09475_ net371 net460 net491 net411 VGND VGND VPWR VPWR _01476_ sky130_fd_sc_hd__nand4_1
XFILLER_0_136_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08426_ _00382_ _00384_ VGND VGND VPWR VPWR _00476_ sky130_fd_sc_hd__nor2_1
XFILLER_0_18_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08357_ _00335_ _00351_ VGND VGND VPWR VPWR _00407_ sky130_fd_sc_hd__nand2_1
XFILLER_0_116_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08288_ net257 net525 VGND VGND VPWR VPWR _00339_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10250_ net139 net393 net384 net184 VGND VGND VPWR VPWR _02272_ sky130_fd_sc_hd__a22o_1
X_10181_ _02051_ _02053_ _02195_ _02196_ VGND VGND VPWR VPWR _02197_ sky130_fd_sc_hd__a211o_1
Xfanout240 net242 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__clkbuf_2
Xfanout262 net269 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__buf_2
Xfanout251 net254 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__clkbuf_4
X_13940_ _06291_ _06292_ VGND VGND VPWR VPWR _06293_ sky130_fd_sc_hd__nor2_1
Xfanout273 net278 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__clkbuf_2
Xfanout295 net797 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__buf_2
Xfanout284 net285 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_97_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13871_ _06216_ _06217_ VGND VGND VPWR VPWR _06218_ sky130_fd_sc_hd__or2_2
X_12822_ _05070_ _05071_ VGND VGND VPWR VPWR _05072_ sky130_fd_sc_hd__and2_1
XFILLER_0_69_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12753_ _04995_ _04996_ VGND VGND VPWR VPWR _04997_ sky130_fd_sc_hd__or2_2
XFILLER_0_139_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11704_ _03778_ _03855_ _03856_ VGND VGND VPWR VPWR _03857_ sky130_fd_sc_hd__and3_1
XFILLER_0_56_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12684_ _04870_ _04877_ _04921_ VGND VGND VPWR VPWR _04922_ sky130_fd_sc_hd__a21o_1
X_14423_ _06725_ _06791_ _06817_ _06741_ VGND VGND VPWR VPWR _06818_ sky130_fd_sc_hd__a31o_1
XFILLER_0_126_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11635_ net745 net248 VGND VGND VPWR VPWR _03782_ sky130_fd_sc_hd__nand2_1
XFILLER_0_64_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11566_ net224 net461 VGND VGND VPWR VPWR _03706_ sky130_fd_sc_hd__nand2_1
XFILLER_0_123_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14354_ _06741_ _06742_ VGND VGND VPWR VPWR _06743_ sky130_fd_sc_hd__or2_1
XFILLER_0_24_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10517_ net185 net140 net363 net353 VGND VGND VPWR VPWR _02563_ sky130_fd_sc_hd__and4_1
XFILLER_0_40_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13305_ net543 net398 VGND VGND VPWR VPWR _05601_ sky130_fd_sc_hd__nand2_1
X_14285_ _06661_ _06584_ _06510_ VGND VGND VPWR VPWR _06669_ sky130_fd_sc_hd__a21o_1
XFILLER_0_122_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11497_ _03444_ _03568_ _03626_ _03629_ VGND VGND VPWR VPWR _03630_ sky130_fd_sc_hd__a211o_1
XFILLER_0_110_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13236_ _05521_ _05522_ _05524_ VGND VGND VPWR VPWR _05525_ sky130_fd_sc_hd__nand3_2
X_10448_ _02485_ _02487_ VGND VGND VPWR VPWR _02488_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10379_ _02328_ _02410_ _02411_ VGND VGND VPWR VPWR _02412_ sky130_fd_sc_hd__a21oi_1
X_13167_ _05431_ _05447_ _05448_ VGND VGND VPWR VPWR _05449_ sky130_fd_sc_hd__nand3_2
X_12118_ net215 net205 net143 net135 VGND VGND VPWR VPWR _04308_ sky130_fd_sc_hd__nand4_1
X_13098_ net629 net638 net389 net380 VGND VGND VPWR VPWR _05373_ sky130_fd_sc_hd__and4_1
XFILLER_0_137_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12049_ _04231_ _04232_ VGND VGND VPWR VPWR _04233_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_46_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07590_ _04587_ _04609_ VGND VGND VPWR VPWR _04619_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09260_ _01277_ VGND VGND VPWR VPWR _00038_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_118_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08211_ net151 net644 net499 net299 VGND VGND VPWR VPWR _00263_ sky130_fd_sc_hd__a22o_1
XFILLER_0_90_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09191_ _01219_ VGND VGND VPWR VPWR _00027_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08142_ net196 net613 VGND VGND VPWR VPWR _00195_ sky130_fd_sc_hd__nand2_1
X_08073_ _00124_ _00125_ _07309_ _07276_ VGND VGND VPWR VPWR _00127_ sky130_fd_sc_hd__a211o_1
XFILLER_0_43_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08975_ _00951_ _00950_ VGND VGND VPWR VPWR _01017_ sky130_fd_sc_hd__or2b_1
X_07926_ _07143_ _07150_ VGND VGND VPWR VPWR _07221_ sky130_fd_sc_hd__and2_1
Xhold37 b_cos\[17\] VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 net94 VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07857_ _07137_ _07138_ _07151_ VGND VGND VPWR VPWR _07153_ sky130_fd_sc_hd__nand3_2
X_07788_ _06603_ _06766_ _06744_ VGND VGND VPWR VPWR _06777_ sky130_fd_sc_hd__a21o_1
XFILLER_0_78_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09527_ _01458_ _01469_ VGND VGND VPWR VPWR _01528_ sky130_fd_sc_hd__nand2_1
X_09458_ _01409_ _01418_ _01416_ VGND VGND VPWR VPWR _01459_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_108_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08409_ net196 net592 _00456_ _00457_ VGND VGND VPWR VPWR _00459_ sky130_fd_sc_hd__nand4_2
XFILLER_0_93_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09389_ net673 net401 _01374_ _01373_ VGND VGND VPWR VPWR _01390_ sky130_fd_sc_hd__a22o_1
X_11420_ _03522_ _03544_ VGND VGND VPWR VPWR _03545_ sky130_fd_sc_hd__or2_1
X_11351_ _03457_ _03455_ _03456_ VGND VGND VPWR VPWR _03469_ sky130_fd_sc_hd__nand3_1
XFILLER_0_34_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10302_ _02247_ _02256_ _02254_ VGND VGND VPWR VPWR _02328_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_21_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11282_ _03391_ _03392_ VGND VGND VPWR VPWR _03393_ sky130_fd_sc_hd__or2_1
XFILLER_0_104_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14070_ _06433_ _06434_ VGND VGND VPWR VPWR _06435_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10233_ _02150_ _02152_ _02151_ VGND VGND VPWR VPWR _02253_ sky130_fd_sc_hd__a21bo_1
X_13021_ _05284_ _05287_ VGND VGND VPWR VPWR _05288_ sky130_fd_sc_hd__xnor2_1
X_10164_ net387 _02176_ _02177_ VGND VGND VPWR VPWR _02178_ sky130_fd_sc_hd__a21bo_1
X_10095_ _02084_ _02085_ _02101_ VGND VGND VPWR VPWR _02104_ sky130_fd_sc_hd__o21ba_1
X_13923_ _06274_ VGND VGND VPWR VPWR _00096_ sky130_fd_sc_hd__clkbuf_1
X_13854_ _06121_ _06130_ _06129_ VGND VGND VPWR VPWR _06199_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_16_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12805_ _04863_ _05052_ VGND VGND VPWR VPWR _05054_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_84_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10997_ _03014_ _03015_ _03013_ VGND VGND VPWR VPWR _03084_ sky130_fd_sc_hd__a21oi_2
X_13785_ net504 net469 VGND VGND VPWR VPWR _06125_ sky130_fd_sc_hd__and2_1
XFILLER_0_29_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12736_ _04973_ _04975_ _04979_ VGND VGND VPWR VPWR _04980_ sky130_fd_sc_hd__nand3_1
XFILLER_0_57_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12667_ _04886_ _04904_ VGND VGND VPWR VPWR _04905_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_72_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11618_ _03735_ _03736_ _03760_ _03761_ VGND VGND VPWR VPWR _03763_ sky130_fd_sc_hd__a2bb2oi_1
XFILLER_0_108_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14406_ _06795_ _06796_ _06797_ VGND VGND VPWR VPWR _06800_ sky130_fd_sc_hd__nor3_1
XFILLER_0_142_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12598_ _04828_ _04829_ VGND VGND VPWR VPWR _04830_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14337_ _06662_ _06723_ _06724_ VGND VGND VPWR VPWR _06725_ sky130_fd_sc_hd__a21o_1
X_11549_ _03664_ _03665_ _03685_ _03686_ VGND VGND VPWR VPWR _03687_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_52_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14268_ _06648_ _06649_ VGND VGND VPWR VPWR _06650_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14199_ _06572_ _06573_ _06553_ _06554_ VGND VGND VPWR VPWR _06575_ sky130_fd_sc_hd__a211oi_2
X_13219_ _05464_ _05465_ _05473_ VGND VGND VPWR VPWR _05506_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08760_ _00803_ _00804_ VGND VGND VPWR VPWR _00805_ sky130_fd_sc_hd__xnor2_2
X_08691_ _00735_ _00736_ VGND VGND VPWR VPWR _00737_ sky130_fd_sc_hd__xnor2_1
X_07711_ _05841_ _05917_ _05928_ VGND VGND VPWR VPWR _05939_ sky130_fd_sc_hd__and3_1
XFILLER_0_79_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07642_ _04804_ _04772_ _04793_ VGND VGND VPWR VPWR _05183_ sky130_fd_sc_hd__nand3_1
XFILLER_0_73_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07573_ _03243_ _04162_ _04424_ _04391_ VGND VGND VPWR VPWR _04435_ sky130_fd_sc_hd__a211o_1
X_09312_ a_sin\[10\] b_cos\[10\] VGND VGND VPWR VPWR _01322_ sky130_fd_sc_hd__or2b_1
XFILLER_0_118_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09243_ _01262_ _01263_ VGND VGND VPWR VPWR _01264_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09174_ _01196_ _01199_ _01197_ VGND VGND VPWR VPWR _01205_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_8_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08125_ _00174_ _00175_ _00176_ VGND VGND VPWR VPWR _00178_ sky130_fd_sc_hd__a21o_1
XFILLER_0_71_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08056_ _07247_ _07248_ VGND VGND VPWR VPWR _00110_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08958_ _00997_ _00998_ VGND VGND VPWR VPWR _01000_ sky130_fd_sc_hd__nand2_1
X_08889_ _00928_ _00931_ VGND VGND VPWR VPWR _00932_ sky130_fd_sc_hd__xnor2_1
X_07909_ _07204_ VGND VGND VPWR VPWR _00000_ sky130_fd_sc_hd__clkbuf_1
X_10920_ _02928_ _02999_ VGND VGND VPWR VPWR _03000_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_67_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10851_ _02865_ _02872_ VGND VGND VPWR VPWR _02925_ sky130_fd_sc_hd__nand2_1
XFILLER_0_137_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10782_ _02795_ _02849_ VGND VGND VPWR VPWR _02850_ sky130_fd_sc_hd__xnor2_1
X_13570_ _05712_ _05890_ _05791_ VGND VGND VPWR VPWR _05891_ sky130_fd_sc_hd__a21o_1
X_12521_ _04743_ _04744_ _04660_ _04745_ VGND VGND VPWR VPWR _04746_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_109_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12452_ net671 net251 net242 net680 VGND VGND VPWR VPWR _04671_ sky130_fd_sc_hd__a22oi_1
X_11403_ net306 net226 net729 net736 VGND VGND VPWR VPWR _03526_ sky130_fd_sc_hd__and4_1
XFILLER_0_81_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12383_ _04593_ _04595_ VGND VGND VPWR VPWR _04596_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_50_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11334_ _03445_ _03449_ net174 net744 VGND VGND VPWR VPWR _03450_ sky130_fd_sc_hd__o211a_1
XFILLER_0_104_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14122_ net631 net454 net445 net640 VGND VGND VPWR VPWR _06491_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_10_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11265_ _03371_ _03372_ _03373_ VGND VGND VPWR VPWR _03375_ sky130_fd_sc_hd__and3_1
X_14053_ _06400_ _06414_ _06415_ VGND VGND VPWR VPWR _06416_ sky130_fd_sc_hd__nand3_1
X_10216_ _02232_ _02234_ VGND VGND VPWR VPWR _02235_ sky130_fd_sc_hd__nor2_1
X_13004_ _05256_ _05257_ _05267_ VGND VGND VPWR VPWR _05269_ sky130_fd_sc_hd__and3_1
X_11196_ _03256_ _03255_ VGND VGND VPWR VPWR _03299_ sky130_fd_sc_hd__nor2_1
XFILLER_0_94_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10147_ _02156_ _02158_ _02149_ VGND VGND VPWR VPWR _02160_ sky130_fd_sc_hd__a21o_1
X_10078_ net801 _02083_ _01999_ _02021_ VGND VGND VPWR VPWR _02085_ sky130_fd_sc_hd__o211a_4
X_13906_ _06198_ _06256_ VGND VGND VPWR VPWR _06257_ sky130_fd_sc_hd__xor2_2
XFILLER_0_134_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13837_ _06114_ _06133_ _06180_ VGND VGND VPWR VPWR _06181_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_18_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13768_ _06104_ _06105_ VGND VGND VPWR VPWR _06106_ sky130_fd_sc_hd__or2_1
X_12719_ _04943_ _04960_ VGND VGND VPWR VPWR _04961_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_84_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_84_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13699_ _06028_ _06029_ _06030_ VGND VGND VPWR VPWR _06031_ sky130_fd_sc_hd__nand3_1
XFILLER_0_142_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09930_ _01658_ VGND VGND VPWR VPWR _01930_ sky130_fd_sc_hd__inv_2
XFILLER_0_110_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09861_ _01836_ _01861_ _01851_ VGND VGND VPWR VPWR _01862_ sky130_fd_sc_hd__o21bai_1
X_08812_ _00720_ _00856_ _00792_ VGND VGND VPWR VPWR _00857_ sky130_fd_sc_hd__o21ba_1
X_09792_ _01783_ _01791_ _01792_ _01753_ VGND VGND VPWR VPWR _01793_ sky130_fd_sc_hd__o211a_1
X_08743_ _00726_ _00727_ _00787_ _00788_ VGND VGND VPWR VPWR _00789_ sky130_fd_sc_hd__a211o_1
XFILLER_0_84_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08674_ _00719_ _00647_ _00649_ VGND VGND VPWR VPWR _00721_ sky130_fd_sc_hd__and3_1
X_07625_ _04500_ _04978_ _04988_ VGND VGND VPWR VPWR _04999_ sky130_fd_sc_hd__and3_1
XFILLER_0_49_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07556_ _04184_ _04195_ _04239_ VGND VGND VPWR VPWR _04249_ sky130_fd_sc_hd__a21o_1
XFILLER_0_91_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07487_ net177 net507 net515 net167 VGND VGND VPWR VPWR _03495_ sky130_fd_sc_hd__a22oi_1
X_09226_ _01249_ VGND VGND VPWR VPWR _00032_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09157_ a_cos\[5\] b_sin\[5\] VGND VGND VPWR VPWR _01190_ sky130_fd_sc_hd__or2_1
X_08108_ _00145_ _00160_ VGND VGND VPWR VPWR _00161_ sky130_fd_sc_hd__xnor2_2
X_09088_ _01127_ VGND VGND VPWR VPWR _01128_ sky130_fd_sc_hd__inv_2
XFILLER_0_16_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08039_ net222 net213 net597 VGND VGND VPWR VPWR _07333_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11050_ _03077_ _03078_ _03076_ VGND VGND VPWR VPWR _03141_ sky130_fd_sc_hd__a21oi_1
X_10001_ _01964_ _01965_ _01999_ _02000_ VGND VGND VPWR VPWR _02002_ sky130_fd_sc_hd__a22oi_4
X_14740_ clknet_3_3_0_clk _00041_ net317 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dfrtp_2
X_11952_ net135 _00201_ _00202_ net143 net223 VGND VGND VPWR VPWR _04127_ sky130_fd_sc_hd__a32o_1
XFILLER_0_99_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11883_ _03962_ _04051_ VGND VGND VPWR VPWR _04052_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_86_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10903_ _02907_ _02909_ _02979_ _02980_ VGND VGND VPWR VPWR _02982_ sky130_fd_sc_hd__o211ai_1
X_14671_ _07085_ _07067_ _07042_ VGND VGND VPWR VPWR _07086_ sky130_fd_sc_hd__a21oi_1
X_10834_ _02809_ _02834_ _02904_ _02905_ VGND VGND VPWR VPWR _02907_ sky130_fd_sc_hd__o211a_1
X_13622_ _05944_ _05945_ _05943_ VGND VGND VPWR VPWR _05947_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_54_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13553_ _05851_ _05870_ _05871_ VGND VGND VPWR VPWR _05872_ sky130_fd_sc_hd__and3_2
X_12504_ _04711_ _04712_ _04726_ VGND VGND VPWR VPWR _04727_ sky130_fd_sc_hd__a21o_2
X_10765_ _02808_ _02809_ _02831_ VGND VGND VPWR VPWR _02833_ sky130_fd_sc_hd__o21a_1
XFILLER_0_54_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10696_ _02398_ _02400_ _02585_ _02757_ VGND VGND VPWR VPWR _02758_ sky130_fd_sc_hd__a211o_1
X_13484_ _05785_ _05786_ _05789_ VGND VGND VPWR VPWR _05796_ sky130_fd_sc_hd__nor3_2
X_12435_ _04650_ _04651_ VGND VGND VPWR VPWR _04653_ sky130_fd_sc_hd__xor2_2
XFILLER_0_81_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12366_ _04485_ _04487_ _04575_ _04577_ VGND VGND VPWR VPWR _04578_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_136_Right_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11317_ _03304_ _03305_ _03306_ VGND VGND VPWR VPWR _03432_ sky130_fd_sc_hd__a21o_1
X_14105_ net521 net415 VGND VGND VPWR VPWR _06473_ sky130_fd_sc_hd__and2b_1
XFILLER_0_1_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12297_ _04400_ _04403_ VGND VGND VPWR VPWR _04503_ sky130_fd_sc_hd__nand2_1
X_11248_ net195 net695 VGND VGND VPWR VPWR _03356_ sky130_fd_sc_hd__nand2_1
X_14036_ _06315_ VGND VGND VPWR VPWR _06398_ sky130_fd_sc_hd__inv_2
X_11179_ _03277_ _03278_ _03279_ VGND VGND VPWR VPWR _03280_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_89_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07410_ _02625_ _02636_ _02582_ VGND VGND VPWR VPWR _02658_ sky130_fd_sc_hd__a21o_1
X_08390_ _00437_ _00438_ _00430_ VGND VGND VPWR VPWR _00440_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09011_ _00868_ VGND VGND VPWR VPWR _01052_ sky130_fd_sc_hd__inv_2
XFILLER_0_60_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_103_Right_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09913_ _01864_ _01865_ _01866_ _01909_ _01913_ VGND VGND VPWR VPWR _01914_ sky130_fd_sc_hd__a41o_1
Xfanout603 net610 VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__buf_2
Xfanout614 net619 VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__buf_6
Xfanout636 net637 VGND VGND VPWR VPWR net636 sky130_fd_sc_hd__buf_4
Xfanout625 net627 VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__buf_4
X_09844_ _01825_ _01830_ _01824_ VGND VGND VPWR VPWR _01845_ sky130_fd_sc_hd__a21bo_1
Xfanout658 net659 VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__clkbuf_2
Xfanout647 net648 VGND VGND VPWR VPWR net647 sky130_fd_sc_hd__clkbuf_4
Xfanout669 net672 VGND VGND VPWR VPWR net669 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_119_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09775_ net709 net390 net381 net717 VGND VGND VPWR VPWR _01776_ sky130_fd_sc_hd__a22oi_1
X_08726_ net509 net237 VGND VGND VPWR VPWR _00772_ sky130_fd_sc_hd__and2b_1
XFILLER_0_96_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08657_ _00582_ _00581_ VGND VGND VPWR VPWR _00704_ sky130_fd_sc_hd__and2b_1
XFILLER_0_139_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07608_ _04772_ _04793_ _04804_ VGND VGND VPWR VPWR _04815_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_95_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08588_ _00633_ _00634_ _00567_ _00568_ VGND VGND VPWR VPWR _00636_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07539_ _02418_ _02440_ _02429_ VGND VGND VPWR VPWR _04064_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_91_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10550_ net675 net430 net422 net688 VGND VGND VPWR VPWR _02598_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_52_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09209_ _01227_ _01229_ _01226_ VGND VGND VPWR VPWR _01235_ sky130_fd_sc_hd__a21bo_1
X_10481_ _02413_ _02419_ VGND VGND VPWR VPWR _02523_ sky130_fd_sc_hd__and2b_1
XFILLER_0_17_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12220_ _04406_ _04407_ _04416_ _04417_ VGND VGND VPWR VPWR _04419_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_122_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12151_ _04340_ _04343_ VGND VGND VPWR VPWR _04344_ sky130_fd_sc_hd__xnor2_1
X_12082_ _04267_ _04176_ VGND VGND VPWR VPWR _04268_ sky130_fd_sc_hd__nor2_1
X_11102_ _03182_ _03195_ VGND VGND VPWR VPWR _03197_ sky130_fd_sc_hd__or2_1
X_11033_ _03120_ _03121_ VGND VGND VPWR VPWR _03122_ sky130_fd_sc_hd__or2_1
X_12984_ _05244_ _05245_ _05240_ VGND VGND VPWR VPWR _05247_ sky130_fd_sc_hd__a21o_1
X_11935_ _04106_ _04107_ VGND VGND VPWR VPWR _04109_ sky130_fd_sc_hd__and2b_1
XFILLER_0_87_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14723_ clknet_3_7_0_clk _00024_ net325 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_129_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14654_ _07043_ _07067_ VGND VGND VPWR VPWR _07068_ sky130_fd_sc_hd__xor2_1
X_11866_ _04031_ _04033_ VGND VGND VPWR VPWR _04034_ sky130_fd_sc_hd__and2b_1
X_13605_ _05925_ _05926_ _05927_ VGND VGND VPWR VPWR _05929_ sky130_fd_sc_hd__nand3_2
X_11797_ _03955_ _03777_ _03860_ _03953_ _03954_ VGND VGND VPWR VPWR _03959_ sky130_fd_sc_hd__o2111a_4
X_10817_ net667 net417 VGND VGND VPWR VPWR _02889_ sky130_fd_sc_hd__and2b_1
XFILLER_0_39_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14585_ _06724_ _06793_ _06931_ VGND VGND VPWR VPWR _06994_ sky130_fd_sc_hd__o21a_1
XFILLER_0_137_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10748_ net650 net433 net425 net667 VGND VGND VPWR VPWR _02814_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_55_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13536_ net611 net620 net386 VGND VGND VPWR VPWR _05854_ sky130_fd_sc_hd__and3_1
XFILLER_0_137_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13467_ _05379_ _05744_ _05777_ _05778_ VGND VGND VPWR VPWR _05779_ sky130_fd_sc_hd__a211o_2
X_12418_ net190 net154 net302 net275 VGND VGND VPWR VPWR _04634_ sky130_fd_sc_hd__a22oi_2
X_10679_ _02737_ _02738_ VGND VGND VPWR VPWR _02739_ sky130_fd_sc_hd__nor2_1
XFILLER_0_106_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13398_ _05638_ _05646_ _05648_ _05700_ _05702_ VGND VGND VPWR VPWR _05703_ sky130_fd_sc_hd__a32o_1
X_12349_ _04504_ _04509_ VGND VGND VPWR VPWR _04559_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14019_ net512 net428 net420 net521 VGND VGND VPWR VPWR _06379_ sky130_fd_sc_hd__a22oi_1
X_07890_ _07167_ _07184_ _07185_ VGND VGND VPWR VPWR _07186_ sky130_fd_sc_hd__and3_4
XFILLER_0_65_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09560_ _01549_ _01550_ _01559_ VGND VGND VPWR VPWR _01561_ sky130_fd_sc_hd__a21oi_1
X_08511_ _00557_ _00559_ VGND VGND VPWR VPWR _00560_ sky130_fd_sc_hd__xnor2_1
X_09491_ _01430_ _01432_ _01431_ VGND VGND VPWR VPWR _01492_ sky130_fd_sc_hd__o21ba_1
X_08442_ _00423_ _00473_ VGND VGND VPWR VPWR _00491_ sky130_fd_sc_hd__and2_1
XFILLER_0_77_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08373_ _00406_ _00422_ VGND VGND VPWR VPWR _00423_ sky130_fd_sc_hd__xor2_1
XFILLER_0_81_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout400 net401 VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__clkbuf_4
Xfanout411 net413 VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__buf_4
Xfanout422 net44 VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout466 net4 VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__clkbuf_4
Xfanout444 net449 VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__clkbuf_2
Xfanout455 net458 VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__clkbuf_2
Xfanout433 net434 VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__buf_2
Xfanout499 net501 VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__clkbuf_4
X_09827_ net717 net391 net382 net724 VGND VGND VPWR VPWR _01828_ sky130_fd_sc_hd__a22oi_1
Xfanout488 net492 VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__clkbuf_4
Xfanout477 net482 VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__buf_6
X_09758_ _01734_ _01758_ VGND VGND VPWR VPWR _01759_ sky130_fd_sc_hd__nor2_1
X_08709_ _00613_ _00754_ VGND VGND VPWR VPWR _00755_ sky130_fd_sc_hd__xor2_1
XFILLER_0_96_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11720_ _03780_ _03873_ VGND VGND VPWR VPWR _03874_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09689_ _01676_ _01677_ _01678_ VGND VGND VPWR VPWR _01690_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_139_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11651_ net696 net150 net298 net705 VGND VGND VPWR VPWR _03799_ sky130_fd_sc_hd__a22oi_2
X_11582_ net159 net705 _03656_ _03655_ VGND VGND VPWR VPWR _03723_ sky130_fd_sc_hd__a31o_1
X_10602_ _02644_ _02654_ VGND VGND VPWR VPWR _02655_ sky130_fd_sc_hd__xnor2_1
X_14370_ _06759_ _06760_ VGND VGND VPWR VPWR _06761_ sky130_fd_sc_hd__or2_1
XFILLER_0_36_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10533_ _02508_ _02579_ VGND VGND VPWR VPWR _02580_ sky130_fd_sc_hd__xnor2_1
X_13321_ net561 net400 VGND VGND VPWR VPWR _05618_ sky130_fd_sc_hd__nand2_1
XFILLER_0_122_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10464_ _02492_ _02489_ VGND VGND VPWR VPWR _02504_ sky130_fd_sc_hd__and2b_1
X_13252_ net527 net398 _05513_ _05511_ VGND VGND VPWR VPWR _05542_ sky130_fd_sc_hd__a22o_1
X_12203_ net191 net275 net182 net172 VGND VGND VPWR VPWR _04400_ sky130_fd_sc_hd__nand4_2
X_10395_ _02409_ _02428_ VGND VGND VPWR VPWR _02430_ sky130_fd_sc_hd__xor2_1
X_13183_ _05455_ _05458_ VGND VGND VPWR VPWR _05466_ sky130_fd_sc_hd__or2b_1
XFILLER_0_32_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12134_ _04322_ _04324_ VGND VGND VPWR VPWR _04325_ sky130_fd_sc_hd__xor2_2
X_12065_ _04165_ _04181_ VGND VGND VPWR VPWR _04250_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_8_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11016_ _03052_ _03050_ _03104_ VGND VGND VPWR VPWR _03105_ sky130_fd_sc_hd__o21ai_1
X_12967_ net528 net355 net345 net536 VGND VGND VPWR VPWR _05229_ sky130_fd_sc_hd__a22oi_2
X_11918_ net696 net282 net263 net705 VGND VGND VPWR VPWR _04090_ sky130_fd_sc_hd__a22oi_2
X_12898_ _05106_ VGND VGND VPWR VPWR _05154_ sky130_fd_sc_hd__inv_2
X_14706_ clknet_3_3_0_clk _00007_ net319 VGND VGND VPWR VPWR b_sin\[7\] sky130_fd_sc_hd__dfrtp_1
X_11849_ _04012_ _04013_ _04014_ VGND VGND VPWR VPWR _04015_ sky130_fd_sc_hd__or3_1
XFILLER_0_68_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14637_ net586 net440 _06978_ _06924_ VGND VGND VPWR VPWR _07050_ sky130_fd_sc_hd__a31o_1
XFILLER_0_138_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14568_ _06965_ _06966_ VGND VGND VPWR VPWR _06975_ sky130_fd_sc_hd__or2b_1
XFILLER_0_82_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13519_ _05817_ _05833_ _05834_ VGND VGND VPWR VPWR _05835_ sky130_fd_sc_hd__nand3_2
X_14499_ _06899_ _06900_ VGND VGND VPWR VPWR _06901_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08991_ _00970_ _00979_ _01032_ VGND VGND VPWR VPWR _01033_ sky130_fd_sc_hd__o21ai_1
X_07942_ _07234_ _07235_ _07227_ VGND VGND VPWR VPWR _07237_ sky130_fd_sc_hd__a21o_1
XFILLER_0_76_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07873_ net213 net206 net624 net633 VGND VGND VPWR VPWR _07169_ sky130_fd_sc_hd__and4_1
X_09612_ _01611_ _01612_ VGND VGND VPWR VPWR _01613_ sky130_fd_sc_hd__nor2_1
X_09543_ net552 net392 net383 net647 VGND VGND VPWR VPWR _01544_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_92_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09474_ net552 net401 VGND VGND VPWR VPWR _01475_ sky130_fd_sc_hd__and2_1
X_08425_ _00382_ _00384_ VGND VGND VPWR VPWR _00475_ sky130_fd_sc_hd__nand2_1
XFILLER_0_135_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08356_ _00327_ _00330_ VGND VGND VPWR VPWR _00406_ sky130_fd_sc_hd__or2_1
XFILLER_0_58_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08287_ _00336_ _00337_ VGND VGND VPWR VPWR _00338_ sky130_fd_sc_hd__or2_1
XFILLER_0_73_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10180_ _02193_ _02194_ _02174_ VGND VGND VPWR VPWR _02196_ sky130_fd_sc_hd__a21oi_1
Xfanout230 net234 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__buf_2
Xfanout241 net242 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__clkbuf_4
Xfanout274 net277 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__clkbuf_4
Xfanout252 net253 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__clkbuf_4
Xfanout263 net269 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__clkbuf_4
Xfanout296 net298 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__buf_1
Xfanout285 net286 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__clkbuf_4
X_13870_ _06214_ _06215_ _06206_ VGND VGND VPWR VPWR _06217_ sky130_fd_sc_hd__a21oi_1
X_12821_ _04993_ _04996_ _05069_ VGND VGND VPWR VPWR _05071_ sky130_fd_sc_hd__o21ai_1
X_12752_ net189 net259 _04994_ VGND VGND VPWR VPWR _04996_ sky130_fd_sc_hd__and3_1
XFILLER_0_139_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12683_ _04871_ _04876_ VGND VGND VPWR VPWR _04921_ sky130_fd_sc_hd__and2b_1
X_11703_ _03853_ _03854_ _03764_ _03769_ VGND VGND VPWR VPWR _03856_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_127_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11634_ net745 net248 _03779_ VGND VGND VPWR VPWR _03780_ sky130_fd_sc_hd__and3_1
X_14422_ _06730_ _06738_ VGND VGND VPWR VPWR _06817_ sky130_fd_sc_hd__or2_1
XFILLER_0_126_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11565_ _03634_ _03636_ _03635_ VGND VGND VPWR VPWR _03705_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_4_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14353_ _06720_ _06721_ _06740_ VGND VGND VPWR VPWR _06742_ sky130_fd_sc_hd__nor3_1
X_11496_ _03402_ _03403_ _03628_ VGND VGND VPWR VPWR _03629_ sky130_fd_sc_hd__and3_1
XFILLER_0_80_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10516_ net140 net363 net353 net185 VGND VGND VPWR VPWR _02562_ sky130_fd_sc_hd__a22oi_1
X_13304_ _05546_ _05544_ _05543_ VGND VGND VPWR VPWR _05599_ sky130_fd_sc_hd__o21ai_1
X_14284_ _06661_ _06666_ VGND VGND VPWR VPWR _06667_ sky130_fd_sc_hd__xnor2_1
X_10447_ _02349_ _02381_ _02486_ VGND VGND VPWR VPWR _02487_ sky130_fd_sc_hd__a21oi_1
X_13235_ _05497_ _05499_ VGND VGND VPWR VPWR _05524_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_33_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10378_ _02329_ _02347_ VGND VGND VPWR VPWR _02411_ sky130_fd_sc_hd__nor2_1
X_13166_ _05217_ _05210_ _05216_ VGND VGND VPWR VPWR _05448_ sky130_fd_sc_hd__a21o_1
X_12117_ net205 net143 net135 net215 VGND VGND VPWR VPWR _04307_ sky130_fd_sc_hd__a22o_1
X_13097_ net493 net367 VGND VGND VPWR VPWR _05372_ sky130_fd_sc_hd__nand2_1
X_12048_ _04120_ _04137_ _04136_ VGND VGND VPWR VPWR _04232_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_46_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13999_ _06252_ _06254_ VGND VGND VPWR VPWR _06358_ sky130_fd_sc_hd__nand2_1
X_08210_ _00260_ _00261_ VGND VGND VPWR VPWR _00262_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09190_ net92 _01218_ net130 VGND VGND VPWR VPWR _01219_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08141_ _00185_ _00193_ VGND VGND VPWR VPWR _00194_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08072_ _07309_ _07276_ _00124_ _00125_ VGND VGND VPWR VPWR _00126_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_15_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08974_ _01014_ _01015_ VGND VGND VPWR VPWR _01016_ sky130_fd_sc_hd__or2_1
X_07925_ _07149_ _07148_ VGND VGND VPWR VPWR _07220_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold38 net99 VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__dlygate4sd3_1
Xhold49 net75 VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__dlygate4sd3_1
X_07856_ _07137_ _07138_ _07151_ VGND VGND VPWR VPWR _07152_ sky130_fd_sc_hd__a21o_2
X_07787_ _06744_ _06755_ VGND VGND VPWR VPWR _06766_ sky130_fd_sc_hd__nor2_1
X_09526_ _01459_ _01468_ VGND VGND VPWR VPWR _01527_ sky130_fd_sc_hd__or2b_1
XFILLER_0_93_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09457_ _01456_ _01457_ VGND VGND VPWR VPWR _01458_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08408_ net196 net592 _00456_ _00457_ VGND VGND VPWR VPWR _00458_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09388_ _01374_ _01372_ _01373_ VGND VGND VPWR VPWR _01389_ sky130_fd_sc_hd__nand3_1
XFILLER_0_136_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08339_ _00317_ _00389_ VGND VGND VPWR VPWR _00390_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_62_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11350_ _03460_ _03461_ _03467_ VGND VGND VPWR VPWR _03468_ sky130_fd_sc_hd__nand3_1
XFILLER_0_62_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_89_Left_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10301_ _02307_ _02326_ VGND VGND VPWR VPWR _02327_ sky130_fd_sc_hd__xor2_2
XFILLER_0_15_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11281_ _03390_ _03268_ VGND VGND VPWR VPWR _03392_ sky130_fd_sc_hd__nor2_1
X_13020_ _05285_ _05286_ VGND VGND VPWR VPWR _05287_ sky130_fd_sc_hd__nor2_1
X_10232_ _02248_ _02249_ _02250_ VGND VGND VPWR VPWR _02252_ sky130_fd_sc_hd__nand3_1
X_10163_ net184 net397 net387 net270 VGND VGND VPWR VPWR _02177_ sky130_fd_sc_hd__a22o_1
XFILLER_0_100_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10094_ _02084_ _02085_ _02101_ VGND VGND VPWR VPWR _02102_ sky130_fd_sc_hd__nor3b_4
XPHY_EDGE_ROW_98_Left_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13922_ b_cos\[5\] _06273_ _05794_ VGND VGND VPWR VPWR _06274_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13853_ _06179_ _06197_ VGND VGND VPWR VPWR _06198_ sky130_fd_sc_hd__xor2_2
X_12804_ _04998_ _05051_ VGND VGND VPWR VPWR _05052_ sky130_fd_sc_hd__xor2_2
XFILLER_0_69_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10996_ _03080_ _03082_ VGND VGND VPWR VPWR _03083_ sky130_fd_sc_hd__nor2_1
X_13784_ net640 net495 net334 net478 VGND VGND VPWR VPWR _06123_ sky130_fd_sc_hd__nand4_2
XFILLER_0_123_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12735_ _04912_ _04976_ _04977_ VGND VGND VPWR VPWR _04979_ sky130_fd_sc_hd__o21a_1
XFILLER_0_32_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12666_ _04901_ _04903_ VGND VGND VPWR VPWR _04904_ sky130_fd_sc_hd__and2_1
XFILLER_0_84_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12597_ _04825_ _04827_ VGND VGND VPWR VPWR _04829_ sky130_fd_sc_hd__and2_1
X_11617_ _03735_ _03736_ _03760_ _03761_ VGND VGND VPWR VPWR _03762_ sky130_fd_sc_hd__and4bb_2
XFILLER_0_115_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14405_ _06795_ _06796_ _06797_ VGND VGND VPWR VPWR _06799_ sky130_fd_sc_hd__o21a_1
XFILLER_0_25_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11548_ _03683_ _03684_ _03666_ _03667_ VGND VGND VPWR VPWR _03686_ sky130_fd_sc_hd__o211a_1
XFILLER_0_4_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14336_ _06517_ _06664_ VGND VGND VPWR VPWR _06724_ sky130_fd_sc_hd__and2_2
XFILLER_0_12_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11479_ net148 net295 net722 net731 VGND VGND VPWR VPWR _03610_ sky130_fd_sc_hd__and4_1
XFILLER_0_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14267_ net596 net587 net333 net479 VGND VGND VPWR VPWR _06649_ sky130_fd_sc_hd__and4_1
X_14198_ _06553_ _06554_ _06572_ _06573_ VGND VGND VPWR VPWR _06574_ sky130_fd_sc_hd__o211a_1
XFILLER_0_21_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13218_ _05464_ _05465_ _05473_ VGND VGND VPWR VPWR _05505_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13149_ _05354_ _05359_ _05427_ _05428_ VGND VGND VPWR VPWR _05429_ sky130_fd_sc_hd__a211o_1
X_07710_ _05435_ _05885_ _05797_ _05874_ VGND VGND VPWR VPWR _05928_ sky130_fd_sc_hd__a211o_1
X_08690_ net260 net634 VGND VGND VPWR VPWR _00736_ sky130_fd_sc_hd__nand2_1
X_07641_ _05064_ _05140_ _05161_ VGND VGND VPWR VPWR _05172_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_73_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07572_ _04391_ _04402_ _04413_ VGND VGND VPWR VPWR _04424_ sky130_fd_sc_hd__nor3_2
XFILLER_0_87_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09311_ _01321_ VGND VGND VPWR VPWR _00045_ sky130_fd_sc_hd__clkbuf_1
X_09242_ a_cos\[17\] b_sin\[17\] VGND VGND VPWR VPWR _01263_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09173_ _01202_ _01203_ VGND VGND VPWR VPWR _01204_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08124_ _00174_ _00175_ _00176_ VGND VGND VPWR VPWR _00177_ sky130_fd_sc_hd__nand3_1
XFILLER_0_44_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08055_ _07345_ _07346_ _07347_ VGND VGND VPWR VPWR _00109_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_3_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08957_ _00997_ _00998_ VGND VGND VPWR VPWR _00999_ sky130_fd_sc_hd__or2_1
X_08888_ net292 _00929_ _00930_ VGND VGND VPWR VPWR _00931_ sky130_fd_sc_hd__a21oi_1
X_07908_ b_sin\[0\] _07203_ _02027_ VGND VGND VPWR VPWR _07204_ sky130_fd_sc_hd__mux2_1
X_07839_ _03649_ _03704_ VGND VGND VPWR VPWR _07135_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10850_ _02922_ _02923_ VGND VGND VPWR VPWR _02924_ sky130_fd_sc_hd__nand2_4
XFILLER_0_66_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09509_ net709 net717 net331 net476 VGND VGND VPWR VPWR _01510_ sky130_fd_sc_hd__and4_1
X_10781_ _02800_ _02848_ VGND VGND VPWR VPWR _02849_ sky130_fd_sc_hd__xor2_2
XFILLER_0_137_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12520_ _04661_ _04645_ _04646_ VGND VGND VPWR VPWR _04745_ sky130_fd_sc_hd__nor3_1
XFILLER_0_109_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12451_ _04561_ _04564_ _04562_ VGND VGND VPWR VPWR _04670_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_117_Right_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11402_ net209 net743 VGND VGND VPWR VPWR _03525_ sky130_fd_sc_hd__nand2_1
X_12382_ _04502_ _04512_ _04594_ VGND VGND VPWR VPWR _04595_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_105_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14121_ _06428_ _06436_ VGND VGND VPWR VPWR _06490_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11333_ _03446_ _03448_ VGND VGND VPWR VPWR _03449_ sky130_fd_sc_hd__nor2_1
XFILLER_0_50_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11264_ _03368_ _03370_ _03369_ VGND VGND VPWR VPWR _03373_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_104_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14052_ _06412_ _06413_ _06405_ VGND VGND VPWR VPWR _06415_ sky130_fd_sc_hd__a21o_1
X_10215_ _02133_ _02132_ VGND VGND VPWR VPWR _02234_ sky130_fd_sc_hd__and2b_1
X_13003_ _05256_ _05257_ _05267_ VGND VGND VPWR VPWR _05268_ sky130_fd_sc_hd__a21oi_1
X_11195_ _03291_ _03292_ _03296_ VGND VGND VPWR VPWR _03298_ sky130_fd_sc_hd__a21o_1
X_10146_ _02149_ _02156_ _02158_ VGND VGND VPWR VPWR _02159_ sky130_fd_sc_hd__nand3_1
X_10077_ _01999_ _02021_ net801 _02083_ VGND VGND VPWR VPWR _02084_ sky130_fd_sc_hd__a211oi_4
X_13905_ _06252_ _06254_ VGND VGND VPWR VPWR _06256_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13836_ _06116_ _06132_ VGND VGND VPWR VPWR _06180_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10979_ _03062_ _03063_ VGND VGND VPWR VPWR _03064_ sky130_fd_sc_hd__xor2_1
X_13767_ _06101_ _06103_ VGND VGND VPWR VPWR _06105_ sky130_fd_sc_hd__and2_1
X_12718_ _04958_ _04959_ VGND VGND VPWR VPWR _04960_ sky130_fd_sc_hd__and2_1
XFILLER_0_17_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13698_ _05943_ _05944_ _05945_ VGND VGND VPWR VPWR _06030_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_142_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12649_ _04830_ _04832_ VGND VGND VPWR VPWR _04885_ sky130_fd_sc_hd__or2_1
XFILLER_0_111_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14319_ _06703_ _06704_ _06618_ _06633_ VGND VGND VPWR VPWR _06706_ sky130_fd_sc_hd__a211o_1
XFILLER_0_25_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09860_ _01849_ _01850_ _01833_ _01839_ VGND VGND VPWR VPWR _01861_ sky130_fd_sc_hd__o211a_1
XFILLER_0_0_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08811_ _00716_ _00791_ VGND VGND VPWR VPWR _00856_ sky130_fd_sc_hd__or2_1
X_09791_ _01750_ _01751_ _01752_ VGND VGND VPWR VPWR _01792_ sky130_fd_sc_hd__a21o_1
XFILLER_0_84_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08742_ _00785_ _00786_ _00692_ _00728_ VGND VGND VPWR VPWR _00788_ sky130_fd_sc_hd__a211oi_2
X_08673_ _00647_ _00649_ _00719_ VGND VGND VPWR VPWR _00720_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_108_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07624_ _04445_ _04435_ _04152_ VGND VGND VPWR VPWR _04988_ sky130_fd_sc_hd__a21o_1
XFILLER_0_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07555_ _04206_ _04217_ _04228_ VGND VGND VPWR VPWR _04239_ sky130_fd_sc_hd__o21bai_1
X_07486_ net158 net524 VGND VGND VPWR VPWR _03484_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09225_ net80 _01248_ net130 VGND VGND VPWR VPWR _01249_ sky130_fd_sc_hd__mux2_1
XFILLER_0_133_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09156_ _01189_ VGND VGND VPWR VPWR _00022_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08107_ _00146_ _00159_ VGND VGND VPWR VPWR _00160_ sky130_fd_sc_hd__xnor2_2
X_09087_ _01125_ _01126_ VGND VGND VPWR VPWR _01127_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08038_ net206 net613 VGND VGND VPWR VPWR _07332_ sky130_fd_sc_hd__and2_1
XFILLER_0_102_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10000_ _01964_ _01965_ _01999_ _02000_ VGND VGND VPWR VPWR _02001_ sky130_fd_sc_hd__and4_1
X_09989_ _01986_ _01987_ _01988_ VGND VGND VPWR VPWR _01989_ sky130_fd_sc_hd__nand3_1
XFILLER_0_99_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11951_ _04012_ _04013_ _04014_ VGND VGND VPWR VPWR _04126_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_98_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11882_ _04049_ _04050_ VGND VGND VPWR VPWR _04051_ sky130_fd_sc_hd__or2_1
X_10902_ _02979_ _02980_ _02907_ _02909_ VGND VGND VPWR VPWR _02981_ sky130_fd_sc_hd__a211o_1
X_14670_ _07043_ VGND VGND VPWR VPWR _07085_ sky130_fd_sc_hd__inv_2
X_10833_ _02904_ _02905_ _02809_ _02834_ VGND VGND VPWR VPWR _02906_ sky130_fd_sc_hd__a211oi_2
X_13621_ _05943_ _05944_ _05945_ VGND VGND VPWR VPWR _05946_ sky130_fd_sc_hd__or3_1
X_10764_ _02811_ _02830_ VGND VGND VPWR VPWR _02831_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13552_ _05867_ _05868_ _05869_ VGND VGND VPWR VPWR _05871_ sky130_fd_sc_hd__a21o_1
X_12503_ _04718_ _04725_ VGND VGND VPWR VPWR _04726_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_82_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13483_ _05795_ VGND VGND VPWR VPWR _00091_ sky130_fd_sc_hd__clkbuf_1
X_10695_ _02584_ _02675_ _02676_ VGND VGND VPWR VPWR _02757_ sky130_fd_sc_hd__or3_1
XFILLER_0_35_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12434_ net162 net145 VGND VGND VPWR VPWR _04651_ sky130_fd_sc_hd__nand2_1
XFILLER_0_120_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12365_ _04559_ _04560_ _04574_ VGND VGND VPWR VPWR _04577_ sky130_fd_sc_hd__and3_1
XFILLER_0_50_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11316_ _03422_ _03423_ _03430_ VGND VGND VPWR VPWR _03431_ sky130_fd_sc_hd__nor3_1
XFILLER_0_105_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14104_ _06469_ _06470_ VGND VGND VPWR VPWR _06471_ sky130_fd_sc_hd__nor2_1
X_12296_ _04495_ _04501_ VGND VGND VPWR VPWR _04502_ sky130_fd_sc_hd__xnor2_1
X_14035_ _06394_ _06395_ VGND VGND VPWR VPWR _06397_ sky130_fd_sc_hd__nand2_1
X_11247_ _03351_ _03353_ _03347_ VGND VGND VPWR VPWR _03355_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_26_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11178_ net307 net228 net677 net684 VGND VGND VPWR VPWR _03279_ sky130_fd_sc_hd__nand4_1
X_10129_ _02125_ _02139_ VGND VGND VPWR VPWR _02140_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13819_ _06049_ _06066_ _06065_ VGND VGND VPWR VPWR _06162_ sky130_fd_sc_hd__a21boi_2
X_14799_ clknet_3_6_0_clk _00100_ net321 VGND VGND VPWR VPWR b_cos\[9\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_35_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09010_ _01049_ _01050_ VGND VGND VPWR VPWR _01051_ sky130_fd_sc_hd__xor2_1
XFILLER_0_115_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_44_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09912_ _01862_ _01858_ _01859_ _01910_ _01912_ VGND VGND VPWR VPWR _01913_ sky130_fd_sc_hd__a32o_1
XFILLER_0_1_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout615 net619 VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__clkbuf_4
Xfanout604 net610 VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__clkbuf_4
Xfanout626 net627 VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__buf_2
X_09843_ _01780_ _01774_ _01779_ VGND VGND VPWR VPWR _01844_ sky130_fd_sc_hd__nand3_1
Xfanout648 net655 VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__clkbuf_2
Xfanout637 net21 VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__buf_4
XFILLER_0_95_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout659 net663 VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__buf_2
X_09774_ net725 net366 VGND VGND VPWR VPWR _01775_ sky130_fd_sc_hd__nand2_1
X_08725_ _00768_ _00769_ _00770_ VGND VGND VPWR VPWR _00771_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_96_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08656_ _00701_ _00702_ VGND VGND VPWR VPWR _00703_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_53_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07607_ _04706_ _04761_ _04717_ VGND VGND VPWR VPWR _04804_ sky130_fd_sc_hd__nand3_1
X_08587_ _00567_ _00568_ _00633_ _00634_ VGND VGND VPWR VPWR _00635_ sky130_fd_sc_hd__a211o_1
XFILLER_0_49_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07538_ net195 net532 _04032_ _04043_ net523 VGND VGND VPWR VPWR _04054_ sky130_fd_sc_hd__a32o_1
XFILLER_0_49_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07469_ net310 net232 net606 net613 VGND VGND VPWR VPWR _03297_ sky130_fd_sc_hd__nand4_2
XFILLER_0_36_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09208_ _01232_ _01233_ VGND VGND VPWR VPWR _01234_ sky130_fd_sc_hd__nand2_1
X_10480_ _02520_ _02521_ VGND VGND VPWR VPWR _02522_ sky130_fd_sc_hd__or2_1
XFILLER_0_51_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09139_ _01173_ _01174_ VGND VGND VPWR VPWR _01175_ sky130_fd_sc_hd__and2b_1
XFILLER_0_121_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12150_ _04057_ _04060_ _04341_ _04342_ VGND VGND VPWR VPWR _04343_ sky130_fd_sc_hd__o31a_1
X_11101_ _03182_ _03195_ VGND VGND VPWR VPWR _03196_ sky130_fd_sc_hd__nand2_1
XFILLER_0_130_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12081_ _04166_ _04171_ VGND VGND VPWR VPWR _04267_ sky130_fd_sc_hd__and2b_1
XFILLER_0_102_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11032_ _02924_ _03119_ VGND VGND VPWR VPWR _03121_ sky130_fd_sc_hd__nor2_1
XFILLER_0_99_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12983_ _05240_ _05244_ _05245_ VGND VGND VPWR VPWR _05246_ sky130_fd_sc_hd__nand3_1
X_11934_ _04104_ _04105_ _04089_ VGND VGND VPWR VPWR _04107_ sky130_fd_sc_hd__a21o_1
XFILLER_0_87_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14722_ clknet_3_7_0_clk _00023_ net325 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_24_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14653_ _07065_ _07066_ VGND VGND VPWR VPWR _07067_ sky130_fd_sc_hd__nor2_1
X_11865_ _04029_ _04030_ _04026_ VGND VGND VPWR VPWR _04033_ sky130_fd_sc_hd__a21o_1
X_13604_ _05857_ _05866_ _05865_ VGND VGND VPWR VPWR _05927_ sky130_fd_sc_hd__a21bo_1
X_11796_ _03953_ _03954_ _03957_ VGND VGND VPWR VPWR _03958_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_82_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10816_ _02885_ _02887_ VGND VGND VPWR VPWR _02888_ sky130_fd_sc_hd__nor2_1
XFILLER_0_54_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14584_ _06952_ _06953_ VGND VGND VPWR VPWR _06992_ sky130_fd_sc_hd__or2_1
XFILLER_0_28_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10747_ _02688_ _02692_ _02689_ VGND VGND VPWR VPWR _02813_ sky130_fd_sc_hd__o21ba_1
X_13535_ net629 net368 VGND VGND VPWR VPWR _05853_ sky130_fd_sc_hd__and2_1
XFILLER_0_27_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10678_ _02600_ _02601_ _02599_ VGND VGND VPWR VPWR _02738_ sky130_fd_sc_hd__a21o_1
XFILLER_0_42_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13466_ _05774_ _05775_ _05756_ VGND VGND VPWR VPWR _05778_ sky130_fd_sc_hd__a21oi_2
X_12417_ _04631_ _04632_ VGND VGND VPWR VPWR _04633_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_113_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13397_ _05701_ _05575_ VGND VGND VPWR VPWR _05702_ sky130_fd_sc_hd__xnor2_1
X_12348_ _04494_ _04515_ VGND VGND VPWR VPWR _04558_ sky130_fd_sc_hd__or2b_1
X_12279_ net557 net293 _04480_ _04481_ VGND VGND VPWR VPWR _04483_ sky130_fd_sc_hd__nand4_2
XFILLER_0_121_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14018_ _06304_ _06307_ _06305_ VGND VGND VPWR VPWR _06378_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_4_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08510_ _00474_ _00477_ _00558_ VGND VGND VPWR VPWR _00559_ sky130_fd_sc_hd__a21o_1
X_09490_ _01441_ _01443_ _01442_ VGND VGND VPWR VPWR _01491_ sky130_fd_sc_hd__o21ba_1
X_08441_ _00472_ _00470_ VGND VGND VPWR VPWR _00490_ sky130_fd_sc_hd__and2b_1
XFILLER_0_81_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08372_ _00409_ _00421_ VGND VGND VPWR VPWR _00422_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout401 net404 VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_1_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout412 net414 VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__buf_4
Xfanout423 net426 VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__buf_2
Xfanout445 net449 VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__clkbuf_4
Xfanout456 net458 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__clkbuf_4
Xfanout434 net435 VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__clkbuf_4
X_09826_ net716 net724 net390 net382 VGND VGND VPWR VPWR _01827_ sky130_fd_sc_hd__and4_1
Xfanout467 net468 VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__clkbuf_4
Xfanout478 net482 VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__clkbuf_4
Xfanout489 net492 VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__clkbuf_4
X_09757_ _01724_ _01731_ _01733_ VGND VGND VPWR VPWR _01758_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_61_Left_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08708_ _00750_ _00753_ VGND VGND VPWR VPWR _00754_ sky130_fd_sc_hd__xor2_1
XFILLER_0_96_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09688_ _01686_ _01688_ VGND VGND VPWR VPWR _01689_ sky130_fd_sc_hd__nor2_1
XFILLER_0_68_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08639_ _00682_ _00684_ VGND VGND VPWR VPWR _00686_ sky130_fd_sc_hd__and2_1
X_11650_ net289 net713 VGND VGND VPWR VPWR _03798_ sky130_fd_sc_hd__nand2_1
X_11581_ _03719_ _03720_ _03703_ VGND VGND VPWR VPWR _03722_ sky130_fd_sc_hd__a21o_1
XFILLER_0_126_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10601_ _02645_ _02653_ VGND VGND VPWR VPWR _02654_ sky130_fd_sc_hd__xor2_1
X_10532_ _02576_ _02578_ VGND VGND VPWR VPWR _02579_ sky130_fd_sc_hd__xnor2_1
X_13320_ _05603_ _05602_ _05601_ VGND VGND VPWR VPWR _05617_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_107_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_70_Left_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10463_ _02503_ VGND VGND VPWR VPWR _00061_ sky130_fd_sc_hd__clkbuf_1
X_13251_ _05513_ _05510_ _05511_ VGND VGND VPWR VPWR _05541_ sky130_fd_sc_hd__nand3_1
X_12202_ net191 net182 net172 net275 VGND VGND VPWR VPWR _04399_ sky130_fd_sc_hd__a22o_1
XFILLER_0_122_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10394_ _02412_ _02427_ VGND VGND VPWR VPWR _02428_ sky130_fd_sc_hd__xnor2_1
X_13182_ _05463_ _05462_ _05461_ _05449_ VGND VGND VPWR VPWR _05465_ sky130_fd_sc_hd__o211ai_2
X_12133_ _04216_ _04230_ _04323_ VGND VGND VPWR VPWR _04324_ sky130_fd_sc_hd__o21a_1
XFILLER_0_103_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12064_ _04248_ VGND VGND VPWR VPWR _00077_ sky130_fd_sc_hd__clkbuf_1
X_11015_ _03101_ _03102_ VGND VGND VPWR VPWR _03104_ sky130_fd_sc_hd__and2b_1
XFILLER_0_35_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14705_ clknet_3_3_0_clk _00006_ net318 VGND VGND VPWR VPWR b_sin\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_59_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12966_ net544 net338 VGND VGND VPWR VPWR _05228_ sky130_fd_sc_hd__nand2_1
X_11917_ _04025_ _04033_ _04031_ VGND VGND VPWR VPWR _04089_ sky130_fd_sc_hd__a21o_1
X_12897_ _05098_ _05108_ _05152_ VGND VGND VPWR VPWR _05153_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_75_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11848_ net312 net135 net235 VGND VGND VPWR VPWR _04014_ sky130_fd_sc_hd__and3_1
X_14636_ net595 net605 net434 net426 VGND VGND VPWR VPWR _07049_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_109_Left_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14567_ _01926_ _06971_ _06973_ _06974_ VGND VGND VPWR VPWR _00105_ sky130_fd_sc_hd__a31o_1
XFILLER_0_27_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11779_ _03936_ _03937_ _03917_ VGND VGND VPWR VPWR _03939_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_83_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13518_ _05831_ _05832_ _05823_ VGND VGND VPWR VPWR _05834_ sky130_fd_sc_hd__a21o_1
XFILLER_0_70_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14498_ _06875_ _06898_ VGND VGND VPWR VPWR _06900_ sky130_fd_sc_hd__nand2_1
XFILLER_0_113_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13449_ net620 net395 net386 net629 VGND VGND VPWR VPWR _05759_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08990_ _01030_ _01031_ VGND VGND VPWR VPWR _01032_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_118_Left_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07941_ _07227_ _07234_ _07235_ VGND VGND VPWR VPWR _07236_ sky130_fd_sc_hd__nand3_2
X_07872_ net197 net770 VGND VGND VPWR VPWR _07168_ sky130_fd_sc_hd__nand2_1
X_09611_ net692 net701 net332 net476 VGND VGND VPWR VPWR _01612_ sky130_fd_sc_hd__and4_1
XFILLER_0_92_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09542_ net552 net647 net392 net383 VGND VGND VPWR VPWR _01543_ sky130_fd_sc_hd__and4_1
XFILLER_0_93_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09473_ _01423_ _01425_ _01424_ VGND VGND VPWR VPWR _01474_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_127_Left_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08424_ _00423_ _00473_ VGND VGND VPWR VPWR _00474_ sky130_fd_sc_hd__xor2_1
XFILLER_0_46_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08355_ _00403_ _00332_ _00404_ VGND VGND VPWR VPWR _00405_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_18_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08286_ net281 net263 net508 net516 VGND VGND VPWR VPWR _00337_ sky130_fd_sc_hd__and4_1
XFILLER_0_33_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout220 net221 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__buf_2
Xfanout231 net233 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__buf_4
XFILLER_0_100_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout264 net269 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__buf_2
Xfanout253 net254 VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__clkbuf_4
Xfanout242 net63 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__buf_2
Xfanout297 net298 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__clkbuf_4
Xfanout275 net277 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__clkbuf_4
Xfanout286 net287 VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__clkbuf_4
X_09809_ net708 net485 net407 net716 VGND VGND VPWR VPWR _01810_ sky130_fd_sc_hd__a22o_1
X_12820_ _04993_ _04996_ _05069_ VGND VGND VPWR VPWR _05070_ sky130_fd_sc_hd__or3_1
X_12751_ net189 net259 _04994_ VGND VGND VPWR VPWR _04995_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_139_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11702_ _03764_ _03769_ _03853_ _03854_ VGND VGND VPWR VPWR _03855_ sky130_fd_sc_hd__a211o_1
XFILLER_0_84_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12682_ _04920_ VGND VGND VPWR VPWR _00085_ sky130_fd_sc_hd__clkbuf_1
X_11633_ net255 net745 _03751_ _03752_ VGND VGND VPWR VPWR _03779_ sky130_fd_sc_hd__a31o_1
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14421_ _06761_ _06763_ VGND VGND VPWR VPWR _06816_ sky130_fd_sc_hd__or2_1
XFILLER_0_37_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11564_ _03641_ _03646_ _03640_ VGND VGND VPWR VPWR _03703_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_52_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14352_ _06720_ _06721_ _06740_ VGND VGND VPWR VPWR _06741_ sky130_fd_sc_hd__o21a_1
X_11495_ _03437_ _03563_ _03443_ VGND VGND VPWR VPWR _03628_ sky130_fd_sc_hd__a21o_1
XFILLER_0_52_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10515_ _02466_ _02472_ VGND VGND VPWR VPWR _02561_ sky130_fd_sc_hd__and2_4
X_13303_ _05546_ _05543_ _05544_ VGND VGND VPWR VPWR _05598_ sky130_fd_sc_hd__or3_1
X_14283_ _06662_ _06665_ VGND VGND VPWR VPWR _06666_ sky130_fd_sc_hd__xor2_1
X_10446_ _02378_ _02380_ VGND VGND VPWR VPWR _02486_ sky130_fd_sc_hd__nor2_1
X_13234_ _05507_ _05520_ _05519_ VGND VGND VPWR VPWR _05522_ sky130_fd_sc_hd__a21o_1
XFILLER_0_21_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10377_ _02329_ _02347_ VGND VGND VPWR VPWR _02410_ sky130_fd_sc_hd__nand2_1
X_13165_ _05439_ _05444_ _05445_ VGND VGND VPWR VPWR _05447_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_20_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12116_ _04303_ _04305_ VGND VGND VPWR VPWR _04306_ sky130_fd_sc_hd__nor2_1
X_13096_ _05367_ _05368_ _05363_ VGND VGND VPWR VPWR _05371_ sky130_fd_sc_hd__a21o_1
X_12047_ _04216_ _04230_ VGND VGND VPWR VPWR _04231_ sky130_fd_sc_hd__xnor2_1
X_13998_ _06301_ _06356_ VGND VGND VPWR VPWR _06357_ sky130_fd_sc_hd__xor2_1
XFILLER_0_75_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12949_ _05206_ _05207_ _05208_ VGND VGND VPWR VPWR _05209_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_141_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14619_ _06788_ VGND VGND VPWR VPWR _07030_ sky130_fd_sc_hd__inv_2
X_08140_ _00191_ _00192_ VGND VGND VPWR VPWR _00193_ sky130_fd_sc_hd__or2b_1
XFILLER_0_70_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08071_ _07329_ _07330_ _00122_ _00123_ VGND VGND VPWR VPWR _00125_ sky130_fd_sc_hd__a22o_1
XFILLER_0_3_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08973_ _01013_ _01011_ VGND VGND VPWR VPWR _01015_ sky130_fd_sc_hd__and2b_1
XFILLER_0_87_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07924_ _07217_ _07218_ VGND VGND VPWR VPWR _07219_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold39 a_cos\[1\] VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__dlygate4sd3_1
X_07855_ _07143_ _07150_ VGND VGND VPWR VPWR _07151_ sky130_fd_sc_hd__xnor2_1
X_07786_ _06614_ _06625_ _06733_ VGND VGND VPWR VPWR _06755_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_97_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09525_ _01525_ VGND VGND VPWR VPWR _01526_ sky130_fd_sc_hd__inv_2
X_09456_ net734 net741 net330 net475 VGND VGND VPWR VPWR _01457_ sky130_fd_sc_hd__and4_1
X_08407_ net214 net204 net580 VGND VGND VPWR VPWR _00457_ sky130_fd_sc_hd__o21a_2
XFILLER_0_66_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09387_ _01381_ _01382_ _01387_ VGND VGND VPWR VPWR _01388_ sky130_fd_sc_hd__nand3_1
XFILLER_0_105_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08338_ _00386_ _00388_ VGND VGND VPWR VPWR _00389_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_117_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08269_ net249 net533 net541 net239 VGND VGND VPWR VPWR _00320_ sky130_fd_sc_hd__a22oi_1
X_11280_ _03390_ _03268_ VGND VGND VPWR VPWR _03391_ sky130_fd_sc_hd__and2_1
XFILLER_0_104_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10300_ _02310_ _02325_ VGND VGND VPWR VPWR _02326_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_61_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10231_ _02248_ _02249_ _02250_ VGND VGND VPWR VPWR _02251_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10162_ net184 net270 net396 VGND VGND VPWR VPWR _02176_ sky130_fd_sc_hd__and3_1
X_10093_ _01938_ _02100_ VGND VGND VPWR VPWR _02101_ sky130_fd_sc_hd__xor2_1
X_13921_ _06265_ _06272_ VGND VGND VPWR VPWR _06273_ sky130_fd_sc_hd__xor2_1
X_13852_ _06181_ _06196_ VGND VGND VPWR VPWR _06197_ sky130_fd_sc_hd__xnor2_2
X_12803_ _05049_ _05050_ VGND VGND VPWR VPWR _05051_ sky130_fd_sc_hd__xor2_2
X_13783_ net640 net334 net478 net495 VGND VGND VPWR VPWR _06122_ sky130_fd_sc_hd__a22o_1
X_12734_ _04778_ _04850_ _04915_ _04849_ VGND VGND VPWR VPWR _04977_ sky130_fd_sc_hd__or4bb_1
XFILLER_0_85_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10995_ _02991_ _03074_ _03079_ VGND VGND VPWR VPWR _03082_ sky130_fd_sc_hd__o21a_1
XFILLER_0_139_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12665_ _04898_ _04900_ VGND VGND VPWR VPWR _04903_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11616_ _03757_ _03758_ _03738_ _03739_ VGND VGND VPWR VPWR _03761_ sky130_fd_sc_hd__a211o_1
X_12596_ _04825_ _04827_ VGND VGND VPWR VPWR _04828_ sky130_fd_sc_hd__nor2_1
X_14404_ net615 net438 VGND VGND VPWR VPWR _06797_ sky130_fd_sc_hd__nand2_1
X_11547_ _03666_ _03667_ _03683_ _03684_ VGND VGND VPWR VPWR _03685_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_108_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14335_ _06517_ _06664_ VGND VGND VPWR VPWR _06723_ sky130_fd_sc_hd__or2_1
XFILLER_0_123_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11478_ net288 net738 VGND VGND VPWR VPWR _03609_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14266_ net587 net333 net479 net596 VGND VGND VPWR VPWR _06648_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_122_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14197_ _06555_ _06556_ _06571_ VGND VGND VPWR VPWR _06573_ sky130_fd_sc_hd__nand3_1
X_10429_ net393 net384 VGND VGND VPWR VPWR _02467_ sky130_fd_sc_hd__or2_2
X_13217_ _05493_ _05500_ _05503_ VGND VGND VPWR VPWR _05504_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13148_ _05421_ _05422_ _05426_ VGND VGND VPWR VPWR _05428_ sky130_fd_sc_hd__a21oi_1
X_13079_ _05328_ _05329_ _05349_ _05350_ VGND VGND VPWR VPWR _05352_ sky130_fd_sc_hd__or4_4
XFILLER_0_73_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07640_ _03966_ _05150_ VGND VGND VPWR VPWR _05161_ sky130_fd_sc_hd__or2_1
XFILLER_0_79_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07571_ _03977_ _04130_ VGND VGND VPWR VPWR _04413_ sky130_fd_sc_hd__xnor2_1
X_09310_ net110 _01320_ net129 VGND VGND VPWR VPWR _01321_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09241_ _01257_ _01259_ _01256_ VGND VGND VPWR VPWR _01262_ sky130_fd_sc_hd__o21ba_1
X_09172_ a_cos\[7\] b_sin\[7\] VGND VGND VPWR VPWR _01203_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08123_ _07317_ _07318_ _07319_ VGND VGND VPWR VPWR _00176_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_16_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08054_ _07345_ _07346_ _07347_ VGND VGND VPWR VPWR _07348_ sky130_fd_sc_hd__and3_2
XFILLER_0_31_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08956_ _00864_ _00934_ _00862_ VGND VGND VPWR VPWR _00998_ sky130_fd_sc_hd__a21o_1
X_08887_ net292 net581 _00878_ VGND VGND VPWR VPWR _00930_ sky130_fd_sc_hd__a21oi_1
X_07907_ _07126_ _07200_ _07202_ VGND VGND VPWR VPWR _07203_ sky130_fd_sc_hd__o21a_1
XFILLER_0_98_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07838_ _07132_ _07133_ VGND VGND VPWR VPWR _07134_ sky130_fd_sc_hd__nor2_1
X_07769_ _06549_ _06559_ VGND VGND VPWR VPWR _06570_ sky130_fd_sc_hd__and2b_1
X_09508_ net727 net467 VGND VGND VPWR VPWR _01509_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10780_ net133 net342 _02709_ _02648_ VGND VGND VPWR VPWR _02848_ sky130_fd_sc_hd__a31o_1
XFILLER_0_137_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09439_ _01383_ _01385_ _01384_ VGND VGND VPWR VPWR _01440_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_19_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12450_ _04575_ _04578_ VGND VGND VPWR VPWR _04669_ sky130_fd_sc_hd__or2_1
XFILLER_0_47_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11401_ _03485_ _03501_ VGND VGND VPWR VPWR _03524_ sky130_fd_sc_hd__nor2_1
X_12381_ _04495_ _04501_ VGND VGND VPWR VPWR _04594_ sky130_fd_sc_hd__nand2_1
XFILLER_0_62_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14120_ _06430_ _06435_ VGND VGND VPWR VPWR _06489_ sky130_fd_sc_hd__or2b_1
X_11332_ _03445_ _03447_ VGND VGND VPWR VPWR _03448_ sky130_fd_sc_hd__or2_1
XFILLER_0_15_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11263_ net194 net704 _03320_ _03318_ net695 VGND VGND VPWR VPWR _03372_ sky130_fd_sc_hd__a32o_1
XFILLER_0_105_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14051_ _06405_ _06412_ _06413_ VGND VGND VPWR VPWR _06414_ sky130_fd_sc_hd__nand3_2
X_11194_ _03293_ _03294_ _03295_ VGND VGND VPWR VPWR _03296_ sky130_fd_sc_hd__a21bo_1
X_10214_ _02126_ _02131_ VGND VGND VPWR VPWR _02232_ sky130_fd_sc_hd__and2b_1
X_13002_ _05258_ _05266_ VGND VGND VPWR VPWR _05267_ sky130_fd_sc_hd__xor2_1
X_10145_ _02153_ _02154_ _02155_ VGND VGND VPWR VPWR _02158_ sky130_fd_sc_hd__a21o_1
X_10076_ _02055_ _02056_ _02080_ VGND VGND VPWR VPWR _02083_ sky130_fd_sc_hd__o21ba_1
X_13904_ _06134_ _06163_ _06253_ VGND VGND VPWR VPWR _06254_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_89_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13835_ _06106_ _06109_ VGND VGND VPWR VPWR _06179_ sky130_fd_sc_hd__or2_1
X_10978_ _02997_ _03055_ VGND VGND VPWR VPWR _03063_ sky130_fd_sc_hd__nand2_2
X_13766_ _06101_ _06103_ VGND VGND VPWR VPWR _06104_ sky130_fd_sc_hd__nor2_1
XFILLER_0_127_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12717_ _04954_ _04957_ VGND VGND VPWR VPWR _04959_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13697_ _06024_ _06025_ _06027_ VGND VGND VPWR VPWR _06029_ sky130_fd_sc_hd__nand3_1
XFILLER_0_128_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12648_ _04882_ _04883_ VGND VGND VPWR VPWR _04884_ sky130_fd_sc_hd__xnor2_2
X_12579_ _04735_ _04808_ VGND VGND VPWR VPWR _04809_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_104_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14318_ _06618_ _06633_ _06703_ _06704_ VGND VGND VPWR VPWR _06705_ sky130_fd_sc_hd__o211a_1
X_14249_ b_cos\[9\] _06629_ _05794_ VGND VGND VPWR VPWR _06630_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08810_ _00854_ VGND VGND VPWR VPWR _00855_ sky130_fd_sc_hd__inv_2
XFILLER_0_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09790_ _01783_ _01784_ _01790_ VGND VGND VPWR VPWR _01791_ sky130_fd_sc_hd__nor3_1
X_08741_ _00692_ _00728_ _00785_ _00786_ VGND VGND VPWR VPWR _00787_ sky130_fd_sc_hd__o211a_1
X_08672_ _00718_ VGND VGND VPWR VPWR _00719_ sky130_fd_sc_hd__inv_2
X_07623_ _04674_ _04956_ _04967_ VGND VGND VPWR VPWR _04978_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_48_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07554_ net308 net229 net497 net506 VGND VGND VPWR VPWR _04228_ sky130_fd_sc_hd__and4_1
XFILLER_0_76_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07485_ _02669_ _02690_ _02680_ VGND VGND VPWR VPWR _03473_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_64_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09224_ _01246_ _01247_ VGND VGND VPWR VPWR _01248_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_63_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09155_ net87 _01188_ net128 VGND VGND VPWR VPWR _01189_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09086_ _01072_ _01085_ _01123_ VGND VGND VPWR VPWR _01126_ sky130_fd_sc_hd__and3_1
X_08106_ _00157_ _00158_ VGND VGND VPWR VPWR _00159_ sky130_fd_sc_hd__nand2_1
XFILLER_0_71_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08037_ _07253_ _07270_ _07271_ VGND VGND VPWR VPWR _07331_ sky130_fd_sc_hd__nand3_2
XFILLER_0_4_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09988_ _01639_ _01641_ _01640_ VGND VGND VPWR VPWR _01988_ sky130_fd_sc_hd__o21bai_1
X_08939_ _00965_ _00963_ VGND VGND VPWR VPWR _00981_ sky130_fd_sc_hd__or2b_1
X_11950_ _04121_ _04124_ VGND VGND VPWR VPWR _04125_ sky130_fd_sc_hd__xor2_1
X_10901_ _02977_ _02978_ _02901_ _02920_ VGND VGND VPWR VPWR _02980_ sky130_fd_sc_hd__a211o_1
X_11881_ _04047_ _04048_ _03877_ VGND VGND VPWR VPWR _04050_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_67_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10832_ _02880_ _02881_ _02903_ VGND VGND VPWR VPWR _02905_ sky130_fd_sc_hd__or3_1
XFILLER_0_39_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13620_ net494 net503 net341 net337 VGND VGND VPWR VPWR _05945_ sky130_fd_sc_hd__and4_1
XFILLER_0_94_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10763_ _02828_ _02829_ VGND VGND VPWR VPWR _02830_ sky130_fd_sc_hd__nand2_1
X_13551_ _05867_ _05868_ _05869_ VGND VGND VPWR VPWR _05870_ sky130_fd_sc_hd__nand3_1
X_12502_ _04723_ _04724_ VGND VGND VPWR VPWR _04725_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_81_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13482_ b_cos\[0\] _05793_ _05794_ VGND VGND VPWR VPWR _05795_ sky130_fd_sc_hd__mux2_1
X_10694_ _02753_ _02754_ VGND VGND VPWR VPWR _02755_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_54_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12433_ _04649_ _04648_ VGND VGND VPWR VPWR _04650_ sky130_fd_sc_hd__nor2b_4
X_12364_ _04559_ _04560_ _04574_ VGND VGND VPWR VPWR _04575_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_124_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11315_ _03424_ _03428_ VGND VGND VPWR VPWR _03430_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_50_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14103_ net504 net513 net428 net420 VGND VGND VPWR VPWR _06470_ sky130_fd_sc_hd__and4_1
X_12295_ _04313_ _04499_ VGND VGND VPWR VPWR _04501_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_120_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14034_ _06376_ _06393_ VGND VGND VPWR VPWR _06395_ sky130_fd_sc_hd__or2_1
XFILLER_0_22_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11246_ _03347_ _03351_ _03353_ VGND VGND VPWR VPWR _03354_ sky130_fd_sc_hd__nand3_1
XFILLER_0_129_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11177_ net307 net677 net684 net228 VGND VGND VPWR VPWR _03278_ sky130_fd_sc_hd__a22o_1
X_10128_ _02137_ _02138_ VGND VGND VPWR VPWR _02139_ sky130_fd_sc_hd__nand2_1
X_10059_ _02060_ _02063_ VGND VGND VPWR VPWR _02064_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_54_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14798_ clknet_3_4_0_clk _00099_ net319 VGND VGND VPWR VPWR b_cos\[8\] sky130_fd_sc_hd__dfrtp_1
X_13818_ _06145_ _06160_ VGND VGND VPWR VPWR _06161_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_97_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13749_ _05897_ _05987_ VGND VGND VPWR VPWR _06086_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09911_ _01800_ _01911_ VGND VGND VPWR VPWR _01912_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout605 net610 VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__buf_2
Xfanout627 net628 VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__buf_4
XFILLER_0_95_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09842_ _01840_ _01842_ VGND VGND VPWR VPWR _01843_ sky130_fd_sc_hd__xnor2_1
Xfanout649 net655 VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__clkbuf_4
Xfanout638 net639 VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__clkbuf_4
Xfanout616 net619 VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__dlymetal6s2s_1
X_09773_ _01768_ _01769_ _01773_ VGND VGND VPWR VPWR _01774_ sky130_fd_sc_hd__a21o_1
X_08724_ net251 net243 net645 net500 VGND VGND VPWR VPWR _00770_ sky130_fd_sc_hd__and4_1
X_08655_ _00576_ _00577_ _00575_ VGND VGND VPWR VPWR _00702_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_135_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07606_ _04511_ _04782_ VGND VGND VPWR VPWR _04793_ sky130_fd_sc_hd__xnor2_1
X_08586_ _00631_ _00632_ _00569_ _00570_ VGND VGND VPWR VPWR _00634_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_119_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07537_ net211 net202 net514 VGND VGND VPWR VPWR _04043_ sky130_fd_sc_hd__and3_1
X_07468_ net224 net624 VGND VGND VPWR VPWR _03286_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07399_ _02473_ _02527_ VGND VGND VPWR VPWR _02538_ sky130_fd_sc_hd__xnor2_2
X_09207_ a_cos\[12\] b_sin\[12\] VGND VGND VPWR VPWR _01233_ sky130_fd_sc_hd__or2_1
X_09138_ a_cos\[2\] b_sin\[2\] VGND VGND VPWR VPWR _01174_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09069_ _01057_ _01060_ _01107_ VGND VGND VPWR VPWR _01109_ sky130_fd_sc_hd__nor3_1
X_11100_ _03193_ _03194_ VGND VGND VPWR VPWR _03195_ sky130_fd_sc_hd__nor2_1
X_12080_ _04264_ _04265_ VGND VGND VPWR VPWR _04266_ sky130_fd_sc_hd__or2_1
X_11031_ _02924_ _03119_ VGND VGND VPWR VPWR _03120_ sky130_fd_sc_hd__and2_1
X_12982_ _05242_ _05243_ _05241_ VGND VGND VPWR VPWR _05245_ sky130_fd_sc_hd__a21o_1
X_11933_ _04089_ _04104_ _04105_ VGND VGND VPWR VPWR _04106_ sky130_fd_sc_hd__and3_1
XFILLER_0_99_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14721_ clknet_3_0_0_clk _00022_ net314 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dfrtp_1
X_11864_ _04026_ _04029_ _04030_ VGND VGND VPWR VPWR _04031_ sky130_fd_sc_hd__and3_1
X_14652_ _07009_ _07064_ VGND VGND VPWR VPWR _07066_ sky130_fd_sc_hd__nor2_1
XFILLER_0_95_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10815_ net555 net650 net433 net425 VGND VGND VPWR VPWR _02887_ sky130_fd_sc_hd__and4_1
X_13603_ _05923_ _05924_ _05915_ VGND VGND VPWR VPWR _05926_ sky130_fd_sc_hd__a21o_1
X_11795_ _03955_ _03777_ _03860_ VGND VGND VPWR VPWR _03957_ sky130_fd_sc_hd__o21a_1
X_14583_ _06989_ _06990_ VGND VGND VPWR VPWR _06991_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10746_ _02684_ _02685_ _02703_ _02704_ VGND VGND VPWR VPWR _02812_ sky130_fd_sc_hd__o211ai_1
X_13534_ _05840_ _05850_ VGND VGND VPWR VPWR _05851_ sky130_fd_sc_hd__xor2_1
XFILLER_0_82_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10677_ _02730_ _02736_ VGND VGND VPWR VPWR _02737_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13465_ _05756_ _05774_ _05775_ VGND VGND VPWR VPWR _05777_ sky130_fd_sc_hd__and3_1
X_12416_ net654 net260 VGND VGND VPWR VPWR _04632_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13396_ _05569_ _05576_ VGND VGND VPWR VPWR _05701_ sky130_fd_sc_hd__and2b_1
X_12347_ _04513_ _04514_ VGND VGND VPWR VPWR _04557_ sky130_fd_sc_hd__or2b_1
XFILLER_0_50_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12278_ net557 net293 _04480_ _04481_ VGND VGND VPWR VPWR _04482_ sky130_fd_sc_hd__a22o_1
XFILLER_0_121_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11229_ _03331_ _03334_ VGND VGND VPWR VPWR _03335_ sky130_fd_sc_hd__xnor2_1
X_14017_ _06302_ _06322_ _06319_ VGND VGND VPWR VPWR _06377_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_4_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08440_ _00406_ _00422_ _00488_ VGND VGND VPWR VPWR _00489_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_105_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08371_ _00418_ _00420_ VGND VGND VPWR VPWR _00421_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_86_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout413 net414 VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__clkbuf_4
Xfanout402 net404 VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__buf_4
X_09825_ net733 net366 VGND VGND VPWR VPWR _01826_ sky130_fd_sc_hd__nand2_1
Xfanout457 net458 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__buf_2
Xfanout446 net449 VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__clkbuf_2
Xfanout435 net43 VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__clkbuf_4
Xfanout424 net426 VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__buf_2
Xfanout479 net482 VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__clkbuf_2
Xfanout468 net473 VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__clkbuf_4
X_09756_ _01755_ _01754_ _01753_ _01750_ VGND VGND VPWR VPWR _01757_ sky130_fd_sc_hd__o211ai_2
X_08707_ _00615_ _00752_ VGND VGND VPWR VPWR _00753_ sky130_fd_sc_hd__xor2_4
X_09687_ _01686_ _01687_ net734 net339 VGND VGND VPWR VPWR _01688_ sky130_fd_sc_hd__and4bb_1
X_08638_ _00682_ _00684_ VGND VGND VPWR VPWR _00685_ sky130_fd_sc_hd__nor2_1
XFILLER_0_139_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08569_ net181 net171 net589 net581 VGND VGND VPWR VPWR _00617_ sky130_fd_sc_hd__and4_1
XFILLER_0_76_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11580_ _03703_ _03719_ _03720_ VGND VGND VPWR VPWR _03721_ sky130_fd_sc_hd__nand3_4
XFILLER_0_107_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10600_ _02646_ _02652_ VGND VGND VPWR VPWR _02653_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_37_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10531_ _02430_ _02488_ _02577_ VGND VGND VPWR VPWR _02578_ sky130_fd_sc_hd__a21o_1
XFILLER_0_9_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13250_ _05518_ _05515_ _05517_ VGND VGND VPWR VPWR _05540_ sky130_fd_sc_hd__nand3_1
X_12201_ _04307_ _04309_ _04308_ VGND VGND VPWR VPWR _04398_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_122_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10462_ a_cos\[6\] _02502_ _02303_ VGND VGND VPWR VPWR _02503_ sky130_fd_sc_hd__mux2_1
XFILLER_0_60_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10393_ _02424_ _02426_ VGND VGND VPWR VPWR _02427_ sky130_fd_sc_hd__xnor2_1
X_13181_ _05449_ _05461_ _05462_ _05463_ VGND VGND VPWR VPWR _05464_ sky130_fd_sc_hd__a211o_1
X_12132_ _04227_ _04229_ VGND VGND VPWR VPWR _04323_ sky130_fd_sc_hd__or2b_1
XFILLER_0_130_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12063_ a_sin\[4\] _04247_ _04160_ VGND VGND VPWR VPWR _04248_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11014_ _03053_ _03054_ _03100_ VGND VGND VPWR VPWR _03102_ sky130_fd_sc_hd__nand3_1
X_12965_ net528 net536 net355 net345 VGND VGND VPWR VPWR _05227_ sky130_fd_sc_hd__and4_1
X_11916_ _03995_ _03997_ VGND VGND VPWR VPWR _04088_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14704_ clknet_3_3_0_clk _00005_ net317 VGND VGND VPWR VPWR b_sin\[5\] sky130_fd_sc_hd__dfrtp_1
X_12896_ _05109_ _05131_ _05132_ VGND VGND VPWR VPWR _05152_ sky130_fd_sc_hd__or3_1
X_11847_ net312 net135 net235 VGND VGND VPWR VPWR _04013_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_129_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14635_ _06998_ _07005_ _07046_ VGND VGND VPWR VPWR _07048_ sky130_fd_sc_hd__a21o_1
X_11778_ _03917_ _03936_ _03937_ VGND VGND VPWR VPWR _03938_ sky130_fd_sc_hd__and3_1
X_14566_ b_cos\[14\] _00918_ VGND VGND VPWR VPWR _06974_ sky130_fd_sc_hd__and2_1
X_10729_ _02772_ _02773_ _02791_ _02792_ VGND VGND VPWR VPWR _02793_ sky130_fd_sc_hd__o211a_1
XFILLER_0_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13517_ _05823_ _05831_ _05832_ VGND VGND VPWR VPWR _05833_ sky130_fd_sc_hd__nand3_2
X_14497_ _06875_ _06898_ VGND VGND VPWR VPWR _06899_ sky130_fd_sc_hd__or2_1
XFILLER_0_141_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13448_ net620 net629 net395 net386 VGND VGND VPWR VPWR _05758_ sky130_fd_sc_hd__and4_1
XFILLER_0_2_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13379_ net570 net400 VGND VGND VPWR VPWR _05682_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07940_ _07231_ _07232_ _07233_ VGND VGND VPWR VPWR _07235_ sky130_fd_sc_hd__a21o_1
X_07871_ _07157_ _07166_ VGND VGND VPWR VPWR _07167_ sky130_fd_sc_hd__xor2_2
XFILLER_0_76_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09610_ net692 net332 net476 net701 VGND VGND VPWR VPWR _01611_ sky130_fd_sc_hd__a22oi_2
X_09541_ net664 net367 VGND VGND VPWR VPWR _01542_ sky130_fd_sc_hd__nand2_1
XFILLER_0_116_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09472_ _01429_ _01434_ _01428_ VGND VGND VPWR VPWR _01473_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_25_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08423_ _00470_ _00472_ VGND VGND VPWR VPWR _00473_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08354_ _00318_ _00331_ VGND VGND VPWR VPWR _00404_ sky130_fd_sc_hd__nand2_1
XFILLER_0_73_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08285_ net281 net508 net516 net263 VGND VGND VPWR VPWR _00336_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_116_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout221 net66 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__buf_6
Xfanout232 net234 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__buf_4
Xfanout210 net217 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__buf_6
Xfanout243 net246 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__clkbuf_4
Xfanout265 net268 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__clkbuf_4
Xfanout254 net62 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__clkbuf_4
Xfanout298 net303 VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__buf_4
Xfanout276 net277 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__clkbuf_4
Xfanout287 net59 VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__buf_4
X_09808_ net724 net399 VGND VGND VPWR VPWR _01809_ sky130_fd_sc_hd__and2_1
XFILLER_0_97_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09739_ net699 net399 VGND VGND VPWR VPWR _01740_ sky130_fd_sc_hd__and2_1
XFILLER_0_69_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12750_ _04992_ _04993_ VGND VGND VPWR VPWR _04994_ sky130_fd_sc_hd__nor2_1
XFILLER_0_139_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11701_ _03851_ _03852_ _03787_ VGND VGND VPWR VPWR _03854_ sky130_fd_sc_hd__a21oi_2
X_12681_ a_sin\[12\] _04919_ _04160_ VGND VGND VPWR VPWR _04920_ sky130_fd_sc_hd__mux2_1
XFILLER_0_127_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11632_ _03766_ VGND VGND VPWR VPWR _03778_ sky130_fd_sc_hd__inv_2
X_14420_ _06813_ _06814_ VGND VGND VPWR VPWR _06815_ sky130_fd_sc_hd__xor2_1
XFILLER_0_112_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14351_ _06725_ _06739_ VGND VGND VPWR VPWR _06740_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11563_ _03650_ _03651_ _03661_ VGND VGND VPWR VPWR _03702_ sky130_fd_sc_hd__nand3_2
XFILLER_0_24_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13302_ _05554_ _05548_ _05553_ VGND VGND VPWR VPWR _05597_ sky130_fd_sc_hd__nand3_1
XFILLER_0_134_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11494_ _03623_ _03624_ _03625_ VGND VGND VPWR VPWR _03626_ sky130_fd_sc_hd__and3_1
XFILLER_0_107_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10514_ _02458_ _02460_ VGND VGND VPWR VPWR _02559_ sky130_fd_sc_hd__nand2_1
XFILLER_0_40_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14282_ _06517_ _06664_ VGND VGND VPWR VPWR _06665_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_122_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10445_ _02453_ _02483_ VGND VGND VPWR VPWR _02485_ sky130_fd_sc_hd__xnor2_1
X_13233_ _05507_ _05519_ _05520_ VGND VGND VPWR VPWR _05521_ sky130_fd_sc_hd__nand3_2
XFILLER_0_21_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13164_ _05432_ _05438_ _05433_ VGND VGND VPWR VPWR _05445_ sky130_fd_sc_hd__nand3_1
XFILLER_0_32_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12115_ _04301_ _04302_ _04295_ VGND VGND VPWR VPWR _04305_ sky130_fd_sc_hd__a21oi_1
X_10376_ _02322_ _02324_ VGND VGND VPWR VPWR _02409_ sky130_fd_sc_hd__or2_1
X_13095_ _05363_ _05367_ _05368_ VGND VGND VPWR VPWR _05370_ sky130_fd_sc_hd__nand3_1
XFILLER_0_137_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12046_ _04227_ _04229_ VGND VGND VPWR VPWR _04230_ sky130_fd_sc_hd__xor2_1
XFILLER_0_46_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13997_ _06352_ _06355_ VGND VGND VPWR VPWR _06356_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_87_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12948_ net493 net502 net484 net406 VGND VGND VPWR VPWR _05208_ sky130_fd_sc_hd__and4_1
X_12879_ _05109_ _05133_ VGND VGND VPWR VPWR _05134_ sky130_fd_sc_hd__xor2_1
XFILLER_0_134_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14618_ _07018_ _07019_ VGND VGND VPWR VPWR _07029_ sky130_fd_sc_hd__and2b_1
XFILLER_0_83_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14549_ _06940_ _06954_ VGND VGND VPWR VPWR _06955_ sky130_fd_sc_hd__xnor2_1
X_08070_ _07329_ _07330_ _00122_ _00123_ VGND VGND VPWR VPWR _00124_ sky130_fd_sc_hd__nand4_2
XFILLER_0_31_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08972_ _01011_ _01013_ VGND VGND VPWR VPWR _01014_ sky130_fd_sc_hd__and2b_1
X_07923_ _07152_ _07154_ _07216_ VGND VGND VPWR VPWR _07218_ sky130_fd_sc_hd__and3_1
X_07854_ _07148_ _07149_ VGND VGND VPWR VPWR _07150_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07785_ _06614_ _06625_ _06733_ VGND VGND VPWR VPWR _06744_ sky130_fd_sc_hd__and3_1
XFILLER_0_36_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09524_ _01450_ net121 _01523_ _01524_ VGND VGND VPWR VPWR _01525_ sky130_fd_sc_hd__o211a_1
X_09455_ _01454_ _01455_ VGND VGND VPWR VPWR _01456_ sky130_fd_sc_hd__nor2_1
X_08406_ net214 net204 net580 VGND VGND VPWR VPWR _00456_ sky130_fd_sc_hd__nand3_2
XFILLER_0_78_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09386_ _01383_ _01386_ VGND VGND VPWR VPWR _01387_ sky130_fd_sc_hd__xnor2_1
X_08337_ _00255_ _00305_ _00387_ VGND VGND VPWR VPWR _00388_ sky130_fd_sc_hd__a21o_1
XFILLER_0_62_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08268_ net257 net533 _00259_ _00258_ net516 VGND VGND VPWR VPWR _00319_ sky130_fd_sc_hd__a32o_1
XFILLER_0_15_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08199_ _00240_ _00241_ _00250_ VGND VGND VPWR VPWR _00251_ sky130_fd_sc_hd__a21oi_2
X_10230_ net675 net473 VGND VGND VPWR VPWR _02250_ sky130_fd_sc_hd__and2_1
XFILLER_0_120_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10161_ net371 net369 VGND VGND VPWR VPWR _02175_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10092_ _02086_ _02099_ VGND VGND VPWR VPWR _02100_ sky130_fd_sc_hd__xnor2_1
X_13920_ _06268_ _06271_ VGND VGND VPWR VPWR _06272_ sky130_fd_sc_hd__nand2_1
XFILLER_0_88_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13851_ _06193_ _06195_ VGND VGND VPWR VPWR _06196_ sky130_fd_sc_hd__xnor2_2
X_12802_ net259 net145 VGND VGND VPWR VPWR _05050_ sky130_fd_sc_hd__nand2_1
X_10994_ _02991_ _03074_ _03079_ VGND VGND VPWR VPWR _03080_ sky130_fd_sc_hd__nor3_1
X_13782_ _06119_ _06120_ VGND VGND VPWR VPWR _06121_ sky130_fd_sc_hd__xnor2_2
X_12733_ _04917_ _04914_ VGND VGND VPWR VPWR _04976_ sky130_fd_sc_hd__nor2_1
XFILLER_0_38_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12664_ _04898_ _04900_ VGND VGND VPWR VPWR _04901_ sky130_fd_sc_hd__or2_2
X_14403_ net595 net605 net456 net446 VGND VGND VPWR VPWR _06796_ sky130_fd_sc_hd__and4_1
XFILLER_0_32_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11615_ _03738_ _03739_ _03757_ _03758_ VGND VGND VPWR VPWR _03760_ sky130_fd_sc_hd__o211ai_4
X_12595_ _04754_ _04755_ _04753_ VGND VGND VPWR VPWR _04827_ sky130_fd_sc_hd__a21o_1
XFILLER_0_120_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11546_ _03668_ _03669_ _03681_ VGND VGND VPWR VPWR _03684_ sky130_fd_sc_hd__and3_1
XFILLER_0_108_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14334_ _06647_ _06654_ VGND VGND VPWR VPWR _06721_ sky130_fd_sc_hd__and2_1
XFILLER_0_52_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14265_ _06644_ _06645_ VGND VGND VPWR VPWR _06647_ sky130_fd_sc_hd__xnor2_1
X_11477_ _03386_ _03388_ VGND VGND VPWR VPWR _03608_ sky130_fd_sc_hd__nor2_1
X_13216_ _05278_ _05502_ VGND VGND VPWR VPWR _05503_ sky130_fd_sc_hd__or2_1
X_14196_ _06555_ _06556_ _06571_ VGND VGND VPWR VPWR _06572_ sky130_fd_sc_hd__a21o_1
XFILLER_0_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10428_ net132 net393 net384 VGND VGND VPWR VPWR _02466_ sky130_fd_sc_hd__nand3_1
X_10359_ _02306_ _02390_ VGND VGND VPWR VPWR _02391_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13147_ _05421_ _05422_ _05426_ VGND VGND VPWR VPWR _05427_ sky130_fd_sc_hd__and3_1
XFILLER_0_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13078_ _05328_ _05329_ _05349_ _05350_ VGND VGND VPWR VPWR _05351_ sky130_fd_sc_hd__o22ai_1
X_12029_ net557 net160 _04209_ _04210_ VGND VGND VPWR VPWR _04211_ sky130_fd_sc_hd__a22o_1
X_07570_ _04380_ _04369_ _04358_ _04326_ VGND VGND VPWR VPWR _04402_ sky130_fd_sc_hd__o211a_1
XFILLER_0_73_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09240_ _01261_ VGND VGND VPWR VPWR _00034_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09171_ a_cos\[7\] b_sin\[7\] VGND VGND VPWR VPWR _01202_ sky130_fd_sc_hd__or2_1
XFILLER_0_44_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08122_ _00171_ _00172_ _00173_ VGND VGND VPWR VPWR _00175_ sky130_fd_sc_hd__nand3_1
XFILLER_0_43_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08053_ _07258_ _07266_ _07265_ VGND VGND VPWR VPWR _07347_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_102_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_131_Right_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08955_ _00864_ _00996_ VGND VGND VPWR VPWR _00997_ sky130_fd_sc_hd__xnor2_1
X_07906_ _07126_ _07201_ VGND VGND VPWR VPWR _07202_ sky130_fd_sc_hd__nand2_1
X_08886_ _00876_ _00878_ _00877_ VGND VGND VPWR VPWR _00929_ sky130_fd_sc_hd__a21o_1
X_07837_ _03803_ _03825_ _07131_ VGND VGND VPWR VPWR _07133_ sky130_fd_sc_hd__and3_1
X_07768_ _06233_ _06538_ net123 net762 VGND VGND VPWR VPWR _06559_ sky130_fd_sc_hd__a211o_1
XFILLER_0_78_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09507_ net735 net467 _01465_ _01463_ VGND VGND VPWR VPWR _01508_ sky130_fd_sc_hd__a31o_1
X_07699_ net771 _05787_ _05688_ _05776_ VGND VGND VPWR VPWR _05808_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_78_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09438_ _01410_ _01413_ VGND VGND VPWR VPWR _01439_ sky130_fd_sc_hd__or2b_1
XFILLER_0_137_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09369_ net129 net795 VGND VGND VPWR VPWR _01371_ sky130_fd_sc_hd__or2_1
X_12380_ net799 _04592_ VGND VGND VPWR VPWR _04593_ sky130_fd_sc_hd__xnor2_1
X_11400_ _03485_ _03501_ VGND VGND VPWR VPWR _03523_ sky130_fd_sc_hd__and2_1
XFILLER_0_105_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11331_ net209 net730 net737 net199 VGND VGND VPWR VPWR _03447_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_22_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11262_ _03368_ _03369_ _03370_ VGND VGND VPWR VPWR _03371_ sky130_fd_sc_hd__or3_1
X_14050_ _06409_ _06410_ _06411_ VGND VGND VPWR VPWR _06413_ sky130_fd_sc_hd__a21o_1
X_11193_ net307 net228 net684 net694 VGND VGND VPWR VPWR _03295_ sky130_fd_sc_hd__nand4_1
X_10213_ _02229_ _02230_ VGND VGND VPWR VPWR _02231_ sky130_fd_sc_hd__or2_1
X_13001_ _05260_ _05265_ VGND VGND VPWR VPWR _05266_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10144_ _02153_ _02154_ _02155_ VGND VGND VPWR VPWR _02156_ sky130_fd_sc_hd__nand3_1
X_10075_ _02055_ _02056_ _02080_ VGND VGND VPWR VPWR _02082_ sky130_fd_sc_hd__nor3b_4
X_13903_ _06161_ _06162_ VGND VGND VPWR VPWR _06253_ sky130_fd_sc_hd__nor2_1
X_13834_ _06011_ _06111_ _06176_ VGND VGND VPWR VPWR _06177_ sky130_fd_sc_hd__o21a_1
XFILLER_0_97_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10977_ _03060_ _03061_ VGND VGND VPWR VPWR _03062_ sky130_fd_sc_hd__xor2_1
X_13765_ _06003_ _06005_ _06002_ VGND VGND VPWR VPWR _06103_ sky130_fd_sc_hd__a21o_1
X_12716_ _04954_ _04957_ VGND VGND VPWR VPWR _04958_ sky130_fd_sc_hd__or2_1
X_13696_ _06024_ _06025_ _06027_ VGND VGND VPWR VPWR _06028_ sky130_fd_sc_hd__a21o_1
X_12647_ _04807_ _04810_ _04813_ VGND VGND VPWR VPWR _04883_ sky130_fd_sc_hd__a21o_1
XFILLER_0_84_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12578_ net162 net136 _04649_ _04648_ VGND VGND VPWR VPWR _04808_ sky130_fd_sc_hd__a31oi_4
XFILLER_0_80_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11529_ _03662_ _03663_ _03589_ _03631_ VGND VGND VPWR VPWR _03665_ sky130_fd_sc_hd__o211a_1
XFILLER_0_80_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14317_ _06700_ _06702_ _06634_ _06636_ VGND VGND VPWR VPWR _06704_ sky130_fd_sc_hd__a211o_1
X_14248_ _06623_ _06628_ VGND VGND VPWR VPWR _06629_ sky130_fd_sc_hd__xor2_1
XFILLER_0_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14179_ _06501_ _06502_ VGND VGND VPWR VPWR _06553_ sky130_fd_sc_hd__and2_1
XFILLER_0_110_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08740_ _00763_ _00764_ _00784_ VGND VGND VPWR VPWR _00786_ sky130_fd_sc_hd__or3_1
XFILLER_0_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08671_ _00716_ _00717_ VGND VGND VPWR VPWR _00718_ sky130_fd_sc_hd__nor2_1
X_07622_ _04902_ _04945_ _04685_ _04424_ VGND VGND VPWR VPWR _04967_ sky130_fd_sc_hd__a211o_1
XFILLER_0_17_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07553_ net308 net497 net506 net229 VGND VGND VPWR VPWR _04217_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_76_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07484_ net158 net534 _02810_ _02799_ VGND VGND VPWR VPWR _03462_ sky130_fd_sc_hd__a31o_1
X_09223_ _01239_ _01241_ _01238_ VGND VGND VPWR VPWR _01247_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_17_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09154_ _01186_ _01187_ VGND VGND VPWR VPWR _01188_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08105_ _00155_ _00156_ VGND VGND VPWR VPWR _00158_ sky130_fd_sc_hd__nand2_1
XFILLER_0_140_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09085_ _01124_ VGND VGND VPWR VPWR _01125_ sky130_fd_sc_hd__inv_2
XFILLER_0_44_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08036_ _07327_ _07328_ _07310_ VGND VGND VPWR VPWR _07330_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09987_ _01984_ _01985_ _01983_ VGND VGND VPWR VPWR _01987_ sky130_fd_sc_hd__o21ai_1
X_08938_ net788 _00919_ _00980_ VGND VGND VPWR VPWR _00013_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_99_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08869_ _00911_ _00912_ VGND VGND VPWR VPWR _00913_ sky130_fd_sc_hd__or2_1
X_10900_ _02901_ _02920_ _02977_ _02978_ VGND VGND VPWR VPWR _02979_ sky130_fd_sc_hd__o211ai_2
X_11880_ _03877_ _04047_ _04048_ VGND VGND VPWR VPWR _04049_ sky130_fd_sc_hd__and3_1
XFILLER_0_86_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10831_ _02880_ _02881_ _02903_ VGND VGND VPWR VPWR _02904_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_137_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10762_ _02703_ _02812_ _02827_ VGND VGND VPWR VPWR _02829_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13550_ _05761_ _05770_ _05769_ VGND VGND VPWR VPWR _05869_ sky130_fd_sc_hd__a21bo_1
X_12501_ _04634_ _04637_ _04635_ VGND VGND VPWR VPWR _04724_ sky130_fd_sc_hd__o21ba_1
X_13481_ _02017_ VGND VGND VPWR VPWR _05794_ sky130_fd_sc_hd__buf_4
X_12432_ net182 net172 net136 VGND VGND VPWR VPWR _04649_ sky130_fd_sc_hd__o21a_1
X_10693_ _02668_ _02671_ VGND VGND VPWR VPWR _02754_ sky130_fd_sc_hd__or2_1
XFILLER_0_124_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12363_ _04566_ _04573_ VGND VGND VPWR VPWR _04574_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_117_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12294_ _04497_ _04498_ VGND VGND VPWR VPWR _04499_ sky130_fd_sc_hd__or2_1
X_11314_ _03425_ _03427_ VGND VGND VPWR VPWR _03428_ sky130_fd_sc_hd__xor2_1
X_14102_ net504 net428 net420 net513 VGND VGND VPWR VPWR _06469_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_22_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11245_ _03349_ _03350_ _03348_ VGND VGND VPWR VPWR _03353_ sky130_fd_sc_hd__a21o_1
XFILLER_0_50_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14033_ _06376_ _06393_ VGND VGND VPWR VPWR _06394_ sky130_fd_sc_hd__nand2_1
XFILLER_0_120_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11176_ net220 net694 VGND VGND VPWR VPWR _03277_ sky130_fd_sc_hd__and2_1
XFILLER_0_38_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10127_ _02134_ _02136_ VGND VGND VPWR VPWR _02138_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10058_ _02061_ _02062_ VGND VGND VPWR VPWR _02063_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14797_ clknet_3_4_0_clk _00098_ net319 VGND VGND VPWR VPWR b_cos\[7\] sky130_fd_sc_hd__dfrtp_1
X_13817_ _06158_ _06159_ VGND VGND VPWR VPWR _06160_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_128_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13748_ _06083_ _06084_ VGND VGND VPWR VPWR _06085_ sky130_fd_sc_hd__nor2_1
XFILLER_0_128_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13679_ _06007_ _06008_ VGND VGND VPWR VPWR _06009_ sky130_fd_sc_hd__xor2_1
XFILLER_0_79_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09910_ _01793_ _01794_ _01799_ VGND VGND VPWR VPWR _01911_ sky130_fd_sc_hd__o21a_1
Xfanout606 net609 VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_95_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout617 net619 VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__clkbuf_4
X_09841_ _01785_ _01841_ VGND VGND VPWR VPWR _01842_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout628 net22 VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__buf_4
Xfanout639 net646 VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__buf_2
X_09772_ _01770_ _01771_ _01772_ VGND VGND VPWR VPWR _01773_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_119_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08723_ net251 net645 VGND VGND VPWR VPWR _00769_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08654_ _00695_ _00700_ VGND VGND VPWR VPWR _00701_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07605_ _04522_ _04533_ VGND VGND VPWR VPWR _04782_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08585_ _00569_ _00570_ _00631_ _00632_ VGND VGND VPWR VPWR _00633_ sky130_fd_sc_hd__o211a_1
XFILLER_0_48_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07536_ net211 net514 net523 net202 VGND VGND VPWR VPWR _04032_ sky130_fd_sc_hd__a22o_1
XFILLER_0_76_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07467_ _02592_ _02614_ _02603_ VGND VGND VPWR VPWR _03275_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_107_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09206_ a_cos\[12\] b_sin\[12\] VGND VGND VPWR VPWR _01232_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07398_ _02484_ _02516_ VGND VGND VPWR VPWR _02527_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_91_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09137_ a_cos\[2\] b_sin\[2\] VGND VGND VPWR VPWR _01173_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09068_ _01057_ _01060_ _01107_ VGND VGND VPWR VPWR _01108_ sky130_fd_sc_hd__o21a_1
XFILLER_0_130_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08019_ net290 net281 net524 net533 VGND VGND VPWR VPWR _07313_ sky130_fd_sc_hd__and4_1
XFILLER_0_32_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11030_ _03110_ _03118_ VGND VGND VPWR VPWR _03119_ sky130_fd_sc_hd__xnor2_1
X_12981_ _05241_ _05242_ _05243_ VGND VGND VPWR VPWR _05244_ sky130_fd_sc_hd__nand3_1
X_11932_ _04102_ _04103_ _04094_ VGND VGND VPWR VPWR _04105_ sky130_fd_sc_hd__a21o_1
XFILLER_0_115_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14720_ clknet_3_2_0_clk _00021_ net314 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dfrtp_1
X_11863_ net652 net169 _04027_ _04028_ VGND VGND VPWR VPWR _04030_ sky130_fd_sc_hd__nand4_2
X_14651_ _07009_ _07064_ VGND VGND VPWR VPWR _07065_ sky130_fd_sc_hd__and2_1
X_10814_ net555 net433 net425 net650 VGND VGND VPWR VPWR _02885_ sky130_fd_sc_hd__a22oi_1
X_13602_ _05915_ _05923_ _05924_ VGND VGND VPWR VPWR _05925_ sky130_fd_sc_hd__nand3_1
XFILLER_0_28_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11794_ _03773_ VGND VGND VPWR VPWR _03955_ sky130_fd_sc_hd__inv_2
XFILLER_0_94_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14582_ _06788_ _06976_ _06988_ VGND VGND VPWR VPWR _06990_ sky130_fd_sc_hd__a21oi_1
X_10745_ _02741_ _02743_ VGND VGND VPWR VPWR _02811_ sky130_fd_sc_hd__or2_1
X_13533_ _05848_ _05849_ VGND VGND VPWR VPWR _05850_ sky130_fd_sc_hd__and2b_1
XFILLER_0_137_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10676_ _02733_ _02735_ VGND VGND VPWR VPWR _02736_ sky130_fd_sc_hd__xor2_1
XFILLER_0_54_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13464_ _05771_ _05772_ _05773_ VGND VGND VPWR VPWR _05775_ sky130_fd_sc_hd__a21o_1
X_12415_ _04628_ _04629_ VGND VGND VPWR VPWR _04631_ sky130_fd_sc_hd__nor2_1
X_13395_ _05643_ _05646_ VGND VGND VPWR VPWR _05700_ sky130_fd_sc_hd__nand2_1
X_12346_ _04537_ _04555_ VGND VGND VPWR VPWR _04556_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_106_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12277_ net377 net464 net152 net300 VGND VGND VPWR VPWR _04481_ sky130_fd_sc_hd__nand4_2
XFILLER_0_49_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11228_ _03332_ _03333_ VGND VGND VPWR VPWR _03334_ sky130_fd_sc_hd__nor2_1
X_14016_ _06295_ _06297_ VGND VGND VPWR VPWR _06376_ sky130_fd_sc_hd__or2_1
X_11159_ net156 net736 _03250_ _03251_ VGND VGND VPWR VPWR _03258_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08370_ _00319_ _00324_ _00419_ VGND VGND VPWR VPWR _00420_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_81_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout414 net46 VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout403 net404 VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__clkbuf_4
Xfanout447 net449 VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__clkbuf_4
Xfanout425 net426 VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__buf_2
X_09824_ _01821_ _01823_ _01822_ VGND VGND VPWR VPWR _01825_ sky130_fd_sc_hd__a21o_1
Xfanout436 net437 VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__clkbuf_4
Xfanout469 net472 VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__clkbuf_4
Xfanout458 net40 VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__clkbuf_8
X_09755_ _01750_ _01753_ _01754_ _01755_ VGND VGND VPWR VPWR _01756_ sky130_fd_sc_hd__a211o_1
X_08706_ _00677_ _00751_ VGND VGND VPWR VPWR _00752_ sky130_fd_sc_hd__xor2_4
X_09686_ net719 net357 net348 net726 VGND VGND VPWR VPWR _01687_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_69_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08637_ _00612_ _00622_ _00683_ VGND VGND VPWR VPWR _00684_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_139_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08568_ net171 net589 net583 net181 VGND VGND VPWR VPWR _00616_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_135_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08499_ _00460_ _00461_ _00462_ _00465_ VGND VGND VPWR VPWR _00548_ sky130_fd_sc_hd__a31o_1
X_07519_ _03583_ _03594_ _03825_ _03836_ VGND VGND VPWR VPWR _03847_ sky130_fd_sc_hd__and4bb_2
XFILLER_0_9_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10530_ _02487_ _02485_ VGND VGND VPWR VPWR _02577_ sky130_fd_sc_hd__and2b_1
XFILLER_0_52_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10461_ _02498_ _02501_ VGND VGND VPWR VPWR _02502_ sky130_fd_sc_hd__xor2_1
XFILLER_0_10_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12200_ _04298_ _04300_ VGND VGND VPWR VPWR _04397_ sky130_fd_sc_hd__nand2_1
XFILLER_0_51_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10392_ _02425_ _02321_ VGND VGND VPWR VPWR _02426_ sky130_fd_sc_hd__nor2_1
X_13180_ _05220_ _05221_ _05236_ VGND VGND VPWR VPWR _05463_ sky130_fd_sc_hd__and3_1
XFILLER_0_32_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12131_ _04306_ _04321_ VGND VGND VPWR VPWR _04322_ sky130_fd_sc_hd__xnor2_2
X_12062_ _04245_ _04246_ VGND VGND VPWR VPWR _04247_ sky130_fd_sc_hd__xnor2_1
X_11013_ _03053_ _03054_ _03100_ VGND VGND VPWR VPWR _03101_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_99_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12964_ net563 net338 _05224_ _05222_ VGND VGND VPWR VPWR _05225_ sky130_fd_sc_hd__a31o_1
X_11915_ _04002_ _04003_ _04038_ _04039_ VGND VGND VPWR VPWR _04087_ sky130_fd_sc_hd__and4_1
X_14703_ clknet_3_3_0_clk _00004_ net316 VGND VGND VPWR VPWR b_sin\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_59_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12895_ _05134_ _05136_ _05141_ VGND VGND VPWR VPWR _05151_ sky130_fd_sc_hd__o21ai_1
X_11846_ net233 net143 VGND VGND VPWR VPWR _04012_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14634_ _07007_ _07006_ VGND VGND VPWR VPWR _07046_ sky130_fd_sc_hd__and2b_1
XFILLER_0_138_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11777_ _03932_ _03933_ _03935_ VGND VGND VPWR VPWR _03937_ sky130_fd_sc_hd__a21o_1
XFILLER_0_82_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14565_ _06919_ _06916_ _06970_ VGND VGND VPWR VPWR _06973_ sky130_fd_sc_hd__or3_1
XFILLER_0_126_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10728_ _02774_ _02775_ _02790_ VGND VGND VPWR VPWR _02792_ sky130_fd_sc_hd__nand3_1
X_13516_ _05827_ _05828_ _05829_ VGND VGND VPWR VPWR _05832_ sky130_fd_sc_hd__a21o_1
X_14496_ _06834_ _06897_ VGND VGND VPWR VPWR _06898_ sky130_fd_sc_hd__xor2_1
X_10659_ _02644_ _02716_ VGND VGND VPWR VPWR _02717_ sky130_fd_sc_hd__xnor2_1
X_13447_ net638 net368 VGND VGND VPWR VPWR _05757_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13378_ net656 net400 _05679_ _05680_ VGND VGND VPWR VPWR _05681_ sky130_fd_sc_hd__and4_1
XFILLER_0_121_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12329_ _04464_ _04466_ VGND VGND VPWR VPWR _04537_ sky130_fd_sc_hd__or2_1
XFILLER_0_2_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07870_ _07164_ _07165_ VGND VGND VPWR VPWR _07166_ sky130_fd_sc_hd__and2b_1
XFILLER_0_92_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09540_ _01538_ _01539_ _01534_ VGND VGND VPWR VPWR _01541_ sky130_fd_sc_hd__a21o_1
XFILLER_0_78_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09471_ _01437_ _01438_ _01447_ VGND VGND VPWR VPWR _01472_ sky130_fd_sc_hd__nand3_1
X_08422_ _00353_ _00381_ _00471_ VGND VGND VPWR VPWR _00472_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_58_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08353_ _00240_ _00241_ _00250_ VGND VGND VPWR VPWR _00403_ sky130_fd_sc_hd__a21o_1
XFILLER_0_46_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08284_ _00277_ _00285_ _00283_ VGND VGND VPWR VPWR _00335_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_61_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout222 net224 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__clkbuf_4
Xfanout200 net201 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__clkbuf_4
Xfanout211 net217 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__buf_2
Xfanout233 net234 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__buf_2
Xfanout255 net257 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__clkbuf_4
Xfanout244 net245 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout299 net303 VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__buf_4
Xfanout277 net278 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__clkbuf_4
Xfanout288 net289 VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__buf_2
Xfanout266 net267 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__clkbuf_4
X_07999_ _07132_ _07283_ _07282_ VGND VGND VPWR VPWR _07293_ sky130_fd_sc_hd__a21boi_1
X_09807_ _01805_ _01806_ _01804_ VGND VGND VPWR VPWR _01808_ sky130_fd_sc_hd__a21o_1
X_09738_ net690 net399 _01673_ _01672_ VGND VGND VPWR VPWR _01739_ sky130_fd_sc_hd__a22o_1
X_09669_ _01393_ _01392_ _01391_ VGND VGND VPWR VPWR _01670_ sky130_fd_sc_hd__o21ai_1
X_11700_ _03787_ _03851_ _03852_ VGND VGND VPWR VPWR _03853_ sky130_fd_sc_hd__and3_2
X_12680_ _04915_ _04918_ VGND VGND VPWR VPWR _04919_ sky130_fd_sc_hd__xnor2_1
X_11631_ _03630_ _03697_ _03700_ _03775_ _03776_ VGND VGND VPWR VPWR _03777_ sky130_fd_sc_hd__a41o_1
XFILLER_0_126_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11562_ _03589_ _03631_ _03662_ _03663_ VGND VGND VPWR VPWR _03701_ sky130_fd_sc_hd__a211o_1
X_14350_ _06730_ _06738_ VGND VGND VPWR VPWR _06739_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_119_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10513_ _02553_ _02557_ VGND VGND VPWR VPWR _02558_ sky130_fd_sc_hd__xnor2_1
X_13301_ _05593_ _05595_ VGND VGND VPWR VPWR _05596_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_135_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11493_ _03621_ _03622_ _03394_ VGND VGND VPWR VPWR _03625_ sky130_fd_sc_hd__a21o_1
XFILLER_0_80_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14281_ _06579_ _06663_ VGND VGND VPWR VPWR _06664_ sky130_fd_sc_hd__xnor2_4
X_10444_ _02481_ _02482_ VGND VGND VPWR VPWR _02483_ sky130_fd_sc_hd__nor2_1
X_13232_ _05445_ _05439_ _05444_ VGND VGND VPWR VPWR _05520_ sky130_fd_sc_hd__a21o_1
X_10375_ _02307_ _02326_ _02406_ VGND VGND VPWR VPWR _02408_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_0_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13163_ _05440_ _05443_ VGND VGND VPWR VPWR _05444_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_33_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12114_ _04295_ _04301_ _04302_ VGND VGND VPWR VPWR _04303_ sky130_fd_sc_hd__and3_1
X_13094_ _05365_ _05366_ _05364_ VGND VGND VPWR VPWR _05368_ sky130_fd_sc_hd__a21o_1
X_12045_ _04125_ _04132_ _04131_ VGND VGND VPWR VPWR _04229_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_46_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13996_ _06220_ _06251_ _06354_ VGND VGND VPWR VPWR _06355_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_99_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12947_ net493 net484 net405 net502 VGND VGND VPWR VPWR _05207_ sky130_fd_sc_hd__a22oi_2
X_12878_ _05131_ _05132_ VGND VGND VPWR VPWR _05133_ sky130_fd_sc_hd__nor2_1
XFILLER_0_62_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11829_ _03990_ _03991_ _03989_ VGND VGND VPWR VPWR _03993_ sky130_fd_sc_hd__o21ai_1
X_14617_ _00919_ _07024_ _07027_ _07028_ VGND VGND VPWR VPWR _00106_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_8_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_112_Right_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14548_ _06952_ _06953_ VGND VGND VPWR VPWR _06954_ sky130_fd_sc_hd__xor2_1
XFILLER_0_141_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14479_ net616 net623 net431 net423 VGND VGND VPWR VPWR _06879_ sky130_fd_sc_hd__and4_1
XFILLER_0_113_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08971_ _00944_ _00946_ _01012_ VGND VGND VPWR VPWR _01013_ sky130_fd_sc_hd__a21oi_1
X_07922_ _07152_ _07154_ _07216_ VGND VGND VPWR VPWR _07217_ sky130_fd_sc_hd__a21oi_2
X_07853_ _03660_ _03682_ _03671_ VGND VGND VPWR VPWR _07149_ sky130_fd_sc_hd__o21ba_1
X_07784_ _06646_ _06711_ _06722_ VGND VGND VPWR VPWR _06733_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09523_ _01502_ _01503_ _01521_ _01522_ VGND VGND VPWR VPWR _01524_ sky130_fd_sc_hd__or4_4
XFILLER_0_93_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09454_ net741 net467 _01452_ _01453_ VGND VGND VPWR VPWR _01455_ sky130_fd_sc_hd__o2bb2a_1
X_08405_ _00452_ _00453_ _00446_ VGND VGND VPWR VPWR _00455_ sky130_fd_sc_hd__a21o_1
XFILLER_0_93_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09385_ _01384_ _01385_ VGND VGND VPWR VPWR _01386_ sky130_fd_sc_hd__nor2_1
XFILLER_0_136_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08336_ _00303_ _00304_ VGND VGND VPWR VPWR _00387_ sky130_fd_sc_hd__and2b_1
XFILLER_0_46_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08267_ _00256_ _00275_ _00273_ VGND VGND VPWR VPWR _00318_ sky130_fd_sc_hd__a21o_1
XFILLER_0_62_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08198_ _00248_ _00249_ VGND VGND VPWR VPWR _00250_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_120_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_58_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10160_ _02165_ _02173_ VGND VGND VPWR VPWR _02174_ sky130_fd_sc_hd__xor2_1
X_10091_ _02087_ _02098_ VGND VGND VPWR VPWR _02099_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13850_ _06194_ _06105_ VGND VGND VPWR VPWR _06195_ sky130_fd_sc_hd__nor2_1
X_12801_ _05047_ _05048_ VGND VGND VPWR VPWR _05049_ sky130_fd_sc_hd__nor2_2
X_10993_ _03077_ _03078_ VGND VGND VPWR VPWR _03079_ sky130_fd_sc_hd__xor2_1
X_13781_ net529 net437 VGND VGND VPWR VPWR _06120_ sky130_fd_sc_hd__nand2_1
X_12732_ _04444_ _04618_ _04974_ _04697_ _04620_ VGND VGND VPWR VPWR _04975_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_139_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_67_Left_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12663_ _04899_ _04829_ VGND VGND VPWR VPWR _04900_ sky130_fd_sc_hd__nor2_1
X_14402_ net595 net456 net446 net605 VGND VGND VPWR VPWR _06795_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_37_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11614_ _03740_ _03741_ _03756_ VGND VGND VPWR VPWR _03758_ sky130_fd_sc_hd__nand3_2
X_12594_ _04819_ _04824_ VGND VGND VPWR VPWR _04825_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11545_ _03668_ _03669_ _03681_ VGND VGND VPWR VPWR _03683_ sky130_fd_sc_hd__a21oi_2
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14333_ _06653_ _06652_ VGND VGND VPWR VPWR _06720_ sky130_fd_sc_hd__and2b_1
X_11476_ net279 net745 VGND VGND VPWR VPWR _03607_ sky130_fd_sc_hd__nand2_1
X_14264_ net632 net438 VGND VGND VPWR VPWR _06645_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10427_ _02461_ _02463_ _02455_ VGND VGND VPWR VPWR _02465_ sky130_fd_sc_hd__a21oi_1
X_13215_ net572 net330 net475 net658 VGND VGND VPWR VPWR _05502_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_21_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14195_ _06562_ _06569_ VGND VGND VPWR VPWR _06571_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_20_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10358_ _02387_ _02389_ VGND VGND VPWR VPWR _02390_ sky130_fd_sc_hd__xnor2_2
X_13146_ _05423_ _05425_ VGND VGND VPWR VPWR _05426_ sky130_fd_sc_hd__and2_1
X_10289_ _02312_ _02313_ VGND VGND VPWR VPWR _02314_ sky130_fd_sc_hd__nor2_1
X_13077_ _05346_ _05348_ _05330_ _05331_ VGND VGND VPWR VPWR _05350_ sky130_fd_sc_hd__o211a_1
X_12028_ net376 net462 net180 net170 VGND VGND VPWR VPWR _04210_ sky130_fd_sc_hd__nand4_2
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13979_ net577 net394 net385 VGND VGND VPWR VPWR _06336_ sky130_fd_sc_hd__nand3_1
XFILLER_0_88_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09170_ _01201_ VGND VGND VPWR VPWR _00024_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08121_ _00171_ _00172_ _00173_ VGND VGND VPWR VPWR _00174_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08052_ _07343_ _07344_ _07336_ VGND VGND VPWR VPWR _07346_ sky130_fd_sc_hd__a21o_1
XFILLER_0_71_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08954_ _00985_ _00995_ VGND VGND VPWR VPWR _00996_ sky130_fd_sc_hd__xor2_2
X_07905_ _04467_ _07200_ VGND VGND VPWR VPWR _07201_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_138_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08885_ _00926_ _00927_ VGND VGND VPWR VPWR _00928_ sky130_fd_sc_hd__nor2_1
XFILLER_0_98_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07836_ _03803_ _03825_ _07131_ VGND VGND VPWR VPWR _07132_ sky130_fd_sc_hd__a21oi_2
X_07767_ net764 net123 _06538_ _06233_ VGND VGND VPWR VPWR _06549_ sky130_fd_sc_hd__o211a_1
XFILLER_0_79_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09506_ _01439_ _01446_ VGND VGND VPWR VPWR _01507_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07698_ _05688_ _05776_ net771 _05787_ VGND VGND VPWR VPWR _05797_ sky130_fd_sc_hd__o211a_4
XFILLER_0_78_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09437_ _01435_ _01436_ _01421_ VGND VGND VPWR VPWR _01438_ sky130_fd_sc_hd__a21o_1
XFILLER_0_74_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09368_ _01164_ net789 _01370_ VGND VGND VPWR VPWR _00053_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_19_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08319_ net311 net231 net222 net580 VGND VGND VPWR VPWR _00370_ sky130_fd_sc_hd__and4_2
X_09299_ a_sin\[8\] b_cos\[8\] VGND VGND VPWR VPWR _01311_ sky130_fd_sc_hd__or2b_1
XFILLER_0_117_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11330_ net193 net744 VGND VGND VPWR VPWR _03446_ sky130_fd_sc_hd__nand2_1
XFILLER_0_105_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11261_ net176 net704 net712 net165 VGND VGND VPWR VPWR _03370_ sky130_fd_sc_hd__a22oi_1
X_11192_ net307 net684 net694 net228 VGND VGND VPWR VPWR _03294_ sky130_fd_sc_hd__a22o_1
X_10212_ _02227_ _02228_ VGND VGND VPWR VPWR _02230_ sky130_fd_sc_hd__and2_1
X_13000_ _05261_ _05264_ VGND VGND VPWR VPWR _05265_ sky130_fd_sc_hd__xnor2_1
X_10143_ _02065_ _02066_ _02067_ VGND VGND VPWR VPWR _02155_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_27_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10074_ _02078_ _02079_ VGND VGND VPWR VPWR _02080_ sky130_fd_sc_hd__and2_1
XFILLER_0_89_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13902_ _06220_ _06251_ VGND VGND VPWR VPWR _06252_ sky130_fd_sc_hd__xnor2_2
X_13833_ _06094_ _06110_ VGND VGND VPWR VPWR _06176_ sky130_fd_sc_hd__nand2_1
XFILLER_0_134_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13764_ _06095_ _06100_ VGND VGND VPWR VPWR _06101_ sky130_fd_sc_hd__xnor2_1
X_10976_ net186 net439 VGND VGND VPWR VPWR _03061_ sky130_fd_sc_hd__nand2_1
XFILLER_0_128_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12715_ _04955_ _04897_ VGND VGND VPWR VPWR _04957_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13695_ net512 net468 VGND VGND VPWR VPWR _06027_ sky130_fd_sc_hd__and2_1
X_12646_ _04859_ _04881_ VGND VGND VPWR VPWR _04882_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_38_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12577_ _04582_ _04736_ _04580_ VGND VGND VPWR VPWR _04807_ sky130_fd_sc_hd__a21o_1
XFILLER_0_41_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14316_ _06634_ _06636_ _06700_ _06702_ VGND VGND VPWR VPWR _06703_ sky130_fd_sc_hd__o211ai_4
X_11528_ _03589_ _03631_ _03662_ _03663_ VGND VGND VPWR VPWR _03664_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_7_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11459_ _03579_ _03580_ _03586_ VGND VGND VPWR VPWR _03588_ sky130_fd_sc_hd__a21o_1
XFILLER_0_123_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14247_ _06457_ net112 _06627_ VGND VGND VPWR VPWR _06628_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_0_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14178_ _06487_ _06532_ _06533_ VGND VGND VPWR VPWR _06552_ sky130_fd_sc_hd__nor3_1
XFILLER_0_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13129_ _05400_ _05406_ VGND VGND VPWR VPWR _05407_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08670_ _00713_ _00714_ _00715_ VGND VGND VPWR VPWR _00717_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_108_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07621_ _04424_ _04685_ _04945_ _04902_ VGND VGND VPWR VPWR _04956_ sky130_fd_sc_hd__o211ai_2
X_07552_ net221 net514 VGND VGND VPWR VPWR _04206_ sky130_fd_sc_hd__nand2_1
XFILLER_0_119_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07483_ _03418_ _03429_ _03264_ VGND VGND VPWR VPWR _03451_ sky130_fd_sc_hd__a21o_1
X_09222_ _01244_ _01245_ VGND VGND VPWR VPWR _01246_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09153_ _01178_ _01181_ _01179_ VGND VGND VPWR VPWR _01187_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_8_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08104_ _00155_ _00156_ VGND VGND VPWR VPWR _00157_ sky130_fd_sc_hd__or2_2
X_09084_ _01072_ _01085_ _01123_ VGND VGND VPWR VPWR _01124_ sky130_fd_sc_hd__a21o_1
X_08035_ _07310_ _07327_ _07328_ VGND VGND VPWR VPWR _07329_ sky130_fd_sc_hd__nand3_2
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09986_ _01983_ _01984_ _01985_ VGND VGND VPWR VPWR _01986_ sky130_fd_sc_hd__or3_1
X_08937_ _00918_ _00978_ _00979_ VGND VGND VPWR VPWR _00980_ sky130_fd_sc_hd__or3_1
XFILLER_0_99_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08868_ _00849_ _00850_ _00909_ _00910_ VGND VGND VPWR VPWR _00912_ sky130_fd_sc_hd__a211oi_1
X_07819_ _05939_ _05950_ _06287_ _07101_ VGND VGND VPWR VPWR _07112_ sky130_fd_sc_hd__or4_4
X_08799_ _00826_ _00843_ VGND VGND VPWR VPWR _00844_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_79_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10830_ _02882_ _02902_ VGND VGND VPWR VPWR _02903_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10761_ _02703_ _02812_ _02827_ VGND VGND VPWR VPWR _02828_ sky130_fd_sc_hd__nand3_1
XFILLER_0_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12500_ _04721_ _04722_ VGND VGND VPWR VPWR _04723_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_109_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10692_ _02682_ _02752_ VGND VGND VPWR VPWR _02753_ sky130_fd_sc_hd__xnor2_2
X_13480_ _05713_ _05792_ VGND VGND VPWR VPWR _05793_ sky130_fd_sc_hd__xnor2_1
X_12431_ net182 net172 net136 VGND VGND VPWR VPWR _04648_ sky130_fd_sc_hd__and3_2
XFILLER_0_109_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12362_ _04571_ _04572_ VGND VGND VPWR VPWR _04573_ sky130_fd_sc_hd__xor2_1
XFILLER_0_50_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12293_ _04408_ _04409_ _04496_ VGND VGND VPWR VPWR _04498_ sky130_fd_sc_hd__and3_1
X_11313_ _03262_ _03426_ VGND VGND VPWR VPWR _03427_ sky130_fd_sc_hd__nor2_1
X_14101_ _06403_ _06404_ VGND VGND VPWR VPWR _06468_ sky130_fd_sc_hd__nor2_1
X_11244_ _03348_ _03349_ _03350_ VGND VGND VPWR VPWR _03351_ sky130_fd_sc_hd__nand3_1
X_14032_ _06377_ _06392_ VGND VGND VPWR VPWR _06393_ sky130_fd_sc_hd__xor2_1
XFILLER_0_30_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11175_ _03272_ _03273_ _03274_ VGND VGND VPWR VPWR _03276_ sky130_fd_sc_hd__or3_1
X_10126_ _02134_ _02136_ VGND VGND VPWR VPWR _02137_ sky130_fd_sc_hd__or2_2
X_10057_ net692 net701 net473 net453 VGND VGND VPWR VPWR _02062_ sky130_fd_sc_hd__and4_1
X_14796_ clknet_3_1_0_clk _00097_ net317 VGND VGND VPWR VPWR b_cos\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13816_ _06054_ _06061_ _06060_ VGND VGND VPWR VPWR _06159_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_85_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10959_ _03041_ _03042_ VGND VGND VPWR VPWR _03043_ sky130_fd_sc_hd__xor2_1
XFILLER_0_46_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13747_ _06080_ _06082_ _05982_ _05985_ VGND VGND VPWR VPWR _06084_ sky130_fd_sc_hd__o211a_1
XFILLER_0_128_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13678_ _05804_ _05967_ _05968_ VGND VGND VPWR VPWR _06008_ sky130_fd_sc_hd__o21ba_1
X_12629_ _04787_ _04862_ VGND VGND VPWR VPWR _04863_ sky130_fd_sc_hd__nor2_4
XFILLER_0_14_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout607 net608 VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__clkbuf_4
Xfanout618 net619 VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__clkbuf_2
X_09840_ net734 net358 net348 net741 VGND VGND VPWR VPWR _01841_ sky130_fd_sc_hd__a22oi_1
Xfanout629 net637 VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__clkbuf_4
X_09771_ net690 net699 net485 net407 VGND VGND VPWR VPWR _01772_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_13_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08722_ net243 net500 VGND VGND VPWR VPWR _00768_ sky130_fd_sc_hd__nand2_1
X_08653_ _00698_ _00699_ VGND VGND VPWR VPWR _00700_ sky130_fd_sc_hd__xor2_1
XFILLER_0_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07604_ _04706_ _04717_ _04761_ VGND VGND VPWR VPWR _04772_ sky130_fd_sc_hd__a21o_1
XFILLER_0_89_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08584_ _00629_ _00630_ _00589_ VGND VGND VPWR VPWR _00632_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_76_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07535_ net157 net566 _04010_ _03988_ VGND VGND VPWR VPWR _04021_ sky130_fd_sc_hd__a31o_1
XFILLER_0_76_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07466_ _02658_ _02712_ _02647_ VGND VGND VPWR VPWR _03264_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_76_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09205_ _01231_ VGND VGND VPWR VPWR _00029_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_22_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07397_ _02495_ _02505_ VGND VGND VPWR VPWR _02516_ sky130_fd_sc_hd__and2b_1
XFILLER_0_63_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09136_ _01165_ _01169_ _01167_ VGND VGND VPWR VPWR _01172_ sky130_fd_sc_hd__o21a_1
XFILLER_0_72_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09067_ _01100_ _01106_ VGND VGND VPWR VPWR _01107_ sky130_fd_sc_hd__xor2_1
XFILLER_0_4_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08018_ net290 net524 net533 net281 VGND VGND VPWR VPWR _07312_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_32_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_31_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09969_ net674 net340 VGND VGND VPWR VPWR _01969_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12980_ net620 net484 net406 net629 VGND VGND VPWR VPWR _05243_ sky130_fd_sc_hd__a22o_1
X_11931_ _04094_ _04102_ _04103_ VGND VGND VPWR VPWR _04104_ sky130_fd_sc_hd__nand3_1
X_11862_ net652 net169 _04027_ _04028_ VGND VGND VPWR VPWR _04029_ sky130_fd_sc_hd__a22o_1
XFILLER_0_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14650_ _07045_ _07063_ VGND VGND VPWR VPWR _07064_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_138_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10813_ _02776_ _02780_ _02778_ VGND VGND VPWR VPWR _02884_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_39_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13601_ _05921_ _05922_ _05860_ _05916_ VGND VGND VPWR VPWR _05924_ sky130_fd_sc_hd__a211o_1
X_14581_ _06788_ _06976_ _06988_ VGND VGND VPWR VPWR _06989_ sky130_fd_sc_hd__and3_1
X_11793_ _03951_ _03952_ _03865_ _03857_ VGND VGND VPWR VPWR _03954_ sky130_fd_sc_hd__a211o_1
XFILLER_0_95_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_40_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13532_ _05846_ _05847_ _05842_ VGND VGND VPWR VPWR _05849_ sky130_fd_sc_hd__a21o_1
XFILLER_0_131_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10744_ _02721_ _02725_ _02807_ VGND VGND VPWR VPWR _02809_ sky130_fd_sc_hd__o21a_1
X_10675_ net688 net416 VGND VGND VPWR VPWR _02735_ sky130_fd_sc_hd__and2b_1
X_13463_ _05771_ _05772_ _05773_ VGND VGND VPWR VPWR _05774_ sky130_fd_sc_hd__nand3_4
X_12414_ net464 net558 net286 net268 VGND VGND VPWR VPWR _04629_ sky130_fd_sc_hd__and4_1
X_13394_ _05647_ _05649_ _05650_ _05697_ VGND VGND VPWR VPWR _05698_ sky130_fd_sc_hd__o211a_1
X_12345_ _04538_ _04553_ VGND VGND VPWR VPWR _04555_ sky130_fd_sc_hd__xor2_1
XFILLER_0_90_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12276_ net377 net152 net300 net464 VGND VGND VPWR VPWR _04480_ sky130_fd_sc_hd__a22o_1
XFILLER_0_121_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11227_ net176 net712 net721 net165 VGND VGND VPWR VPWR _03333_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_120_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14015_ _06280_ _06300_ _06373_ VGND VGND VPWR VPWR _06375_ sky130_fd_sc_hd__o21ai_1
X_11158_ _03254_ _03255_ _03256_ VGND VGND VPWR VPWR _03257_ sky130_fd_sc_hd__o21ba_1
X_10109_ _02118_ VGND VGND VPWR VPWR _00057_ sky130_fd_sc_hd__clkbuf_1
X_11089_ net187 net273 net432 net424 VGND VGND VPWR VPWR _03183_ sky130_fd_sc_hd__and4_1
XFILLER_0_81_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14779_ clknet_3_6_0_clk _00080_ net319 VGND VGND VPWR VPWR a_sin\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_18_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout404 net47 VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_1_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09823_ _01821_ _01822_ _01823_ VGND VGND VPWR VPWR _01824_ sky130_fd_sc_hd__nand3_1
Xfanout415 net45 VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__clkbuf_4
Xfanout426 net44 VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__buf_2
Xfanout437 net440 VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__clkbuf_4
Xfanout448 net449 VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__buf_2
Xfanout459 net460 VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__clkbuf_4
X_09754_ _01684_ _01685_ _01694_ VGND VGND VPWR VPWR _01755_ sky130_fd_sc_hd__and3_1
X_08705_ net161 net581 VGND VGND VPWR VPWR _00751_ sky130_fd_sc_hd__nand2_2
X_09685_ net719 net726 net357 net348 VGND VGND VPWR VPWR _01686_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_126_Right_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08636_ _00611_ VGND VGND VPWR VPWR _00683_ sky130_fd_sc_hd__inv_2
XFILLER_0_49_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08567_ _00457_ _00532_ _00456_ VGND VGND VPWR VPWR _00615_ sky130_fd_sc_hd__a21boi_4
XFILLER_0_77_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08498_ _00537_ _00546_ VGND VGND VPWR VPWR _00547_ sky130_fd_sc_hd__xnor2_1
X_07518_ _03803_ _03814_ _03605_ _03616_ VGND VGND VPWR VPWR _03836_ sky130_fd_sc_hd__a211o_1
XFILLER_0_77_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07449_ net288 net575 _02984_ _02973_ VGND VGND VPWR VPWR _03081_ sky130_fd_sc_hd__a31o_1
XFILLER_0_92_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10460_ _02395_ _02499_ _02500_ VGND VGND VPWR VPWR _02501_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_17_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09119_ _01153_ _01157_ VGND VGND VPWR VPWR _01158_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10391_ _02311_ _02316_ VGND VGND VPWR VPWR _02425_ sky130_fd_sc_hd__and2b_1
XFILLER_0_32_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12130_ _04319_ _04320_ VGND VGND VPWR VPWR _04321_ sky130_fd_sc_hd__and2_1
XFILLER_0_102_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12061_ _04154_ _04157_ VGND VGND VPWR VPWR _04246_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11012_ _03098_ _03099_ VGND VGND VPWR VPWR _03100_ sky130_fd_sc_hd__xor2_1
X_12963_ _05222_ _05223_ VGND VGND VPWR VPWR _05224_ sky130_fd_sc_hd__nor2_1
X_11914_ _04038_ VGND VGND VPWR VPWR _04085_ sky130_fd_sc_hd__inv_2
XFILLER_0_87_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14702_ clknet_3_2_0_clk _00003_ net316 VGND VGND VPWR VPWR b_sin\[3\] sky130_fd_sc_hd__dfrtp_1
X_12894_ _05144_ VGND VGND VPWR VPWR _05149_ sky130_fd_sc_hd__inv_2
X_14633_ _06977_ _06984_ _07044_ VGND VGND VPWR VPWR _07045_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_142_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11845_ _03924_ _03925_ _03926_ VGND VGND VPWR VPWR _04011_ sky130_fd_sc_hd__nor3_1
XFILLER_0_83_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11776_ _03932_ _03933_ _03935_ VGND VGND VPWR VPWR _03936_ sky130_fd_sc_hd__nand3_2
XFILLER_0_95_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14564_ _06919_ _06916_ _06970_ VGND VGND VPWR VPWR _06971_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_27_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10727_ _02774_ _02775_ _02790_ VGND VGND VPWR VPWR _02791_ sky130_fd_sc_hd__a21o_1
X_13515_ _05827_ _05828_ _05829_ VGND VGND VPWR VPWR _05831_ sky130_fd_sc_hd__nand3_1
X_14495_ _06894_ _06895_ VGND VGND VPWR VPWR _06897_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13446_ _05745_ _05755_ VGND VGND VPWR VPWR _05756_ sky130_fd_sc_hd__xor2_2
XFILLER_0_36_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10658_ _02708_ _02715_ VGND VGND VPWR VPWR _02716_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13377_ net562 net487 net409 net570 VGND VGND VPWR VPWR _05680_ sky130_fd_sc_hd__a22o_1
X_10589_ _02279_ VGND VGND VPWR VPWR _02641_ sky130_fd_sc_hd__inv_2
XFILLER_0_2_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12328_ _04516_ _04517_ VGND VGND VPWR VPWR _04536_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12259_ _04359_ _04360_ _04357_ VGND VGND VPWR VPWR _04461_ sky130_fd_sc_hd__a21o_1
XFILLER_0_92_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09470_ _01450_ _01451_ _01470_ VGND VGND VPWR VPWR _01471_ sky130_fd_sc_hd__nor3_1
XFILLER_0_116_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08421_ _00378_ _00380_ VGND VGND VPWR VPWR _00471_ sky130_fd_sc_hd__nor2_1
X_08352_ _00317_ _00389_ VGND VGND VPWR VPWR _00402_ sky130_fd_sc_hd__and2b_1
XFILLER_0_74_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08283_ _00269_ _00271_ VGND VGND VPWR VPWR _00334_ sky130_fd_sc_hd__nand2_1
XFILLER_0_73_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout212 net217 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__buf_2
Xfanout201 net207 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__buf_6
Xfanout223 net224 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_100_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout234 net65 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__buf_6
Xfanout256 net257 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__clkbuf_2
Xfanout245 net246 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__clkbuf_4
Xfanout289 net294 VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__buf_2
Xfanout267 net268 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__clkbuf_4
X_07998_ next_state _07289_ _07290_ _07292_ VGND VGND VPWR VPWR _00001_ sky130_fd_sc_hd__a31o_1
X_09806_ _01804_ _01805_ _01806_ VGND VGND VPWR VPWR _01807_ sky130_fd_sc_hd__nand3_1
Xfanout278 net6 VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__clkbuf_4
X_09737_ _01673_ _01671_ _01672_ VGND VGND VPWR VPWR _01738_ sky130_fd_sc_hd__nand3_1
XFILLER_0_69_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09668_ _01393_ _01391_ _01392_ VGND VGND VPWR VPWR _01669_ sky130_fd_sc_hd__or3_1
X_08619_ _00664_ _00665_ VGND VGND VPWR VPWR _00666_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09599_ _01596_ _01599_ VGND VGND VPWR VPWR _01600_ sky130_fd_sc_hd__xnor2_1
X_11630_ _03773_ _03774_ _03698_ VGND VGND VPWR VPWR _03776_ sky130_fd_sc_hd__and3_1
XFILLER_0_49_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11561_ _03698_ _03699_ VGND VGND VPWR VPWR _03700_ sky130_fd_sc_hd__nor2_1
XFILLER_0_108_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10512_ _02369_ _02556_ VGND VGND VPWR VPWR _02557_ sky130_fd_sc_hd__xor2_1
X_13300_ _05560_ _05594_ VGND VGND VPWR VPWR _05595_ sky130_fd_sc_hd__or2_1
XFILLER_0_123_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11492_ _03271_ _03401_ _03400_ VGND VGND VPWR VPWR _03624_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_64_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14280_ net578 net342 VGND VGND VPWR VPWR _06663_ sky130_fd_sc_hd__nand2_2
XFILLER_0_134_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10443_ net126 _02480_ _02374_ _02454_ VGND VGND VPWR VPWR _02482_ sky130_fd_sc_hd__o211a_1
X_13231_ _05515_ _05517_ _05518_ VGND VGND VPWR VPWR _05519_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_122_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10374_ _02310_ _02325_ VGND VGND VPWR VPWR _02406_ sky130_fd_sc_hd__or2_1
XFILLER_0_60_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13162_ _05441_ _05442_ VGND VGND VPWR VPWR _05443_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12113_ _04299_ _04300_ _04296_ VGND VGND VPWR VPWR _04302_ sky130_fd_sc_hd__a21o_1
X_13093_ _05364_ _05365_ _05366_ VGND VGND VPWR VPWR _05367_ sky130_fd_sc_hd__nand3_1
X_12044_ _04223_ _04226_ VGND VGND VPWR VPWR _04227_ sky130_fd_sc_hd__xor2_1
X_13995_ _06248_ _06250_ VGND VGND VPWR VPWR _06354_ sky130_fd_sc_hd__nor2_1
X_12946_ net510 net398 VGND VGND VPWR VPWR _05206_ sky130_fd_sc_hd__nand2_1
X_12877_ _05076_ _05130_ VGND VGND VPWR VPWR _05132_ sky130_fd_sc_hd__nor2_1
X_11828_ _03989_ _03990_ _03991_ VGND VGND VPWR VPWR _03992_ sky130_fd_sc_hd__or3_1
X_14616_ net781 _07291_ VGND VGND VPWR VPWR _07028_ sky130_fd_sc_hd__nand2_1
X_14547_ _06883_ _06887_ _06884_ VGND VGND VPWR VPWR _06953_ sky130_fd_sc_hd__o21ba_1
X_11759_ _03906_ _03916_ VGND VGND VPWR VPWR _03917_ sky130_fd_sc_hd__xor2_1
XFILLER_0_56_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14478_ net616 net431 net423 net623 VGND VGND VPWR VPWR _06878_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_36_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13429_ _05735_ _05736_ VGND VGND VPWR VPWR _05737_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_141_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08970_ _00891_ _00942_ VGND VGND VPWR VPWR _01012_ sky130_fd_sc_hd__nor2_1
XFILLER_0_87_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07921_ _07214_ _07215_ VGND VGND VPWR VPWR _07216_ sky130_fd_sc_hd__nand2_1
X_07852_ _07144_ _07147_ VGND VGND VPWR VPWR _07148_ sky130_fd_sc_hd__xnor2_1
Xinput1 alpha[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_2
XFILLER_0_127_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07783_ _06657_ _06668_ _06701_ VGND VGND VPWR VPWR _06722_ sky130_fd_sc_hd__and3_1
XFILLER_0_79_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09522_ _01502_ _01503_ _01521_ _01522_ VGND VGND VPWR VPWR _01523_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_94_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09453_ _01452_ _01453_ net741 net467 VGND VGND VPWR VPWR _01454_ sky130_fd_sc_hd__and4bb_1
X_08404_ _00446_ _00452_ _00453_ VGND VGND VPWR VPWR _00454_ sky130_fd_sc_hd__nand3_1
XFILLER_0_59_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09384_ net673 net392 net383 net682 VGND VGND VPWR VPWR _01385_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_136_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08335_ _00333_ _00385_ VGND VGND VPWR VPWR _00386_ sky130_fd_sc_hd__xor2_2
XFILLER_0_47_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08266_ _00239_ _00253_ _00316_ VGND VGND VPWR VPWR _00317_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_74_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08197_ _00148_ _00151_ _00149_ VGND VGND VPWR VPWR _00249_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_61_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_5_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10090_ _02096_ _02097_ VGND VGND VPWR VPWR _02098_ sky130_fd_sc_hd__xnor2_1
X_12800_ net286 net268 net137 VGND VGND VPWR VPWR _05048_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_16_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10992_ net466 net418 VGND VGND VPWR VPWR _03078_ sky130_fd_sc_hd__and2b_1
X_13780_ _06117_ _06118_ VGND VGND VPWR VPWR _06119_ sky130_fd_sc_hd__nor2_1
XFILLER_0_139_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12731_ _04779_ _04912_ _04914_ _04849_ VGND VGND VPWR VPWR _04974_ sky130_fd_sc_hd__or4b_4
XFILLER_0_85_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12662_ _04819_ _04824_ VGND VGND VPWR VPWR _04899_ sky130_fd_sc_hd__and2b_1
XFILLER_0_96_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11613_ _03740_ _03741_ _03756_ VGND VGND VPWR VPWR _03757_ sky130_fd_sc_hd__a21o_2
X_14401_ _06724_ _06793_ VGND VGND VPWR VPWR _06794_ sky130_fd_sc_hd__nor2_2
X_12593_ _04822_ _04823_ VGND VGND VPWR VPWR _04824_ sky130_fd_sc_hd__xor2_1
XFILLER_0_92_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11544_ _03677_ _03680_ VGND VGND VPWR VPWR _03681_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_80_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14332_ _06717_ _06718_ VGND VGND VPWR VPWR _06719_ sky130_fd_sc_hd__nand2_1
X_11475_ _03367_ _03377_ _03375_ VGND VGND VPWR VPWR _03606_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_122_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14263_ _06642_ _06643_ VGND VGND VPWR VPWR _06644_ sky130_fd_sc_hd__nor2_1
XFILLER_0_122_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10426_ _02455_ _02461_ _02463_ VGND VGND VPWR VPWR _02464_ sky130_fd_sc_hd__and3_1
X_13214_ _05497_ _05499_ VGND VGND VPWR VPWR _05500_ sky130_fd_sc_hd__or2b_1
XFILLER_0_0_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14194_ _06567_ _06568_ VGND VGND VPWR VPWR _06569_ sky130_fd_sc_hd__xnor2_1
X_10357_ _02238_ _02292_ _02388_ VGND VGND VPWR VPWR _02389_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13145_ _05342_ _05346_ _05349_ VGND VGND VPWR VPWR _05425_ sky130_fd_sc_hd__or3_1
X_10288_ net702 net715 net429 net421 VGND VGND VPWR VPWR _02313_ sky130_fd_sc_hd__and4_1
XFILLER_0_57_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13076_ _05330_ _05331_ _05346_ _05348_ VGND VGND VPWR VPWR _05349_ sky130_fd_sc_hd__a211oi_2
X_12027_ net376 net180 net170 net462 VGND VGND VPWR VPWR _04209_ sky130_fd_sc_hd__a22o_1
XFILLER_0_88_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13978_ _06332_ _06333_ _06325_ VGND VGND VPWR VPWR _06335_ sky130_fd_sc_hd__a21oi_1
X_12929_ net638 net493 net483 net406 VGND VGND VPWR VPWR _05187_ sky130_fd_sc_hd__nand4_2
XFILLER_0_118_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08120_ net290 net516 VGND VGND VPWR VPWR _00173_ sky130_fd_sc_hd__and2_1
XFILLER_0_83_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08051_ _07336_ _07343_ _07344_ VGND VGND VPWR VPWR _07345_ sky130_fd_sc_hd__nand3_1
XFILLER_0_98_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08953_ _00868_ _00994_ VGND VGND VPWR VPWR _00995_ sky130_fd_sc_hd__xor2_2
XFILLER_0_138_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07904_ _03890_ _07199_ VGND VGND VPWR VPWR _07200_ sky130_fd_sc_hd__xnor2_2
X_08884_ _00923_ _00924_ _00925_ VGND VGND VPWR VPWR _00927_ sky130_fd_sc_hd__nor3_1
X_07835_ _07128_ _07130_ VGND VGND VPWR VPWR _07131_ sky130_fd_sc_hd__or2_1
X_07766_ _06189_ _06222_ _06211_ VGND VGND VPWR VPWR _06538_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09505_ _01440_ _01445_ VGND VGND VPWR VPWR _01506_ sky130_fd_sc_hd__or2b_1
X_07697_ _05325_ _05336_ net763 VGND VGND VPWR VPWR _05787_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09436_ _01421_ _01435_ _01436_ VGND VGND VPWR VPWR _01437_ sky130_fd_sc_hd__nand3_2
XFILLER_0_137_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09367_ _01995_ _01368_ _01369_ VGND VGND VPWR VPWR _01370_ sky130_fd_sc_hd__or3_1
XFILLER_0_117_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08318_ _00365_ _00366_ _00367_ VGND VGND VPWR VPWR _00369_ sky130_fd_sc_hd__nand3_1
X_09298_ b_cos\[8\] a_sin\[8\] VGND VGND VPWR VPWR _01310_ sky130_fd_sc_hd__or2b_1
XFILLER_0_62_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08249_ _00194_ _00213_ _00212_ VGND VGND VPWR VPWR _00301_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_62_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11260_ net156 net721 VGND VGND VPWR VPWR _03369_ sky130_fd_sc_hd__nand2_1
X_11191_ net220 net703 VGND VGND VPWR VPWR _03293_ sky130_fd_sc_hd__and2_1
XFILLER_0_120_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10211_ _02227_ _02228_ VGND VGND VPWR VPWR _02229_ sky130_fd_sc_hd__nor2_1
X_10142_ _02150_ _02151_ _02152_ VGND VGND VPWR VPWR _02154_ sky130_fd_sc_hd__nand3_1
XFILLER_0_100_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10073_ _02076_ _02077_ _02057_ VGND VGND VPWR VPWR _02079_ sky130_fd_sc_hd__a21o_1
X_13901_ _06248_ _06250_ VGND VGND VPWR VPWR _06251_ sky130_fd_sc_hd__xor2_2
X_13832_ _06175_ VGND VGND VPWR VPWR _00095_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_134_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13763_ _06098_ _06099_ VGND VGND VPWR VPWR _06100_ sky130_fd_sc_hd__xor2_1
X_12714_ _04887_ _04893_ VGND VGND VPWR VPWR _04955_ sky130_fd_sc_hd__and2b_1
X_10975_ net141 _03057_ _03058_ VGND VGND VPWR VPWR _03060_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_85_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13694_ net494 net504 net334 net477 VGND VGND VPWR VPWR _06025_ sky130_fd_sc_hd__nand4_2
X_12645_ _04861_ _04879_ VGND VGND VPWR VPWR _04881_ sky130_fd_sc_hd__xnor2_2
X_12576_ _04784_ _04785_ _04803_ VGND VGND VPWR VPWR _04806_ sky130_fd_sc_hd__nor3_1
XFILLER_0_25_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11527_ _03650_ _03651_ _03661_ VGND VGND VPWR VPWR _03663_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_80_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14315_ _06698_ _06699_ _06637_ _06616_ VGND VGND VPWR VPWR _06702_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_25_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11458_ _03579_ _03580_ _03586_ VGND VGND VPWR VPWR _03587_ sky130_fd_sc_hd__nand3_2
XFILLER_0_1_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14246_ _06453_ _06454_ _06545_ _06624_ _06544_ VGND VGND VPWR VPWR _06627_ sky130_fd_sc_hd__a311oi_4
X_11389_ net194 net737 _03465_ _03464_ VGND VGND VPWR VPWR _03511_ sky130_fd_sc_hd__a31o_1
XFILLER_0_110_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10409_ _02442_ _02443_ _02444_ VGND VGND VPWR VPWR _02445_ sky130_fd_sc_hd__nand3_2
X_14177_ _06466_ _06486_ _06550_ VGND VGND VPWR VPWR _06551_ sky130_fd_sc_hd__o21a_1
X_13128_ _05401_ _05405_ VGND VGND VPWR VPWR _05406_ sky130_fd_sc_hd__xnor2_1
X_13059_ _05283_ _05288_ VGND VGND VPWR VPWR _05330_ sky130_fd_sc_hd__or2b_1
X_07620_ _04902_ _04913_ _04934_ VGND VGND VPWR VPWR _04945_ sky130_fd_sc_hd__nand3_1
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07551_ net754 _02114_ _02103_ VGND VGND VPWR VPWR _04195_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_88_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07482_ _03264_ _03418_ _03429_ VGND VGND VPWR VPWR _03440_ sky130_fd_sc_hd__nand3_4
XFILLER_0_75_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09221_ a_cos\[14\] b_sin\[14\] VGND VGND VPWR VPWR _01245_ sky130_fd_sc_hd__or2_1
X_09152_ _01184_ _01185_ VGND VGND VPWR VPWR _01186_ sky130_fd_sc_hd__and2b_1
XFILLER_0_44_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_86_Left_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08103_ _07211_ _07302_ _07301_ VGND VGND VPWR VPWR _00156_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_17_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09083_ _01121_ _01122_ VGND VGND VPWR VPWR _01123_ sky130_fd_sc_hd__xor2_1
XFILLER_0_71_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput70 sin[6] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_101_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08034_ _07325_ _07326_ _07311_ VGND VGND VPWR VPWR _07328_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09985_ net184 net139 net490 net411 VGND VGND VPWR VPWR _01985_ sky130_fd_sc_hd__and4_2
XPHY_EDGE_ROW_95_Left_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08936_ _00974_ _00977_ _00972_ VGND VGND VPWR VPWR _00979_ sky130_fd_sc_hd__a21oi_4
X_08867_ _00909_ _00910_ _00849_ _00850_ VGND VGND VPWR VPWR _00911_ sky130_fd_sc_hd__o211a_1
X_07818_ _07036_ _07058_ _07069_ _07080_ _07090_ VGND VGND VPWR VPWR _07101_ sky130_fd_sc_hd__o221a_1
X_08798_ _00841_ _00842_ VGND VGND VPWR VPWR _00843_ sky130_fd_sc_hd__nand2_1
X_07749_ _06298_ _06342_ net174 net660 VGND VGND VPWR VPWR _06353_ sky130_fd_sc_hd__o211a_1
XFILLER_0_55_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10760_ _02824_ _02826_ VGND VGND VPWR VPWR _02827_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10691_ _02750_ _02751_ VGND VGND VPWR VPWR _02752_ sky130_fd_sc_hd__or2b_1
X_09419_ _01404_ _01405_ _01419_ VGND VGND VPWR VPWR _01420_ sky130_fd_sc_hd__nand3_1
X_12430_ net190 net162 _04588_ _04586_ VGND VGND VPWR VPWR _04647_ sky130_fd_sc_hd__a31o_1
XFILLER_0_47_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12361_ _04481_ _04483_ VGND VGND VPWR VPWR _04572_ sky130_fd_sc_hd__nand2_1
XFILLER_0_105_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14100_ _06416_ _06419_ VGND VGND VPWR VPWR _06467_ sky130_fd_sc_hd__nand2_1
X_12292_ _04408_ _04409_ _04496_ VGND VGND VPWR VPWR _04497_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_133_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11312_ net156 net743 _03260_ _03261_ VGND VGND VPWR VPWR _03426_ sky130_fd_sc_hd__o2bb2a_1
X_11243_ net309 net556 net651 net230 VGND VGND VPWR VPWR _03350_ sky130_fd_sc_hd__a22o_1
XFILLER_0_120_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14031_ _06389_ _06391_ VGND VGND VPWR VPWR _06392_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_129_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11174_ net307 net668 net677 net228 VGND VGND VPWR VPWR _03274_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_101_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10125_ _01935_ _02095_ _02094_ VGND VGND VPWR VPWR _02136_ sky130_fd_sc_hd__a21bo_1
X_10056_ net692 net473 net453 net701 VGND VGND VPWR VPWR _02061_ sky130_fd_sc_hd__a22oi_1
X_14795_ clknet_3_1_0_clk _00096_ net317 VGND VGND VPWR VPWR b_cos\[5\] sky130_fd_sc_hd__dfrtp_1
X_13815_ _06155_ _06156_ VGND VGND VPWR VPWR _06158_ sky130_fd_sc_hd__nor2_1
XFILLER_0_58_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10958_ _02978_ _02979_ VGND VGND VPWR VPWR _03042_ sky130_fd_sc_hd__nand2_1
X_13746_ _05982_ _05985_ _06080_ _06082_ VGND VGND VPWR VPWR _06083_ sky130_fd_sc_hd__a211oi_2
X_13677_ _06000_ _06006_ VGND VGND VPWR VPWR _06007_ sky130_fd_sc_hd__xnor2_1
X_12628_ _04735_ _04808_ VGND VGND VPWR VPWR _04862_ sky130_fd_sc_hd__nor2_2
XFILLER_0_66_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10889_ _02966_ _02894_ VGND VGND VPWR VPWR _02967_ sky130_fd_sc_hd__nor2_1
XFILLER_0_26_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12559_ _04584_ net760 VGND VGND VPWR VPWR _04787_ sky130_fd_sc_hd__nor2_4
XFILLER_0_124_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14229_ _06605_ _06606_ VGND VGND VPWR VPWR _06608_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout608 net609 VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__clkbuf_4
Xfanout619 net23 VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_107_Right_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09770_ net690 net485 net407 net699 VGND VGND VPWR VPWR _01771_ sky130_fd_sc_hd__a22oi_2
X_08721_ _00657_ _00660_ _00658_ VGND VGND VPWR VPWR _00767_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_28_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08652_ net517 net236 VGND VGND VPWR VPWR _00699_ sky130_fd_sc_hd__and2b_1
X_07603_ _04728_ _04739_ _04750_ VGND VGND VPWR VPWR _04761_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_135_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08583_ _00589_ _00629_ _00630_ VGND VGND VPWR VPWR _00631_ sky130_fd_sc_hd__or3_1
X_07534_ _03988_ _03999_ VGND VGND VPWR VPWR _04010_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07465_ _02745_ _02756_ _02853_ VGND VGND VPWR VPWR _03253_ sky130_fd_sc_hd__nand3_2
XFILLER_0_76_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09204_ net77 _01230_ net130 VGND VGND VPWR VPWR _01231_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07396_ net177 net523 net532 net164 VGND VGND VPWR VPWR _02505_ sky130_fd_sc_hd__a22o_1
XFILLER_0_63_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09135_ _01170_ _01171_ net84 net796 VGND VGND VPWR VPWR _00019_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_17_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09066_ _01103_ _01105_ VGND VGND VPWR VPWR _01106_ sky130_fd_sc_hd__xor2_2
XFILLER_0_114_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08017_ _07243_ _07251_ _07250_ VGND VGND VPWR VPWR _07311_ sky130_fd_sc_hd__a21o_1
XFILLER_0_8_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09968_ _01634_ _01636_ _01635_ VGND VGND VPWR VPWR _01968_ sky130_fd_sc_hd__o21bai_1
X_08919_ _00960_ _00961_ VGND VGND VPWR VPWR _00962_ sky130_fd_sc_hd__nor2_1
X_11930_ _04099_ _04100_ _04101_ VGND VGND VPWR VPWR _04103_ sky130_fd_sc_hd__a21o_1
X_09899_ net400 _01893_ _01899_ VGND VGND VPWR VPWR _01900_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_99_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11861_ net462 net559 net197 net179 VGND VGND VPWR VPWR _04028_ sky130_fd_sc_hd__nand4_2
X_11792_ _03865_ _03857_ _03951_ _03952_ VGND VGND VPWR VPWR _03953_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_67_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10812_ _02791_ VGND VGND VPWR VPWR _02883_ sky130_fd_sc_hd__inv_2
XFILLER_0_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13600_ _05860_ _05916_ _05921_ _05922_ VGND VGND VPWR VPWR _05923_ sky130_fd_sc_hd__o211ai_2
X_14580_ _06986_ _06987_ VGND VGND VPWR VPWR _06988_ sky130_fd_sc_hd__or2_1
X_10743_ _02721_ _02725_ _02807_ VGND VGND VPWR VPWR _02808_ sky130_fd_sc_hd__nor3_1
X_13531_ _05842_ _05846_ _05847_ VGND VGND VPWR VPWR _05848_ sky130_fd_sc_hd__and3_1
XFILLER_0_137_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10674_ _02731_ _02732_ VGND VGND VPWR VPWR _02733_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13462_ _05371_ _05376_ _05370_ VGND VGND VPWR VPWR _05773_ sky130_fd_sc_hd__a21bo_1
X_12413_ net464 net286 net268 net558 VGND VGND VPWR VPWR _04628_ sky130_fd_sc_hd__a22oi_1
X_13393_ _05588_ _05651_ _05673_ _05695_ _05696_ VGND VGND VPWR VPWR _05697_ sky130_fd_sc_hd__o221a_1
X_12344_ _04550_ _04552_ VGND VGND VPWR VPWR _04553_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12275_ _04476_ _04477_ VGND VGND VPWR VPWR _04479_ sky130_fd_sc_hd__xor2_1
X_14014_ _06283_ _06299_ VGND VGND VPWR VPWR _06373_ sky130_fd_sc_hd__or2_1
X_11226_ net175 net165 net711 net721 VGND VGND VPWR VPWR _03332_ sky130_fd_sc_hd__and4_1
XFILLER_0_121_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11157_ net210 net201 net703 net711 VGND VGND VPWR VPWR _03256_ sky130_fd_sc_hd__and4_1
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10108_ a_cos\[2\] _02117_ _00486_ VGND VGND VPWR VPWR _02118_ sky130_fd_sc_hd__mux2_1
X_11088_ _03132_ _03139_ _03181_ VGND VGND VPWR VPWR _03182_ sky130_fd_sc_hd__a21o_1
X_10039_ net133 net490 net416 VGND VGND VPWR VPWR _02042_ sky130_fd_sc_hd__and3_1
XFILLER_0_58_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14778_ clknet_3_3_0_clk _00079_ net317 VGND VGND VPWR VPWR a_sin\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13729_ _05915_ _05924_ _05923_ VGND VGND VPWR VPWR _06064_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_128_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout405 net414 VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__clkbuf_4
Xfanout416 net45 VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__clkbuf_4
X_09822_ _01772_ _01771_ _01770_ VGND VGND VPWR VPWR _01823_ sky130_fd_sc_hd__o21ai_1
Xfanout438 net440 VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout427 net435 VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__clkbuf_4
X_09753_ _01684_ _01685_ _01694_ VGND VGND VPWR VPWR _01754_ sky130_fd_sc_hd__a21oi_1
Xfanout449 net41 VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__clkbuf_8
X_08704_ net161 net589 _00676_ _00675_ VGND VGND VPWR VPWR _00750_ sky130_fd_sc_hd__a31o_1
XFILLER_0_55_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09684_ _01668_ _01683_ _01682_ VGND VGND VPWR VPWR _01685_ sky130_fd_sc_hd__a21o_1
X_08635_ _00613_ _00681_ VGND VGND VPWR VPWR _00682_ sky130_fd_sc_hd__xnor2_1
X_08566_ net161 net608 _00542_ _00541_ VGND VGND VPWR VPWR _00614_ sky130_fd_sc_hd__a31o_1
X_07517_ _03605_ _03616_ _03803_ _03814_ VGND VGND VPWR VPWR _03825_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_49_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08497_ _00538_ _00545_ VGND VGND VPWR VPWR _00546_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_92_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07448_ _02462_ _02538_ VGND VGND VPWR VPWR _03070_ sky130_fd_sc_hd__or2b_1
XFILLER_0_64_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07379_ net195 net514 VGND VGND VPWR VPWR _02320_ sky130_fd_sc_hd__nand2_1
XFILLER_0_91_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09118_ _01154_ _01156_ VGND VGND VPWR VPWR _01157_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_44_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10390_ _02422_ _02423_ VGND VGND VPWR VPWR _02424_ sky130_fd_sc_hd__or2_1
X_09049_ _00993_ _01088_ VGND VGND VPWR VPWR _01089_ sky130_fd_sc_hd__xor2_2
XFILLER_0_20_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12060_ _04243_ _04244_ VGND VGND VPWR VPWR _04245_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11011_ _02968_ _03031_ _03030_ VGND VGND VPWR VPWR _03099_ sky130_fd_sc_hd__o21ai_1
X_12962_ net535 net355 net345 net544 VGND VGND VPWR VPWR _05223_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_35_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11913_ _04067_ _04083_ VGND VGND VPWR VPWR _04084_ sky130_fd_sc_hd__xnor2_1
X_12893_ _01926_ _05146_ _05147_ _05148_ VGND VGND VPWR VPWR _00089_ sky130_fd_sc_hd__a31o_1
X_14701_ clknet_3_2_0_clk _00002_ net316 VGND VGND VPWR VPWR b_sin\[2\] sky130_fd_sc_hd__dfrtp_1
X_11844_ _04005_ _04008_ VGND VGND VPWR VPWR _04009_ sky130_fd_sc_hd__xnor2_1
X_14632_ _06724_ _06793_ _06983_ VGND VGND VPWR VPWR _07044_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_142_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11775_ _03829_ _03838_ _03837_ VGND VGND VPWR VPWR _03935_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_95_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14563_ _06968_ _06969_ VGND VGND VPWR VPWR _06970_ sky130_fd_sc_hd__and2b_1
XFILLER_0_138_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10726_ _02781_ _02789_ VGND VGND VPWR VPWR _02790_ sky130_fd_sc_hd__xnor2_1
X_13514_ _05730_ _05731_ _05733_ VGND VGND VPWR VPWR _05829_ sky130_fd_sc_hd__o21bai_1
X_14494_ _06876_ _06877_ _06893_ VGND VGND VPWR VPWR _06895_ sky130_fd_sc_hd__a21o_1
XFILLER_0_70_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10657_ _02646_ _02714_ VGND VGND VPWR VPWR _02715_ sky130_fd_sc_hd__xnor2_1
X_13445_ _05752_ _05753_ VGND VGND VPWR VPWR _05755_ sky130_fd_sc_hd__and2b_1
XFILLER_0_141_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13376_ net562 net570 net487 net409 VGND VGND VPWR VPWR _05679_ sky130_fd_sc_hd__nand4_1
X_10588_ _02372_ _02556_ VGND VGND VPWR VPWR _02640_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12327_ _04451_ _04469_ VGND VGND VPWR VPWR _04535_ sky130_fd_sc_hd__or2_1
XFILLER_0_51_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12258_ _04453_ _04459_ VGND VGND VPWR VPWR _04460_ sky130_fd_sc_hd__xnor2_1
X_11209_ _03273_ _03274_ _03272_ VGND VGND VPWR VPWR _03313_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_76_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12189_ _04381_ _04382_ _04383_ VGND VGND VPWR VPWR _04385_ sky130_fd_sc_hd__nand3_1
XFILLER_0_76_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08420_ _00444_ _00469_ VGND VGND VPWR VPWR _00470_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08351_ _00386_ _00388_ VGND VGND VPWR VPWR _00401_ sky130_fd_sc_hd__and2b_1
XFILLER_0_73_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08282_ _00251_ _00332_ VGND VGND VPWR VPWR _00333_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_73_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout213 net216 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__clkbuf_4
Xfanout202 net207 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__buf_2
Xfanout224 net66 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__clkbuf_4
Xfanout235 net236 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__buf_2
Xfanout246 net63 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__buf_2
Xfanout257 net61 VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__buf_4
Xfanout268 net269 VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__clkbuf_4
Xfanout279 net287 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__clkbuf_4
X_07997_ b_sin\[1\] _07291_ VGND VGND VPWR VPWR _07292_ sky130_fd_sc_hd__and2_1
X_09805_ net699 net485 net407 net708 VGND VGND VPWR VPWR _01806_ sky130_fd_sc_hd__a22o_1
X_09736_ _01681_ _01675_ _01680_ VGND VGND VPWR VPWR _01737_ sky130_fd_sc_hd__nand3_1
XFILLER_0_97_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09667_ _01401_ _01395_ _01400_ VGND VGND VPWR VPWR _01668_ sky130_fd_sc_hd__nand3_1
X_08618_ net292 net617 VGND VGND VPWR VPWR _00665_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09598_ _01597_ _01598_ VGND VGND VPWR VPWR _01599_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08549_ net260 net500 VGND VGND VPWR VPWR _00597_ sky130_fd_sc_hd__nand2_1
X_11560_ _03623_ _03625_ _03624_ VGND VGND VPWR VPWR _03699_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_64_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10511_ _02554_ _02555_ VGND VGND VPWR VPWR _02556_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_9_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11491_ _03394_ _03621_ _03622_ VGND VGND VPWR VPWR _03623_ sky130_fd_sc_hd__nand3_1
XFILLER_0_107_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13230_ _05508_ _05514_ _05509_ VGND VGND VPWR VPWR _05518_ sky130_fd_sc_hd__nand3_1
XFILLER_0_122_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10442_ _02374_ _02454_ net126 _02480_ VGND VGND VPWR VPWR _02481_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_17_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10373_ _02306_ _02390_ VGND VGND VPWR VPWR _02405_ sky130_fd_sc_hd__and2b_1
XFILLER_0_0_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13161_ net519 net527 net388 net379 VGND VGND VPWR VPWR _05442_ sky130_fd_sc_hd__and4_1
XFILLER_0_32_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12112_ _04296_ _04299_ _04300_ VGND VGND VPWR VPWR _04301_ sky130_fd_sc_hd__nand3_1
X_13092_ net602 net489 net412 net611 VGND VGND VPWR VPWR _05366_ sky130_fd_sc_hd__a22o_1
X_12043_ net223 _00202_ _04224_ _04225_ VGND VGND VPWR VPWR _04226_ sky130_fd_sc_hd__a31o_1
XFILLER_0_130_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13994_ _06323_ _06351_ VGND VGND VPWR VPWR _06352_ sky130_fd_sc_hd__xnor2_1
X_12945_ net502 net398 _05187_ _05186_ VGND VGND VPWR VPWR _05205_ sky130_fd_sc_hd__a22o_1
X_12876_ _05076_ _05130_ VGND VGND VPWR VPWR _05131_ sky130_fd_sc_hd__and2_1
X_11827_ net669 net679 net159 net150 VGND VGND VPWR VPWR _03991_ sky130_fd_sc_hd__and4_1
XFILLER_0_68_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14615_ _07023_ _07025_ VGND VGND VPWR VPWR _07027_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11758_ _03914_ _03915_ VGND VGND VPWR VPWR _03916_ sky130_fd_sc_hd__and2b_1
XFILLER_0_83_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14546_ _06949_ _06951_ VGND VGND VPWR VPWR _06952_ sky130_fd_sc_hd__xor2_2
XFILLER_0_102_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10709_ _02727_ VGND VGND VPWR VPWR _02771_ sky130_fd_sc_hd__inv_2
XFILLER_0_55_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11689_ _03712_ _03718_ _03711_ VGND VGND VPWR VPWR _03841_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_83_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14477_ _06792_ _06811_ VGND VGND VPWR VPWR _06877_ sky130_fd_sc_hd__nand2_1
XFILLER_0_141_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13428_ _05401_ _05404_ _05403_ VGND VGND VPWR VPWR _05736_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_140_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13359_ _05620_ _05618_ _05619_ VGND VGND VPWR VPWR _05660_ sky130_fd_sc_hd__or3_1
XFILLER_0_3_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07920_ _07128_ _07213_ VGND VGND VPWR VPWR _07215_ sky130_fd_sc_hd__or2_1
X_07851_ _07145_ _07146_ VGND VGND VPWR VPWR _07147_ sky130_fd_sc_hd__nor2_1
Xinput2 alpha[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_1
X_07782_ _06657_ _06668_ _06701_ VGND VGND VPWR VPWR _06711_ sky130_fd_sc_hd__a21o_1
X_09521_ _01519_ _01520_ _01504_ _01505_ VGND VGND VPWR VPWR _01522_ sky130_fd_sc_hd__o211a_1
XFILLER_0_78_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09452_ net726 net330 net475 net734 VGND VGND VPWR VPWR _01453_ sky130_fd_sc_hd__a22oi_1
X_08403_ _00450_ _00451_ _00447_ VGND VGND VPWR VPWR _00453_ sky130_fd_sc_hd__a21o_1
XFILLER_0_59_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09383_ net673 net682 net392 net383 VGND VGND VPWR VPWR _01384_ sky130_fd_sc_hd__and4_1
X_08334_ _00382_ _00384_ VGND VGND VPWR VPWR _00385_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_19_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08265_ _00157_ _00254_ VGND VGND VPWR VPWR _00316_ sky130_fd_sc_hd__nor2_1
XFILLER_0_61_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08196_ _00242_ _00247_ VGND VGND VPWR VPWR _00248_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10991_ _03075_ _03076_ VGND VGND VPWR VPWR _03077_ sky130_fd_sc_hd__nor2_1
X_09719_ net700 net391 net381 net708 VGND VGND VPWR VPWR _01720_ sky130_fd_sc_hd__a22oi_1
X_12730_ _04971_ _04972_ VGND VGND VPWR VPWR _04973_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12661_ _04896_ _04897_ VGND VGND VPWR VPWR _04898_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_106_Left_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11612_ _03749_ _03755_ VGND VGND VPWR VPWR _03756_ sky130_fd_sc_hd__xnor2_1
X_14400_ _06665_ _06714_ VGND VGND VPWR VPWR _06793_ sky130_fd_sc_hd__nor2b_2
X_12592_ net671 net237 VGND VGND VPWR VPWR _04823_ sky130_fd_sc_hd__and2b_1
XFILLER_0_80_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11543_ _03678_ _03679_ VGND VGND VPWR VPWR _03680_ sky130_fd_sc_hd__nor2_1
XFILLER_0_53_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14331_ _06713_ _06716_ VGND VGND VPWR VPWR _06718_ sky130_fd_sc_hd__or2_1
X_11474_ _03602_ _03601_ _03570_ _03365_ VGND VGND VPWR VPWR _03604_ sky130_fd_sc_hd__o211a_1
XFILLER_0_52_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14262_ net615 net622 net454 net445 VGND VGND VPWR VPWR _06643_ sky130_fd_sc_hd__and4_1
X_10425_ _02459_ _02460_ _02456_ VGND VGND VPWR VPWR _02463_ sky130_fd_sc_hd__a21o_1
X_14193_ _06497_ _06500_ _06498_ VGND VGND VPWR VPWR _06568_ sky130_fd_sc_hd__o21ba_1
X_13213_ _05491_ _05498_ VGND VGND VPWR VPWR _05499_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13144_ _05346_ _05349_ _05342_ VGND VGND VPWR VPWR _05423_ sky130_fd_sc_hd__o21ai_2
XPHY_EDGE_ROW_115_Left_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10356_ _02290_ _02291_ VGND VGND VPWR VPWR _02388_ sky130_fd_sc_hd__and2b_1
X_10287_ net702 net429 net421 net710 VGND VGND VPWR VPWR _02312_ sky130_fd_sc_hd__a22oi_1
X_13075_ _05332_ _05333_ _05345_ VGND VGND VPWR VPWR _05348_ sky130_fd_sc_hd__and3_1
X_12026_ net375 net197 _04123_ _04122_ net205 VGND VGND VPWR VPWR _04208_ sky130_fd_sc_hd__a32o_1
X_13977_ _06325_ _06332_ _06333_ VGND VGND VPWR VPWR _06334_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_124_Left_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12928_ net638 net483 net405 net493 VGND VGND VPWR VPWR _05186_ sky130_fd_sc_hd__a22o_1
XFILLER_0_87_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12859_ _05073_ _05072_ VGND VGND VPWR VPWR _05112_ sky130_fd_sc_hd__or2b_1
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14529_ _06923_ _06932_ VGND VGND VPWR VPWR _06933_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_28_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08050_ _07341_ _07342_ _07261_ _07337_ VGND VGND VPWR VPWR _07344_ sky130_fd_sc_hd__a211o_1
XFILLER_0_24_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_133_Left_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08952_ _00991_ _00993_ VGND VGND VPWR VPWR _00994_ sky130_fd_sc_hd__xor2_2
X_08883_ _00923_ _00924_ _00925_ VGND VGND VPWR VPWR _00926_ sky130_fd_sc_hd__o21a_1
X_07903_ net115 _07198_ VGND VGND VPWR VPWR _07199_ sky130_fd_sc_hd__or2_1
X_07834_ _07127_ _07129_ VGND VGND VPWR VPWR _07130_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_142_Left_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07765_ _06353_ _06494_ _06505_ _06516_ VGND VGND VPWR VPWR _06527_ sky130_fd_sc_hd__nor4_4
X_07696_ _05688_ _05699_ _05765_ VGND VGND VPWR VPWR _05776_ sky130_fd_sc_hd__nor3_4
XFILLER_0_78_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09504_ _01460_ _01467_ VGND VGND VPWR VPWR _01505_ sky130_fd_sc_hd__or2b_1
XFILLER_0_63_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09435_ _01428_ _01429_ _01434_ VGND VGND VPWR VPWR _01436_ sky130_fd_sc_hd__a21o_1
XFILLER_0_136_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09366_ _01366_ _01363_ _01367_ VGND VGND VPWR VPWR _01369_ sky130_fd_sc_hd__a21oi_1
X_08317_ _00365_ _00366_ _00367_ VGND VGND VPWR VPWR _00368_ sky130_fd_sc_hd__a21o_1
XFILLER_0_90_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09297_ _01309_ VGND VGND VPWR VPWR _00043_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_74_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08248_ _00286_ _00299_ VGND VGND VPWR VPWR _00300_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_35_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_120_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08179_ _00229_ _00231_ VGND VGND VPWR VPWR _00232_ sky130_fd_sc_hd__nor2_1
X_10210_ _02129_ _02130_ _02128_ VGND VGND VPWR VPWR _02228_ sky130_fd_sc_hd__a21o_1
X_11190_ net220 net694 _03279_ _03278_ VGND VGND VPWR VPWR _03292_ sky130_fd_sc_hd__a22o_1
XFILLER_0_30_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10141_ _02150_ _02151_ _02152_ VGND VGND VPWR VPWR _02153_ sky130_fd_sc_hd__a21o_1
XFILLER_0_30_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10072_ _02057_ _02076_ _02077_ VGND VGND VPWR VPWR _02078_ sky130_fd_sc_hd__nand3_1
X_13900_ _06145_ _06160_ _06249_ VGND VGND VPWR VPWR _06250_ sky130_fd_sc_hd__o21a_1
X_13831_ b_cos\[4\] _06174_ _05794_ VGND VGND VPWR VPWR _06175_ sky130_fd_sc_hd__mux2_1
X_13762_ net29 net415 VGND VGND VPWR VPWR _06099_ sky130_fd_sc_hd__and2b_1
X_10974_ net134 net457 net448 net141 VGND VGND VPWR VPWR _03058_ sky130_fd_sc_hd__a22oi_2
X_12713_ _04952_ _04953_ VGND VGND VPWR VPWR _04954_ sky130_fd_sc_hd__xor2_1
XFILLER_0_97_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13693_ net494 net334 net477 net504 VGND VGND VPWR VPWR _06024_ sky130_fd_sc_hd__a22o_1
X_12644_ _04863_ _04878_ VGND VGND VPWR VPWR _04879_ sky130_fd_sc_hd__xor2_1
XFILLER_0_84_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12575_ _04784_ _04785_ _04803_ VGND VGND VPWR VPWR _04805_ sky130_fd_sc_hd__o21a_1
XFILLER_0_81_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11526_ _03650_ _03651_ _03661_ VGND VGND VPWR VPWR _03662_ sky130_fd_sc_hd__and3_1
X_14314_ _06637_ _06616_ _06698_ _06699_ VGND VGND VPWR VPWR _06700_ sky130_fd_sc_hd__a211o_4
XFILLER_0_80_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11457_ _03581_ _03585_ VGND VGND VPWR VPWR _03586_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_111_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14245_ _06544_ _06624_ _06458_ VGND VGND VPWR VPWR _06626_ sky130_fd_sc_hd__nor3b_1
X_11388_ _03424_ _03509_ VGND VGND VPWR VPWR _03510_ sky130_fd_sc_hd__or2_1
X_10408_ _02336_ _02338_ _02337_ VGND VGND VPWR VPWR _02444_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_0_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14176_ _06467_ _06485_ VGND VGND VPWR VPWR _06550_ sky130_fd_sc_hd__nand2_1
XFILLER_0_110_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13127_ _05403_ _05404_ VGND VGND VPWR VPWR _05405_ sky130_fd_sc_hd__nor2_1
X_10339_ _02279_ _02368_ VGND VGND VPWR VPWR _02369_ sky130_fd_sc_hd__nor2_2
X_13058_ _05326_ _05327_ _05256_ _05295_ VGND VGND VPWR VPWR _05329_ sky130_fd_sc_hd__o211a_1
X_12009_ net687 net696 net282 net264 VGND VGND VPWR VPWR _04189_ sky130_fd_sc_hd__and4_1
XFILLER_0_108_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07550_ _02124_ _02103_ _02114_ VGND VGND VPWR VPWR _04184_ sky130_fd_sc_hd__or3_4
XFILLER_0_119_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07481_ _03341_ _03352_ _03407_ VGND VGND VPWR VPWR _03429_ sky130_fd_sc_hd__a21o_1
X_09220_ a_cos\[14\] b_sin\[14\] VGND VGND VPWR VPWR _01244_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09151_ a_cos\[4\] b_sin\[4\] VGND VGND VPWR VPWR _01185_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09082_ _01016_ _01018_ _01068_ _01067_ _01054_ VGND VGND VPWR VPWR _01122_ sky130_fd_sc_hd__o32a_1
X_08102_ _00153_ _00154_ VGND VGND VPWR VPWR _00155_ sky130_fd_sc_hd__xor2_1
XFILLER_0_71_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08033_ _07311_ _07325_ _07326_ VGND VGND VPWR VPWR _07327_ sky130_fd_sc_hd__nand3_2
XFILLER_0_44_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput71 sin[7] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_102_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput60 sin[13] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_141_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09984_ net139 net490 net411 net184 VGND VGND VPWR VPWR _01984_ sky130_fd_sc_hd__a22oi_2
X_08935_ _00972_ _00974_ _00977_ VGND VGND VPWR VPWR _00978_ sky130_fd_sc_hd__and3_1
XFILLER_0_99_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08866_ _00907_ _00908_ _00842_ _00860_ VGND VGND VPWR VPWR _00910_ sky130_fd_sc_hd__o211a_1
XFILLER_0_98_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07817_ _06255_ _06276_ _05961_ _05874_ VGND VGND VPWR VPWR _07090_ sky130_fd_sc_hd__a211o_1
X_08797_ _00746_ _00827_ _00840_ VGND VGND VPWR VPWR _00842_ sky130_fd_sc_hd__a21o_1
X_07748_ _06309_ _06331_ VGND VGND VPWR VPWR _06342_ sky130_fd_sc_hd__nor2_1
X_07679_ net193 net565 VGND VGND VPWR VPWR _05589_ sky130_fd_sc_hd__nand2_1
XFILLER_0_109_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10690_ _02748_ _02749_ _02664_ _02683_ VGND VGND VPWR VPWR _02751_ sky130_fd_sc_hd__a211o_1
X_09418_ _01409_ _01418_ VGND VGND VPWR VPWR _01419_ sky130_fd_sc_hd__xor2_1
X_09349_ a_sin\[14\] b_cos\[14\] VGND VGND VPWR VPWR _01354_ sky130_fd_sc_hd__and2b_1
X_12360_ _04569_ _04570_ VGND VGND VPWR VPWR _04571_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_133_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11311_ net194 net730 _03415_ _03414_ VGND VGND VPWR VPWR _03425_ sky130_fd_sc_hd__a31o_1
XFILLER_0_7_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12291_ net198 net138 VGND VGND VPWR VPWR _04496_ sky130_fd_sc_hd__and2_1
XFILLER_0_120_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11242_ net309 net230 net556 net651 VGND VGND VPWR VPWR _03349_ sky130_fd_sc_hd__nand4_2
XFILLER_0_132_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14030_ _06390_ _06294_ VGND VGND VPWR VPWR _06391_ sky130_fd_sc_hd__nor2_1
X_11173_ net220 net684 VGND VGND VPWR VPWR _03273_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10124_ _02132_ _02133_ VGND VGND VPWR VPWR _02134_ sky130_fd_sc_hd__xor2_1
X_10055_ net710 net443 VGND VGND VPWR VPWR _02060_ sky130_fd_sc_hd__nand2_1
XFILLER_0_54_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13814_ _06150_ _06151_ _06154_ VGND VGND VPWR VPWR _06156_ sky130_fd_sc_hd__a21oi_1
X_14794_ clknet_3_1_0_clk _00095_ net317 VGND VGND VPWR VPWR b_cos\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_128_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10957_ _03037_ _03040_ VGND VGND VPWR VPWR _03041_ sky130_fd_sc_hd__xor2_1
X_13745_ _06078_ _06079_ _05996_ VGND VGND VPWR VPWR _06082_ sky130_fd_sc_hd__o21a_1
XFILLER_0_85_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13676_ _06003_ _06005_ VGND VGND VPWR VPWR _06006_ sky130_fd_sc_hd__xor2_1
X_12627_ _04794_ _04801_ _04860_ VGND VGND VPWR VPWR _04861_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_128_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10888_ _02884_ _02890_ VGND VGND VPWR VPWR _02966_ sky130_fd_sc_hd__and2b_1
XFILLER_0_26_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12558_ _04584_ _04734_ VGND VGND VPWR VPWR _04786_ sky130_fd_sc_hd__nand2_1
XFILLER_0_110_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11509_ net212 net203 net651 net668 VGND VGND VPWR VPWR _03643_ sky130_fd_sc_hd__and4_1
X_12489_ _04584_ _04653_ VGND VGND VPWR VPWR _04711_ sky130_fd_sc_hd__or2_1
XFILLER_0_124_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14228_ _06605_ _06606_ VGND VGND VPWR VPWR _06607_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout609 net610 VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__buf_2
XFILLER_0_0_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14159_ _06441_ _06488_ _06530_ _06531_ VGND VGND VPWR VPWR _06532_ sky130_fd_sc_hd__o211a_1
XFILLER_0_119_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08720_ _00653_ _00654_ _00670_ _00671_ VGND VGND VPWR VPWR _00766_ sky130_fd_sc_hd__o211ai_2
X_08651_ _00696_ _00697_ VGND VGND VPWR VPWR _00698_ sky130_fd_sc_hd__nor2_1
X_07602_ net306 net226 net506 net514 VGND VGND VPWR VPWR _04750_ sky130_fd_sc_hd__nand4_1
X_08582_ _00627_ _00628_ _00590_ _00591_ VGND VGND VPWR VPWR _00630_ sky130_fd_sc_hd__o211a_1
X_07533_ net175 net539 net548 net166 VGND VGND VPWR VPWR _03999_ sky130_fd_sc_hd__a22oi_1
X_07464_ _02897_ _02908_ _03221_ _03232_ VGND VGND VPWR VPWR _03243_ sky130_fd_sc_hd__or4_4
XFILLER_0_48_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09203_ _01228_ _01229_ VGND VGND VPWR VPWR _01230_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_57_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07395_ net177 net167 net522 net531 VGND VGND VPWR VPWR _02495_ sky130_fd_sc_hd__and4_1
XFILLER_0_91_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09134_ _01165_ _01169_ VGND VGND VPWR VPWR _01171_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09065_ net237 _01104_ VGND VGND VPWR VPWR _01105_ sky130_fd_sc_hd__and2_1
XFILLER_0_142_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08016_ _07234_ _07236_ VGND VGND VPWR VPWR _07310_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09967_ _01627_ _01628_ VGND VGND VPWR VPWR _01967_ sky130_fd_sc_hd__nand2_1
X_08918_ _00939_ _00959_ VGND VGND VPWR VPWR _00961_ sky130_fd_sc_hd__nor2_1
X_09898_ net741 net400 _01893_ _01897_ _01898_ VGND VGND VPWR VPWR _01899_ sky130_fd_sc_hd__a311o_1
X_08849_ _00829_ _00891_ _00892_ VGND VGND VPWR VPWR _00893_ sky130_fd_sc_hd__a21oi_1
X_11860_ net461 net197 net179 net559 VGND VGND VPWR VPWR _04027_ sky130_fd_sc_hd__a22o_1
XFILLER_0_67_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11791_ _03949_ _03950_ _03785_ VGND VGND VPWR VPWR _03952_ sky130_fd_sc_hd__a21o_1
XFILLER_0_95_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10811_ _02824_ _02826_ VGND VGND VPWR VPWR _02882_ sky130_fd_sc_hd__or2_1
XFILLER_0_94_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10742_ _02805_ _02806_ VGND VGND VPWR VPWR _02807_ sky130_fd_sc_hd__and2_1
X_13530_ _05844_ _05845_ _05843_ VGND VGND VPWR VPWR _05847_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_55_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10673_ net667 net676 net433 net425 VGND VGND VPWR VPWR _02732_ sky130_fd_sc_hd__and4_1
X_13461_ _05769_ _05770_ _05761_ VGND VGND VPWR VPWR _05772_ sky130_fd_sc_hd__a21o_1
X_12412_ _04583_ _04591_ VGND VGND VPWR VPWR _04627_ sky130_fd_sc_hd__nand2_1
X_13392_ _05653_ _05672_ VGND VGND VPWR VPWR _05696_ sky130_fd_sc_hd__nand2_1
X_12343_ _04551_ _04463_ VGND VGND VPWR VPWR _04552_ sky130_fd_sc_hd__nor2_1
XFILLER_0_106_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12274_ net679 net61 VGND VGND VPWR VPWR _04477_ sky130_fd_sc_hd__nand2_1
X_11225_ net156 net729 VGND VGND VPWR VPWR _03331_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14013_ _06361_ _06279_ VGND VGND VPWR VPWR _06372_ sky130_fd_sc_hd__and2b_1
X_11156_ net210 net703 net711 net201 VGND VGND VPWR VPWR _03255_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_4_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10107_ _02113_ _02116_ VGND VGND VPWR VPWR _02117_ sky130_fd_sc_hd__xnor2_1
X_11087_ _03141_ _03140_ VGND VGND VPWR VPWR _03181_ sky130_fd_sc_hd__and2b_1
X_10038_ net133 net490 net416 VGND VGND VPWR VPWR _02041_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_129_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14777_ clknet_3_3_0_clk _00078_ net317 VGND VGND VPWR VPWR a_sin\[5\] sky130_fd_sc_hd__dfrtp_1
X_11989_ net713 net248 net240 net723 VGND VGND VPWR VPWR _04167_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_14_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13728_ _06060_ _06061_ _06054_ VGND VGND VPWR VPWR _06063_ sky130_fd_sc_hd__a21o_1
XFILLER_0_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13659_ _05897_ _05987_ VGND VGND VPWR VPWR _05988_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_140_Right_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_124_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout439 net440 VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__clkbuf_4
X_09821_ _01804_ _01806_ _01805_ VGND VGND VPWR VPWR _01822_ sky130_fd_sc_hd__a21bo_1
Xfanout428 net435 VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout406 net414 VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__clkbuf_2
Xfanout417 net45 VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__clkbuf_4
X_09752_ _01750_ _01751_ _01752_ VGND VGND VPWR VPWR _01753_ sky130_fd_sc_hd__nand3_2
X_08703_ _00746_ _00747_ _00729_ _00730_ VGND VGND VPWR VPWR _00749_ sky130_fd_sc_hd__a211oi_1
X_09683_ _01668_ _01682_ _01683_ VGND VGND VPWR VPWR _01684_ sky130_fd_sc_hd__nand3_2
X_08634_ _00674_ _00680_ VGND VGND VPWR VPWR _00681_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_139_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08565_ _00611_ _00612_ VGND VGND VPWR VPWR _00613_ sky130_fd_sc_hd__nor2_2
XFILLER_0_77_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07516_ _03627_ _03638_ _03792_ VGND VGND VPWR VPWR _03814_ sky130_fd_sc_hd__nand3_2
XFILLER_0_76_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08496_ _00539_ _00544_ VGND VGND VPWR VPWR _00545_ sky130_fd_sc_hd__xor2_1
XFILLER_0_18_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07447_ _02473_ _02527_ VGND VGND VPWR VPWR _03059_ sky130_fd_sc_hd__or2b_1
XFILLER_0_91_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07378_ _02277_ _02288_ _02233_ VGND VGND VPWR VPWR _02309_ sky130_fd_sc_hd__a21o_1
XFILLER_0_134_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09117_ _01155_ _01091_ _00862_ VGND VGND VPWR VPWR _01156_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09048_ net258 _01041_ _01087_ VGND VGND VPWR VPWR _01088_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_32_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11010_ _03096_ _03097_ VGND VGND VPWR VPWR _03098_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12961_ net535 net544 net355 net345 VGND VGND VPWR VPWR _05222_ sky130_fd_sc_hd__and4_1
X_11912_ _04068_ _04082_ VGND VGND VPWR VPWR _04083_ sky130_fd_sc_hd__xnor2_1
X_12892_ a_sin\[16\] _00918_ VGND VGND VPWR VPWR _05148_ sky130_fd_sc_hd__and2_1
X_14700_ clknet_3_2_0_clk _00001_ net315 VGND VGND VPWR VPWR b_sin\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_59_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11843_ net216 _04006_ _04007_ VGND VGND VPWR VPWR _04008_ sky130_fd_sc_hd__a21bo_1
X_14631_ _07041_ _07042_ VGND VGND VPWR VPWR _07043_ sky130_fd_sc_hd__or2_1
XFILLER_0_68_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11774_ _03930_ _03931_ _03922_ VGND VGND VPWR VPWR _03933_ sky130_fd_sc_hd__a21o_1
X_14562_ _06920_ _06921_ _06967_ VGND VGND VPWR VPWR _06969_ sky130_fd_sc_hd__nand3_1
XFILLER_0_126_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10725_ _02786_ _02787_ VGND VGND VPWR VPWR _02789_ sky130_fd_sc_hd__xnor2_1
X_13513_ _05825_ _05826_ _05824_ VGND VGND VPWR VPWR _05828_ sky130_fd_sc_hd__o21ai_1
X_14493_ _06876_ _06877_ _06893_ VGND VGND VPWR VPWR _06894_ sky130_fd_sc_hd__nand3_1
X_10656_ _02711_ _02713_ VGND VGND VPWR VPWR _02714_ sky130_fd_sc_hd__xnor2_1
X_13444_ _05750_ _05751_ _05746_ VGND VGND VPWR VPWR _05753_ sky130_fd_sc_hd__a21o_1
XFILLER_0_106_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10587_ _02635_ _02637_ _02543_ _02545_ VGND VGND VPWR VPWR _02639_ sky130_fd_sc_hd__o211a_1
X_13375_ net562 net570 net485 net407 VGND VGND VPWR VPWR _05678_ sky130_fd_sc_hd__and4_1
XFILLER_0_3_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12326_ _04468_ _04452_ VGND VGND VPWR VPWR _04534_ sky130_fd_sc_hd__or2b_1
XFILLER_0_11_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12257_ _04457_ _04458_ VGND VGND VPWR VPWR _04459_ sky130_fd_sc_hd__xor2_1
XFILLER_0_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11208_ _03309_ _03310_ _03311_ VGND VGND VPWR VPWR _03312_ sky130_fd_sc_hd__nand3_1
X_12188_ _04381_ _04382_ _04383_ VGND VGND VPWR VPWR _04384_ sky130_fd_sc_hd__a21o_1
XFILLER_0_76_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11139_ _03172_ _03196_ VGND VGND VPWR VPWR _03237_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08350_ _00400_ VGND VGND VPWR VPWR _00005_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08281_ _00318_ _00331_ VGND VGND VPWR VPWR _00332_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_74_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout203 net207 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__buf_2
Xfanout214 net216 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_100_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout225 net227 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__buf_2
Xfanout247 net250 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__buf_2
Xfanout236 net64 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__clkbuf_4
X_09804_ net699 net708 net485 net407 VGND VGND VPWR VPWR _01805_ sky130_fd_sc_hd__nand4_1
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout258 net260 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__clkbuf_4
Xfanout269 net60 VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__clkbuf_4
X_07996_ _02006_ VGND VGND VPWR VPWR _07291_ sky130_fd_sc_hd__buf_4
XFILLER_0_5_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09735_ _01698_ _01699_ _01706_ VGND VGND VPWR VPWR _01736_ sky130_fd_sc_hd__a21oi_1
X_09666_ _01592_ _01593_ _01526_ _01530_ VGND VGND VPWR VPWR _01667_ sky130_fd_sc_hd__o211ai_1
X_08617_ _00662_ _00663_ VGND VGND VPWR VPWR _00664_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_19_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09597_ net742 net429 VGND VGND VPWR VPWR _01598_ sky130_fd_sc_hd__nand2_1
X_08548_ _00594_ _00595_ VGND VGND VPWR VPWR _00596_ sky130_fd_sc_hd__nor2_1
XFILLER_0_119_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08479_ _00509_ _00510_ _00526_ _00527_ VGND VGND VPWR VPWR _00528_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_9_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11490_ _03620_ _03619_ _03569_ _03381_ VGND VGND VPWR VPWR _03622_ sky130_fd_sc_hd__o211ai_2
X_10510_ net132 net370 VGND VGND VPWR VPWR _02555_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10441_ _02464_ _02465_ _02477_ _02478_ VGND VGND VPWR VPWR _02480_ sky130_fd_sc_hd__o22a_1
XFILLER_0_33_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_28_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10372_ _02387_ _02389_ VGND VGND VPWR VPWR _02404_ sky130_fd_sc_hd__and2b_1
XFILLER_0_60_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13160_ net518 net388 net379 net527 VGND VGND VPWR VPWR _05441_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_33_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12111_ net464 net163 _04297_ _04298_ VGND VGND VPWR VPWR _04300_ sky130_fd_sc_hd__nand4_1
XFILLER_0_103_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13091_ net602 net611 net489 net412 VGND VGND VPWR VPWR _05365_ sky130_fd_sc_hd__nand4_1
XFILLER_0_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12042_ net312 net233 net223 net135 VGND VGND VPWR VPWR _04225_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13993_ _06349_ _06350_ VGND VGND VPWR VPWR _06351_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_37_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12944_ _05187_ _05185_ _05186_ VGND VGND VPWR VPWR _05203_ sky130_fd_sc_hd__nand3_1
XFILLER_0_87_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12875_ _05111_ _05128_ VGND VGND VPWR VPWR _05130_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_62_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11826_ net670 net159 net150 net679 VGND VGND VPWR VPWR _03990_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_68_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14614_ _06919_ _06916_ _06968_ _06969_ VGND VGND VPWR VPWR _07025_ sky130_fd_sc_hd__o31a_1
X_11757_ _03911_ _03913_ _03907_ VGND VGND VPWR VPWR _03915_ sky130_fd_sc_hd__a21o_1
XFILLER_0_83_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14545_ _06880_ _06881_ _06879_ VGND VGND VPWR VPWR _06951_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_138_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10708_ _02728_ _02746_ VGND VGND VPWR VPWR _02770_ sky130_fd_sc_hd__nor2_1
X_11688_ _03837_ _03838_ _03829_ VGND VGND VPWR VPWR _03840_ sky130_fd_sc_hd__a21o_1
X_14476_ _06794_ _06810_ VGND VGND VPWR VPWR _06876_ sky130_fd_sc_hd__or2_1
XFILLER_0_126_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10639_ net186 net272 net336 net481 VGND VGND VPWR VPWR _02695_ sky130_fd_sc_hd__and4_1
XFILLER_0_3_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13427_ _05730_ _05734_ VGND VGND VPWR VPWR _05735_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_140_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13358_ _05654_ _05658_ VGND VGND VPWR VPWR _05659_ sky130_fd_sc_hd__nor2_1
X_12309_ _04494_ _04515_ VGND VGND VPWR VPWR _04516_ sky130_fd_sc_hd__xnor2_1
X_13289_ net561 net569 net388 net379 VGND VGND VPWR VPWR _05583_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07850_ net149 net297 net524 net534 VGND VGND VPWR VPWR _07146_ sky130_fd_sc_hd__and4_1
X_07781_ net218 net573 _06679_ _06690_ VGND VGND VPWR VPWR _06701_ sky130_fd_sc_hd__a31o_1
Xinput3 alpha[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_1
XFILLER_0_127_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09520_ _01504_ _01505_ _01519_ _01520_ VGND VGND VPWR VPWR _01521_ sky130_fd_sc_hd__a211oi_4
X_09451_ net726 net734 net330 net475 VGND VGND VPWR VPWR _01452_ sky130_fd_sc_hd__and4_1
X_08402_ _00447_ _00450_ _00451_ VGND VGND VPWR VPWR _00452_ sky130_fd_sc_hd__nand3_1
X_09382_ net691 net366 VGND VGND VPWR VPWR _01383_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08333_ _00276_ _00302_ _00383_ VGND VGND VPWR VPWR _00384_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_74_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08264_ _00315_ VGND VGND VPWR VPWR _00004_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_117_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08195_ _00245_ _00246_ VGND VGND VPWR VPWR _00247_ sky130_fd_sc_hd__xor2_1
XFILLER_0_132_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07979_ _07184_ _07242_ _07272_ _07273_ VGND VGND VPWR VPWR _07274_ sky130_fd_sc_hd__a211o_1
X_09718_ net699 net708 net391 net381 VGND VGND VPWR VPWR _01719_ sky130_fd_sc_hd__and4_1
XFILLER_0_97_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10990_ net273 net374 net432 net424 VGND VGND VPWR VPWR _03076_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09649_ _01647_ _01648_ _01649_ VGND VGND VPWR VPWR _01650_ sky130_fd_sc_hd__nand3_4
XFILLER_0_139_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12660_ _04894_ _04895_ VGND VGND VPWR VPWR _04897_ sky130_fd_sc_hd__and2_1
XFILLER_0_84_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11611_ _03750_ _03754_ VGND VGND VPWR VPWR _03755_ sky130_fd_sc_hd__xor2_1
XFILLER_0_108_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12591_ _04820_ _04821_ VGND VGND VPWR VPWR _04822_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14330_ _06713_ _06716_ VGND VGND VPWR VPWR _06717_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11542_ net280 net738 net745 net262 VGND VGND VPWR VPWR _03679_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_108_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11473_ _03365_ _03570_ _03601_ _03602_ VGND VGND VPWR VPWR _03603_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_80_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14261_ net615 net456 net445 net622 VGND VGND VPWR VPWR _06642_ sky130_fd_sc_hd__a22oi_2
X_10424_ _02456_ _02459_ _02460_ VGND VGND VPWR VPWR _02461_ sky130_fd_sc_hd__nand3_1
X_14192_ _06565_ _06566_ VGND VGND VPWR VPWR _06567_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_21_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13212_ _05453_ _05492_ VGND VGND VPWR VPWR _05498_ sky130_fd_sc_hd__nor2_1
XFILLER_0_110_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13143_ _05419_ _05420_ _05360_ _05352_ VGND VGND VPWR VPWR _05422_ sky130_fd_sc_hd__o211ai_2
X_10355_ _02327_ _02385_ VGND VGND VPWR VPWR _02387_ sky130_fd_sc_hd__xor2_2
XFILLER_0_21_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10286_ _02242_ _02246_ _02243_ VGND VGND VPWR VPWR _02311_ sky130_fd_sc_hd__o21ba_1
X_13074_ _05332_ _05333_ _05345_ VGND VGND VPWR VPWR _05346_ sky130_fd_sc_hd__a21oi_2
X_12025_ _04115_ _04116_ _04114_ VGND VGND VPWR VPWR _04207_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_73_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13976_ _06329_ _06330_ _06326_ VGND VGND VPWR VPWR _06333_ sky130_fd_sc_hd__a21o_1
XFILLER_0_87_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12927_ net502 net398 VGND VGND VPWR VPWR _05185_ sky130_fd_sc_hd__and2_1
X_12858_ _05046_ _05054_ _05110_ VGND VGND VPWR VPWR _05111_ sky130_fd_sc_hd__a21bo_1
X_11809_ _03885_ _03965_ _03970_ VGND VGND VPWR VPWR _03971_ sky130_fd_sc_hd__or3_1
XFILLER_0_113_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12789_ _05036_ VGND VGND VPWR VPWR _05037_ sky130_fd_sc_hd__inv_2
XFILLER_0_125_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14528_ _06794_ _06931_ VGND VGND VPWR VPWR _06932_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_114_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14459_ net595 net586 net456 net446 VGND VGND VPWR VPWR _06857_ sky130_fd_sc_hd__and4_1
XFILLER_0_126_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08951_ _00992_ VGND VGND VPWR VPWR _00993_ sky130_fd_sc_hd__buf_2
X_08882_ net258 net607 VGND VGND VPWR VPWR _00925_ sky130_fd_sc_hd__nand2_1
X_07902_ _07194_ _07195_ _07196_ VGND VGND VPWR VPWR _07198_ sky130_fd_sc_hd__o21a_1
XFILLER_0_138_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07833_ net247 net662 VGND VGND VPWR VPWR _07129_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07764_ _06364_ _06483_ _06472_ VGND VGND VPWR VPWR _06516_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_79_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07695_ _05710_ _05754_ VGND VGND VPWR VPWR _05765_ sky130_fd_sc_hd__xnor2_1
X_09503_ _01461_ _01466_ VGND VGND VPWR VPWR _01504_ sky130_fd_sc_hd__or2b_1
XFILLER_0_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09434_ _01428_ _01429_ _01434_ VGND VGND VPWR VPWR _01435_ sky130_fd_sc_hd__nand3_1
XFILLER_0_137_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09365_ _01366_ _01363_ _01367_ VGND VGND VPWR VPWR _01368_ sky130_fd_sc_hd__and3_1
XFILLER_0_47_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08316_ net196 net601 VGND VGND VPWR VPWR _00367_ sky130_fd_sc_hd__and2_1
X_09296_ net108 _01308_ net129 VGND VGND VPWR VPWR _01309_ sky130_fd_sc_hd__mux2_1
XANTENNA_30 net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_19_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08247_ _00297_ _00298_ VGND VGND VPWR VPWR _00299_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08178_ _00226_ _00230_ _00228_ VGND VGND VPWR VPWR _00231_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_43_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10140_ net686 net473 VGND VGND VPWR VPWR _02152_ sky130_fd_sc_hd__and2_1
X_10071_ _02074_ _02075_ _02058_ VGND VGND VPWR VPWR _02077_ sky130_fd_sc_hd__a21o_1
X_13830_ _06172_ _06173_ VGND VGND VPWR VPWR _06174_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13761_ _06096_ _06097_ VGND VGND VPWR VPWR _06098_ sky130_fd_sc_hd__nor2_1
X_10973_ net134 net457 net448 VGND VGND VPWR VPWR _03057_ sky130_fd_sc_hd__and3_1
X_12712_ _04890_ _04892_ _04889_ VGND VGND VPWR VPWR _04953_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_69_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13692_ _06021_ _06022_ VGND VGND VPWR VPWR _06023_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_127_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12643_ _04870_ _04877_ VGND VGND VPWR VPWR _04878_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_38_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12574_ _04788_ _04802_ VGND VGND VPWR VPWR _04803_ sky130_fd_sc_hd__xor2_1
XFILLER_0_65_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11525_ _03652_ _03659_ VGND VGND VPWR VPWR _03661_ sky130_fd_sc_hd__xor2_2
XFILLER_0_4_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14313_ _06674_ _06675_ _06697_ VGND VGND VPWR VPWR _06699_ sky130_fd_sc_hd__nor3_2
X_14244_ _06453_ _06543_ VGND VGND VPWR VPWR _06624_ sky130_fd_sc_hd__nor2_1
X_11456_ _03582_ _03584_ VGND VGND VPWR VPWR _03585_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11387_ net176 net737 net744 net165 VGND VGND VPWR VPWR _03509_ sky130_fd_sc_hd__a22oi_1
X_14175_ _06548_ VGND VGND VPWR VPWR _00099_ sky130_fd_sc_hd__clkbuf_1
X_10407_ _02438_ _02439_ _02441_ VGND VGND VPWR VPWR _02443_ sky130_fd_sc_hd__nand3_1
XFILLER_0_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13126_ net528 net329 net474 net536 VGND VGND VPWR VPWR _05404_ sky130_fd_sc_hd__a22oi_2
X_10338_ net490 net413 net403 VGND VGND VPWR VPWR _02368_ sky130_fd_sc_hd__and3_1
X_13057_ _05256_ _05295_ _05326_ _05327_ VGND VGND VPWR VPWR _05328_ sky130_fd_sc_hd__a211oi_1
X_12008_ net687 net282 net264 net696 VGND VGND VPWR VPWR _04188_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_108_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10269_ _02238_ _02292_ VGND VGND VPWR VPWR _02293_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_88_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13959_ _06207_ _06209_ _06208_ VGND VGND VPWR VPWR _06314_ sky130_fd_sc_hd__a21bo_1
X_07480_ _03341_ _03352_ _03407_ VGND VGND VPWR VPWR _03418_ sky130_fd_sc_hd__nand3_2
XFILLER_0_33_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09150_ a_cos\[4\] b_sin\[4\] VGND VGND VPWR VPWR _01184_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08101_ _07210_ _07297_ _07298_ VGND VGND VPWR VPWR _00154_ sky130_fd_sc_hd__o21ba_1
X_09081_ _01118_ _01120_ VGND VGND VPWR VPWR _01121_ sky130_fd_sc_hd__xor2_1
XFILLER_0_16_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08032_ _07323_ _07324_ _07316_ VGND VGND VPWR VPWR _07326_ sky130_fd_sc_hd__a21o_1
Xinput61 sin[14] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__buf_2
Xinput72 sin[8] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__clkbuf_1
Xinput50 cos[5] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_2
XFILLER_0_3_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09983_ net270 net403 VGND VGND VPWR VPWR _01983_ sky130_fd_sc_hd__nand2_1
X_08934_ _00792_ _00855_ _00975_ _00976_ VGND VGND VPWR VPWR _00977_ sky130_fd_sc_hd__o31a_1
XFILLER_0_58_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08865_ _00842_ _00860_ _00907_ _00908_ VGND VGND VPWR VPWR _00909_ sky130_fd_sc_hd__a211oi_2
X_07816_ _06276_ _07047_ VGND VGND VPWR VPWR _07080_ sky130_fd_sc_hd__nand2_1
X_08796_ _00746_ _00827_ _00840_ VGND VGND VPWR VPWR _00841_ sky130_fd_sc_hd__nand3_1
X_07747_ _06298_ _06320_ VGND VGND VPWR VPWR _06331_ sky130_fd_sc_hd__or2_4
XFILLER_0_79_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07678_ _05512_ _05523_ _05567_ VGND VGND VPWR VPWR _05578_ sky130_fd_sc_hd__a21o_1
XFILLER_0_67_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09417_ _01416_ _01417_ VGND VGND VPWR VPWR _01418_ sky130_fd_sc_hd__nor2_1
XFILLER_0_118_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09348_ _01353_ VGND VGND VPWR VPWR _00050_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11310_ net176 net165 net737 net743 VGND VGND VPWR VPWR _03424_ sky130_fd_sc_hd__and4_1
X_09279_ _01292_ _01293_ VGND VGND VPWR VPWR _01294_ sky130_fd_sc_hd__nand2_1
X_12290_ _04317_ _04412_ VGND VGND VPWR VPWR _04495_ sky130_fd_sc_hd__nand2_1
XFILLER_0_105_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11241_ net221 net668 VGND VGND VPWR VPWR _03348_ sky130_fd_sc_hd__and2_1
X_11172_ net307 net228 net668 net677 VGND VGND VPWR VPWR _03272_ sky130_fd_sc_hd__and4_1
XFILLER_0_101_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10123_ _01934_ _02089_ _02090_ VGND VGND VPWR VPWR _02133_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_30_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10054_ _01967_ _01975_ _01974_ VGND VGND VPWR VPWR _02058_ sky130_fd_sc_hd__a21o_1
X_13813_ _06150_ _06151_ _06154_ VGND VGND VPWR VPWR _06155_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_121_Right_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14793_ clknet_3_1_0_clk _00094_ net318 VGND VGND VPWR VPWR b_cos\[3\] sky130_fd_sc_hd__dfrtp_1
X_10956_ _02953_ _02970_ _03039_ VGND VGND VPWR VPWR _03040_ sky130_fd_sc_hd__a21bo_1
X_13744_ _05996_ _06078_ _06079_ VGND VGND VPWR VPWR _06080_ sky130_fd_sc_hd__nor3_1
X_10887_ _02963_ _02964_ VGND VGND VPWR VPWR _02965_ sky130_fd_sc_hd__or2_1
X_13675_ net572 net415 VGND VGND VPWR VPWR _06005_ sky130_fd_sc_hd__and2b_1
X_12626_ _04799_ _04800_ VGND VGND VPWR VPWR _04860_ sky130_fd_sc_hd__and2_1
XFILLER_0_109_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12557_ _04718_ _04725_ VGND VGND VPWR VPWR _04785_ sky130_fd_sc_hd__and2_1
XFILLER_0_123_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11508_ net195 net678 VGND VGND VPWR VPWR _03642_ sky130_fd_sc_hd__nand2_1
X_12488_ _04633_ _04640_ VGND VGND VPWR VPWR _04710_ sky130_fd_sc_hd__and2_1
XFILLER_0_80_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11439_ _03563_ _03564_ _03437_ VGND VGND VPWR VPWR _03566_ sky130_fd_sc_hd__a21o_1
X_14227_ _06471_ _06473_ _06470_ VGND VGND VPWR VPWR _06606_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14158_ _06529_ _06508_ _06509_ VGND VGND VPWR VPWR _06531_ sky130_fd_sc_hd__or3_4
X_13109_ net503 net356 net346 net511 VGND VGND VPWR VPWR _05385_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_21_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14089_ _06265_ _06366_ VGND VGND VPWR VPWR _06456_ sky130_fd_sc_hd__nand2_1
X_08650_ net251 net243 net500 net509 VGND VGND VPWR VPWR _00697_ sky130_fd_sc_hd__and4_1
X_07601_ net306 net506 net514 net226 VGND VGND VPWR VPWR _04739_ sky130_fd_sc_hd__a22o_1
X_08581_ _00590_ _00591_ _00627_ _00628_ VGND VGND VPWR VPWR _00629_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_89_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07532_ net175 net164 net539 net548 VGND VGND VPWR VPWR _03988_ sky130_fd_sc_hd__and4_1
XFILLER_0_88_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07463_ _03200_ _03211_ _03016_ _03049_ VGND VGND VPWR VPWR _03232_ sky130_fd_sc_hd__o211a_1
XFILLER_0_29_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09202_ _01222_ _01223_ _01220_ VGND VGND VPWR VPWR _01229_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_17_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07394_ net157 net539 VGND VGND VPWR VPWR _02484_ sky130_fd_sc_hd__nand2_1
XFILLER_0_91_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09133_ _01165_ _01169_ net796 VGND VGND VPWR VPWR _01170_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09064_ net610 VGND VGND VPWR VPWR _01104_ sky130_fd_sc_hd__inv_2
XFILLER_0_142_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08015_ _07184_ _07242_ _07272_ _07273_ VGND VGND VPWR VPWR _07309_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_4_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09966_ _01633_ _01650_ _01651_ VGND VGND VPWR VPWR _01966_ sky130_fd_sc_hd__nand3_2
X_08917_ _00939_ _00959_ VGND VGND VPWR VPWR _00960_ sky130_fd_sc_hd__and2_1
X_09897_ net735 net742 VGND VGND VPWR VPWR _01898_ sky130_fd_sc_hd__nand2_2
XFILLER_0_99_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08848_ net253 net243 net626 net634 VGND VGND VPWR VPWR _00892_ sky130_fd_sc_hd__and4_1
X_08779_ _00822_ net122 _00758_ _00761_ VGND VGND VPWR VPWR _00824_ sky130_fd_sc_hd__o211a_1
X_11790_ _03785_ _03949_ _03950_ VGND VGND VPWR VPWR _03951_ sky130_fd_sc_hd__nand3_2
XFILLER_0_67_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10810_ _02846_ _02806_ _02879_ VGND VGND VPWR VPWR _02881_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_138_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10741_ _02804_ _02793_ _02794_ VGND VGND VPWR VPWR _02806_ sky130_fd_sc_hd__or3_1
X_13460_ _05761_ _05769_ _05770_ VGND VGND VPWR VPWR _05771_ sky130_fd_sc_hd__nand3_2
X_12411_ _04584_ _04590_ VGND VGND VPWR VPWR _04626_ sky130_fd_sc_hd__or2_1
X_10672_ net667 net433 net425 net676 VGND VGND VPWR VPWR _02731_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_62_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13391_ _05674_ _05675_ _05694_ VGND VGND VPWR VPWR _05695_ sky130_fd_sc_hd__and3_1
X_12342_ _04453_ _04459_ VGND VGND VPWR VPWR _04551_ sky130_fd_sc_hd__and2b_1
X_12273_ _04474_ _04475_ VGND VGND VPWR VPWR _04476_ sky130_fd_sc_hd__or2_1
X_11224_ _03284_ _03285_ _03287_ VGND VGND VPWR VPWR _03329_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_120_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14012_ _06357_ _06360_ VGND VGND VPWR VPWR _06371_ sky130_fd_sc_hd__and2_1
XFILLER_0_31_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11155_ net193 net720 VGND VGND VPWR VPWR _03254_ sky130_fd_sc_hd__nand2_1
X_10106_ _02115_ _02018_ VGND VGND VPWR VPWR _02116_ sky130_fd_sc_hd__nand2_1
X_11086_ _03110_ _03118_ _03179_ VGND VGND VPWR VPWR _03180_ sky130_fd_sc_hd__a21bo_1
X_10037_ net139 net411 VGND VGND VPWR VPWR _02040_ sky130_fd_sc_hd__nand2_1
X_11988_ _04090_ _04093_ _04091_ VGND VGND VPWR VPWR _04166_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_98_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14776_ clknet_3_3_0_clk _00077_ net317 VGND VGND VPWR VPWR a_sin\[4\] sky130_fd_sc_hd__dfrtp_1
X_10939_ _02957_ _02958_ _02956_ VGND VGND VPWR VPWR _03021_ sky130_fd_sc_hd__a21oi_1
X_13727_ _06054_ _06060_ _06061_ VGND VGND VPWR VPWR _06062_ sky130_fd_sc_hd__nand3_1
XFILLER_0_39_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13658_ _05985_ _05986_ VGND VGND VPWR VPWR _05987_ sky130_fd_sc_hd__and2_1
XFILLER_0_121_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12609_ _04839_ _04840_ _04747_ _04841_ VGND VGND VPWR VPWR _04842_ sky130_fd_sc_hd__a211o_1
XFILLER_0_54_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13589_ net611 net385 VGND VGND VPWR VPWR _05911_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout429 net435 VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__buf_2
Xfanout407 net408 VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__clkbuf_4
X_09820_ _01772_ _01770_ _01771_ VGND VGND VPWR VPWR _01821_ sky130_fd_sc_hd__or3_1
Xfanout418 net45 VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__clkbuf_2
X_09751_ _01728_ _01730_ VGND VGND VPWR VPWR _01752_ sky130_fd_sc_hd__xnor2_1
X_08702_ _00729_ _00730_ _00746_ _00747_ VGND VGND VPWR VPWR _00748_ sky130_fd_sc_hd__o211a_1
X_09682_ _01401_ _01395_ _01400_ VGND VGND VPWR VPWR _01683_ sky130_fd_sc_hd__a21o_1
X_08633_ _00615_ _00679_ VGND VGND VPWR VPWR _00680_ sky130_fd_sc_hd__xor2_1
X_08564_ _00533_ _00534_ _00293_ VGND VGND VPWR VPWR _00612_ sky130_fd_sc_hd__o21a_1
XFILLER_0_49_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07515_ _03627_ _03638_ _03792_ VGND VGND VPWR VPWR _03803_ sky130_fd_sc_hd__a21o_2
XFILLER_0_76_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08495_ _00542_ _00543_ VGND VGND VPWR VPWR _00544_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07446_ _03027_ _03038_ VGND VGND VPWR VPWR _03049_ sky130_fd_sc_hd__or2b_1
XFILLER_0_134_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07377_ _02233_ _02277_ _02288_ VGND VGND VPWR VPWR _02299_ sky130_fd_sc_hd__nand3_1
X_09116_ _00863_ VGND VGND VPWR VPWR _01155_ sky130_fd_sc_hd__inv_2
XFILLER_0_130_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09047_ net258 net582 _01041_ VGND VGND VPWR VPWR _01087_ sky130_fd_sc_hd__a21o_1
XFILLER_0_60_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09949_ _01947_ _01948_ VGND VGND VPWR VPWR _01949_ sky130_fd_sc_hd__or2_1
X_12960_ _05202_ _05219_ _05218_ VGND VGND VPWR VPWR _05221_ sky130_fd_sc_hd__a21o_1
X_11911_ _04080_ _04081_ VGND VGND VPWR VPWR _04082_ sky130_fd_sc_hd__nand2_1
X_12891_ _05088_ _05095_ _05145_ VGND VGND VPWR VPWR _05147_ sky130_fd_sc_hd__or3_1
XFILLER_0_99_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11842_ net188 net223 net216 net274 VGND VGND VPWR VPWR _04007_ sky130_fd_sc_hd__a22o_1
XFILLER_0_68_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14630_ _07030_ _06987_ _07040_ VGND VGND VPWR VPWR _07042_ sky130_fd_sc_hd__o21a_1
X_14561_ _06920_ _06921_ _06967_ VGND VGND VPWR VPWR _06968_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_138_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11773_ _03922_ _03930_ _03931_ VGND VGND VPWR VPWR _03932_ sky130_fd_sc_hd__nand3_1
XFILLER_0_83_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13512_ _05824_ _05825_ _05826_ VGND VGND VPWR VPWR _05827_ sky130_fd_sc_hd__or3_1
XFILLER_0_27_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10724_ _02694_ _02697_ _02695_ VGND VGND VPWR VPWR _02787_ sky130_fd_sc_hd__o21ba_1
X_14492_ _06891_ _06892_ VGND VGND VPWR VPWR _06893_ sky130_fd_sc_hd__nand2_1
XFILLER_0_125_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10655_ net142 net342 VGND VGND VPWR VPWR _02713_ sky130_fd_sc_hd__nand2_1
X_13443_ _05746_ _05750_ _05751_ VGND VGND VPWR VPWR _05752_ sky130_fd_sc_hd__and3_1
XFILLER_0_91_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13374_ _05659_ _05668_ VGND VGND VPWR VPWR _05676_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12325_ next_state _04530_ _04531_ _04532_ VGND VGND VPWR VPWR _00080_ sky130_fd_sc_hd__a31o_1
X_10586_ _02543_ _02545_ _02635_ _02637_ VGND VGND VPWR VPWR _02638_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_2_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12256_ net706 net235 VGND VGND VPWR VPWR _04458_ sky130_fd_sc_hd__and2b_1
XFILLER_0_50_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11207_ net309 net651 net668 net230 VGND VGND VPWR VPWR _03311_ sky130_fd_sc_hd__a22o_1
X_12187_ net653 net293 VGND VGND VPWR VPWR _04383_ sky130_fd_sc_hd__and2_1
XFILLER_0_102_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11138_ _03227_ _03235_ VGND VGND VPWR VPWR _03236_ sky130_fd_sc_hd__xnor2_1
X_11069_ net780 _07291_ VGND VGND VPWR VPWR _03162_ sky130_fd_sc_hd__nand2_1
XFILLER_0_116_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14759_ clknet_3_1_0_clk _00060_ net318 VGND VGND VPWR VPWR a_cos\[5\] sky130_fd_sc_hd__dfrtp_1
X_08280_ _00327_ _00330_ VGND VGND VPWR VPWR _00331_ sky130_fd_sc_hd__xor2_2
XFILLER_0_128_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout204 net207 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout215 net216 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__clkbuf_2
Xfanout226 net227 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__buf_6
Xfanout237 net64 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__clkbuf_4
X_09803_ net716 net399 VGND VGND VPWR VPWR _01804_ sky130_fd_sc_hd__and2_1
Xfanout259 net260 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__buf_2
Xfanout248 net250 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__buf_2
X_07995_ _04467_ _07126_ _07200_ _07286_ _07287_ VGND VGND VPWR VPWR _07290_ sky130_fd_sc_hd__a2111o_4
X_09734_ _01698_ _01699_ _01706_ VGND VGND VPWR VPWR _01735_ sky130_fd_sc_hd__and3_1
X_09665_ _01595_ _01665_ VGND VGND VPWR VPWR _01666_ sky130_fd_sc_hd__xnor2_1
X_08616_ net153 net301 net599 net608 VGND VGND VPWR VPWR _00663_ sky130_fd_sc_hd__and4_1
X_09596_ _01575_ _01576_ _01577_ VGND VGND VPWR VPWR _01597_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_49_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08547_ net283 net265 net634 net645 VGND VGND VPWR VPWR _00595_ sky130_fd_sc_hd__and4_1
XFILLER_0_49_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08478_ _00524_ _00525_ _00511_ VGND VGND VPWR VPWR _00527_ sky130_fd_sc_hd__a21o_1
XFILLER_0_92_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07429_ _02745_ _02756_ _02853_ VGND VGND VPWR VPWR _02864_ sky130_fd_sc_hd__and3_1
XFILLER_0_64_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10440_ _02464_ _02465_ _02477_ _02478_ VGND VGND VPWR VPWR _02479_ sky130_fd_sc_hd__nor4_1
X_10371_ _02403_ VGND VGND VPWR VPWR _00060_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12110_ net464 net160 _04297_ _04298_ VGND VGND VPWR VPWR _04299_ sky130_fd_sc_hd__a22o_1
X_13090_ net620 net402 VGND VGND VPWR VPWR _05364_ sky130_fd_sc_hd__and2_1
X_12041_ net312 net233 net143 VGND VGND VPWR VPWR _04224_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13992_ net125 _06348_ _06245_ _06324_ VGND VGND VPWR VPWR _06350_ sky130_fd_sc_hd__o211a_1
XFILLER_0_88_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12943_ _05195_ _05196_ _05201_ VGND VGND VPWR VPWR _05202_ sky130_fd_sc_hd__nand3_1
XFILLER_0_88_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12874_ _05126_ _05127_ VGND VGND VPWR VPWR _05128_ sky130_fd_sc_hd__and2_1
X_11825_ net687 net298 VGND VGND VPWR VPWR _03989_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14613_ _06919_ _06916_ _06968_ _06969_ _07023_ VGND VGND VPWR VPWR _07024_ sky130_fd_sc_hd__o311a_4
X_11756_ _03907_ _03911_ _03913_ VGND VGND VPWR VPWR _03914_ sky130_fd_sc_hd__and3_1
X_14544_ _06947_ _06948_ VGND VGND VPWR VPWR _06949_ sky130_fd_sc_hd__nor2_1
XFILLER_0_71_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10707_ _02729_ _02744_ VGND VGND VPWR VPWR _02769_ sky130_fd_sc_hd__and2_1
X_14475_ _06872_ _06873_ VGND VGND VPWR VPWR _06875_ sky130_fd_sc_hd__and2_1
X_11687_ _03829_ _03837_ _03838_ VGND VGND VPWR VPWR _03839_ sky130_fd_sc_hd__nand3_2
XFILLER_0_125_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13426_ _05731_ _05733_ VGND VGND VPWR VPWR _05734_ sky130_fd_sc_hd__nor2_1
XFILLER_0_36_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10638_ net186 net336 net481 net272 VGND VGND VPWR VPWR _02694_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_3_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10569_ _02561_ _02566_ VGND VGND VPWR VPWR _02619_ sky130_fd_sc_hd__or2b_1
X_13357_ net569 net391 net381 net656 VGND VGND VPWR VPWR _05658_ sky130_fd_sc_hd__a22oi_1
X_12308_ _04513_ _04514_ VGND VGND VPWR VPWR _04515_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13288_ _05538_ _05539_ _05581_ VGND VGND VPWR VPWR _05582_ sky130_fd_sc_hd__a21o_1
X_12239_ _04438_ _04439_ VGND VGND VPWR VPWR _04440_ sky130_fd_sc_hd__nand2_1
X_07780_ net304 net225 net547 net565 VGND VGND VPWR VPWR _06690_ sky130_fd_sc_hd__and4_1
Xinput4 alpha[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_4
XFILLER_0_79_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09450_ _01449_ _01448_ _01420_ _01404_ VGND VGND VPWR VPWR _01451_ sky130_fd_sc_hd__o211a_1
X_08401_ net161 net617 _00448_ _00449_ VGND VGND VPWR VPWR _00451_ sky130_fd_sc_hd__nand4_1
XFILLER_0_78_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09381_ _01379_ _01380_ _01375_ VGND VGND VPWR VPWR _01382_ sky130_fd_sc_hd__a21o_1
X_08332_ _00300_ _00301_ VGND VGND VPWR VPWR _00383_ sky130_fd_sc_hd__and2b_1
XFILLER_0_59_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08263_ b_sin\[4\] _00314_ _02027_ VGND VGND VPWR VPWR _00315_ sky130_fd_sc_hd__mux2_1
XFILLER_0_117_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08194_ net567 net236 VGND VGND VPWR VPWR _00246_ sky130_fd_sc_hd__and2b_1
XFILLER_0_6_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07978_ _07270_ _07271_ _07253_ VGND VGND VPWR VPWR _07273_ sky130_fd_sc_hd__a21oi_2
X_09717_ _01709_ _01710_ _01704_ VGND VGND VPWR VPWR _01718_ sky130_fd_sc_hd__a21o_1
X_09648_ _01541_ _01546_ _01540_ VGND VGND VPWR VPWR _01649_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_139_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09579_ _01574_ _01579_ VGND VGND VPWR VPWR _01580_ sky130_fd_sc_hd__xnor2_1
X_11610_ _03751_ _03753_ VGND VGND VPWR VPWR _03754_ sky130_fd_sc_hd__nand2_1
X_12590_ net558 net654 net254 net246 VGND VGND VPWR VPWR _04821_ sky130_fd_sc_hd__and4_1
X_11541_ net280 net261 net738 net745 VGND VGND VPWR VPWR _03678_ sky130_fd_sc_hd__and4_1
XFILLER_0_52_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11472_ _03589_ _03590_ _03600_ VGND VGND VPWR VPWR _03602_ sky130_fd_sc_hd__and3_1
XFILLER_0_92_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14260_ _06583_ _06577_ VGND VGND VPWR VPWR _06641_ sky130_fd_sc_hd__or2b_1
XFILLER_0_135_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10423_ net372 net344 _02457_ _02458_ VGND VGND VPWR VPWR _02460_ sky130_fd_sc_hd__nand4_2
X_13211_ _05494_ _05496_ VGND VGND VPWR VPWR _05497_ sky130_fd_sc_hd__nor2_1
X_14191_ net615 net469 VGND VGND VPWR VPWR _06566_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10354_ _02382_ _02384_ VGND VGND VPWR VPWR _02385_ sky130_fd_sc_hd__xnor2_1
X_13142_ _05360_ _05352_ _05419_ _05420_ VGND VGND VPWR VPWR _05421_ sky130_fd_sc_hd__a211o_4
XFILLER_0_131_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10285_ _02239_ _02259_ _02308_ VGND VGND VPWR VPWR _02310_ sky130_fd_sc_hd__o21ba_1
X_13073_ _05341_ _05344_ VGND VGND VPWR VPWR _05345_ sky130_fd_sc_hd__xnor2_1
X_12024_ _04185_ _04204_ VGND VGND VPWR VPWR _04205_ sky130_fd_sc_hd__xor2_2
Xfanout590 net591 VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_88_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13975_ _06326_ _06329_ _06330_ VGND VGND VPWR VPWR _06332_ sky130_fd_sc_hd__nand3_1
X_12926_ _00919_ _05180_ _05182_ _05184_ VGND VGND VPWR VPWR _00090_ sky130_fd_sc_hd__o31ai_1
X_12857_ _04787_ _04862_ _05052_ VGND VGND VPWR VPWR _05110_ sky130_fd_sc_hd__o21ai_1
X_11808_ _03870_ _03969_ VGND VGND VPWR VPWR _03970_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_56_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_1_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12788_ _04983_ _04984_ _05035_ VGND VGND VPWR VPWR _05036_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_83_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11739_ _03798_ _03799_ _03800_ VGND VGND VPWR VPWR _03895_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_56_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14527_ _06929_ _06930_ VGND VGND VPWR VPWR _06931_ sky130_fd_sc_hd__xor2_1
XFILLER_0_118_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14458_ net586 net456 net446 net595 VGND VGND VPWR VPWR _06856_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_3_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13409_ _05415_ _05417_ VGND VGND VPWR VPWR _05715_ sky130_fd_sc_hd__nand2_1
X_14389_ _06628_ _06780_ _06781_ VGND VGND VPWR VPWR _06782_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08950_ _00930_ _00984_ VGND VGND VPWR VPWR _00992_ sky130_fd_sc_hd__or2b_1
XFILLER_0_138_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_135_Right_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08881_ net284 net266 net598 net590 VGND VGND VPWR VPWR _00924_ sky130_fd_sc_hd__and4_1
X_07901_ _07194_ _07195_ _07196_ VGND VGND VPWR VPWR _07197_ sky130_fd_sc_hd__nor3_4
X_07832_ net247 net662 _07127_ VGND VGND VPWR VPWR _07128_ sky130_fd_sc_hd__and3_1
X_07763_ net174 net660 _06298_ _06342_ VGND VGND VPWR VPWR _06505_ sky130_fd_sc_hd__a211oi_1
X_09502_ _01500_ _01501_ _01437_ _01472_ VGND VGND VPWR VPWR _01503_ sky130_fd_sc_hd__o211a_1
X_07694_ _05721_ _05743_ VGND VGND VPWR VPWR _05754_ sky130_fd_sc_hd__xor2_1
XFILLER_0_2_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09433_ _01430_ _01433_ VGND VGND VPWR VPWR _01434_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_137_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09364_ b_cos\[17\] a_sin\[17\] VGND VGND VPWR VPWR _01367_ sky130_fd_sc_hd__xor2_1
XFILLER_0_59_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_56_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08315_ net214 net204 net588 net580 VGND VGND VPWR VPWR _00366_ sky130_fd_sc_hd__nand4_1
XFILLER_0_59_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09295_ _01306_ _01307_ VGND VGND VPWR VPWR _01308_ sky130_fd_sc_hd__xnor2_2
XANTENNA_20 net672 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_31 net619 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08246_ _00199_ _00208_ _00207_ VGND VGND VPWR VPWR _00298_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_34_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08177_ _00227_ VGND VGND VPWR VPWR _00230_ sky130_fd_sc_hd__inv_2
XFILLER_0_6_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10070_ _02058_ _02074_ _02075_ VGND VGND VPWR VPWR _02076_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_102_Right_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10972_ _02995_ _02998_ _03055_ VGND VGND VPWR VPWR _03056_ sky130_fd_sc_hd__a21bo_1
X_13760_ net542 net546 net427 net419 VGND VGND VPWR VPWR _06097_ sky130_fd_sc_hd__and4_1
X_12711_ _04950_ _04951_ VGND VGND VPWR VPWR _04952_ sky130_fd_sc_hd__nor2_1
XFILLER_0_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13691_ net537 net437 VGND VGND VPWR VPWR _06022_ sky130_fd_sc_hd__nand2_1
X_12642_ _04871_ _04876_ VGND VGND VPWR VPWR _04877_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_38_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12573_ _04794_ _04801_ VGND VGND VPWR VPWR _04802_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_26_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11524_ _03653_ _03658_ VGND VGND VPWR VPWR _03659_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_53_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14312_ _06674_ _06675_ _06697_ VGND VGND VPWR VPWR _06698_ sky130_fd_sc_hd__o21a_1
X_11455_ net212 net668 net677 net203 VGND VGND VPWR VPWR _03584_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_53_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14243_ _06621_ _06622_ VGND VGND VPWR VPWR _06623_ sky130_fd_sc_hd__xnor2_2
X_10406_ _02438_ _02439_ _02441_ VGND VGND VPWR VPWR _02442_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11386_ _03504_ _03505_ _03507_ VGND VGND VPWR VPWR _03508_ sky130_fd_sc_hd__nand3_1
X_14174_ b_cos\[8\] _06547_ _05794_ VGND VGND VPWR VPWR _06548_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13125_ net528 net536 net329 net474 VGND VGND VPWR VPWR _05403_ sky130_fd_sc_hd__and4_1
XFILLER_0_21_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10337_ _02362_ _02363_ _02365_ VGND VGND VPWR VPWR _02367_ sky130_fd_sc_hd__nand3_1
X_10268_ _02290_ _02291_ VGND VGND VPWR VPWR _02292_ sky130_fd_sc_hd__xnor2_2
X_13056_ _05313_ _05315_ _05324_ VGND VGND VPWR VPWR _05327_ sky130_fd_sc_hd__a21oi_1
X_12007_ _04111_ _04118_ _04186_ VGND VGND VPWR VPWR _04187_ sky130_fd_sc_hd__a21oi_2
X_10199_ _02216_ VGND VGND VPWR VPWR _00058_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13958_ net640 net469 _06310_ _06311_ VGND VGND VPWR VPWR _06313_ sky130_fd_sc_hd__nand4_2
XFILLER_0_124_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12909_ net146 net245 VGND VGND VPWR VPWR _05166_ sky130_fd_sc_hd__nand2_1
XFILLER_0_88_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13889_ _06234_ _06235_ _06236_ VGND VGND VPWR VPWR _06238_ sky130_fd_sc_hd__nand3_1
XFILLER_0_91_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09080_ _01047_ _01048_ _01050_ _01119_ VGND VGND VPWR VPWR _01120_ sky130_fd_sc_hd__o31a_1
X_08100_ _00147_ _00152_ VGND VGND VPWR VPWR _00153_ sky130_fd_sc_hd__xor2_1
X_08031_ _07316_ _07323_ _07324_ VGND VGND VPWR VPWR _07325_ sky130_fd_sc_hd__nand3_2
XFILLER_0_71_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput40 cos[12] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__buf_1
XFILLER_0_25_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput73 sin[9] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__clkbuf_4
Xinput62 sin[15] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput51 cos[6] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09982_ _01978_ _01981_ VGND VGND VPWR VPWR _01982_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08933_ _00914_ _00912_ _00911_ VGND VGND VPWR VPWR _00976_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_58_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08864_ _00861_ _00846_ _00906_ VGND VGND VPWR VPWR _00908_ sky130_fd_sc_hd__a21oi_2
X_07815_ _06353_ _06559_ _06549_ VGND VGND VPWR VPWR _07069_ sky130_fd_sc_hd__a21oi_1
X_08795_ _00836_ _00839_ VGND VGND VPWR VPWR _00840_ sky130_fd_sc_hd__xnor2_1
X_07746_ net208 net565 net573 net199 VGND VGND VPWR VPWR _06320_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_74_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_64_Left_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07677_ _05534_ _05545_ _05556_ VGND VGND VPWR VPWR _05567_ sky130_fd_sc_hd__a21bo_1
X_09416_ _01413_ _01415_ _01414_ VGND VGND VPWR VPWR _01417_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_137_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09347_ net98 _01352_ net129 VGND VGND VPWR VPWR _01353_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09278_ a_sin\[5\] b_cos\[5\] VGND VGND VPWR VPWR _01293_ sky130_fd_sc_hd__or2b_1
XFILLER_0_117_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08229_ net160 net635 _00279_ _00280_ VGND VGND VPWR VPWR _00281_ sky130_fd_sc_hd__a22o_1
XFILLER_0_133_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_73_Left_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11240_ _03310_ _03311_ _03309_ VGND VGND VPWR VPWR _03347_ sky130_fd_sc_hd__a21bo_1
X_11171_ _03259_ _03267_ _03270_ VGND VGND VPWR VPWR _03271_ sky130_fd_sc_hd__a21oi_2
X_10122_ _02126_ _02131_ VGND VGND VPWR VPWR _02132_ sky130_fd_sc_hd__xnor2_1
X_10053_ _01958_ _01960_ VGND VGND VPWR VPWR _02057_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_82_Left_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13812_ net402 _02182_ _06152_ _06153_ VGND VGND VPWR VPWR _06154_ sky130_fd_sc_hd__a31oi_2
X_14792_ clknet_3_0_0_clk _00093_ net318 VGND VGND VPWR VPWR b_cos\[2\] sky130_fd_sc_hd__dfrtp_1
X_10955_ _02950_ _02971_ VGND VGND VPWR VPWR _03039_ sky130_fd_sc_hd__or2_1
XFILLER_0_58_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13743_ _06076_ _06077_ _05962_ _05980_ VGND VGND VPWR VPWR _06079_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_128_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10886_ _02960_ _02961_ VGND VGND VPWR VPWR _02964_ sky130_fd_sc_hd__and2_1
X_13674_ _06001_ _06002_ VGND VGND VPWR VPWR _06003_ sky130_fd_sc_hd__nor2_1
XFILLER_0_128_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12625_ _04856_ _04857_ VGND VGND VPWR VPWR _04859_ sky130_fd_sc_hd__nor2_2
XFILLER_0_66_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12556_ _04724_ _04723_ VGND VGND VPWR VPWR _04784_ sky130_fd_sc_hd__and2b_1
XFILLER_0_65_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11507_ _03637_ _03639_ _03633_ VGND VGND VPWR VPWR _03641_ sky130_fd_sc_hd__a21o_1
XFILLER_0_124_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_91_Left_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12487_ _04639_ _04638_ VGND VGND VPWR VPWR _04709_ sky130_fd_sc_hd__and2b_1
XFILLER_0_102_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11438_ _03437_ _03563_ _03564_ VGND VGND VPWR VPWR _03565_ sky130_fd_sc_hd__nand3_1
XFILLER_0_110_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14226_ _06598_ _06604_ VGND VGND VPWR VPWR _06605_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11369_ _03485_ _03488_ VGND VGND VPWR VPWR _03489_ sky130_fd_sc_hd__nor2_1
X_14157_ _06508_ _06509_ _06529_ VGND VGND VPWR VPWR _06530_ sky130_fd_sc_hd__o21ai_1
X_13108_ net519 net338 VGND VGND VPWR VPWR _05384_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14088_ _06453_ _06454_ VGND VGND VPWR VPWR _06455_ sky130_fd_sc_hd__nand2_1
X_13039_ net638 net389 net380 net493 VGND VGND VPWR VPWR _05308_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_28_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07600_ net219 net522 VGND VGND VPWR VPWR _04728_ sky130_fd_sc_hd__and2_1
X_08580_ _00626_ _00609_ _00610_ VGND VGND VPWR VPWR _00628_ sky130_fd_sc_hd__nor3_2
XFILLER_0_89_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07531_ _03956_ _03966_ VGND VGND VPWR VPWR _03977_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07462_ _03016_ _03049_ _03200_ _03211_ VGND VGND VPWR VPWR _03221_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_48_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07393_ _02157_ _02179_ _02168_ VGND VGND VPWR VPWR _02473_ sky130_fd_sc_hd__o21ba_1
X_09201_ _01226_ _01227_ VGND VGND VPWR VPWR _01228_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09132_ _01167_ _01168_ VGND VGND VPWR VPWR _01169_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09063_ _01101_ _01102_ VGND VGND VPWR VPWR _01103_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08014_ _07214_ _07307_ VGND VGND VPWR VPWR _07308_ sky130_fd_sc_hd__xor2_1
XFILLER_0_4_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_139_Left_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09965_ _01962_ _01963_ _01944_ _01945_ VGND VGND VPWR VPWR _01965_ sky130_fd_sc_hd__a211o_2
X_08916_ _00941_ _00958_ VGND VGND VPWR VPWR _00959_ sky130_fd_sc_hd__xnor2_1
X_09896_ net487 net409 VGND VGND VPWR VPWR _01897_ sky130_fd_sc_hd__nand2_4
X_08847_ net253 net626 VGND VGND VPWR VPWR _00891_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08778_ _00821_ _00815_ _00816_ VGND VGND VPWR VPWR _00823_ sky130_fd_sc_hd__nor3_1
X_07729_ _06004_ _05993_ VGND VGND VPWR VPWR _06135_ sky130_fd_sc_hd__and2b_1
XFILLER_0_137_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10740_ _02793_ _02794_ _02804_ VGND VGND VPWR VPWR _02805_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_82_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10671_ _02621_ _02624_ _02622_ VGND VGND VPWR VPWR _02730_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_48_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12410_ _04566_ _04573_ VGND VGND VPWR VPWR _04625_ sky130_fd_sc_hd__and2_1
XFILLER_0_106_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13390_ _05676_ _05690_ _05693_ _05685_ _05691_ VGND VGND VPWR VPWR _05694_ sky130_fd_sc_hd__a32o_1
XFILLER_0_35_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12341_ _04548_ _04549_ VGND VGND VPWR VPWR _04550_ sky130_fd_sc_hd__xor2_1
XFILLER_0_106_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12272_ net653 net670 net283 net265 VGND VGND VPWR VPWR _04475_ sky130_fd_sc_hd__and4_1
XFILLER_0_106_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11223_ _03250_ _03252_ VGND VGND VPWR VPWR _03328_ sky130_fd_sc_hd__nor2_1
XFILLER_0_121_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14011_ _06370_ VGND VGND VPWR VPWR _00097_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11154_ _03250_ _03251_ net156 net736 VGND VGND VPWR VPWR _03252_ sky130_fd_sc_hd__and4bb_1
X_10105_ _01927_ _01928_ _02010_ _02011_ VGND VGND VPWR VPWR _02115_ sky130_fd_sc_hd__o211ai_2
X_11085_ _02858_ _02927_ _03117_ VGND VGND VPWR VPWR _03179_ sky130_fd_sc_hd__o21ai_1
X_10036_ _01983_ _01984_ _01985_ VGND VGND VPWR VPWR _02039_ sky130_fd_sc_hd__nor3_1
XFILLER_0_86_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11987_ _04088_ _04107_ _04106_ VGND VGND VPWR VPWR _04165_ sky130_fd_sc_hd__a21o_1
XFILLER_0_98_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14775_ clknet_3_2_0_clk _00076_ net317 VGND VGND VPWR VPWR a_sin\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10938_ _03018_ _03019_ VGND VGND VPWR VPWR _03020_ sky130_fd_sc_hd__nor2_1
X_13726_ _06058_ _06056_ _06057_ VGND VGND VPWR VPWR _06061_ sky130_fd_sc_hd__nand3_1
XFILLER_0_86_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10869_ _02928_ _02944_ VGND VGND VPWR VPWR _02945_ sky130_fd_sc_hd__xor2_2
XFILLER_0_6_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13657_ _05982_ _05984_ _05812_ VGND VGND VPWR VPWR _05986_ sky130_fd_sc_hd__a21o_1
XFILLER_0_38_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12608_ _04746_ _04747_ _04769_ VGND VGND VPWR VPWR _04841_ sky130_fd_sc_hd__nor3_1
X_13588_ _05900_ _05909_ VGND VGND VPWR VPWR _05910_ sky130_fd_sc_hd__xor2_1
XFILLER_0_124_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12539_ _04643_ _04749_ _04765_ VGND VGND VPWR VPWR _04766_ sky130_fd_sc_hd__and3_1
XFILLER_0_5_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14209_ _06242_ _06425_ VGND VGND VPWR VPWR _06586_ sky130_fd_sc_hd__nand2_1
Xfanout408 net409 VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_39_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout419 net422 VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__buf_2
X_09750_ _01737_ _01749_ _01748_ VGND VGND VPWR VPWR _01751_ sky130_fd_sc_hd__a21o_1
XFILLER_0_39_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08701_ _00731_ _00732_ _00745_ VGND VGND VPWR VPWR _00747_ sky130_fd_sc_hd__nand3_2
X_09681_ _01675_ _01680_ _01681_ VGND VGND VPWR VPWR _01682_ sky130_fd_sc_hd__a21bo_1
X_08632_ _00677_ _00678_ VGND VGND VPWR VPWR _00679_ sky130_fd_sc_hd__xor2_1
XFILLER_0_55_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08563_ _00370_ _00535_ VGND VGND VPWR VPWR _00611_ sky130_fd_sc_hd__and2_1
XFILLER_0_89_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08494_ net161 net608 VGND VGND VPWR VPWR _00543_ sky130_fd_sc_hd__nand2_1
X_07514_ _03715_ _03781_ VGND VGND VPWR VPWR _03792_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07445_ _02951_ _03005_ VGND VGND VPWR VPWR _03038_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_91_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07376_ _02255_ _02266_ _02244_ VGND VGND VPWR VPWR _02288_ sky130_fd_sc_hd__a21o_1
XFILLER_0_91_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09115_ _01095_ _01117_ _01094_ VGND VGND VPWR VPWR _01154_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_33_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09046_ _00993_ _01043_ _00984_ VGND VGND VPWR VPWR _01086_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_5_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09948_ net710 net718 net451 net443 VGND VGND VPWR VPWR _01948_ sky130_fd_sc_hd__and4_1
X_09879_ _01876_ _01867_ _01878_ _01879_ VGND VGND VPWR VPWR _01880_ sky130_fd_sc_hd__or4b_1
X_11910_ _04078_ _04079_ VGND VGND VPWR VPWR _04081_ sky130_fd_sc_hd__nand2_1
X_12890_ _05088_ _05095_ _05145_ VGND VGND VPWR VPWR _05146_ sky130_fd_sc_hd__o21ai_1
X_11841_ net188 net274 net222 VGND VGND VPWR VPWR _04006_ sky130_fd_sc_hd__and3_1
X_11772_ _03927_ _03928_ _03929_ VGND VGND VPWR VPWR _03931_ sky130_fd_sc_hd__a21o_1
XFILLER_0_95_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14560_ _06965_ _06966_ VGND VGND VPWR VPWR _06967_ sky130_fd_sc_hd__xor2_1
XFILLER_0_137_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10723_ _02784_ _02785_ VGND VGND VPWR VPWR _02786_ sky130_fd_sc_hd__xnor2_1
X_13511_ net511 net520 net329 net474 VGND VGND VPWR VPWR _05826_ sky130_fd_sc_hd__and4_1
XFILLER_0_83_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14491_ _06888_ _06890_ VGND VGND VPWR VPWR _06892_ sky130_fd_sc_hd__nand2_1
XFILLER_0_138_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13442_ _05748_ _05749_ _05747_ VGND VGND VPWR VPWR _05751_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_35_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10654_ _02710_ VGND VGND VPWR VPWR _02711_ sky130_fd_sc_hd__buf_2
XFILLER_0_141_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10585_ _02619_ _02620_ _02634_ VGND VGND VPWR VPWR _02637_ sky130_fd_sc_hd__and3_1
X_13373_ _05654_ _05670_ VGND VGND VPWR VPWR _05675_ sky130_fd_sc_hd__or2_1
X_12324_ a_sin\[7\] _00918_ VGND VGND VPWR VPWR _04532_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12255_ _04454_ _04455_ VGND VGND VPWR VPWR _04457_ sky130_fd_sc_hd__nor2_1
X_11206_ net221 net677 VGND VGND VPWR VPWR _03310_ sky130_fd_sc_hd__and2_1
X_12186_ net464 net557 net152 net300 VGND VGND VPWR VPWR _04382_ sky130_fd_sc_hd__nand4_1
XFILLER_0_121_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11137_ _03228_ _03234_ VGND VGND VPWR VPWR _03235_ sky130_fd_sc_hd__xnor2_1
X_11068_ _03158_ _03160_ VGND VGND VPWR VPWR _03161_ sky130_fd_sc_hd__nor2_1
X_10019_ _01964_ _01965_ _01999_ _02000_ VGND VGND VPWR VPWR _02021_ sky130_fd_sc_hd__nand4_2
XFILLER_0_116_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14758_ clknet_3_0_0_clk _00059_ net316 VGND VGND VPWR VPWR a_cos\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_73_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13709_ net621 net360 net350 net630 VGND VGND VPWR VPWR _06042_ sky130_fd_sc_hd__a22o_1
X_14689_ _07088_ _07105_ VGND VGND VPWR VPWR _07106_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_132_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout205 net207 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__buf_2
XFILLER_0_2_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout216 net217 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__buf_2
Xfanout227 net228 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__buf_6
Xfanout238 net64 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__clkbuf_2
X_09802_ _01765_ _01766_ _01802_ VGND VGND VPWR VPWR _01803_ sky130_fd_sc_hd__a21o_1
Xfanout249 net250 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__clkbuf_4
X_07994_ _07286_ _07287_ _07288_ VGND VGND VPWR VPWR _07289_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_66_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09733_ _01724_ _01731_ _01733_ VGND VGND VPWR VPWR _01734_ sky130_fd_sc_hd__a21oi_2
X_09664_ _01589_ _01664_ VGND VGND VPWR VPWR _01665_ sky130_fd_sc_hd__xnor2_2
X_08615_ net153 net599 net608 net301 VGND VGND VPWR VPWR _00662_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_96_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09595_ _01581_ _01583_ VGND VGND VPWR VPWR _01596_ sky130_fd_sc_hd__nand2_1
XFILLER_0_82_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08546_ net283 net634 net644 net265 VGND VGND VPWR VPWR _00594_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_77_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08477_ _00511_ _00524_ _00525_ VGND VGND VPWR VPWR _00526_ sky130_fd_sc_hd__nand3_1
XFILLER_0_65_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07428_ _02766_ _02843_ VGND VGND VPWR VPWR _02853_ sky130_fd_sc_hd__xor2_2
XFILLER_0_92_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07359_ net221 net506 VGND VGND VPWR VPWR _02103_ sky130_fd_sc_hd__nand2_1
XFILLER_0_92_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10370_ a_cos\[5\] _02402_ _02303_ VGND VGND VPWR VPWR _02403_ sky130_fd_sc_hd__mux2_1
XFILLER_0_33_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09029_ _01051_ _01069_ VGND VGND VPWR VPWR _01070_ sky130_fd_sc_hd__xor2_1
X_12040_ _04221_ _04222_ VGND VGND VPWR VPWR _04223_ sky130_fd_sc_hd__nor2_1
X_13991_ _06245_ _06324_ net125 _06348_ VGND VGND VPWR VPWR _06349_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_99_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12942_ _05197_ _05200_ VGND VGND VPWR VPWR _05201_ sky130_fd_sc_hd__xnor2_1
X_12873_ _05113_ _05125_ VGND VGND VPWR VPWR _05127_ sky130_fd_sc_hd__or2_1
X_14612_ _07021_ _07022_ VGND VGND VPWR VPWR _07023_ sky130_fd_sc_hd__nor2_1
X_11824_ _03983_ _03986_ VGND VGND VPWR VPWR _03987_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_68_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11755_ _03909_ _03910_ _03908_ VGND VGND VPWR VPWR _03913_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14543_ _06857_ _06941_ _06946_ VGND VGND VPWR VPWR _06948_ sky130_fd_sc_hd__o21a_1
XFILLER_0_126_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10706_ _02682_ _02750_ _02751_ VGND VGND VPWR VPWR _02768_ sky130_fd_sc_hd__nor3b_1
XFILLER_0_55_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14474_ _06870_ _06871_ VGND VGND VPWR VPWR _06873_ sky130_fd_sc_hd__nand2_1
X_11686_ _03833_ _03834_ _03835_ VGND VGND VPWR VPWR _03838_ sky130_fd_sc_hd__a21o_1
XFILLER_0_125_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13425_ net519 net529 net329 net474 VGND VGND VPWR VPWR _05733_ sky130_fd_sc_hd__and4_1
XFILLER_0_141_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10637_ _02691_ _02692_ VGND VGND VPWR VPWR _02693_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_116_Right_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10568_ _02552_ _02572_ VGND VGND VPWR VPWR _02618_ sky130_fd_sc_hd__nor2_1
XFILLER_0_51_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13356_ _05656_ _05624_ VGND VGND VPWR VPWR _05657_ sky130_fd_sc_hd__xor2_1
XFILLER_0_140_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12307_ _04412_ _04414_ _04415_ _04418_ VGND VGND VPWR VPWR _04514_ sky130_fd_sc_hd__a31o_1
XFILLER_0_87_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10499_ _02540_ _02541_ _02542_ VGND VGND VPWR VPWR _02543_ sky130_fd_sc_hd__nand3_2
XFILLER_0_23_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13287_ _05570_ _05577_ _05579_ _05580_ VGND VGND VPWR VPWR _05581_ sky130_fd_sc_hd__a211oi_2
X_12238_ _04340_ _04343_ VGND VGND VPWR VPWR _04439_ sky130_fd_sc_hd__or2b_1
X_12169_ _04258_ _04259_ _04257_ VGND VGND VPWR VPWR _04363_ sky130_fd_sc_hd__a21o_1
Xinput5 alpha[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__buf_4
X_08400_ net161 net617 _00448_ _00449_ VGND VGND VPWR VPWR _00450_ sky130_fd_sc_hd__a22o_1
X_09380_ _01375_ _01379_ _01380_ VGND VGND VPWR VPWR _01381_ sky130_fd_sc_hd__nand3_1
X_08331_ _00353_ _00381_ VGND VGND VPWR VPWR _00382_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_7_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08262_ _00312_ _00313_ VGND VGND VPWR VPWR _00314_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_46_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08193_ _00243_ _00244_ VGND VGND VPWR VPWR _00245_ sky130_fd_sc_hd__nor2_1
XFILLER_0_15_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07977_ _07253_ _07270_ _07271_ VGND VGND VPWR VPWR _07272_ sky130_fd_sc_hd__and3_1
X_09716_ _01712_ _01714_ VGND VGND VPWR VPWR _01717_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09647_ _01645_ _01646_ _01638_ VGND VGND VPWR VPWR _01648_ sky130_fd_sc_hd__a21o_1
X_09578_ _01575_ _01578_ VGND VGND VPWR VPWR _01579_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08529_ net525 net236 VGND VGND VPWR VPWR _00577_ sky130_fd_sc_hd__and2b_1
XFILLER_0_77_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11540_ _03670_ _03676_ VGND VGND VPWR VPWR _03677_ sky130_fd_sc_hd__xor2_1
XFILLER_0_108_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11471_ _03589_ _03590_ _03600_ VGND VGND VPWR VPWR _03601_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_104_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10422_ net372 net344 _02457_ _02458_ VGND VGND VPWR VPWR _02459_ sky130_fd_sc_hd__a22o_1
X_13210_ _05494_ _05495_ net658 net339 VGND VGND VPWR VPWR _05496_ sky130_fd_sc_hd__and4bb_1
X_14190_ _06563_ _06564_ VGND VGND VPWR VPWR _06565_ sky130_fd_sc_hd__nor2_1
XFILLER_0_103_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10353_ _02260_ _02289_ _02383_ VGND VGND VPWR VPWR _02384_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_21_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13141_ _05394_ _05395_ _05417_ _05418_ VGND VGND VPWR VPWR _05420_ sky130_fd_sc_hd__a2bb2oi_1
XFILLER_0_33_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13072_ _05342_ _05343_ VGND VGND VPWR VPWR _05344_ sky130_fd_sc_hd__or2_1
X_12023_ _04187_ _04203_ VGND VGND VPWR VPWR _04204_ sky130_fd_sc_hd__xnor2_2
X_10284_ _02241_ _02258_ VGND VGND VPWR VPWR _02308_ sky130_fd_sc_hd__nor2_1
Xfanout580 net583 VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__clkbuf_4
Xfanout591 net592 VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__clkbuf_2
X_13974_ net612 net343 _06327_ _06328_ VGND VGND VPWR VPWR _06330_ sky130_fd_sc_hd__nand4_2
X_12925_ net790 _07291_ VGND VGND VPWR VPWR _05184_ sky130_fd_sc_hd__nand2_1
X_12856_ _05098_ _05108_ VGND VGND VPWR VPWR _05109_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_87_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11807_ _03967_ _03968_ VGND VGND VPWR VPWR _03969_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12787_ _05031_ _05034_ VGND VGND VPWR VPWR _05035_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_83_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14526_ _06862_ _06922_ VGND VGND VPWR VPWR _06930_ sky130_fd_sc_hd__nand2_2
X_11738_ _03891_ _03892_ _03889_ VGND VGND VPWR VPWR _03894_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_28_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11669_ _03816_ _03817_ _03815_ VGND VGND VPWR VPWR _03819_ sky130_fd_sc_hd__a21bo_1
X_14457_ _06801_ _06808_ _06854_ VGND VGND VPWR VPWR _06855_ sky130_fd_sc_hd__a21o_1
XFILLER_0_36_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14388_ _06631_ _06705_ _06706_ VGND VGND VPWR VPWR _06781_ sky130_fd_sc_hd__o21ai_1
X_13408_ _05429_ VGND VGND VPWR VPWR _05714_ sky130_fd_sc_hd__inv_2
XFILLER_0_3_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13339_ _05588_ _05636_ _05637_ VGND VGND VPWR VPWR _05638_ sky130_fd_sc_hd__a21o_1
XFILLER_0_51_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_102_Left_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08880_ net266 net598 net590 net284 VGND VGND VPWR VPWR _00923_ sky130_fd_sc_hd__a22oi_2
X_07900_ _03879_ _03912_ _03868_ VGND VGND VPWR VPWR _07196_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_47_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07831_ net255 net662 _03737_ _03748_ VGND VGND VPWR VPWR _07127_ sky130_fd_sc_hd__a31o_1
X_07762_ _06364_ _06472_ _06483_ VGND VGND VPWR VPWR _06494_ sky130_fd_sc_hd__and3_1
X_09501_ _01437_ _01472_ _01500_ _01501_ VGND VGND VPWR VPWR _01502_ sky130_fd_sc_hd__a211oi_2
X_07693_ _05075_ _05732_ VGND VGND VPWR VPWR _05743_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09432_ _01431_ _01432_ VGND VGND VPWR VPWR _01433_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_111_Left_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09363_ a_sin\[16\] b_cos\[16\] VGND VGND VPWR VPWR _01366_ sky130_fd_sc_hd__or2b_1
XFILLER_0_47_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08314_ net204 net588 net580 net214 VGND VGND VPWR VPWR _00365_ sky130_fd_sc_hd__a22o_1
XANTENNA_21 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_32 net619 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09294_ _01298_ _01301_ _01299_ VGND VGND VPWR VPWR _01307_ sky130_fd_sc_hd__a21bo_1
XANTENNA_10 net367 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_105_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08245_ _00295_ _00296_ VGND VGND VPWR VPWR _00297_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08176_ _00226_ _00227_ _00228_ VGND VGND VPWR VPWR _00229_ sky130_fd_sc_hd__and3b_1
XFILLER_0_43_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_120_Left_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10971_ net472 _02866_ VGND VGND VPWR VPWR _03055_ sky130_fd_sc_hd__nand2_2
X_12710_ _04865_ _04868_ _04949_ VGND VGND VPWR VPWR _04951_ sky130_fd_sc_hd__o21a_1
XFILLER_0_97_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13690_ _06019_ _06020_ VGND VGND VPWR VPWR _06021_ sky130_fd_sc_hd__nor2_1
X_12641_ _04874_ _04875_ VGND VGND VPWR VPWR _04876_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12572_ _04799_ _04800_ VGND VGND VPWR VPWR _04801_ sky130_fd_sc_hd__xor2_2
XFILLER_0_81_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11523_ _03654_ _03657_ VGND VGND VPWR VPWR _03658_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_108_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14311_ _06676_ _06696_ VGND VGND VPWR VPWR _06697_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_136_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11454_ net212 net203 net668 net677 VGND VGND VPWR VPWR _03582_ sky130_fd_sc_hd__and4_1
X_14242_ _06536_ _06539_ VGND VGND VPWR VPWR _06622_ sky130_fd_sc_hd__or2_2
XFILLER_0_111_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10405_ net649 net471 VGND VGND VPWR VPWR _02441_ sky130_fd_sc_hd__and2_1
XFILLER_0_34_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11385_ _03419_ _03412_ _03417_ VGND VGND VPWR VPWR _03507_ sky130_fd_sc_hd__a21o_1
XFILLER_0_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14173_ _06545_ _06546_ VGND VGND VPWR VPWR _06547_ sky130_fd_sc_hd__xor2_1
X_10336_ _02362_ _02363_ _02365_ VGND VGND VPWR VPWR _02366_ sky130_fd_sc_hd__a21o_1
X_13124_ net545 net468 VGND VGND VPWR VPWR _05401_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10267_ _02164_ _02198_ _02197_ VGND VGND VPWR VPWR _02291_ sky130_fd_sc_hd__a21bo_1
X_13055_ _05313_ _05315_ _05324_ VGND VGND VPWR VPWR _05326_ sky130_fd_sc_hd__and3_1
X_12006_ _04112_ _04117_ VGND VGND VPWR VPWR _04186_ sky130_fd_sc_hd__and2_1
XFILLER_0_108_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10198_ a_cos\[3\] _02215_ _00486_ VGND VGND VPWR VPWR _02216_ sky130_fd_sc_hd__mux2_1
XFILLER_0_17_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13957_ net640 net469 _06310_ _06311_ VGND VGND VPWR VPWR _06312_ sky130_fd_sc_hd__a22o_1
X_12908_ _05119_ _05120_ _05117_ VGND VGND VPWR VPWR _05165_ sky130_fd_sc_hd__a21o_1
XFILLER_0_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13888_ _06234_ _06235_ _06236_ VGND VGND VPWR VPWR _06237_ sky130_fd_sc_hd__a21o_1
X_12839_ _04971_ _04981_ _05036_ _05038_ VGND VGND VPWR VPWR _05091_ sky130_fd_sc_hd__a31o_1
XFILLER_0_8_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14509_ _06781_ _06910_ _06911_ _06848_ VGND VGND VPWR VPWR _06912_ sky130_fd_sc_hd__o211a_1
XFILLER_0_140_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput30 beta[3] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_1
X_08030_ _07320_ _07321_ _07322_ VGND VGND VPWR VPWR _07324_ sky130_fd_sc_hd__a21o_1
Xinput63 sin[16] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput52 cos[7] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__buf_1
XFILLER_0_52_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput41 cos[13] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_1
Xinput74 start VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__buf_1
XFILLER_0_3_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09981_ net396 _01979_ _01980_ VGND VGND VPWR VPWR _01981_ sky130_fd_sc_hd__a21bo_1
X_08932_ _00913_ _00856_ VGND VGND VPWR VPWR _00975_ sky130_fd_sc_hd__or2b_1
XFILLER_0_110_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08863_ _00861_ _00846_ _00906_ VGND VGND VPWR VPWR _00907_ sky130_fd_sc_hd__and3_1
X_07814_ _06276_ _07047_ _06549_ VGND VGND VPWR VPWR _07058_ sky130_fd_sc_hd__a21oi_1
X_08794_ _00837_ _00838_ VGND VGND VPWR VPWR _00839_ sky130_fd_sc_hd__nor2_1
XFILLER_0_74_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07745_ net193 net660 VGND VGND VPWR VPWR _06309_ sky130_fd_sc_hd__nand2_1
X_07676_ net304 net225 net522 net531 VGND VGND VPWR VPWR _05556_ sky130_fd_sc_hd__nand4_2
XFILLER_0_66_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09415_ _01413_ _01414_ _01415_ VGND VGND VPWR VPWR _01416_ sky130_fd_sc_hd__and3_1
XFILLER_0_48_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09346_ _01349_ _01351_ VGND VGND VPWR VPWR _01352_ sky130_fd_sc_hd__xnor2_1
X_09277_ b_cos\[5\] a_sin\[5\] VGND VGND VPWR VPWR _01292_ sky130_fd_sc_hd__or2b_1
X_08228_ net179 net169 net614 net625 VGND VGND VPWR VPWR _00280_ sky130_fd_sc_hd__nand4_2
XFILLER_0_133_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08159_ _00209_ _00210_ _00211_ VGND VGND VPWR VPWR _00212_ sky130_fd_sc_hd__nand3_1
X_11170_ _03268_ _03269_ VGND VGND VPWR VPWR _03270_ sky130_fd_sc_hd__or2_1
XFILLER_0_30_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10121_ _02129_ _02130_ VGND VGND VPWR VPWR _02131_ sky130_fd_sc_hd__xor2_1
X_10052_ _02053_ _02054_ _02022_ _01997_ VGND VGND VPWR VPWR _02056_ sky130_fd_sc_hd__a211oi_4
X_14791_ clknet_3_0_0_clk _00092_ net316 VGND VGND VPWR VPWR b_cos\[1\] sky130_fd_sc_hd__dfrtp_1
X_13811_ net492 net412 net402 net578 VGND VGND VPWR VPWR _06153_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_98_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13742_ _05962_ _05980_ _06076_ _06077_ VGND VGND VPWR VPWR _06078_ sky130_fd_sc_hd__o211a_1
X_10954_ _03035_ _03036_ VGND VGND VPWR VPWR _03037_ sky130_fd_sc_hd__xor2_1
XFILLER_0_85_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10885_ _02960_ _02961_ VGND VGND VPWR VPWR _02963_ sky130_fd_sc_hd__nor2_1
X_13673_ net545 net564 net427 net419 VGND VGND VPWR VPWR _06002_ sky130_fd_sc_hd__and4_1
X_12624_ _04581_ _04809_ VGND VGND VPWR VPWR _04857_ sky130_fd_sc_hd__and2_1
XFILLER_0_72_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12555_ _04748_ _04768_ VGND VGND VPWR VPWR _04783_ sky130_fd_sc_hd__nor2_1
XFILLER_0_93_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11506_ _03633_ _03637_ _03639_ VGND VGND VPWR VPWR _03640_ sky130_fd_sc_hd__nand3_1
XFILLER_0_79_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12486_ _04666_ _04667_ _04687_ VGND VGND VPWR VPWR _04708_ sky130_fd_sc_hd__nor3_1
XFILLER_0_124_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11437_ _03433_ net120 _03442_ _03345_ VGND VGND VPWR VPWR _03564_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_111_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14225_ _06601_ _06602_ VGND VGND VPWR VPWR _06604_ sky130_fd_sc_hd__xor2_1
X_11368_ net209 net736 net743 net200 VGND VGND VPWR VPWR _03488_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_21_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14156_ _06525_ _06528_ VGND VGND VPWR VPWR _06529_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_95_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10319_ _02345_ _02346_ VGND VGND VPWR VPWR _02347_ sky130_fd_sc_hd__or2_1
X_13107_ _05306_ _05308_ _05307_ VGND VGND VPWR VPWR _05383_ sky130_fd_sc_hd__o21ba_1
X_11299_ _03405_ _03406_ _03411_ VGND VGND VPWR VPWR _03412_ sky130_fd_sc_hd__a21o_1
X_14087_ _06371_ _06372_ _06452_ VGND VGND VPWR VPWR _06454_ sky130_fd_sc_hd__or3_2
X_13038_ net638 net493 net389 net380 VGND VGND VPWR VPWR _05307_ sky130_fd_sc_hd__and4_1
XFILLER_0_135_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07530_ net147 net295 net574 net661 VGND VGND VPWR VPWR _03966_ sky130_fd_sc_hd__and4_1
X_07461_ _03059_ _03070_ _03189_ VGND VGND VPWR VPWR _03211_ sky130_fd_sc_hd__and3_1
X_07392_ _02418_ _02451_ VGND VGND VPWR VPWR _02462_ sky130_fd_sc_hd__and2b_1
X_09200_ a_cos\[11\] b_sin\[11\] VGND VGND VPWR VPWR _01227_ sky130_fd_sc_hd__or2_1
XFILLER_0_63_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09131_ a_cos\[1\] b_sin\[1\] VGND VGND VPWR VPWR _01168_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09062_ net253 net245 net600 net591 VGND VGND VPWR VPWR _01102_ sky130_fd_sc_hd__and4_1
XFILLER_0_72_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08013_ _07294_ _07306_ VGND VGND VPWR VPWR _07307_ sky130_fd_sc_hd__xor2_1
XFILLER_0_71_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09964_ _01944_ _01945_ _01962_ _01963_ VGND VGND VPWR VPWR _01964_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_0_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08915_ _00956_ _00957_ VGND VGND VPWR VPWR _00958_ sky130_fd_sc_hd__and2_1
X_09895_ net740 net390 VGND VGND VPWR VPWR _01896_ sky130_fd_sc_hd__nand2_1
X_08846_ _00801_ _00804_ _00802_ VGND VGND VPWR VPWR _00890_ sky130_fd_sc_hd__o21ba_1
X_08777_ _00815_ _00816_ _00821_ VGND VGND VPWR VPWR _00822_ sky130_fd_sc_hd__o21a_1
X_07728_ net193 net573 VGND VGND VPWR VPWR _06124_ sky130_fd_sc_hd__nand2_1
XFILLER_0_95_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07659_ _04837_ _04848_ _04858_ VGND VGND VPWR VPWR _05369_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_138_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10670_ _02635_ _02638_ VGND VGND VPWR VPWR _02729_ sky130_fd_sc_hd__or2_1
XFILLER_0_36_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09329_ _01335_ _01336_ VGND VGND VPWR VPWR _01337_ sky130_fd_sc_hd__or2_1
XFILLER_0_36_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12340_ _04457_ _04458_ _04455_ VGND VGND VPWR VPWR _04549_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_16_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12271_ net653 net283 net265 net670 VGND VGND VPWR VPWR _04474_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_62_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11222_ _03323_ _03325_ _03324_ VGND VGND VPWR VPWR _03327_ sky130_fd_sc_hd__a21o_1
X_14010_ b_cos\[6\] _06369_ _05794_ VGND VGND VPWR VPWR _06370_ sky130_fd_sc_hd__mux2_1
X_11153_ net175 net721 net729 net165 VGND VGND VPWR VPWR _03251_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_101_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10104_ _02110_ _02112_ VGND VGND VPWR VPWR _02113_ sky130_fd_sc_hd__nand2_1
X_11084_ _03175_ _03176_ VGND VGND VPWR VPWR _03177_ sky130_fd_sc_hd__nor2_1
X_10035_ _02034_ _02037_ VGND VGND VPWR VPWR _02038_ sky130_fd_sc_hd__xnor2_1
X_11986_ _04068_ _04080_ _04081_ _04083_ _04067_ VGND VGND VPWR VPWR _04164_ sky130_fd_sc_hd__a32o_1
X_14774_ clknet_3_2_0_clk _00075_ net316 VGND VGND VPWR VPWR a_sin\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_128_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10937_ _02931_ _02934_ _03017_ VGND VGND VPWR VPWR _03019_ sky130_fd_sc_hd__o21a_1
XFILLER_0_14_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13725_ _06056_ _06057_ _06058_ VGND VGND VPWR VPWR _06060_ sky130_fd_sc_hd__a21o_1
XFILLER_0_27_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13656_ _05812_ _05982_ _05984_ VGND VGND VPWR VPWR _05985_ sky130_fd_sc_hd__nand3_1
X_12607_ _04814_ _04816_ _04838_ VGND VGND VPWR VPWR _04840_ sky130_fd_sc_hd__or3_4
XFILLER_0_85_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10868_ _02935_ _02943_ VGND VGND VPWR VPWR _02944_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_26_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10799_ net186 net471 VGND VGND VPWR VPWR _02869_ sky130_fd_sc_hd__nand2_1
X_13587_ _05907_ _05908_ VGND VGND VPWR VPWR _05909_ sky130_fd_sc_hd__and2b_1
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12538_ _04762_ _04764_ VGND VGND VPWR VPWR _04765_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_54_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12469_ _04600_ _04623_ _04688_ _04689_ VGND VGND VPWR VPWR _04690_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_41_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14208_ _06514_ _06584_ VGND VGND VPWR VPWR _06585_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout409 net410 VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_1_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14139_ _06242_ _06425_ VGND VGND VPWR VPWR _06510_ sky130_fd_sc_hd__and2_1
X_08700_ _00731_ _00732_ _00745_ VGND VGND VPWR VPWR _00746_ sky130_fd_sc_hd__a21o_1
X_09680_ _01669_ _01674_ _01670_ VGND VGND VPWR VPWR _01681_ sky130_fd_sc_hd__nand3_1
X_08631_ net161 net589 VGND VGND VPWR VPWR _00678_ sky130_fd_sc_hd__nand2_1
XFILLER_0_55_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08562_ _00607_ _00608_ _00522_ _00524_ VGND VGND VPWR VPWR _00610_ sky130_fd_sc_hd__o211a_1
XFILLER_0_77_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08493_ _00540_ _00541_ VGND VGND VPWR VPWR _00542_ sky130_fd_sc_hd__nor2_1
X_07513_ _03726_ _03770_ VGND VGND VPWR VPWR _03781_ sky130_fd_sc_hd__xor2_1
XFILLER_0_119_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07444_ net279 net662 VGND VGND VPWR VPWR _03027_ sky130_fd_sc_hd__nand2_1
XFILLER_0_119_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07375_ _02244_ _02255_ _02266_ VGND VGND VPWR VPWR _02277_ sky130_fd_sc_hd__nand3_1
XFILLER_0_45_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09114_ _01148_ _01152_ VGND VGND VPWR VPWR _01153_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_115_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09045_ _01073_ _01075_ VGND VGND VPWR VPWR _01085_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09947_ net710 net451 net443 net718 VGND VGND VPWR VPWR _01947_ sky130_fd_sc_hd__a22oi_1
X_09878_ _01870_ _01871_ _01875_ VGND VGND VPWR VPWR _01879_ sky130_fd_sc_hd__a21o_1
X_08829_ _00869_ _00870_ _00871_ VGND VGND VPWR VPWR _00873_ sky130_fd_sc_hd__nor3_1
X_11840_ net375 net206 VGND VGND VPWR VPWR _04005_ sky130_fd_sc_hd__and2_1
XFILLER_0_95_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11771_ _03927_ _03928_ _03929_ VGND VGND VPWR VPWR _03930_ sky130_fd_sc_hd__nand3_1
XFILLER_0_138_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10722_ net272 net471 VGND VGND VPWR VPWR _02785_ sky130_fd_sc_hd__nand2_1
X_13510_ net512 net329 net474 net520 VGND VGND VPWR VPWR _05825_ sky130_fd_sc_hd__a22oi_2
X_14490_ _06888_ _06890_ VGND VGND VPWR VPWR _06891_ sky130_fd_sc_hd__or2_1
XFILLER_0_82_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13441_ _05747_ _05748_ _05749_ VGND VGND VPWR VPWR _05750_ sky130_fd_sc_hd__nand3b_1
X_10653_ _02648_ _02709_ net132 VGND VGND VPWR VPWR _02710_ sky130_fd_sc_hd__and3b_1
X_10584_ _02619_ _02620_ _02634_ VGND VGND VPWR VPWR _02635_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_35_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13372_ _05654_ _05670_ VGND VGND VPWR VPWR _05674_ sky130_fd_sc_hd__nand2_1
X_12323_ _04529_ _04444_ _04446_ VGND VGND VPWR VPWR _04531_ sky130_fd_sc_hd__nand3_1
XFILLER_0_91_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12254_ net688 net697 net250 net241 VGND VGND VPWR VPWR _04455_ sky130_fd_sc_hd__and4_1
X_11205_ net308 net229 net651 net668 VGND VGND VPWR VPWR _03309_ sky130_fd_sc_hd__nand4_1
X_12185_ net464 net152 net300 net557 VGND VGND VPWR VPWR _04381_ sky130_fd_sc_hd__a22o_1
XFILLER_0_76_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11136_ _03231_ _03233_ VGND VGND VPWR VPWR _03234_ sky130_fd_sc_hd__xnor2_1
X_11067_ _03052_ _03050_ _03101_ _03102_ VGND VGND VPWR VPWR _03160_ sky130_fd_sc_hd__o31a_1
X_10018_ _01926_ _02019_ _02020_ VGND VGND VPWR VPWR _00056_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_59_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14757_ clknet_3_0_0_clk _00058_ net316 VGND VGND VPWR VPWR a_cos\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_25_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11969_ _04143_ _04144_ _04085_ _04087_ VGND VGND VPWR VPWR _04146_ sky130_fd_sc_hd__a211oi_2
X_13708_ _05911_ _05913_ _05912_ net395 VGND VGND VPWR VPWR _06041_ sky130_fd_sc_hd__a22o_1
XFILLER_0_132_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14688_ _07095_ _07104_ VGND VGND VPWR VPWR _07105_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_117_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13639_ _05821_ _05822_ VGND VGND VPWR VPWR _05966_ sky130_fd_sc_hd__nor2_1
XFILLER_0_26_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout206 net207 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__clkbuf_4
Xfanout217 net67 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__buf_4
Xfanout228 net234 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__buf_6
X_09801_ _01793_ _01800_ _01801_ _01760_ VGND VGND VPWR VPWR _01802_ sky130_fd_sc_hd__o211a_1
XFILLER_0_5_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout239 net242 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__clkbuf_4
X_07993_ _04467_ _07126_ _07200_ VGND VGND VPWR VPWR _07288_ sky130_fd_sc_hd__a21o_1
X_09732_ _01457_ _01732_ VGND VGND VPWR VPWR _01733_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09663_ _01662_ _01663_ VGND VGND VPWR VPWR _01664_ sky130_fd_sc_hd__xnor2_1
X_08614_ _00659_ _00660_ VGND VGND VPWR VPWR _00661_ sky130_fd_sc_hd__xnor2_1
X_09594_ _01594_ VGND VGND VPWR VPWR _01595_ sky130_fd_sc_hd__inv_2
X_08545_ _00538_ _00545_ VGND VGND VPWR VPWR _00593_ sky130_fd_sc_hd__nand2_1
XFILLER_0_82_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08476_ _00522_ _00523_ _00516_ VGND VGND VPWR VPWR _00525_ sky130_fd_sc_hd__a21o_1
XFILLER_0_119_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07427_ _02777_ _02832_ VGND VGND VPWR VPWR _02843_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_9_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07358_ _02059_ _02070_ _02048_ VGND VGND VPWR VPWR _02092_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_73_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09028_ _01019_ _01068_ VGND VGND VPWR VPWR _01069_ sky130_fd_sc_hd__xnor2_1
Xfanout740 net741 VGND VGND VPWR VPWR net740 sky130_fd_sc_hd__clkbuf_4
X_13990_ _06334_ _06335_ _06345_ _06346_ VGND VGND VPWR VPWR _06348_ sky130_fd_sc_hd__o22a_1
X_12941_ _05198_ _05199_ VGND VGND VPWR VPWR _05200_ sky130_fd_sc_hd__nor2_1
X_12872_ _05113_ _05125_ VGND VGND VPWR VPWR _05126_ sky130_fd_sc_hd__nand2_1
X_11823_ _03984_ _03985_ VGND VGND VPWR VPWR _03986_ sky130_fd_sc_hd__nor2_1
X_14611_ _06964_ _06975_ _07020_ VGND VGND VPWR VPWR _07022_ sky130_fd_sc_hd__and3_1
X_11754_ _03908_ _03909_ _03910_ VGND VGND VPWR VPWR _03911_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_83_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14542_ _06857_ _06941_ _06946_ VGND VGND VPWR VPWR _06947_ sky130_fd_sc_hd__nor3_1
X_11685_ _03833_ _03834_ _03835_ VGND VGND VPWR VPWR _03837_ sky130_fd_sc_hd__nand3_1
X_10705_ _02764_ _02761_ _02765_ VGND VGND VPWR VPWR _02767_ sky130_fd_sc_hd__o21ba_1
X_14473_ _06870_ _06871_ VGND VGND VPWR VPWR _06872_ sky130_fd_sc_hd__or2_1
X_10636_ net650 net439 VGND VGND VPWR VPWR _02692_ sky130_fd_sc_hd__nand2_1
X_13424_ net520 net329 net474 net529 VGND VGND VPWR VPWR _05731_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_36_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10567_ _02569_ _02570_ VGND VGND VPWR VPWR _02617_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13355_ _05625_ _05623_ VGND VGND VPWR VPWR _05656_ sky130_fd_sc_hd__or2b_1
X_12306_ _04502_ _04512_ VGND VGND VPWR VPWR _04513_ sky130_fd_sc_hd__xnor2_1
X_10498_ _02438_ _02441_ _02439_ VGND VGND VPWR VPWR _02542_ sky130_fd_sc_hd__a21bo_1
X_13286_ _05528_ _05529_ _05531_ VGND VGND VPWR VPWR _05580_ sky130_fd_sc_hd__and3_1
X_12237_ _04336_ _04338_ _04335_ VGND VGND VPWR VPWR _04438_ sky130_fd_sc_hd__o21ai_1
X_12168_ _04355_ _04361_ VGND VGND VPWR VPWR _04362_ sky130_fd_sc_hd__xnor2_1
X_12099_ _04284_ _04285_ _04286_ VGND VGND VPWR VPWR _04287_ sky130_fd_sc_hd__nand3_1
X_11119_ next_state _03213_ _03214_ _03215_ VGND VGND VPWR VPWR _00071_ sky130_fd_sc_hd__a31o_1
Xinput6 alpha[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_59_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08330_ _00378_ _00380_ VGND VGND VPWR VPWR _00381_ sky130_fd_sc_hd__xor2_2
XFILLER_0_86_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08261_ _00231_ _00235_ _00229_ VGND VGND VPWR VPWR _00313_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_116_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08192_ net247 net239 net541 net549 VGND VGND VPWR VPWR _00244_ sky130_fd_sc_hd__and4_1
XFILLER_0_55_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07976_ _07267_ _07268_ _07269_ VGND VGND VPWR VPWR _07271_ sky130_fd_sc_hd__a21o_1
X_09715_ _01594_ _01667_ VGND VGND VPWR VPWR _01716_ sky130_fd_sc_hd__nand2_1
X_09646_ _01638_ _01645_ _01646_ VGND VGND VPWR VPWR _01647_ sky130_fd_sc_hd__nand3_2
X_09577_ _01576_ _01577_ VGND VGND VPWR VPWR _01578_ sky130_fd_sc_hd__nor2_1
X_08528_ _00574_ _00575_ VGND VGND VPWR VPWR _00576_ sky130_fd_sc_hd__nor2_1
X_08459_ _00492_ _00507_ VGND VGND VPWR VPWR _00508_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11470_ _03591_ _03599_ VGND VGND VPWR VPWR _03600_ sky130_fd_sc_hd__xnor2_1
X_10421_ net185 net271 net363 net353 VGND VGND VPWR VPWR _02458_ sky130_fd_sc_hd__nand4_2
X_10352_ _02286_ _02287_ VGND VGND VPWR VPWR _02383_ sky130_fd_sc_hd__nor2_1
XFILLER_0_20_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13140_ _05394_ _05395_ _05417_ _05418_ VGND VGND VPWR VPWR _05419_ sky130_fd_sc_hd__and4bb_2
X_13071_ net571 net450 net441 net659 VGND VGND VPWR VPWR _05343_ sky130_fd_sc_hd__a22oi_1
X_12022_ _04192_ _04202_ VGND VGND VPWR VPWR _04203_ sky130_fd_sc_hd__xor2_2
X_10283_ _02231_ _02235_ VGND VGND VPWR VPWR _02307_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout581 net583 VGND VGND VPWR VPWR net581 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_73_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout570 net571 VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__clkbuf_2
X_13973_ net612 net343 _06327_ _06328_ VGND VGND VPWR VPWR _06329_ sky130_fd_sc_hd__a22o_1
Xfanout592 net26 VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__buf_4
X_12924_ _05095_ _05145_ _05181_ _05149_ _05179_ VGND VGND VPWR VPWR _05182_ sky130_fd_sc_hd__a221oi_2
X_12855_ _04987_ _05106_ VGND VGND VPWR VPWR _05108_ sky130_fd_sc_hd__xnor2_1
X_11806_ net723 net732 net256 net248 VGND VGND VPWR VPWR _03968_ sky130_fd_sc_hd__and4_1
X_12786_ _04943_ _04960_ _05033_ VGND VGND VPWR VPWR _05034_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11737_ _03889_ _03891_ _03892_ VGND VGND VPWR VPWR _03893_ sky130_fd_sc_hd__or3_1
XFILLER_0_95_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14525_ _06926_ _06927_ VGND VGND VPWR VPWR _06929_ sky130_fd_sc_hd__xor2_1
XFILLER_0_83_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11668_ _03815_ _03816_ _03817_ VGND VGND VPWR VPWR _03818_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_4_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14456_ _06803_ _06807_ VGND VGND VPWR VPWR _06854_ sky130_fd_sc_hd__and2b_1
XFILLER_0_24_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11599_ net289 net731 _03674_ _03673_ VGND VGND VPWR VPWR _03742_ sky130_fd_sc_hd__a31o_1
X_10619_ _02579_ _02508_ VGND VGND VPWR VPWR _02674_ sky130_fd_sc_hd__or2b_1
X_14387_ _06623_ _06707_ VGND VGND VPWR VPWR _06780_ sky130_fd_sc_hd__and2_1
X_13407_ _05483_ _05712_ VGND VGND VPWR VPWR _05713_ sky130_fd_sc_hd__and2b_1
XFILLER_0_52_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13338_ _05630_ _05635_ _05614_ _05615_ VGND VGND VPWR VPWR _05637_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_110_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13269_ net561 net365 _05552_ _05551_ VGND VGND VPWR VPWR _05561_ sky130_fd_sc_hd__a31o_1
XFILLER_0_138_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07830_ _04489_ _04999_ _07121_ _07124_ _07125_ VGND VGND VPWR VPWR _07126_ sky130_fd_sc_hd__o41a_1
X_07761_ _06157_ _06113_ _06146_ VGND VGND VPWR VPWR _06483_ sky130_fd_sc_hd__a21o_1
XFILLER_0_47_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09500_ _01489_ _01490_ _01499_ VGND VGND VPWR VPWR _01501_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_2_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07692_ _05096_ _05086_ VGND VGND VPWR VPWR _05732_ sky130_fd_sc_hd__nor2_1
XFILLER_0_78_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09431_ net664 net392 net383 net673 VGND VGND VPWR VPWR _01432_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09362_ net796 net787 _01365_ VGND VGND VPWR VPWR _00052_ sky130_fd_sc_hd__a21o_1
XFILLER_0_117_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08313_ _00362_ _00363_ VGND VGND VPWR VPWR _00364_ sky130_fd_sc_hd__nor2_1
XANTENNA_22 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09293_ _01304_ _01305_ VGND VGND VPWR VPWR _01306_ sky130_fd_sc_hd__nand2_1
XFILLER_0_62_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_11 net386 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08244_ _00290_ _00291_ _00294_ VGND VGND VPWR VPWR _00296_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_55_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_33 net637 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08175_ _07217_ _00131_ _00130_ VGND VGND VPWR VPWR _00228_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_43_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07959_ net197 net633 VGND VGND VPWR VPWR _07254_ sky130_fd_sc_hd__and2_1
XFILLER_0_69_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10970_ _03037_ _03040_ VGND VGND VPWR VPWR _03054_ sky130_fd_sc_hd__or2b_1
XFILLER_0_69_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09629_ _01624_ _01628_ _01629_ VGND VGND VPWR VPWR _01630_ sky130_fd_sc_hd__and3_1
X_12640_ _04872_ _04873_ net291 net144 VGND VGND VPWR VPWR _04875_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_127_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12571_ net276 net291 _04721_ _04720_ VGND VGND VPWR VPWR _04800_ sky130_fd_sc_hd__a31o_1
XFILLER_0_92_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14310_ _06694_ _06695_ VGND VGND VPWR VPWR _06696_ sky130_fd_sc_hd__nand2_1
XFILLER_0_136_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11522_ _03655_ _03656_ VGND VGND VPWR VPWR _03657_ sky130_fd_sc_hd__and2b_1
XFILLER_0_19_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11453_ net195 net684 VGND VGND VPWR VPWR _03581_ sky130_fd_sc_hd__nand2_1
X_14241_ _06551_ _06620_ VGND VGND VPWR VPWR _06621_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_123_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10404_ net460 net554 net335 net480 VGND VGND VPWR VPWR _02439_ sky130_fd_sc_hd__nand4_2
XFILLER_0_33_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14172_ _06454_ _06459_ _06453_ VGND VGND VPWR VPWR _06546_ sky130_fd_sc_hd__a21bo_1
X_11384_ _03461_ _03467_ _03460_ VGND VGND VPWR VPWR _03505_ sky130_fd_sc_hd__a21bo_1
X_13123_ _05335_ _05338_ _05337_ VGND VGND VPWR VPWR _05400_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_33_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10335_ net185 net370 VGND VGND VPWR VPWR _02365_ sky130_fd_sc_hd__and2_1
X_10266_ _02260_ _02289_ VGND VGND VPWR VPWR _02290_ sky130_fd_sc_hd__xnor2_2
X_13054_ _05316_ _05323_ VGND VGND VPWR VPWR _05324_ sky130_fd_sc_hd__xnor2_1
X_12005_ _04102_ _04104_ VGND VGND VPWR VPWR _04185_ sky130_fd_sc_hd__and2_1
XFILLER_0_84_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10197_ _02213_ _02214_ VGND VGND VPWR VPWR _02215_ sky130_fd_sc_hd__xnor2_1
X_13956_ net622 net631 net334 net478 VGND VGND VPWR VPWR _06311_ sky130_fd_sc_hd__nand4_2
X_12907_ _05126_ _05163_ VGND VGND VPWR VPWR _05164_ sky130_fd_sc_hd__xnor2_1
X_13887_ net594 net368 VGND VGND VPWR VPWR _06236_ sky130_fd_sc_hd__and2_1
X_12838_ _05088_ _05089_ VGND VGND VPWR VPWR _05090_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12769_ _05013_ _05014_ VGND VGND VPWR VPWR _05015_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14508_ _06776_ _06847_ VGND VGND VPWR VPWR _06911_ sky130_fd_sc_hd__nand2_1
XFILLER_0_141_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput31 beta[4] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_1
Xinput20 beta[10] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__buf_6
X_14439_ _06834_ _06835_ VGND VGND VPWR VPWR _06836_ sky130_fd_sc_hd__and2_1
Xinput64 sin[17] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__buf_2
Xinput53 cos[8] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_4
Xinput42 cos[14] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__buf_1
XFILLER_0_12_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09980_ net371 net396 net387 net459 VGND VGND VPWR VPWR _01980_ sky130_fd_sc_hd__a22o_1
X_08931_ _00647_ _00649_ _00973_ _00719_ VGND VGND VPWR VPWR _00974_ sky130_fd_sc_hd__a211o_4
XFILLER_0_58_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08862_ _00887_ _00905_ VGND VGND VPWR VPWR _00906_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07813_ _06255_ _06266_ _06026_ VGND VGND VPWR VPWR _07047_ sky130_fd_sc_hd__a21o_1
X_08793_ _00775_ _00774_ VGND VGND VPWR VPWR _00838_ sky130_fd_sc_hd__and2b_1
X_07744_ net208 net199 net565 net573 VGND VGND VPWR VPWR _06298_ sky130_fd_sc_hd__and4_1
XFILLER_0_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07675_ net304 net522 net531 net225 VGND VGND VPWR VPWR _05545_ sky130_fd_sc_hd__a22o_1
XFILLER_0_79_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09414_ _01410_ _01412_ _01411_ VGND VGND VPWR VPWR _01415_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_94_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09345_ b_cos\[13\] _01350_ _01345_ VGND VGND VPWR VPWR _01351_ sky130_fd_sc_hd__a21o_1
XFILLER_0_133_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09276_ _01291_ VGND VGND VPWR VPWR _00040_ sky130_fd_sc_hd__clkbuf_1
X_08227_ net179 net614 net625 net169 VGND VGND VPWR VPWR _00279_ sky130_fd_sc_hd__a22o_1
XFILLER_0_62_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08158_ _07336_ _07344_ _07343_ VGND VGND VPWR VPWR _00211_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_15_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08089_ _07214_ _07307_ VGND VGND VPWR VPWR _00142_ sky130_fd_sc_hd__or2_1
XFILLER_0_101_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10120_ net739 net416 VGND VGND VPWR VPWR _02130_ sky130_fd_sc_hd__and2b_1
XFILLER_0_100_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10051_ _02022_ _01997_ _02053_ _02054_ VGND VGND VPWR VPWR _02055_ sky130_fd_sc_hd__o211a_2
XFILLER_0_100_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14790_ clknet_3_0_0_clk _00091_ net315 VGND VGND VPWR VPWR b_cos\[0\] sky130_fd_sc_hd__dfrtp_1
X_13810_ net491 net413 net584 VGND VGND VPWR VPWR _06152_ sky130_fd_sc_hd__a21bo_1
X_10953_ _02947_ _02948_ _02975_ VGND VGND VPWR VPWR _03036_ sky130_fd_sc_hd__o21ai_2
X_13741_ _06074_ _06075_ _06016_ VGND VGND VPWR VPWR _06077_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_66_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10884_ _02888_ _02889_ _02887_ VGND VGND VPWR VPWR _02961_ sky130_fd_sc_hd__a21o_1
X_13672_ net545 net427 net419 net564 VGND VGND VPWR VPWR _06001_ sky130_fd_sc_hd__a22oi_1
X_12623_ _04657_ _04809_ VGND VGND VPWR VPWR _04856_ sky130_fd_sc_hd__nor2_2
XFILLER_0_109_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12554_ _04781_ VGND VGND VPWR VPWR _00083_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_65_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11505_ _03635_ _03636_ _03634_ VGND VGND VPWR VPWR _03639_ sky130_fd_sc_hd__a21o_1
XFILLER_0_109_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12485_ _04668_ _04686_ VGND VGND VPWR VPWR _04707_ sky130_fd_sc_hd__or2_1
XFILLER_0_80_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14224_ net513 net415 VGND VGND VPWR VPWR _06602_ sky130_fd_sc_hd__and2b_1
X_11436_ _03345_ _03442_ net120 _03433_ VGND VGND VPWR VPWR _03563_ sky130_fd_sc_hd__a211o_1
XFILLER_0_80_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11367_ _03486_ _03476_ VGND VGND VPWR VPWR _03487_ sky130_fd_sc_hd__xor2_1
XFILLER_0_1_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14155_ _06427_ _06437_ _06526_ VGND VGND VPWR VPWR _06528_ sky130_fd_sc_hd__o21a_1
X_10318_ _02343_ _02344_ _02335_ VGND VGND VPWR VPWR _02346_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13106_ _05318_ _05320_ _05319_ VGND VGND VPWR VPWR _05382_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_21_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14086_ _06371_ _06372_ _06452_ VGND VGND VPWR VPWR _06453_ sky130_fd_sc_hd__o21ai_2
X_11298_ _03408_ _03409_ _03410_ VGND VGND VPWR VPWR _03411_ sky130_fd_sc_hd__o21bai_1
X_13037_ net502 net367 VGND VGND VPWR VPWR _05306_ sky130_fd_sc_hd__nand2_1
XFILLER_0_119_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10249_ _02261_ _02270_ VGND VGND VPWR VPWR _02271_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_89_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13939_ _06185_ _06186_ _06184_ VGND VGND VPWR VPWR _06292_ sky130_fd_sc_hd__a21o_1
X_07460_ _03059_ _03070_ _03189_ VGND VGND VPWR VPWR _03200_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_119_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07391_ _02418_ _02429_ _02440_ VGND VGND VPWR VPWR _02451_ sky130_fd_sc_hd__or3_1
XFILLER_0_17_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09130_ a_cos\[1\] b_sin\[1\] VGND VGND VPWR VPWR _01167_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09061_ net245 net600 net591 net253 VGND VGND VPWR VPWR _01101_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_142_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08012_ _07295_ _07305_ VGND VGND VPWR VPWR _07306_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_7_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09963_ _01960_ _01961_ _01946_ VGND VGND VPWR VPWR _01963_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08914_ _00952_ _00955_ VGND VGND VPWR VPWR _00957_ sky130_fd_sc_hd__nand2_1
X_09894_ _01889_ _01890_ _01894_ VGND VGND VPWR VPWR _01895_ sky130_fd_sc_hd__and3_1
X_08845_ _00800_ _00813_ _00815_ VGND VGND VPWR VPWR _00889_ sky130_fd_sc_hd__o21bai_2
X_08776_ _00817_ _00820_ VGND VGND VPWR VPWR _00821_ sky130_fd_sc_hd__xnor2_1
X_07727_ _06048_ _06059_ _06102_ VGND VGND VPWR VPWR _06113_ sky130_fd_sc_hd__a21o_1
XFILLER_0_138_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07658_ _05325_ _05336_ _05347_ VGND VGND VPWR VPWR _05358_ sky130_fd_sc_hd__nand3_4
XFILLER_0_67_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07589_ _04587_ _04598_ net157 net574 VGND VGND VPWR VPWR _04609_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_94_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09328_ b_cos\[12\] a_sin\[12\] VGND VGND VPWR VPWR _01336_ sky130_fd_sc_hd__and2b_1
X_09259_ net103 _01276_ net128 VGND VGND VPWR VPWR _01277_ sky130_fd_sc_hd__mux2_1
X_12270_ _04397_ _04405_ _04404_ VGND VGND VPWR VPWR _04473_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_121_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11221_ _03323_ _03324_ _03325_ VGND VGND VPWR VPWR _03326_ sky130_fd_sc_hd__nand3_2
XFILLER_0_114_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11152_ net175 net165 net720 net729 VGND VGND VPWR VPWR _03250_ sky130_fd_sc_hd__and4_1
X_10103_ _02111_ VGND VGND VPWR VPWR _02112_ sky130_fd_sc_hd__inv_2
X_11083_ _03164_ _03121_ _03174_ VGND VGND VPWR VPWR _03176_ sky130_fd_sc_hd__o21a_1
X_10034_ net396 _02035_ _02036_ VGND VGND VPWR VPWR _02037_ sky130_fd_sc_hd__a21bo_1
X_11985_ _04151_ _04063_ VGND VGND VPWR VPWR _04163_ sky130_fd_sc_hd__and2b_1
XFILLER_0_86_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14773_ clknet_3_2_0_clk _00074_ net315 VGND VGND VPWR VPWR a_sin\[1\] sky130_fd_sc_hd__dfrtp_1
X_10936_ _02931_ _02934_ _03017_ VGND VGND VPWR VPWR _03018_ sky130_fd_sc_hd__nor3_1
X_13724_ _05918_ _05919_ _05920_ VGND VGND VPWR VPWR _06058_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_128_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10867_ _02937_ _02942_ VGND VGND VPWR VPWR _02943_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_39_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13655_ net116 _05981_ _05879_ _05881_ VGND VGND VPWR VPWR _05984_ sky130_fd_sc_hd__o211ai_1
X_12606_ _04814_ _04816_ _04838_ VGND VGND VPWR VPWR _04839_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_66_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10798_ net142 _02866_ _02867_ VGND VGND VPWR VPWR _02868_ sky130_fd_sc_hd__a21bo_1
X_13586_ _05904_ _05905_ _05901_ VGND VGND VPWR VPWR _05908_ sky130_fd_sc_hd__a21o_1
XFILLER_0_38_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12537_ _04763_ _04680_ VGND VGND VPWR VPWR _04764_ sky130_fd_sc_hd__nor2_1
X_12468_ _04666_ _04667_ _04687_ VGND VGND VPWR VPWR _04689_ sky130_fd_sc_hd__o21ai_1
X_11419_ _03523_ _03524_ _03543_ _03503_ _03483_ VGND VGND VPWR VPWR _03544_ sky130_fd_sc_hd__o32a_1
X_14207_ _06577_ _06583_ VGND VGND VPWR VPWR _06584_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_111_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12399_ _04527_ _04530_ VGND VGND VPWR VPWR _04614_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14138_ _06506_ _06507_ _06412_ _06414_ VGND VGND VPWR VPWR _06509_ sky130_fd_sc_hd__o211a_1
X_14069_ net604 net342 VGND VGND VPWR VPWR _06434_ sky130_fd_sc_hd__nand2_1
X_08630_ _00675_ _00676_ VGND VGND VPWR VPWR _00677_ sky130_fd_sc_hd__nor2b_2
X_08561_ _00522_ _00524_ _00607_ _00608_ VGND VGND VPWR VPWR _00609_ sky130_fd_sc_hd__a211oi_2
X_08492_ net181 net171 net599 net589 VGND VGND VPWR VPWR _00541_ sky130_fd_sc_hd__and4_1
X_07512_ _03737_ _03759_ VGND VGND VPWR VPWR _03770_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07443_ _02951_ _03005_ VGND VGND VPWR VPWR _03016_ sky130_fd_sc_hd__or2b_1
XFILLER_0_76_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07374_ net308 net624 net633 net229 VGND VGND VPWR VPWR _02266_ sky130_fd_sc_hd__a22o_1
X_09113_ _01149_ _01151_ VGND VGND VPWR VPWR _01152_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09044_ _01026_ _01077_ _01076_ VGND VGND VPWR VPWR _01084_ sky130_fd_sc_hd__a21o_1
XFILLER_0_60_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09946_ _01623_ _01631_ _01630_ VGND VGND VPWR VPWR _01946_ sky130_fd_sc_hd__a21o_1
X_09877_ net733 net390 net382 net740 VGND VGND VPWR VPWR _01878_ sky130_fd_sc_hd__a22oi_2
X_08828_ _00869_ _00870_ _00871_ VGND VGND VPWR VPWR _00872_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08759_ net258 net626 VGND VGND VPWR VPWR _00804_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11770_ _03830_ _03832_ _03831_ VGND VGND VPWR VPWR _03929_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_68_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10721_ _02782_ _02783_ VGND VGND VPWR VPWR _02784_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13440_ net494 net503 net356 net346 VGND VGND VPWR VPWR _05749_ sky130_fd_sc_hd__nand4_1
X_10652_ net360 net350 VGND VGND VPWR VPWR _02709_ sky130_fd_sc_hd__or2_1
XFILLER_0_106_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10583_ _02626_ _02633_ VGND VGND VPWR VPWR _02634_ sky130_fd_sc_hd__xnor2_1
X_13371_ _05653_ _05672_ VGND VGND VPWR VPWR _05673_ sky130_fd_sc_hd__nor2_1
X_12322_ _04444_ _04446_ _04529_ VGND VGND VPWR VPWR _04530_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12253_ net687 net250 net241 net697 VGND VGND VPWR VPWR _04454_ sky130_fd_sc_hd__a22oi_1
X_11204_ _03304_ _03305_ _03306_ VGND VGND VPWR VPWR _03307_ sky130_fd_sc_hd__nand3_2
X_12184_ _04377_ _04378_ VGND VGND VPWR VPWR _04379_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_102_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_79_Left_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11135_ net9 net434 VGND VGND VPWR VPWR _03233_ sky130_fd_sc_hd__nand2_1
X_11066_ _03052_ _03050_ _03101_ _03102_ _03158_ VGND VGND VPWR VPWR _03159_ sky130_fd_sc_hd__o311a_4
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10017_ net784 _02027_ VGND VGND VPWR VPWR _02020_ sky130_fd_sc_hd__nor2_1
XFILLER_0_92_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14756_ clknet_3_0_0_clk _00057_ net316 VGND VGND VPWR VPWR a_cos\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11968_ _04085_ _04087_ _04143_ _04144_ VGND VGND VPWR VPWR _04145_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_88_Left_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13707_ _05903_ _05905_ VGND VGND VPWR VPWR _06040_ sky130_fd_sc_hd__nand2_2
XFILLER_0_129_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11899_ _03983_ _03984_ _03985_ VGND VGND VPWR VPWR _04069_ sky130_fd_sc_hd__o21ba_1
X_10919_ _02995_ _02998_ VGND VGND VPWR VPWR _02999_ sky130_fd_sc_hd__xor2_1
X_14687_ _07038_ _07103_ VGND VGND VPWR VPWR _07104_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_73_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13638_ net659 net415 VGND VGND VPWR VPWR _05965_ sky130_fd_sc_hd__and2b_1
XFILLER_0_15_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13569_ _05714_ _05483_ VGND VGND VPWR VPWR _05890_ sky130_fd_sc_hd__nor2_1
XFILLER_0_54_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_97_Left_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout229 net234 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__buf_4
Xfanout207 net68 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__buf_6
Xfanout218 net219 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__buf_2
X_07992_ _07284_ _07285_ net115 _07206_ VGND VGND VPWR VPWR _07287_ sky130_fd_sc_hd__a211oi_1
X_09800_ _01756_ _01757_ _01759_ VGND VGND VPWR VPWR _01801_ sky130_fd_sc_hd__a21o_1
X_09731_ net735 net331 net476 net741 VGND VGND VPWR VPWR _01732_ sky130_fd_sc_hd__a22oi_1
X_09662_ _01588_ _01591_ _01587_ VGND VGND VPWR VPWR _01663_ sky130_fd_sc_hd__a21boi_2
X_08613_ net260 net645 VGND VGND VPWR VPWR _00660_ sky130_fd_sc_hd__nand2_1
X_09593_ _01526_ _01530_ _01592_ _01593_ VGND VGND VPWR VPWR _01594_ sky130_fd_sc_hd__a211o_1
X_08544_ _00539_ _00544_ VGND VGND VPWR VPWR _00592_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08475_ _00516_ _00522_ _00523_ VGND VGND VPWR VPWR _00524_ sky130_fd_sc_hd__nand3_2
X_07426_ _02788_ _02821_ VGND VGND VPWR VPWR _02832_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_17_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07357_ _02048_ _02059_ _02070_ VGND VGND VPWR VPWR _02081_ sky130_fd_sc_hd__or3_1
XFILLER_0_45_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09027_ _01054_ _01067_ VGND VGND VPWR VPWR _01068_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout730 net11 VGND VGND VPWR VPWR net730 sky130_fd_sc_hd__clkbuf_4
Xfanout741 net742 VGND VGND VPWR VPWR net741 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_130_Right_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09929_ _01581_ _01583_ _01599_ VGND VGND VPWR VPWR _01929_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_99_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12940_ net502 net389 net380 net510 VGND VGND VPWR VPWR _05199_ sky130_fd_sc_hd__a22oi_2
X_12871_ _05123_ _05124_ VGND VGND VPWR VPWR _05125_ sky130_fd_sc_hd__nor2_1
X_11822_ net696 net705 net290 net280 VGND VGND VPWR VPWR _03985_ sky130_fd_sc_hd__and4_1
X_14610_ _06964_ _06975_ _07020_ VGND VGND VPWR VPWR _07021_ sky130_fd_sc_hd__a21oi_2
X_11753_ net652 net669 net178 net168 VGND VGND VPWR VPWR _03910_ sky130_fd_sc_hd__nand4_2
XFILLER_0_95_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14541_ _06944_ _06945_ VGND VGND VPWR VPWR _06946_ sky130_fd_sc_hd__xor2_1
XFILLER_0_28_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11684_ _03706_ _03708_ _03707_ VGND VGND VPWR VPWR _03835_ sky130_fd_sc_hd__o21bai_1
X_10704_ _02753_ _02754_ VGND VGND VPWR VPWR _02765_ sky130_fd_sc_hd__and2b_1
X_14472_ _06790_ _06812_ _06788_ VGND VGND VPWR VPWR _06871_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_126_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10635_ _02688_ _02689_ VGND VGND VPWR VPWR _02691_ sky130_fd_sc_hd__nor2_1
X_13423_ net537 net468 VGND VGND VPWR VPWR _05730_ sky130_fd_sc_hd__nand2_1
XFILLER_0_51_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13354_ net569 net656 net391 net381 VGND VGND VPWR VPWR _05654_ sky130_fd_sc_hd__and4_1
X_12305_ _04503_ _04510_ VGND VGND VPWR VPWR _04512_ sky130_fd_sc_hd__xnor2_1
X_10566_ _02595_ _02615_ VGND VGND VPWR VPWR _02616_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10497_ net554 net471 _02537_ _02539_ VGND VGND VPWR VPWR _02541_ sky130_fd_sc_hd__nand4_2
XFILLER_0_11_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13285_ _05528_ _05529_ _05531_ VGND VGND VPWR VPWR _05579_ sky130_fd_sc_hd__a21oi_1
X_12236_ _04434_ _04436_ VGND VGND VPWR VPWR _04437_ sky130_fd_sc_hd__nand2_1
X_12167_ _04359_ _04360_ VGND VGND VPWR VPWR _04361_ sky130_fd_sc_hd__xor2_1
X_11118_ a_cos\[16\] _00918_ VGND VGND VPWR VPWR _03215_ sky130_fd_sc_hd__and2_1
X_12098_ _04193_ _04196_ _04194_ VGND VGND VPWR VPWR _04286_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_127_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11049_ _03132_ _03139_ VGND VGND VPWR VPWR _03140_ sky130_fd_sc_hd__xor2_1
Xinput7 alpha[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14808_ clknet_3_5_0_clk next_state net325 VGND VGND VPWR VPWR state sky130_fd_sc_hd__dfrtp_4
X_14739_ clknet_3_0_0_clk _00040_ net314 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_59_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08260_ _00310_ _00311_ VGND VGND VPWR VPWR _00312_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08191_ net247 net541 net549 net239 VGND VGND VPWR VPWR _00243_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_62_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_124_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07975_ _07267_ _07268_ _07269_ VGND VGND VPWR VPWR _07270_ sky130_fd_sc_hd__nand3_4
X_09714_ _01594_ _01667_ _01712_ _01714_ VGND VGND VPWR VPWR _01715_ sky130_fd_sc_hd__and4_1
XFILLER_0_97_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09645_ _01642_ _01643_ _01644_ VGND VGND VPWR VPWR _01646_ sky130_fd_sc_hd__a21o_1
XFILLER_0_96_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09576_ net727 net735 net451 net443 VGND VGND VPWR VPWR _01577_ sky130_fd_sc_hd__and4_1
XFILLER_0_93_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08527_ net249 net241 net509 net517 VGND VGND VPWR VPWR _00575_ sky130_fd_sc_hd__and4_1
X_08458_ _00493_ _00506_ VGND VGND VPWR VPWR _00507_ sky130_fd_sc_hd__xor2_1
XFILLER_0_37_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07409_ _02582_ _02625_ _02636_ VGND VGND VPWR VPWR _02647_ sky130_fd_sc_hd__nand3_1
XFILLER_0_52_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08389_ _00430_ _00437_ _00438_ VGND VGND VPWR VPWR _00439_ sky130_fd_sc_hd__nand3_1
XFILLER_0_92_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10420_ net185 net363 net353 net271 VGND VGND VPWR VPWR _02457_ sky130_fd_sc_hd__a22o_1
XFILLER_0_60_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10351_ _02349_ _02381_ VGND VGND VPWR VPWR _02382_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_131_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10282_ _02137_ _02237_ _02305_ VGND VGND VPWR VPWR _02306_ sky130_fd_sc_hd__o21a_1
X_13070_ net571 net659 net450 net441 VGND VGND VPWR VPWR _05342_ sky130_fd_sc_hd__and4_1
X_12021_ _04200_ _04201_ VGND VGND VPWR VPWR _04202_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout560 net3 VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__clkbuf_4
Xfanout582 net583 VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout571 net572 VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__clkbuf_4
X_13972_ net594 net603 net361 net351 VGND VGND VPWR VPWR _06328_ sky130_fd_sc_hd__nand4_2
Xfanout593 net601 VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__clkbuf_4
X_12923_ _05088_ _05143_ VGND VGND VPWR VPWR _05181_ sky130_fd_sc_hd__or2_1
XFILLER_0_88_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12854_ _05099_ _05105_ VGND VGND VPWR VPWR _05106_ sky130_fd_sc_hd__xnor2_1
X_11805_ net722 net256 net248 net731 VGND VGND VPWR VPWR _03967_ sky130_fd_sc_hd__a22oi_1
X_12785_ _04901_ _04961_ VGND VGND VPWR VPWR _05033_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11736_ net687 net696 net150 net297 VGND VGND VPWR VPWR _03892_ sky130_fd_sc_hd__and4_1
X_14524_ net595 net438 VGND VGND VPWR VPWR _06927_ sky130_fd_sc_hd__nand2_1
XFILLER_0_83_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11667_ net669 net178 net168 net678 VGND VGND VPWR VPWR _03817_ sky130_fd_sc_hd__nand4_1
XFILLER_0_126_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14455_ _06852_ VGND VGND VPWR VPWR _00103_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_22_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11598_ _03652_ _03659_ VGND VGND VPWR VPWR _03741_ sky130_fd_sc_hd__nand2_1
X_10618_ _02576_ _02578_ VGND VGND VPWR VPWR _02673_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14386_ _06776_ _06778_ VGND VGND VPWR VPWR _06779_ sky130_fd_sc_hd__or2_2
X_13406_ _05484_ _05485_ _05537_ _05711_ VGND VGND VPWR VPWR _05712_ sky130_fd_sc_hd__or4b_4
X_10549_ _02534_ _02535_ VGND VGND VPWR VPWR _02597_ sky130_fd_sc_hd__nor2_1
XFILLER_0_51_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13337_ _05614_ _05615_ _05630_ _05635_ VGND VGND VPWR VPWR _05636_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_121_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13268_ net569 net656 net357 net347 VGND VGND VPWR VPWR _05560_ sky130_fd_sc_hd__and4_1
X_12219_ _04406_ _04407_ _04416_ _04417_ VGND VGND VPWR VPWR _04418_ sky130_fd_sc_hd__and4_1
X_13199_ _05429_ _05430_ VGND VGND VPWR VPWR _05484_ sky130_fd_sc_hd__nand2_1
XFILLER_0_138_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07760_ _06440_ _06451_ _06462_ VGND VGND VPWR VPWR _06472_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_37_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_16_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07691_ net193 net565 _05611_ _05600_ VGND VGND VPWR VPWR _05721_ sky130_fd_sc_hd__a31o_1
X_09430_ net664 net673 net392 net383 VGND VGND VPWR VPWR _01431_ sky130_fd_sc_hd__and4_1
XFILLER_0_2_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09361_ net131 _01363_ _01364_ VGND VGND VPWR VPWR _01365_ sky130_fd_sc_hd__and3_1
XFILLER_0_59_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08312_ _00360_ _00361_ _00354_ VGND VGND VPWR VPWR _00363_ sky130_fd_sc_hd__a21oi_1
X_09292_ a_sin\[7\] b_cos\[7\] VGND VGND VPWR VPWR _01305_ sky130_fd_sc_hd__or2b_1
X_08243_ _00290_ _00291_ _00294_ VGND VGND VPWR VPWR _00295_ sky130_fd_sc_hd__and3_1
XANTENNA_12 net426 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_23 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_34 net676 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_25_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08174_ _00224_ _00225_ _00141_ _00142_ VGND VGND VPWR VPWR _00227_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_6_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_34_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07958_ _07243_ _07252_ VGND VGND VPWR VPWR _07253_ sky130_fd_sc_hd__xor2_2
X_07889_ _07181_ _07182_ _07183_ VGND VGND VPWR VPWR _07185_ sky130_fd_sc_hd__a21o_1
X_09628_ _01626_ _01627_ _01625_ VGND VGND VPWR VPWR _01629_ sky130_fd_sc_hd__a21bo_1
X_09559_ _01549_ _01550_ _01559_ VGND VGND VPWR VPWR _01560_ sky130_fd_sc_hd__and3_1
X_12570_ _04797_ _04798_ VGND VGND VPWR VPWR _04799_ sky130_fd_sc_hd__nor2_1
XFILLER_0_93_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_43_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11521_ net178 net685 net695 net167 VGND VGND VPWR VPWR _03656_ sky130_fd_sc_hd__a22o_1
XFILLER_0_53_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11452_ _03577_ _03578_ _03573_ VGND VGND VPWR VPWR _03580_ sky130_fd_sc_hd__a21o_1
X_14240_ _06618_ _06619_ VGND VGND VPWR VPWR _06620_ sky130_fd_sc_hd__or2b_1
X_11383_ _03419_ _03412_ _03417_ VGND VGND VPWR VPWR _03504_ sky130_fd_sc_hd__nand3_1
XFILLER_0_61_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10403_ net460 net335 net480 net554 VGND VGND VPWR VPWR _02438_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14171_ _06543_ _06544_ VGND VGND VPWR VPWR _06545_ sky130_fd_sc_hd__nor2_1
XFILLER_0_61_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13122_ _05316_ _05323_ VGND VGND VPWR VPWR _05399_ sky130_fd_sc_hd__or2b_1
X_10334_ net139 net133 net393 net384 VGND VGND VPWR VPWR _02363_ sky130_fd_sc_hd__nand4_1
XFILLER_0_131_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_52_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10265_ _02286_ _02287_ VGND VGND VPWR VPWR _02289_ sky130_fd_sc_hd__xor2_2
X_13053_ _05317_ _05322_ VGND VGND VPWR VPWR _05323_ sky130_fd_sc_hd__xnor2_1
X_12004_ _04080_ _04182_ VGND VGND VPWR VPWR _04183_ sky130_fd_sc_hd__xor2_1
XFILLER_0_84_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10196_ _02115_ _02018_ _02110_ _02111_ VGND VGND VPWR VPWR _02214_ sky130_fd_sc_hd__a31o_1
Xfanout390 net391 VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_17_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13955_ net622 net334 net478 net631 VGND VGND VPWR VPWR _06310_ sky130_fd_sc_hd__a22o_1
XFILLER_0_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12906_ _05158_ _05162_ VGND VGND VPWR VPWR _05163_ sky130_fd_sc_hd__xnor2_1
X_13886_ net584 net578 net394 net385 VGND VGND VPWR VPWR _06235_ sky130_fd_sc_hd__nand4_1
X_12837_ _05030_ _05044_ _05087_ VGND VGND VPWR VPWR _05089_ sky130_fd_sc_hd__and3_1
XFILLER_0_69_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12768_ net465 net238 VGND VGND VPWR VPWR _05014_ sky130_fd_sc_hd__and2b_1
X_11719_ _03867_ _03872_ VGND VGND VPWR VPWR _03873_ sky130_fd_sc_hd__xnor2_1
X_12699_ _04937_ _04938_ VGND VGND VPWR VPWR _04939_ sky130_fd_sc_hd__or2_1
XFILLER_0_83_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14507_ _06779_ _06849_ VGND VGND VPWR VPWR _06910_ sky130_fd_sc_hd__or2_1
Xinput10 alpha[1] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_116_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput21 beta[11] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
X_14438_ _06830_ _06833_ VGND VGND VPWR VPWR _06835_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput43 cos[15] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__buf_1
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput32 beta[5] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_4
Xinput54 cos[9] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_1
XFILLER_0_24_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput65 sin[1] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__buf_1
XFILLER_0_52_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14369_ _06757_ _06758_ VGND VGND VPWR VPWR _06760_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08930_ _00791_ _00913_ _00792_ _00854_ VGND VGND VPWR VPWR _00973_ sky130_fd_sc_hd__or4b_1
XFILLER_0_110_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08861_ _00888_ _00904_ VGND VGND VPWR VPWR _00905_ sky130_fd_sc_hd__xor2_1
X_07812_ _06353_ _06570_ _06592_ _06777_ _07026_ VGND VGND VPWR VPWR _07036_ sky130_fd_sc_hd__o221ai_2
X_08792_ _00767_ _00773_ VGND VGND VPWR VPWR _00837_ sky130_fd_sc_hd__and2b_1
X_07743_ _05874_ _05961_ _06276_ _06255_ VGND VGND VPWR VPWR _06287_ sky130_fd_sc_hd__o211a_1
XFILLER_0_74_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07674_ net218 net538 VGND VGND VPWR VPWR _05534_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09413_ _01396_ _01397_ _01398_ VGND VGND VPWR VPWR _01414_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_87_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09344_ a_sin\[13\] VGND VGND VPWR VPWR _01350_ sky130_fd_sc_hd__inv_2
XFILLER_0_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09275_ net105 _01290_ net128 VGND VGND VPWR VPWR _01291_ sky130_fd_sc_hd__mux2_1
X_08226_ _00195_ _00196_ _00197_ VGND VGND VPWR VPWR _00278_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_105_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08157_ _00207_ _00208_ _00199_ VGND VGND VPWR VPWR _00210_ sky130_fd_sc_hd__a21o_1
XFILLER_0_105_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08088_ _07306_ _07294_ VGND VGND VPWR VPWR _00141_ sky130_fd_sc_hd__or2b_1
XFILLER_0_30_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10050_ _02051_ _02052_ _02033_ VGND VGND VPWR VPWR _02054_ sky130_fd_sc_hd__a21o_1
X_10952_ _03033_ _03034_ VGND VGND VPWR VPWR _03035_ sky130_fd_sc_hd__nand2_1
X_13740_ _06016_ _06074_ _06075_ VGND VGND VPWR VPWR _06076_ sky130_fd_sc_hd__or3_1
XFILLER_0_128_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10883_ _02954_ _02959_ VGND VGND VPWR VPWR _02960_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13671_ _05937_ _05938_ _05940_ VGND VGND VPWR VPWR _06000_ sky130_fd_sc_hd__o21ba_1
X_12622_ _04816_ VGND VGND VPWR VPWR _04855_ sky130_fd_sc_hd__inv_2
X_12553_ a_sin\[10\] _04780_ _04160_ VGND VGND VPWR VPWR _04781_ sky130_fd_sc_hd__mux2_1
XFILLER_0_54_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11504_ _03634_ _03635_ _03636_ VGND VGND VPWR VPWR _03637_ sky130_fd_sc_hd__nand3_1
XFILLER_0_124_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12484_ _04669_ _04684_ VGND VGND VPWR VPWR _04705_ sky130_fd_sc_hd__nand2_1
X_14223_ _06599_ _06600_ VGND VGND VPWR VPWR _06601_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11435_ _03557_ _03559_ _03520_ _03560_ VGND VGND VPWR VPWR _03562_ sky130_fd_sc_hd__a22o_1
XFILLER_0_110_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11366_ _03477_ _03475_ VGND VGND VPWR VPWR _03486_ sky130_fd_sc_hd__nand2_1
XFILLER_0_104_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_60_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14154_ _06422_ _06426_ VGND VGND VPWR VPWR _06526_ sky130_fd_sc_hd__nand2_1
X_11297_ net305 net227 net694 net703 VGND VGND VPWR VPWR _03410_ sky130_fd_sc_hd__and4_1
X_10317_ _02335_ _02343_ _02344_ VGND VGND VPWR VPWR _02345_ sky130_fd_sc_hd__and3_1
X_13105_ _05377_ _05378_ _05362_ VGND VGND VPWR VPWR _05381_ sky130_fd_sc_hd__a21o_1
X_14085_ _06375_ _06450_ VGND VGND VPWR VPWR _06452_ sky130_fd_sc_hd__xnor2_1
X_10248_ _02268_ _02269_ VGND VGND VPWR VPWR _02270_ sky130_fd_sc_hd__nor2_1
X_13036_ _05301_ _05302_ _05297_ VGND VGND VPWR VPWR _05305_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10179_ _02174_ _02193_ _02194_ VGND VGND VPWR VPWR _02195_ sky130_fd_sc_hd__and3_1
XFILLER_0_135_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13938_ _06284_ _06290_ VGND VGND VPWR VPWR _06291_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_88_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13869_ _06206_ _06214_ _06215_ VGND VGND VPWR VPWR _06216_ sky130_fd_sc_hd__and3_1
XFILLER_0_29_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07390_ net174 net531 net538 net164 VGND VGND VPWR VPWR _02440_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_91_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09060_ net258 net590 _01041_ _01039_ VGND VGND VPWR VPWR _01100_ sky130_fd_sc_hd__a31o_1
XFILLER_0_72_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08011_ _07303_ _07304_ VGND VGND VPWR VPWR _07305_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09962_ _01946_ _01960_ _01961_ VGND VGND VPWR VPWR _01962_ sky130_fd_sc_hd__nand3_2
XFILLER_0_40_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08913_ _00952_ _00955_ VGND VGND VPWR VPWR _00956_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09893_ net740 net399 _01893_ _01891_ VGND VGND VPWR VPWR _01894_ sky130_fd_sc_hd__a31o_1
XFILLER_0_85_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08844_ _00836_ _00839_ VGND VGND VPWR VPWR _00888_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_108_Left_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08775_ _00613_ _00819_ VGND VGND VPWR VPWR _00820_ sky130_fd_sc_hd__xnor2_1
X_07726_ _06070_ _06081_ _06091_ VGND VGND VPWR VPWR _06102_ sky130_fd_sc_hd__a21bo_1
X_07657_ _05107_ _05129_ VGND VGND VPWR VPWR _05347_ sky130_fd_sc_hd__xnor2_2
X_07588_ net175 net548 net566 net164 VGND VGND VPWR VPWR _04598_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_48_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09327_ a_sin\[12\] b_cos\[12\] VGND VGND VPWR VPWR _01335_ sky130_fd_sc_hd__and2b_1
XFILLER_0_63_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_117_Left_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09258_ _01274_ _01275_ VGND VGND VPWR VPWR _01276_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_51_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08209_ net257 net533 VGND VGND VPWR VPWR _00261_ sky130_fd_sc_hd__nand2_1
X_09189_ _01216_ _01217_ VGND VGND VPWR VPWR _01218_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_62_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11220_ _03315_ _03316_ _03322_ VGND VGND VPWR VPWR _03325_ sky130_fd_sc_hd__a21o_1
XFILLER_0_121_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11151_ _00919_ _03246_ _03248_ _03249_ VGND VGND VPWR VPWR _00072_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_31_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10102_ _02107_ _02109_ _02008_ _02010_ VGND VGND VPWR VPWR _02111_ sky130_fd_sc_hd__o211a_1
X_11082_ _03164_ _03121_ _03174_ VGND VGND VPWR VPWR _03175_ sky130_fd_sc_hd__nor3_1
X_10033_ net184 net403 net396 net270 VGND VGND VPWR VPWR _02036_ sky130_fd_sc_hd__a22o_1
X_11984_ _04161_ VGND VGND VPWR VPWR _00076_ sky130_fd_sc_hd__clkbuf_1
X_14772_ clknet_3_0_0_clk _00073_ net315 VGND VGND VPWR VPWR a_sin\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_129_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10935_ _03014_ _03015_ VGND VGND VPWR VPWR _03017_ sky130_fd_sc_hd__xor2_1
X_13723_ net578 _01897_ _02182_ _06055_ VGND VGND VPWR VPWR _06057_ sky130_fd_sc_hd__a31o_1
X_10866_ _02938_ _02941_ VGND VGND VPWR VPWR _02942_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_14_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13654_ _05879_ _05881_ net116 _05981_ VGND VGND VPWR VPWR _05982_ sky130_fd_sc_hd__a211o_1
X_12605_ _04817_ _04836_ VGND VGND VPWR VPWR _04838_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10797_ net134 net336 net481 net142 VGND VGND VPWR VPWR _02867_ sky130_fd_sc_hd__a22o_1
X_13585_ _05901_ _05904_ _05905_ VGND VGND VPWR VPWR _05907_ sky130_fd_sc_hd__and3_1
XFILLER_0_26_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12536_ _04670_ _04676_ VGND VGND VPWR VPWR _04763_ sky130_fd_sc_hd__and2b_1
X_12467_ _04666_ _04667_ _04687_ VGND VGND VPWR VPWR _04688_ sky130_fd_sc_hd__or3_4
XFILLER_0_53_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11418_ _03525_ _03534_ _03536_ _03538_ _03542_ VGND VGND VPWR VPWR _03543_ sky130_fd_sc_hd__o32a_1
XFILLER_0_1_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14206_ _06517_ _06582_ VGND VGND VPWR VPWR _06583_ sky130_fd_sc_hd__xnor2_1
X_12398_ _04611_ _04612_ VGND VGND VPWR VPWR _04613_ sky130_fd_sc_hd__or2_1
X_14137_ _06412_ _06414_ _06506_ _06507_ VGND VGND VPWR VPWR _06508_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_120_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11349_ _03463_ _03466_ VGND VGND VPWR VPWR _03467_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14068_ _06431_ _06432_ VGND VGND VPWR VPWR _06433_ sky130_fd_sc_hd__nor2_1
X_13019_ net544 net329 net474 net563 VGND VGND VPWR VPWR _05286_ sky130_fd_sc_hd__a22oi_1
X_08560_ _00592_ _00593_ _00606_ VGND VGND VPWR VPWR _00608_ sky130_fd_sc_hd__and3_1
XFILLER_0_89_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08491_ net171 net599 net589 net181 VGND VGND VPWR VPWR _00540_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_89_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07511_ _03748_ VGND VGND VPWR VPWR _03759_ sky130_fd_sc_hd__inv_2
X_07442_ _02962_ _02994_ VGND VGND VPWR VPWR _03005_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_92_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07373_ net308 net229 net624 net633 VGND VGND VPWR VPWR _02255_ sky130_fd_sc_hd__nand4_2
XFILLER_0_18_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09112_ _01086_ _01090_ _01150_ VGND VGND VPWR VPWR _01151_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_45_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09043_ next_state _01080_ _01082_ _01083_ VGND VGND VPWR VPWR _00015_ sky130_fd_sc_hd__a31o_1
XFILLER_0_5_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_111_Right_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09945_ _01609_ _01616_ VGND VGND VPWR VPWR _01945_ sky130_fd_sc_hd__and2_1
X_09876_ _01876_ VGND VGND VPWR VPWR _01877_ sky130_fd_sc_hd__inv_2
X_08827_ net258 net618 VGND VGND VPWR VPWR _00871_ sky130_fd_sc_hd__nand2_1
X_08758_ _00801_ _00802_ VGND VGND VPWR VPWR _00803_ sky130_fd_sc_hd__nor2_1
XFILLER_0_95_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08689_ _00733_ _00734_ VGND VGND VPWR VPWR _00735_ sky130_fd_sc_hd__nor2_1
X_07709_ _05797_ _05874_ _05435_ net751 VGND VGND VPWR VPWR _05917_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_68_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10720_ net186 net142 net336 net481 VGND VGND VPWR VPWR _02783_ sky130_fd_sc_hd__and4_1
XFILLER_0_137_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10651_ _02649_ _02651_ _02707_ VGND VGND VPWR VPWR _02708_ sky130_fd_sc_hd__o21ai_1
X_10582_ _02631_ _02632_ VGND VGND VPWR VPWR _02633_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13370_ _05654_ _05670_ _05671_ VGND VGND VPWR VPWR _05672_ sky130_fd_sc_hd__a21oi_1
X_12321_ _04527_ _04528_ VGND VGND VPWR VPWR _04529_ sky130_fd_sc_hd__nand2_1
XFILLER_0_90_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12252_ _04375_ _04378_ _04376_ VGND VGND VPWR VPWR _04453_ sky130_fd_sc_hd__o21ba_1
X_11203_ _03263_ _03266_ VGND VGND VPWR VPWR _03306_ sky130_fd_sc_hd__xnor2_1
X_12183_ net687 net257 VGND VGND VPWR VPWR _04378_ sky130_fd_sc_hd__nand2_1
X_11134_ _03229_ _03230_ VGND VGND VPWR VPWR _03231_ sky130_fd_sc_hd__xnor2_1
X_11065_ _03155_ _03156_ VGND VGND VPWR VPWR _03158_ sky130_fd_sc_hd__nor2_1
X_10016_ _02016_ _02018_ VGND VGND VPWR VPWR _02019_ sky130_fd_sc_hd__or2b_1
XFILLER_0_92_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11967_ _04140_ _04142_ _04110_ VGND VGND VPWR VPWR _04144_ sky130_fd_sc_hd__a21o_1
XFILLER_0_98_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14755_ clknet_3_0_0_clk _00056_ net315 VGND VGND VPWR VPWR a_cos\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_59_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10918_ net472 _02996_ _02997_ VGND VGND VPWR VPWR _02998_ sky130_fd_sc_hd__a21boi_1
X_13706_ _06017_ _06038_ VGND VGND VPWR VPWR _06039_ sky130_fd_sc_hd__xor2_1
XFILLER_0_128_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11898_ _04000_ _04002_ VGND VGND VPWR VPWR _04068_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14686_ _07098_ _07102_ VGND VGND VPWR VPWR _07103_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_132_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10849_ _02642_ _02849_ VGND VGND VPWR VPWR _02923_ sky130_fd_sc_hd__nand2_2
XFILLER_0_6_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13637_ _05835_ _05837_ VGND VGND VPWR VPWR _05964_ sky130_fd_sc_hd__nand2_1
XFILLER_0_109_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13568_ _05886_ _05887_ _05796_ _05798_ VGND VGND VPWR VPWR _05889_ sky130_fd_sc_hd__a211oi_1
X_12519_ _04742_ _04730_ _04731_ VGND VGND VPWR VPWR _04744_ sky130_fd_sc_hd__or3_2
XFILLER_0_109_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13499_ _05739_ _05741_ _05811_ VGND VGND VPWR VPWR _05813_ sky130_fd_sc_hd__and3_1
XFILLER_0_124_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout208 net209 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__buf_4
Xfanout219 net220 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__buf_4
X_07991_ net115 _07206_ _07284_ _07285_ VGND VGND VPWR VPWR _07286_ sky130_fd_sc_hd__o211a_1
XFILLER_0_10_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09730_ _01728_ _01730_ VGND VGND VPWR VPWR _01731_ sky130_fd_sc_hd__or2b_1
XFILLER_0_66_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09661_ _01660_ _01661_ VGND VGND VPWR VPWR _01662_ sky130_fd_sc_hd__or2_1
XFILLER_0_96_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08612_ _00657_ _00658_ VGND VGND VPWR VPWR _00659_ sky130_fd_sc_hd__nor2_1
X_09592_ _01587_ _01588_ _01591_ VGND VGND VPWR VPWR _01593_ sky130_fd_sc_hd__a21oi_1
X_08543_ _00530_ _00549_ VGND VGND VPWR VPWR _00591_ sky130_fd_sc_hd__or2b_1
XFILLER_0_82_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08474_ _00519_ _00520_ _00521_ VGND VGND VPWR VPWR _00523_ sky130_fd_sc_hd__a21o_1
XFILLER_0_65_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07425_ _02799_ _02810_ VGND VGND VPWR VPWR _02821_ sky130_fd_sc_hd__and2b_1
XFILLER_0_92_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07356_ net308 net633 net768 net229 VGND VGND VPWR VPWR _02070_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_9_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09026_ _01065_ _01066_ VGND VGND VPWR VPWR _01067_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout731 net732 VGND VGND VPWR VPWR net731 sky130_fd_sc_hd__clkbuf_4
Xfanout720 net721 VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__buf_2
Xfanout742 net1 VGND VGND VPWR VPWR net742 sky130_fd_sc_hd__clkbuf_4
X_09928_ _01587_ _01662_ _01927_ _01589_ VGND VGND VPWR VPWR _01928_ sky130_fd_sc_hd__a211oi_2
X_09859_ _01858_ _01859_ VGND VGND VPWR VPWR _01860_ sky130_fd_sc_hd__nand2_1
X_12870_ _05114_ _05068_ _05122_ VGND VGND VPWR VPWR _05124_ sky130_fd_sc_hd__nor3_1
XFILLER_0_99_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11821_ net696 net290 net282 net705 VGND VGND VPWR VPWR _03984_ sky130_fd_sc_hd__a22oi_2
X_14540_ net623 net417 VGND VGND VPWR VPWR _06945_ sky130_fd_sc_hd__and2b_1
X_11752_ net652 net178 net168 net669 VGND VGND VPWR VPWR _03909_ sky130_fd_sc_hd__a22o_1
X_11683_ _03831_ _03832_ _03830_ VGND VGND VPWR VPWR _03834_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_126_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10703_ _02755_ VGND VGND VPWR VPWR _02764_ sky130_fd_sc_hd__inv_2
X_14471_ _06868_ _06869_ VGND VGND VPWR VPWR _06870_ sky130_fd_sc_hd__and2_1
X_10634_ net463 net554 net455 net447 VGND VGND VPWR VPWR _02689_ sky130_fd_sc_hd__and4_1
X_13422_ _05727_ _05728_ VGND VGND VPWR VPWR _05729_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_141_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13353_ _05635_ _05652_ VGND VGND VPWR VPWR _05653_ sky130_fd_sc_hd__nand2_1
X_12304_ _04504_ _04509_ VGND VGND VPWR VPWR _04510_ sky130_fd_sc_hd__xor2_1
X_10565_ _02612_ _02613_ VGND VGND VPWR VPWR _02615_ sky130_fd_sc_hd__or2b_1
XFILLER_0_23_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10496_ net554 net471 _02537_ _02539_ VGND VGND VPWR VPWR _02540_ sky130_fd_sc_hd__a22o_1
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13284_ _05569_ _05575_ _05576_ VGND VGND VPWR VPWR _05577_ sky130_fd_sc_hd__or3b_1
X_12235_ _04346_ _04348_ _04433_ VGND VGND VPWR VPWR _04436_ sky130_fd_sc_hd__or3_1
XFILLER_0_20_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12166_ net714 net235 VGND VGND VPWR VPWR _04360_ sky130_fd_sc_hd__and2b_1
X_11117_ _03155_ _03159_ _03212_ VGND VGND VPWR VPWR _03214_ sky130_fd_sc_hd__or3_1
X_12097_ _04280_ _04281_ _04283_ VGND VGND VPWR VPWR _04285_ sky130_fd_sc_hd__nand3_1
X_11048_ _03137_ _03138_ VGND VGND VPWR VPWR _03139_ sky130_fd_sc_hd__nor2_1
Xinput8 alpha[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_99_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14807_ clknet_3_4_0_clk _00108_ net322 VGND VGND VPWR VPWR b_cos\[17\] sky130_fd_sc_hd__dfrtp_1
X_12999_ _05262_ _05263_ VGND VGND VPWR VPWR _05264_ sky130_fd_sc_hd__nor2_1
XFILLER_0_129_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14738_ clknet_3_1_0_clk _00039_ net317 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_117_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14669_ _06789_ _07039_ _07030_ VGND VGND VPWR VPWR _07084_ sky130_fd_sc_hd__a21o_1
X_08190_ _00166_ _00169_ _00167_ VGND VGND VPWR VPWR _00242_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_55_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07974_ _07172_ _07180_ _07179_ VGND VGND VPWR VPWR _07269_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09713_ _01530_ _01713_ VGND VGND VPWR VPWR _01714_ sky130_fd_sc_hd__and2_1
X_09644_ _01642_ _01643_ _01644_ VGND VGND VPWR VPWR _01645_ sky130_fd_sc_hd__nand3_1
XFILLER_0_117_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09575_ net727 net451 net443 net735 VGND VGND VPWR VPWR _01576_ sky130_fd_sc_hd__a22oi_2
X_08526_ net249 net509 net517 net241 VGND VGND VPWR VPWR _00574_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_77_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08457_ _00502_ _00505_ VGND VGND VPWR VPWR _00506_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_65_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07408_ _02603_ _02614_ _02592_ VGND VGND VPWR VPWR _02636_ sky130_fd_sc_hd__a21o_1
XFILLER_0_9_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08388_ _00434_ _00435_ _00436_ VGND VGND VPWR VPWR _00438_ sky130_fd_sc_hd__a21o_1
XFILLER_0_80_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10350_ _02378_ _02380_ VGND VGND VPWR VPWR _02381_ sky130_fd_sc_hd__xor2_2
X_09009_ _01037_ _00996_ _00862_ VGND VGND VPWR VPWR _01050_ sky130_fd_sc_hd__o21ba_1
X_10281_ _02219_ _02236_ VGND VGND VPWR VPWR _02305_ sky130_fd_sc_hd__nand2_1
X_12020_ _04197_ _04198_ _04199_ VGND VGND VPWR VPWR _04201_ sky130_fd_sc_hd__a21o_1
Xfanout550 net551 VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__clkbuf_2
Xfanout583 net27 VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__buf_2
Xfanout572 net28 VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__clkbuf_4
Xfanout561 net563 VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__buf_2
X_13971_ net594 net361 net351 net603 VGND VGND VPWR VPWR _06327_ sky130_fd_sc_hd__a22o_1
X_12922_ _05088_ _05095_ _05143_ _05149_ _05179_ VGND VGND VPWR VPWR _05180_ sky130_fd_sc_hd__o311a_1
Xfanout594 net601 VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_69_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12853_ _05103_ _05104_ VGND VGND VPWR VPWR _05105_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11804_ _03886_ _03887_ VGND VGND VPWR VPWR _03965_ sky130_fd_sc_hd__nor2_1
X_12784_ _05029_ _05030_ VGND VGND VPWR VPWR _05031_ sky130_fd_sc_hd__and2b_1
XFILLER_0_84_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11735_ net687 net150 net297 net696 VGND VGND VPWR VPWR _03891_ sky130_fd_sc_hd__a22oi_2
X_14523_ net586 _06924_ _06925_ VGND VGND VPWR VPWR _06926_ sky130_fd_sc_hd__a21oi_1
X_14454_ b_cos\[12\] _06851_ _02017_ VGND VGND VPWR VPWR _06852_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11666_ net669 net178 net168 net678 VGND VGND VPWR VPWR _03816_ sky130_fd_sc_hd__a22o_1
XFILLER_0_36_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13405_ _05582_ _05707_ _05708_ _05704_ _05709_ VGND VGND VPWR VPWR _05711_ sky130_fd_sc_hd__a221o_1
X_11597_ _03653_ _03658_ VGND VGND VPWR VPWR _03740_ sky130_fd_sc_hd__or2b_1
XFILLER_0_98_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10617_ _02668_ _02670_ _02590_ _02591_ VGND VGND VPWR VPWR _02672_ sky130_fd_sc_hd__o211a_1
XFILLER_0_51_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14385_ _06774_ _06775_ _06700_ _06703_ VGND VGND VPWR VPWR _06778_ sky130_fd_sc_hd__o211a_1
XFILLER_0_106_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10548_ _02547_ _02550_ VGND VGND VPWR VPWR _02596_ sky130_fd_sc_hd__nand2_1
X_13336_ _05629_ _05631_ _05634_ VGND VGND VPWR VPWR _05635_ sky130_fd_sc_hd__or3b_4
XFILLER_0_122_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13267_ _05540_ _05557_ _05555_ VGND VGND VPWR VPWR _05559_ sky130_fd_sc_hd__a21oi_1
X_12218_ _04412_ _04414_ _04415_ VGND VGND VPWR VPWR _04417_ sky130_fd_sc_hd__a21o_1
X_10479_ _02518_ _02519_ VGND VGND VPWR VPWR _02521_ sky130_fd_sc_hd__and2_1
XFILLER_0_20_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13198_ _05429_ _05430_ _05480_ _05482_ VGND VGND VPWR VPWR _05483_ sky130_fd_sc_hd__and4_1
X_12149_ _04155_ _04242_ _04244_ VGND VGND VPWR VPWR _04342_ sky130_fd_sc_hd__a21o_1
X_07690_ net174 net164 net573 net660 VGND VGND VPWR VPWR _05710_ sky130_fd_sc_hd__and4_1
XFILLER_0_78_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09360_ _01356_ _01360_ _01362_ VGND VGND VPWR VPWR _01364_ sky130_fd_sc_hd__or3_1
X_08311_ _00354_ _00360_ _00361_ VGND VGND VPWR VPWR _00362_ sky130_fd_sc_hd__and3_1
X_09291_ b_cos\[7\] a_sin\[7\] VGND VGND VPWR VPWR _01304_ sky130_fd_sc_hd__or2b_1
XFILLER_0_129_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08242_ net222 _00202_ _00292_ _00293_ VGND VGND VPWR VPWR _00294_ sky130_fd_sc_hd__a31oi_2
XANTENNA_13 net440 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_35 net5 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_43_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_24 net32 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_103_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08173_ _00141_ _00142_ _00224_ _00225_ VGND VGND VPWR VPWR _00226_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_7_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07957_ _07250_ _07251_ VGND VGND VPWR VPWR _07252_ sky130_fd_sc_hd__and2b_1
X_07888_ _07181_ _07182_ _07183_ VGND VGND VPWR VPWR _07184_ sky130_fd_sc_hd__nand3_4
XFILLER_0_97_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09627_ _01625_ _01626_ _01627_ VGND VGND VPWR VPWR _01628_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_78_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09558_ _01551_ _01558_ VGND VGND VPWR VPWR _01559_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_136_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08509_ _00478_ _00405_ VGND VGND VPWR VPWR _00558_ sky130_fd_sc_hd__and2b_1
XFILLER_0_78_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11520_ net178 net167 net685 net695 VGND VGND VPWR VPWR _03655_ sky130_fd_sc_hd__and4_1
XFILLER_0_108_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09489_ _01487_ _01488_ _01473_ VGND VGND VPWR VPWR _01490_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11451_ _03573_ _03577_ _03578_ VGND VGND VPWR VPWR _03579_ sky130_fd_sc_hd__nand3_1
XFILLER_0_136_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11382_ _03485_ _03501_ _03502_ VGND VGND VPWR VPWR _03503_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_61_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10402_ _02435_ _02436_ VGND VGND VPWR VPWR _02437_ sky130_fd_sc_hd__xnor2_1
X_14170_ _06541_ _06542_ _06539_ _06540_ VGND VGND VPWR VPWR _06544_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_33_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13121_ _05317_ _05322_ VGND VGND VPWR VPWR _05398_ sky130_fd_sc_hd__or2b_1
X_10333_ net133 net393 net384 net139 VGND VGND VPWR VPWR _02362_ sky130_fd_sc_hd__a22o_1
XFILLER_0_104_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10264_ _02174_ _02194_ _02193_ VGND VGND VPWR VPWR _02287_ sky130_fd_sc_hd__a21boi_2
X_13052_ _05318_ _05321_ VGND VGND VPWR VPWR _05322_ sky130_fd_sc_hd__xnor2_1
X_12003_ _04165_ _04181_ VGND VGND VPWR VPWR _04182_ sky130_fd_sc_hd__xnor2_1
X_10195_ _02210_ _02211_ VGND VGND VPWR VPWR _02213_ sky130_fd_sc_hd__nor2_1
Xfanout391 net392 VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__clkbuf_4
Xfanout380 net49 VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__clkbuf_4
X_13954_ _06306_ _06307_ VGND VGND VPWR VPWR _06308_ sky130_fd_sc_hd__xnor2_1
X_12905_ _05159_ _05160_ VGND VGND VPWR VPWR _05162_ sky130_fd_sc_hd__xnor2_1
X_13885_ net578 net394 net385 net584 VGND VGND VPWR VPWR _06234_ sky130_fd_sc_hd__a22o_1
XFILLER_0_124_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12836_ _05030_ _05044_ _05087_ VGND VGND VPWR VPWR _05088_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_139_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12767_ _05011_ _05012_ VGND VGND VPWR VPWR _05013_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14506_ _06906_ _06908_ VGND VGND VPWR VPWR _06909_ sky130_fd_sc_hd__xor2_1
XFILLER_0_126_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11718_ _03869_ _03871_ VGND VGND VPWR VPWR _03872_ sky130_fd_sc_hd__nand2_1
X_12698_ _04859_ _04881_ _04856_ VGND VGND VPWR VPWR _04938_ sky130_fd_sc_hd__a21o_1
XFILLER_0_84_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11649_ _03795_ _03796_ VGND VGND VPWR VPWR _03797_ sky130_fd_sc_hd__xnor2_1
Xinput11 alpha[2] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_2
XFILLER_0_71_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput22 beta[12] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
X_14437_ _06830_ _06833_ VGND VGND VPWR VPWR _06834_ sky130_fd_sc_hd__or2_1
XFILLER_0_142_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput55 rstb VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_1
X_14368_ _06757_ _06758_ VGND VGND VPWR VPWR _06759_ sky130_fd_sc_hd__nor2_1
Xinput44 cos[16] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_2
Xinput33 beta[6] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__buf_1
Xinput66 sin[2] VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13319_ _05601_ _05603_ _05602_ VGND VGND VPWR VPWR _05616_ sky130_fd_sc_hd__or3_1
X_14299_ _06682_ _06683_ VGND VGND VPWR VPWR _06684_ sky130_fd_sc_hd__xor2_1
XFILLER_0_0_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08860_ _00889_ _00903_ VGND VGND VPWR VPWR _00904_ sky130_fd_sc_hd__xnor2_1
X_07811_ _06787_ _06798_ _07015_ _06777_ _06592_ VGND VGND VPWR VPWR _07026_ sky130_fd_sc_hd__a32o_1
X_08791_ _00834_ _00835_ VGND VGND VPWR VPWR _00836_ sky130_fd_sc_hd__xor2_1
X_07742_ _06026_ _06255_ _06266_ VGND VGND VPWR VPWR _06276_ sky130_fd_sc_hd__nand3_2
XFILLER_0_74_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07673_ _05237_ _05226_ _05215_ VGND VGND VPWR VPWR _05523_ sky130_fd_sc_hd__a21o_1
XFILLER_0_66_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09412_ _01410_ _01411_ _01412_ VGND VGND VPWR VPWR _01413_ sky130_fd_sc_hd__or3_1
XFILLER_0_48_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09343_ _01347_ _01348_ VGND VGND VPWR VPWR _01349_ sky130_fd_sc_hd__nand2_1
XFILLER_0_118_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09274_ _01288_ _01289_ VGND VGND VPWR VPWR _01290_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_117_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08225_ _00188_ _00190_ VGND VGND VPWR VPWR _00277_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08156_ _00199_ _00207_ _00208_ VGND VGND VPWR VPWR _00209_ sky130_fd_sc_hd__nand3_1
XFILLER_0_16_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08087_ _00140_ VGND VGND VPWR VPWR _00002_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08989_ _00981_ _00982_ _01029_ VGND VGND VPWR VPWR _01031_ sky130_fd_sc_hd__nand3_2
X_10951_ _03009_ _03032_ VGND VGND VPWR VPWR _03034_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13670_ _05954_ _05956_ VGND VGND VPWR VPWR _05999_ sky130_fd_sc_hd__nand2_1
X_12621_ _04817_ _04836_ VGND VGND VPWR VPWR _04854_ sky130_fd_sc_hd__or2_1
XFILLER_0_85_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10882_ _02957_ _02958_ VGND VGND VPWR VPWR _02959_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_125_Right_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12552_ _04703_ _04779_ VGND VGND VPWR VPWR _04780_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_81_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11503_ net309 net375 net461 net230 VGND VGND VPWR VPWR _03636_ sky130_fd_sc_hd__a22o_1
X_12483_ _04690_ VGND VGND VPWR VPWR _04704_ sky130_fd_sc_hd__inv_2
XFILLER_0_109_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11434_ _03450_ _03554_ _03553_ _03552_ VGND VGND VPWR VPWR _03560_ sky130_fd_sc_hd__o211a_1
X_14222_ net495 net505 net428 net420 VGND VGND VPWR VPWR _06600_ sky130_fd_sc_hd__and4_1
XFILLER_0_123_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11365_ net209 net200 net737 net743 VGND VGND VPWR VPWR _03485_ sky130_fd_sc_hd__and4_1
XFILLER_0_21_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14153_ _06514_ _06524_ VGND VGND VPWR VPWR _06525_ sky130_fd_sc_hd__xnor2_1
X_11296_ net305 net694 net703 net227 VGND VGND VPWR VPWR _03409_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_95_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10316_ _02339_ _02340_ _02341_ VGND VGND VPWR VPWR _02344_ sky130_fd_sc_hd__a21o_1
X_13104_ _05362_ _05377_ _05378_ VGND VGND VPWR VPWR _05379_ sky130_fd_sc_hd__nand3_4
X_14084_ _06447_ _06449_ VGND VGND VPWR VPWR _06450_ sky130_fd_sc_hd__xnor2_1
X_10247_ _02265_ _02267_ _02262_ VGND VGND VPWR VPWR _02269_ sky130_fd_sc_hd__a21oi_1
X_13035_ _05297_ _05301_ _05302_ VGND VGND VPWR VPWR _05304_ sky130_fd_sc_hd__nand3_1
X_10178_ _02189_ _02191_ _02192_ VGND VGND VPWR VPWR _02194_ sky130_fd_sc_hd__a21o_1
X_13937_ _06288_ _06289_ VGND VGND VPWR VPWR _06290_ sky130_fd_sc_hd__xor2_1
XFILLER_0_44_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13868_ _06210_ _06212_ _06213_ VGND VGND VPWR VPWR _06215_ sky130_fd_sc_hd__a21o_1
X_12819_ _05067_ _05068_ VGND VGND VPWR VPWR _05069_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13799_ net630 net343 _06138_ _06139_ VGND VGND VPWR VPWR _06140_ sky130_fd_sc_hd__a22o_1
XFILLER_0_127_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08010_ _07208_ _07209_ _07211_ VGND VGND VPWR VPWR _07304_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_60_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09961_ _01958_ _01959_ _01951_ VGND VGND VPWR VPWR _01961_ sky130_fd_sc_hd__a21o_1
X_08912_ _00953_ _00954_ VGND VGND VPWR VPWR _00955_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09892_ _01891_ _01892_ VGND VGND VPWR VPWR _01893_ sky130_fd_sc_hd__nor2_1
X_08843_ _00885_ _00886_ VGND VGND VPWR VPWR _00887_ sky130_fd_sc_hd__xnor2_1
X_08774_ _00753_ _00818_ VGND VGND VPWR VPWR _00819_ sky130_fd_sc_hd__xor2_2
X_07725_ net304 net225 net531 net538 VGND VGND VPWR VPWR _06091_ sky130_fd_sc_hd__nand4_1
XFILLER_0_95_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07656_ _05183_ _05314_ _05303_ VGND VGND VPWR VPWR _05336_ sky130_fd_sc_hd__a21o_1
XFILLER_0_94_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07587_ net175 net164 net548 net566 VGND VGND VPWR VPWR _04587_ sky130_fd_sc_hd__and4_1
XFILLER_0_75_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09326_ _01334_ VGND VGND VPWR VPWR _00047_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09257_ b_cos\[2\] a_sin\[2\] VGND VGND VPWR VPWR _01275_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08208_ net516 _00258_ _00259_ VGND VGND VPWR VPWR _00260_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_121_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09188_ _01208_ _01211_ _01209_ VGND VGND VPWR VPWR _01217_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_50_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08139_ _00189_ _00190_ _00186_ VGND VGND VPWR VPWR _00192_ sky130_fd_sc_hd__a21o_1
X_11150_ net779 _07291_ VGND VGND VPWR VPWR _03249_ sky130_fd_sc_hd__nand2_1
X_10101_ _02008_ _02010_ _02107_ _02109_ VGND VGND VPWR VPWR _02110_ sky130_fd_sc_hd__a211o_1
X_11081_ _02924_ _03173_ VGND VGND VPWR VPWR _03174_ sky130_fd_sc_hd__xor2_1
X_10032_ net184 net270 net403 VGND VGND VPWR VPWR _02035_ sky130_fd_sc_hd__and3_1
XFILLER_0_98_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14771_ clknet_3_5_0_clk _00072_ net324 VGND VGND VPWR VPWR a_cos\[17\] sky130_fd_sc_hd__dfrtp_1
X_11983_ a_sin\[3\] _04159_ _04160_ VGND VGND VPWR VPWR _04161_ sky130_fd_sc_hd__mux2_1
X_13722_ net578 _01897_ _02182_ _06055_ VGND VGND VPWR VPWR _06056_ sky130_fd_sc_hd__nand4_1
XFILLER_0_85_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10934_ net555 net418 VGND VGND VPWR VPWR _03015_ sky130_fd_sc_hd__and2b_1
XFILLER_0_85_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10865_ _02866_ _02939_ VGND VGND VPWR VPWR _02941_ sky130_fd_sc_hd__and2b_1
XFILLER_0_14_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13653_ _05962_ _05963_ _05979_ VGND VGND VPWR VPWR _05981_ sky130_fd_sc_hd__o21ba_1
X_12604_ _04834_ _04835_ VGND VGND VPWR VPWR _04836_ sky130_fd_sc_hd__nand2_1
XFILLER_0_54_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13584_ net639 net350 _05902_ _05903_ VGND VGND VPWR VPWR _05905_ sky130_fd_sc_hd__nand4_2
X_12535_ _04759_ _04760_ VGND VGND VPWR VPWR _04762_ sky130_fd_sc_hd__or2_1
X_10796_ net134 net336 net481 VGND VGND VPWR VPWR _02866_ sky130_fd_sc_hd__and3_1
XFILLER_0_5_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12466_ _04668_ _04686_ VGND VGND VPWR VPWR _04687_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_81_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12397_ _04608_ _04610_ _04606_ _04607_ VGND VGND VPWR VPWR _04612_ sky130_fd_sc_hd__a211oi_1
X_11417_ _03499_ _03489_ _03498_ _03541_ VGND VGND VPWR VPWR _03542_ sky130_fd_sc_hd__a31o_1
X_14205_ _06579_ _06580_ VGND VGND VPWR VPWR _06582_ sky130_fd_sc_hd__xnor2_1
X_11348_ _03464_ _03465_ VGND VGND VPWR VPWR _03466_ sky130_fd_sc_hd__and2b_1
X_14136_ _06489_ _06490_ _06504_ VGND VGND VPWR VPWR _06507_ sky130_fd_sc_hd__and3_1
XFILLER_0_22_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11279_ _03388_ _03389_ VGND VGND VPWR VPWR _03390_ sky130_fd_sc_hd__nor2_1
X_14067_ net594 net585 net361 net351 VGND VGND VPWR VPWR _06432_ sky130_fd_sc_hd__and4_1
X_13018_ net544 net563 net329 net474 VGND VGND VPWR VPWR _05285_ sky130_fd_sc_hd__and4_1
X_07510_ net279 net261 net567 net575 VGND VGND VPWR VPWR _03748_ sky130_fd_sc_hd__and4_1
XFILLER_0_55_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08490_ _00456_ _00459_ VGND VGND VPWR VPWR _00539_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07441_ _02973_ _02984_ VGND VGND VPWR VPWR _02994_ sky130_fd_sc_hd__and2b_1
XFILLER_0_71_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07372_ net221 net768 VGND VGND VPWR VPWR _02244_ sky130_fd_sc_hd__and2_1
XFILLER_0_57_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09111_ _01052_ _01089_ VGND VGND VPWR VPWR _01150_ sky130_fd_sc_hd__and2_1
XFILLER_0_84_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09042_ b_sin\[15\] _07291_ VGND VGND VPWR VPWR _01083_ sky130_fd_sc_hd__and2_1
XFILLER_0_130_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09944_ _01615_ _01614_ VGND VGND VPWR VPWR _01944_ sky130_fd_sc_hd__and2b_1
XFILLER_0_110_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09875_ _01870_ _01871_ _01875_ VGND VGND VPWR VPWR _01876_ sky130_fd_sc_hd__and3_1
X_08826_ net284 net266 net598 net607 VGND VGND VPWR VPWR _00870_ sky130_fd_sc_hd__and4_1
X_08757_ net284 net266 net607 net618 VGND VGND VPWR VPWR _00802_ sky130_fd_sc_hd__and4_1
X_08688_ net284 net266 net617 net626 VGND VGND VPWR VPWR _00734_ sky130_fd_sc_hd__and4_1
X_07708_ _05490_ _05501_ _05896_ VGND VGND VPWR VPWR _05906_ sky130_fd_sc_hd__a21oi_1
X_07639_ net147 net576 net661 net295 VGND VGND VPWR VPWR _05150_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_138_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10650_ net140 _02648_ VGND VGND VPWR VPWR _02707_ sky130_fd_sc_hd__nand2_1
XFILLER_0_137_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09309_ _01318_ _01319_ VGND VGND VPWR VPWR _01320_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_75_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10581_ _02539_ _02541_ VGND VGND VPWR VPWR _02632_ sky130_fd_sc_hd__nand2_1
XFILLER_0_133_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12320_ _04447_ _04448_ _04526_ VGND VGND VPWR VPWR _04528_ sky130_fd_sc_hd__or3_1
XFILLER_0_23_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12251_ _04373_ _04394_ _04392_ VGND VGND VPWR VPWR _04452_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_106_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11202_ _03290_ _03303_ _03302_ VGND VGND VPWR VPWR _03305_ sky130_fd_sc_hd__a21o_1
X_12182_ _04375_ _04376_ VGND VGND VPWR VPWR _04377_ sky130_fd_sc_hd__nor2_1
X_11133_ net187 net418 VGND VGND VPWR VPWR _03230_ sky130_fd_sc_hd__and2b_1
X_11064_ _03097_ _03108_ _03154_ VGND VGND VPWR VPWR _03156_ sky130_fd_sc_hd__and3_1
X_10015_ _01922_ _02014_ _02012_ _01665_ _02013_ VGND VGND VPWR VPWR _02018_ sky130_fd_sc_hd__a2111o_1
X_11966_ _04110_ _04140_ _04142_ VGND VGND VPWR VPWR _04143_ sky130_fd_sc_hd__nand3_1
X_14754_ clknet_3_2_0_clk _00055_ net315 VGND VGND VPWR VPWR a_cos\[0\] sky130_fd_sc_hd__dfrtp_1
X_10917_ net134 net472 _02939_ VGND VGND VPWR VPWR _02997_ sky130_fd_sc_hd__a21o_1
X_13705_ _06035_ _06036_ VGND VGND VPWR VPWR _06038_ sky130_fd_sc_hd__and2b_1
X_14685_ _07099_ _07100_ VGND VGND VPWR VPWR _07102_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_128_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11897_ _04066_ _03971_ _03972_ _03975_ _03964_ VGND VGND VPWR VPWR _04067_ sky130_fd_sc_hd__a32o_1
X_13636_ _05959_ _05960_ _05875_ _05898_ VGND VGND VPWR VPWR _05963_ sky130_fd_sc_hd__o211a_1
XFILLER_0_132_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10848_ _02921_ VGND VGND VPWR VPWR _02922_ sky130_fd_sc_hd__buf_2
XFILLER_0_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10779_ _02644_ _02801_ _02718_ VGND VGND VPWR VPWR _02847_ sky130_fd_sc_hd__o21ai_1
X_13567_ _05796_ _05798_ _05886_ _05887_ VGND VGND VPWR VPWR _05888_ sky130_fd_sc_hd__o211a_1
XFILLER_0_136_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12518_ _04730_ _04731_ _04742_ VGND VGND VPWR VPWR _04743_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_124_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13498_ _05739_ _05741_ _05811_ VGND VGND VPWR VPWR _05812_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_140_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12449_ _04550_ _04552_ VGND VGND VPWR VPWR _04668_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_136_Left_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_120_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout209 net210 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__buf_4
X_07990_ _07282_ _07283_ _07132_ VGND VGND VPWR VPWR _07285_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14119_ _06421_ _06443_ VGND VGND VPWR VPWR _06488_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09660_ _01658_ _01659_ _01600_ VGND VGND VPWR VPWR _01661_ sky130_fd_sc_hd__a21oi_1
X_08611_ net283 net265 net626 net634 VGND VGND VPWR VPWR _00658_ sky130_fd_sc_hd__and4_1
X_09591_ _01587_ _01588_ _01591_ VGND VGND VPWR VPWR _01592_ sky130_fd_sc_hd__and3_1
X_08542_ _00547_ _00548_ VGND VGND VPWR VPWR _00590_ sky130_fd_sc_hd__or2b_1
XFILLER_0_82_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08473_ _00519_ _00520_ _00521_ VGND VGND VPWR VPWR _00522_ sky130_fd_sc_hd__nand3_2
X_07424_ net177 net515 net523 net167 VGND VGND VPWR VPWR _02810_ sky130_fd_sc_hd__a22o_1
XFILLER_0_119_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07355_ net308 net229 net633 net767 VGND VGND VPWR VPWR _02059_ sky130_fd_sc_hd__and4_1
XFILLER_0_45_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09025_ _01010_ _01015_ _01064_ VGND VGND VPWR VPWR _01066_ sky130_fd_sc_hd__or3b_1
Xfanout732 net11 VGND VGND VPWR VPWR net732 sky130_fd_sc_hd__clkbuf_2
Xfanout721 net12 VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__clkbuf_2
X_09927_ _01660_ _01661_ _01663_ VGND VGND VPWR VPWR _01927_ sky130_fd_sc_hd__nor3_2
Xfanout710 net715 VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__clkbuf_4
Xfanout743 net744 VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__buf_2
X_09858_ _01856_ _01857_ _01852_ VGND VGND VPWR VPWR _01859_ sky130_fd_sc_hd__a21o_1
X_08809_ _00852_ _00853_ VGND VGND VPWR VPWR _00854_ sky130_fd_sc_hd__xnor2_2
X_09789_ _01785_ _01789_ VGND VGND VPWR VPWR _01790_ sky130_fd_sc_hd__xnor2_1
X_11820_ net713 net262 VGND VGND VPWR VPWR _03983_ sky130_fd_sc_hd__nand2_1
X_11751_ net678 net159 VGND VGND VPWR VPWR _03908_ sky130_fd_sc_hd__nand2_1
XFILLER_0_83_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10702_ _02763_ VGND VGND VPWR VPWR _00064_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11682_ _03830_ _03831_ _03832_ VGND VGND VPWR VPWR _03833_ sky130_fd_sc_hd__or3_1
XFILLER_0_48_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14470_ _06790_ _06867_ VGND VGND VPWR VPWR _06869_ sky130_fd_sc_hd__or2_1
XFILLER_0_36_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10633_ net463 net455 net447 net554 VGND VGND VPWR VPWR _02688_ sky130_fd_sc_hd__a22oi_2
X_13421_ net572 net437 VGND VGND VPWR VPWR _05728_ sky130_fd_sc_hd__nand2_1
X_10564_ _02596_ _02611_ VGND VGND VPWR VPWR _02613_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13352_ _05629_ _05631_ _05634_ VGND VGND VPWR VPWR _05652_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_140_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12303_ _04507_ _04508_ VGND VGND VPWR VPWR _04509_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_121_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10495_ net372 net463 net335 net480 VGND VGND VPWR VPWR _02539_ sky130_fd_sc_hd__nand4_2
X_13283_ _05525_ _05568_ _05566_ _05558_ VGND VGND VPWR VPWR _05576_ sky130_fd_sc_hd__a211o_1
X_12234_ _04346_ _04348_ _04433_ VGND VGND VPWR VPWR _04434_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_32_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12165_ _04356_ _04357_ VGND VGND VPWR VPWR _04359_ sky130_fd_sc_hd__nor2_1
X_11116_ _03155_ _03159_ _03212_ VGND VGND VPWR VPWR _03213_ sky130_fd_sc_hd__o21ai_1
X_12096_ _04280_ _04281_ _04283_ VGND VGND VPWR VPWR _04284_ sky130_fd_sc_hd__a21o_1
X_11047_ _03133_ _03134_ _03136_ VGND VGND VPWR VPWR _03138_ sky130_fd_sc_hd__and3_1
Xinput9 alpha[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_2
X_14806_ clknet_3_5_0_clk _00107_ net322 VGND VGND VPWR VPWR b_cos\[16\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_98_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12998_ net519 net355 net345 net528 VGND VGND VPWR VPWR _05263_ sky130_fd_sc_hd__a22oi_2
X_11949_ net204 _04122_ _04123_ VGND VGND VPWR VPWR _04124_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_86_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14737_ clknet_3_2_0_clk _00038_ net314 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_139_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14668_ _07068_ _07070_ _07082_ VGND VGND VPWR VPWR _07083_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_116_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13619_ net494 net341 net337 net503 VGND VGND VPWR VPWR _05944_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_55_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14599_ _06948_ _06996_ _07008_ VGND VGND VPWR VPWR _07009_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_125_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07973_ _07265_ _07266_ _07258_ VGND VGND VPWR VPWR _07268_ sky130_fd_sc_hd__a21o_1
X_09712_ _01525_ _01529_ _01527_ _01528_ VGND VGND VPWR VPWR _01713_ sky130_fd_sc_hd__o211ai_1
X_09643_ _01535_ _01537_ _01536_ VGND VGND VPWR VPWR _01644_ sky130_fd_sc_hd__a21bo_1
X_09574_ net742 net436 VGND VGND VPWR VPWR _01575_ sky130_fd_sc_hd__nand2_1
X_08525_ _00514_ _00515_ VGND VGND VPWR VPWR _00573_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08456_ _00503_ _00504_ VGND VGND VPWR VPWR _00505_ sky130_fd_sc_hd__nor2_1
X_07407_ _02592_ _02603_ _02614_ VGND VGND VPWR VPWR _02625_ sky130_fd_sc_hd__nand3_1
X_08387_ _00434_ _00435_ _00436_ VGND VGND VPWR VPWR _00437_ sky130_fd_sc_hd__nand3_2
XFILLER_0_46_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09008_ _01047_ _01048_ VGND VGND VPWR VPWR _01049_ sky130_fd_sc_hd__nor2_1
X_10280_ _02304_ VGND VGND VPWR VPWR _00059_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_130_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout551 net30 VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__clkbuf_4
Xfanout540 net542 VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__clkbuf_4
Xfanout573 net574 VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__buf_2
Xfanout562 net563 VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__dlymetal6s2s_1
X_13970_ _06234_ _06236_ _06235_ VGND VGND VPWR VPWR _06326_ sky130_fd_sc_hd__a21bo_1
Xfanout584 net592 VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__clkbuf_4
X_12921_ _05151_ _05178_ VGND VGND VPWR VPWR _05179_ sky130_fd_sc_hd__xnor2_1
Xfanout595 net596 VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__clkbuf_4
X_12852_ _05102_ _04863_ VGND VGND VPWR VPWR _05104_ sky130_fd_sc_hd__and2b_1
XFILLER_0_139_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11803_ net1 net235 VGND VGND VPWR VPWR _03964_ sky130_fd_sc_hd__and2b_1
X_12783_ _04940_ _04985_ _05028_ VGND VGND VPWR VPWR _05030_ sky130_fd_sc_hd__a21o_1
X_11734_ net705 net290 VGND VGND VPWR VPWR _03889_ sky130_fd_sc_hd__nand2_1
X_14522_ net579 net456 net446 net586 VGND VGND VPWR VPWR _06925_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_138_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11665_ net158 net685 VGND VGND VPWR VPWR _03815_ sky130_fd_sc_hd__nand2_1
XFILLER_0_83_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14453_ _06849_ _06850_ VGND VGND VPWR VPWR _06851_ sky130_fd_sc_hd__xor2_2
XFILLER_0_138_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10616_ _02590_ _02591_ _02668_ _02670_ VGND VGND VPWR VPWR _02671_ sky130_fd_sc_hd__a211oi_2
X_13404_ _05478_ _05536_ _05486_ VGND VGND VPWR VPWR _05709_ sky130_fd_sc_hd__and3_1
X_11596_ _03677_ _03680_ VGND VGND VPWR VPWR _03739_ sky130_fd_sc_hd__and2_1
XFILLER_0_107_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14384_ _06700_ _06703_ _06774_ _06775_ VGND VGND VPWR VPWR _06776_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_36_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10547_ _02522_ _02524_ VGND VGND VPWR VPWR _02595_ sky130_fd_sc_hd__or2_1
XFILLER_0_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13335_ _05588_ _05632_ VGND VGND VPWR VPWR _05634_ sky130_fd_sc_hd__nor2_1
XFILLER_0_110_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10478_ _02518_ _02519_ VGND VGND VPWR VPWR _02520_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13266_ _05540_ _05555_ _05557_ VGND VGND VPWR VPWR _05558_ sky130_fd_sc_hd__and3_1
X_12217_ _04412_ _04414_ _04415_ VGND VGND VPWR VPWR _04416_ sky130_fd_sc_hd__nand3_1
XFILLER_0_122_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13197_ _05359_ _05481_ VGND VGND VPWR VPWR _05482_ sky130_fd_sc_hd__and2_1
X_12148_ _04154_ _04244_ _04242_ VGND VGND VPWR VPWR _04341_ sky130_fd_sc_hd__o21a_1
XFILLER_0_138_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12079_ _04262_ _04263_ VGND VGND VPWR VPWR _04265_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_139_Right_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08310_ _00358_ _00359_ _00355_ VGND VGND VPWR VPWR _00361_ sky130_fd_sc_hd__a21o_1
XFILLER_0_86_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09290_ _01303_ VGND VGND VPWR VPWR _00042_ sky130_fd_sc_hd__clkbuf_1
X_08241_ net311 net231 net222 net580 VGND VGND VPWR VPWR _00293_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_6_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_14 net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_129_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_25 net207 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_36 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08172_ _00222_ _00223_ _00126_ _00143_ VGND VGND VPWR VPWR _00225_ sky130_fd_sc_hd__o211a_1
XFILLER_0_70_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput110 net110 VGND VGND VPWR VPWR Q[9] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_112_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07956_ _07248_ _07249_ _07244_ VGND VGND VPWR VPWR _07251_ sky130_fd_sc_hd__a21o_1
XFILLER_0_128_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_106_Right_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07887_ _03352_ _03407_ _03341_ VGND VGND VPWR VPWR _07183_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_97_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09626_ net665 net674 net359 net349 VGND VGND VPWR VPWR _01627_ sky130_fd_sc_hd__nand4_2
X_09557_ _01552_ _01557_ VGND VGND VPWR VPWR _01558_ sky130_fd_sc_hd__xnor2_2
X_08508_ _00489_ _00556_ VGND VGND VPWR VPWR _00557_ sky130_fd_sc_hd__xnor2_1
X_09488_ _01473_ _01487_ _01488_ VGND VGND VPWR VPWR _01489_ sky130_fd_sc_hd__nand3_2
XFILLER_0_93_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08439_ _00409_ _00421_ VGND VGND VPWR VPWR _00488_ sky130_fd_sc_hd__or2_1
XFILLER_0_65_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11450_ _03575_ _03576_ _03574_ VGND VGND VPWR VPWR _03578_ sky130_fd_sc_hd__a21o_1
XFILLER_0_34_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11381_ _03487_ _03500_ VGND VGND VPWR VPWR _03502_ sky130_fd_sc_hd__nor2_1
XFILLER_0_104_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10401_ net686 net440 VGND VGND VPWR VPWR _02436_ sky130_fd_sc_hd__nand2_1
X_10332_ _02359_ _02360_ VGND VGND VPWR VPWR _02361_ sky130_fd_sc_hd__nor2_1
X_13120_ _05341_ _05344_ VGND VGND VPWR VPWR _05397_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13051_ _05319_ _05320_ VGND VGND VPWR VPWR _05321_ sky130_fd_sc_hd__nor2_1
X_12002_ _04177_ _04180_ VGND VGND VPWR VPWR _04181_ sky130_fd_sc_hd__xor2_1
X_10263_ _02271_ _02285_ VGND VGND VPWR VPWR _02286_ sky130_fd_sc_hd__xnor2_2
X_10194_ _02208_ _02209_ _02105_ _02107_ VGND VGND VPWR VPWR _02211_ sky130_fd_sc_hd__a211oi_2
Xfanout381 net383 VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__clkbuf_4
Xfanout392 net397 VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__clkbuf_4
Xfanout370 net50 VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__clkbuf_2
X_13953_ net512 net437 VGND VGND VPWR VPWR _06307_ sky130_fd_sc_hd__nand2_1
X_12904_ _04998_ _05101_ _04990_ VGND VGND VPWR VPWR _05160_ sky130_fd_sc_hd__o21ba_1
X_13884_ _06230_ _06231_ VGND VGND VPWR VPWR _06232_ sky130_fd_sc_hd__nor2_1
X_12835_ _05084_ _05085_ VGND VGND VPWR VPWR _05087_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_33_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12766_ net276 net378 net252 net244 VGND VGND VPWR VPWR _05012_ sky130_fd_sc_hd__and4_1
XFILLER_0_83_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14505_ _06844_ _06845_ VGND VGND VPWR VPWR _06908_ sky130_fd_sc_hd__nand2_1
XFILLER_0_126_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11717_ _03782_ _03870_ VGND VGND VPWR VPWR _03871_ sky130_fd_sc_hd__or2_1
X_12697_ _04859_ _04936_ VGND VGND VPWR VPWR _04937_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_140_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11648_ net256 net738 VGND VGND VPWR VPWR _03796_ sky130_fd_sc_hd__nand2_1
Xinput12 alpha[3] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_4
X_14436_ _06832_ _06760_ VGND VGND VPWR VPWR _06833_ sky130_fd_sc_hd__nor2_1
X_11579_ _03711_ _03712_ _03718_ VGND VGND VPWR VPWR _03720_ sky130_fd_sc_hd__a21o_1
XFILLER_0_52_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14367_ _06682_ _06683_ _06681_ VGND VGND VPWR VPWR _06758_ sky130_fd_sc_hd__a21o_1
Xinput45 cos[17] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_4_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput34 beta[7] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_4
Xinput23 beta[13] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput67 sin[3] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__clkbuf_1
Xinput56 sin[0] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__buf_1
XFILLER_0_122_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13318_ _05612_ _05613_ _05596_ VGND VGND VPWR VPWR _05615_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_110_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14298_ net505 net417 VGND VGND VPWR VPWR _06683_ sky130_fd_sc_hd__and2b_1
XFILLER_0_122_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13249_ _05535_ _05533_ _05504_ VGND VGND VPWR VPWR _05539_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07810_ _06820_ _06972_ _06993_ _07004_ VGND VGND VPWR VPWR _07015_ sky130_fd_sc_hd__o31ai_2
X_08790_ _00771_ _00772_ _00770_ VGND VGND VPWR VPWR _00835_ sky130_fd_sc_hd__a21oi_1
X_07741_ net124 _06244_ _06233_ _06189_ VGND VGND VPWR VPWR _06266_ sky130_fd_sc_hd__o211ai_2
X_07672_ _05215_ _05237_ _05226_ VGND VGND VPWR VPWR _05512_ sky130_fd_sc_hd__nand3_1
XFILLER_0_79_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09411_ net700 net357 net347 net709 VGND VGND VPWR VPWR _01412_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_90_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09342_ b_cos\[14\] a_sin\[14\] VGND VGND VPWR VPWR _01348_ sky130_fd_sc_hd__or2b_1
XFILLER_0_59_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09273_ _01278_ _01283_ _01279_ VGND VGND VPWR VPWR _01289_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_47_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08224_ _00256_ _00275_ VGND VGND VPWR VPWR _00276_ sky130_fd_sc_hd__xor2_2
XFILLER_0_7_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08155_ _00203_ _00206_ _00200_ VGND VGND VPWR VPWR _00208_ sky130_fd_sc_hd__a21o_1
XFILLER_0_90_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08086_ b_sin\[2\] _00139_ _02027_ VGND VGND VPWR VPWR _00140_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08988_ _00981_ _00982_ _01029_ VGND VGND VPWR VPWR _01030_ sky130_fd_sc_hd__a21oi_2
X_07939_ _07231_ _07232_ _07233_ VGND VGND VPWR VPWR _07234_ sky130_fd_sc_hd__nand3_1
X_10950_ _03009_ _03032_ VGND VGND VPWR VPWR _03033_ sky130_fd_sc_hd__or2_1
X_10881_ net650 net417 VGND VGND VPWR VPWR _02958_ sky130_fd_sc_hd__and2b_1
X_09609_ net710 net467 VGND VGND VPWR VPWR _01610_ sky130_fd_sc_hd__nand2_1
X_12620_ _04853_ VGND VGND VPWR VPWR _00084_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_66_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12551_ _04777_ _04778_ VGND VGND VPWR VPWR _04779_ sky130_fd_sc_hd__or2_1
XFILLER_0_65_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11502_ net309 net230 net375 net461 VGND VGND VPWR VPWR _03635_ sky130_fd_sc_hd__nand4_2
X_12482_ _04702_ _04698_ VGND VGND VPWR VPWR _04703_ sky130_fd_sc_hd__or2b_1
XFILLER_0_19_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_124_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11433_ _03441_ _03558_ VGND VGND VPWR VPWR _03559_ sky130_fd_sc_hd__nor2_1
XFILLER_0_80_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14221_ net495 net431 net420 net505 VGND VGND VPWR VPWR _06599_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_34_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14152_ _06515_ _06523_ VGND VGND VPWR VPWR _06524_ sky130_fd_sc_hd__xor2_1
X_11364_ _03453_ _03482_ VGND VGND VPWR VPWR _03483_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11295_ net218 net711 VGND VGND VPWR VPWR _03408_ sky130_fd_sc_hd__nand2_1
XFILLER_0_104_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10315_ _02339_ _02340_ _02341_ VGND VGND VPWR VPWR _02343_ sky130_fd_sc_hd__nand3_1
X_13103_ _05370_ _05371_ _05376_ VGND VGND VPWR VPWR _05378_ sky130_fd_sc_hd__a21o_1
X_14083_ _06301_ _06356_ _06448_ VGND VGND VPWR VPWR _06449_ sky130_fd_sc_hd__a21o_1
X_10246_ _02262_ _02265_ _02267_ VGND VGND VPWR VPWR _02268_ sky130_fd_sc_hd__and3_1
X_13034_ _05299_ _05300_ _05298_ VGND VGND VPWR VPWR _05302_ sky130_fd_sc_hd__a21o_1
X_10177_ _02189_ _02191_ _02192_ VGND VGND VPWR VPWR _02193_ sky130_fd_sc_hd__nand3_1
XFILLER_0_89_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13936_ net542 net415 VGND VGND VPWR VPWR _06289_ sky130_fd_sc_hd__and2b_1
X_13867_ _06210_ _06212_ _06213_ VGND VGND VPWR VPWR _06214_ sky130_fd_sc_hd__nand3_1
X_12818_ _05063_ _05065_ _05066_ VGND VGND VPWR VPWR _05068_ sky130_fd_sc_hd__and3_1
XFILLER_0_56_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13798_ net612 net621 net360 net350 VGND VGND VPWR VPWR _06139_ sky130_fd_sc_hd__nand4_2
XFILLER_0_29_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12749_ net286 net268 net144 net137 VGND VGND VPWR VPWR _04993_ sky130_fd_sc_hd__and4_1
XFILLER_0_56_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14419_ _06719_ _06743_ _06717_ VGND VGND VPWR VPWR _06814_ sky130_fd_sc_hd__o21a_1
XFILLER_0_142_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09960_ _01951_ _01958_ _01959_ VGND VGND VPWR VPWR _01960_ sky130_fd_sc_hd__nand3_1
X_08911_ _00898_ _00896_ VGND VGND VPWR VPWR _00954_ sky130_fd_sc_hd__and2b_1
XFILLER_0_0_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09891_ net724 net486 net408 net733 VGND VGND VPWR VPWR _01892_ sky130_fd_sc_hd__a22oi_1
X_08842_ _00817_ _00820_ _00823_ VGND VGND VPWR VPWR _00886_ sky130_fd_sc_hd__a21o_1
X_08773_ net161 net581 _00676_ _00675_ VGND VGND VPWR VPWR _00818_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_85_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07724_ net304 net531 net538 net225 VGND VGND VPWR VPWR _06081_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07655_ _05183_ _05303_ _05314_ VGND VGND VPWR VPWR _05325_ sky130_fd_sc_hd__nand3_2
XFILLER_0_67_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07586_ _04543_ _04565_ VGND VGND VPWR VPWR _04576_ sky130_fd_sc_hd__or2b_1
XFILLER_0_47_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09325_ net95 _01333_ net131 VGND VGND VPWR VPWR _01334_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09256_ _01266_ _01270_ _01269_ VGND VGND VPWR VPWR _01274_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_8_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08207_ net281 net516 net525 net263 VGND VGND VPWR VPWR _00259_ sky130_fd_sc_hd__a22o_1
XFILLER_0_16_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09187_ _01214_ _01215_ VGND VGND VPWR VPWR _01216_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08138_ _00186_ _00189_ _00190_ VGND VGND VPWR VPWR _00191_ sky130_fd_sc_hd__and3_1
XFILLER_0_43_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08069_ _00120_ _00121_ _07270_ _07331_ VGND VGND VPWR VPWR _00123_ sky130_fd_sc_hd__o211ai_4
X_10100_ _02108_ _02106_ _01941_ VGND VGND VPWR VPWR _02109_ sky130_fd_sc_hd__a21oi_1
X_11080_ _03165_ _03172_ VGND VGND VPWR VPWR _03173_ sky130_fd_sc_hd__xnor2_1
X_10031_ net371 net387 VGND VGND VPWR VPWR _02034_ sky130_fd_sc_hd__and2_1
X_14770_ clknet_3_5_0_clk _00071_ net324 VGND VGND VPWR VPWR a_cos\[16\] sky130_fd_sc_hd__dfrtp_1
X_11982_ _02017_ VGND VGND VPWR VPWR _04160_ sky130_fd_sc_hd__buf_4
X_13721_ net584 net403 VGND VGND VPWR VPWR _06055_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10933_ _03012_ _03013_ VGND VGND VPWR VPWR _03014_ sky130_fd_sc_hd__nor2_1
X_10864_ net336 net481 net134 VGND VGND VPWR VPWR _02939_ sky130_fd_sc_hd__o21a_1
XFILLER_0_39_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13652_ _05962_ _05963_ _05979_ VGND VGND VPWR VPWR _05980_ sky130_fd_sc_hd__nor3b_1
XFILLER_0_128_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12603_ _04727_ _04818_ _04833_ VGND VGND VPWR VPWR _04835_ sky130_fd_sc_hd__a21o_1
XFILLER_0_66_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10795_ _02862_ _02863_ VGND VGND VPWR VPWR _02865_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13583_ net639 net350 _05902_ _05903_ VGND VGND VPWR VPWR _05904_ sky130_fd_sc_hd__a22o_1
X_12534_ _04757_ _04758_ VGND VGND VPWR VPWR _04760_ sky130_fd_sc_hd__and2_1
XFILLER_0_66_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12465_ _04669_ _04684_ VGND VGND VPWR VPWR _04686_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_62_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_49_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12396_ _04606_ _04607_ _04608_ _04610_ VGND VGND VPWR VPWR _04611_ sky130_fd_sc_hd__o211a_1
X_11416_ _03525_ _03536_ _03540_ VGND VGND VPWR VPWR _03541_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_22_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14204_ net585 net342 VGND VGND VPWR VPWR _06580_ sky130_fd_sc_hd__nand2_1
X_11347_ net217 net720 net730 net207 VGND VGND VPWR VPWR _03465_ sky130_fd_sc_hd__a22o_1
XFILLER_0_104_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14135_ _06489_ _06490_ _06504_ VGND VGND VPWR VPWR _06506_ sky130_fd_sc_hd__a21oi_1
X_11278_ net288 net745 _03386_ _03387_ VGND VGND VPWR VPWR _03389_ sky130_fd_sc_hd__o2bb2a_1
X_14066_ net585 net361 net351 net594 VGND VGND VPWR VPWR _06431_ sky130_fd_sc_hd__a22oi_1
X_10229_ net649 net666 net335 net480 VGND VGND VPWR VPWR _02249_ sky130_fd_sc_hd__nand4_1
X_13017_ net571 net468 VGND VGND VPWR VPWR _05284_ sky130_fd_sc_hd__nand2_1
X_13919_ _06083_ _06269_ _06270_ VGND VGND VPWR VPWR _06271_ sky130_fd_sc_hd__o21ai_1
X_07440_ net147 net550 net568 net295 VGND VGND VPWR VPWR _02984_ sky130_fd_sc_hd__a22o_1
XFILLER_0_76_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07371_ _02048_ _02070_ _02059_ VGND VGND VPWR VPWR _02233_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_85_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09110_ _01097_ _01113_ _01116_ VGND VGND VPWR VPWR _01149_ sky130_fd_sc_hd__a21o_1
XFILLER_0_17_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09041_ _01079_ _01081_ VGND VGND VPWR VPWR _01082_ sky130_fd_sc_hd__or2_1
XFILLER_0_44_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap120 _03441_ VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__buf_1
XFILLER_0_111_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09943_ _01941_ _01942_ VGND VGND VPWR VPWR _01943_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09874_ _01872_ _01873_ _01874_ VGND VGND VPWR VPWR _01875_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_0_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08825_ net284 net598 net607 net266 VGND VGND VPWR VPWR _00869_ sky130_fd_sc_hd__a22oi_2
X_08756_ net284 net607 net617 net266 VGND VGND VPWR VPWR _00801_ sky130_fd_sc_hd__a22oi_1
X_08687_ net284 net617 net626 net266 VGND VGND VPWR VPWR _00733_ sky130_fd_sc_hd__a22oi_2
X_07707_ _05797_ _05874_ _05435_ _05885_ VGND VGND VPWR VPWR _05896_ sky130_fd_sc_hd__o211a_1
XFILLER_0_138_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07638_ _05107_ _05129_ VGND VGND VPWR VPWR _05140_ sky130_fd_sc_hd__or2b_4
XFILLER_0_137_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07569_ _04326_ _04358_ _04369_ _04380_ VGND VGND VPWR VPWR _04391_ sky130_fd_sc_hd__a211oi_4
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09308_ _01310_ _01313_ _01311_ VGND VGND VPWR VPWR _01319_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_63_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10580_ _02629_ _02630_ VGND VGND VPWR VPWR _02631_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_35_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09239_ net82 _01260_ net130 VGND VGND VPWR VPWR _01261_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12250_ _04366_ _04368_ VGND VGND VPWR VPWR _04451_ sky130_fd_sc_hd__or2_1
XFILLER_0_50_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11201_ _03290_ _03302_ _03303_ VGND VGND VPWR VPWR _03304_ sky130_fd_sc_hd__nand3_2
X_12181_ net670 net679 net282 net264 VGND VGND VPWR VPWR _04376_ sky130_fd_sc_hd__and4_1
XFILLER_0_102_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11132_ net142 net426 VGND VGND VPWR VPWR _03229_ sky130_fd_sc_hd__nand2_1
XFILLER_0_102_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11063_ _03097_ _03108_ _03154_ VGND VGND VPWR VPWR _03155_ sky130_fd_sc_hd__a21oi_2
X_10014_ _02012_ _02013_ _02015_ VGND VGND VPWR VPWR _02016_ sky130_fd_sc_hd__o21a_1
XFILLER_0_98_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11965_ _04138_ _04139_ _04023_ _04036_ VGND VGND VPWR VPWR _04142_ sky130_fd_sc_hd__a211o_1
X_14753_ clknet_3_7_0_clk _00054_ net326 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10916_ _02938_ _02939_ _02866_ VGND VGND VPWR VPWR _02996_ sky130_fd_sc_hd__a21o_1
X_13704_ _06033_ _06034_ _06018_ VGND VGND VPWR VPWR _06036_ sky130_fd_sc_hd__a21o_1
X_14684_ _07053_ _07054_ _07052_ VGND VGND VPWR VPWR _07100_ sky130_fd_sc_hd__a21o_1
X_11896_ _03867_ _03869_ _03871_ VGND VGND VPWR VPWR _04066_ sky130_fd_sc_hd__and3_1
X_13635_ _05875_ _05898_ _05959_ _05960_ VGND VGND VPWR VPWR _05962_ sky130_fd_sc_hd__a211oi_4
X_10847_ _02718_ _02849_ VGND VGND VPWR VPWR _02921_ sky130_fd_sc_hd__or2_1
XFILLER_0_125_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_57_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10778_ _02802_ _02803_ VGND VGND VPWR VPWR _02846_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13566_ _05883_ _05884_ _05799_ VGND VGND VPWR VPWR _05887_ sky130_fd_sc_hd__a21o_1
X_12517_ _04740_ _04741_ VGND VGND VPWR VPWR _04742_ sky130_fd_sc_hd__nand2_1
XFILLER_0_54_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13497_ _05809_ _05810_ VGND VGND VPWR VPWR _05811_ sky130_fd_sc_hd__nand2_1
XFILLER_0_124_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12448_ _04665_ _04599_ _04662_ _04664_ VGND VGND VPWR VPWR _04667_ sky130_fd_sc_hd__o211a_2
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12379_ _04583_ _04591_ VGND VGND VPWR VPWR _04592_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14118_ _06466_ _06486_ VGND VGND VPWR VPWR _06487_ sky130_fd_sc_hd__xnor2_1
X_14049_ _06409_ _06410_ _06411_ VGND VGND VPWR VPWR _06412_ sky130_fd_sc_hd__nand3_2
X_08610_ net283 net625 net634 net265 VGND VGND VPWR VPWR _00657_ sky130_fd_sc_hd__a22oi_2
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09590_ _01589_ _01590_ VGND VGND VPWR VPWR _01591_ sky130_fd_sc_hd__and2_1
X_08541_ _00571_ _00588_ VGND VGND VPWR VPWR _00589_ sky130_fd_sc_hd__xnor2_1
X_08472_ _00431_ _00433_ _00432_ VGND VGND VPWR VPWR _00521_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_49_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07423_ net177 net167 net515 net523 VGND VGND VPWR VPWR _02799_ sky130_fd_sc_hd__and4_1
XFILLER_0_15_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07354_ net221 net497 VGND VGND VPWR VPWR _02048_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09024_ _01010_ _01015_ _01064_ VGND VGND VPWR VPWR _01065_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_72_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout700 net707 VGND VGND VPWR VPWR net700 sky130_fd_sc_hd__buf_2
XFILLER_0_40_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout711 net715 VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__clkbuf_4
Xfanout722 net12 VGND VGND VPWR VPWR net722 sky130_fd_sc_hd__buf_2
Xfanout733 net734 VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__buf_2
X_09926_ _02017_ VGND VGND VPWR VPWR _01926_ sky130_fd_sc_hd__buf_4
Xfanout744 net1 VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__clkbuf_2
X_09857_ _01852_ _01856_ _01857_ VGND VGND VPWR VPWR _01858_ sky130_fd_sc_hd__nand3_1
X_08808_ _00787_ _00789_ VGND VGND VPWR VPWR _00853_ sky130_fd_sc_hd__or2b_1
X_09788_ _01786_ _01788_ VGND VGND VPWR VPWR _01789_ sky130_fd_sc_hd__xor2_1
X_08739_ _00763_ _00764_ _00784_ VGND VGND VPWR VPWR _00785_ sky130_fd_sc_hd__o21ai_1
X_11750_ _03824_ _03827_ _03826_ VGND VGND VPWR VPWR _03907_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_95_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10701_ a_cos\[9\] _02762_ _02303_ VGND VGND VPWR VPWR _02763_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11681_ net310 net188 net232 net274 VGND VGND VPWR VPWR _03832_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_63_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10632_ _02653_ _02645_ VGND VGND VPWR VPWR _02687_ sky130_fd_sc_hd__or2b_1
X_13420_ _05725_ _05726_ VGND VGND VPWR VPWR _05727_ sky130_fd_sc_hd__nor2_1
XFILLER_0_91_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10563_ _02596_ _02611_ VGND VGND VPWR VPWR _02612_ sky130_fd_sc_hd__nor2_1
X_13351_ _05637_ _05636_ VGND VGND VPWR VPWR _05651_ sky130_fd_sc_hd__and2b_1
X_12302_ net275 net162 VGND VGND VPWR VPWR _04508_ sky130_fd_sc_hd__nand2_1
XFILLER_0_122_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10494_ net372 net335 net480 net463 VGND VGND VPWR VPWR _02537_ sky130_fd_sc_hd__a22o_1
XFILLER_0_32_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13282_ _05573_ _05574_ VGND VGND VPWR VPWR _05575_ sky130_fd_sc_hd__or2_1
XFILLER_0_121_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12233_ _04350_ _04432_ VGND VGND VPWR VPWR _04433_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_32_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12164_ net697 net706 net249 net240 VGND VGND VPWR VPWR _04357_ sky130_fd_sc_hd__and4_1
XFILLER_0_102_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12095_ net670 net293 VGND VGND VPWR VPWR _04283_ sky130_fd_sc_hd__and2_1
X_11115_ _03209_ _03210_ VGND VGND VPWR VPWR _03212_ sky130_fd_sc_hd__nor2_1
X_11046_ _03133_ _03134_ _03136_ VGND VGND VPWR VPWR _03137_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_36_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14805_ clknet_3_4_0_clk _00106_ net322 VGND VGND VPWR VPWR b_cos\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_86_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14736_ clknet_3_0_0_clk _00037_ net314 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dfrtp_1
X_12997_ net519 net528 net355 net345 VGND VGND VPWR VPWR _05262_ sky130_fd_sc_hd__and4_1
X_11948_ net188 net214 net204 net274 VGND VGND VPWR VPWR _04123_ sky130_fd_sc_hd__a22o_1
X_11879_ _04045_ _04046_ _03944_ _03947_ VGND VGND VPWR VPWR _04048_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_52_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14667_ _07072_ _07071_ VGND VGND VPWR VPWR _07082_ sky130_fd_sc_hd__or2b_1
XFILLER_0_7_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13618_ net512 net477 VGND VGND VPWR VPWR _05943_ sky130_fd_sc_hd__nand2_1
X_14598_ _07006_ _07007_ VGND VGND VPWR VPWR _07008_ sky130_fd_sc_hd__xor2_1
XFILLER_0_70_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13549_ _05865_ _05866_ _05857_ VGND VGND VPWR VPWR _05868_ sky130_fd_sc_hd__a21o_1
XFILLER_0_15_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07972_ _07258_ _07265_ _07266_ VGND VGND VPWR VPWR _07267_ sky130_fd_sc_hd__nand3_2
X_09711_ _01709_ _01711_ VGND VGND VPWR VPWR _01712_ sky130_fd_sc_hd__nand2_1
X_09642_ _01640_ _01641_ _01639_ VGND VGND VPWR VPWR _01643_ sky130_fd_sc_hd__o21ai_1
X_09573_ _01568_ _01573_ VGND VGND VPWR VPWR _01574_ sky130_fd_sc_hd__xnor2_1
X_08524_ _00526_ _00528_ VGND VGND VPWR VPWR _00572_ sky130_fd_sc_hd__nand2_1
XFILLER_0_93_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08455_ _00417_ _00416_ VGND VGND VPWR VPWR _00504_ sky130_fd_sc_hd__and2b_1
XFILLER_0_46_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07406_ net310 net613 net624 net232 VGND VGND VPWR VPWR _02614_ sky130_fd_sc_hd__a22o_1
X_08386_ _00341_ _00343_ _00342_ VGND VGND VPWR VPWR _00436_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_92_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09007_ _01037_ _01046_ VGND VGND VPWR VPWR _01048_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout541 net542 VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__clkbuf_2
Xfanout530 net32 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__buf_2
Xfanout574 net576 VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__clkbuf_4
X_09909_ _01856_ _01858_ VGND VGND VPWR VPWR _01910_ sky130_fd_sc_hd__nand2_1
Xfanout563 net29 VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__clkbuf_4
Xfanout552 net560 VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__clkbuf_4
X_12920_ _05153_ _05177_ VGND VGND VPWR VPWR _05178_ sky130_fd_sc_hd__xnor2_1
Xfanout596 net601 VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__clkbuf_4
Xfanout585 net592 VGND VGND VPWR VPWR net585 sky130_fd_sc_hd__buf_2
X_12851_ _04787_ _04862_ _05102_ VGND VGND VPWR VPWR _05103_ sky130_fd_sc_hd__o21a_1
X_11802_ _03900_ _03903_ VGND VGND VPWR VPWR _03963_ sky130_fd_sc_hd__nand2_1
X_12782_ _04940_ _04985_ _05028_ VGND VGND VPWR VPWR _05029_ sky130_fd_sc_hd__and3_1
XFILLER_0_96_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11733_ _03886_ _03887_ VGND VGND VPWR VPWR _03888_ sky130_fd_sc_hd__xor2_1
XFILLER_0_96_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14521_ net579 net456 net446 VGND VGND VPWR VPWR _06924_ sky130_fd_sc_hd__and3_1
X_11664_ _03713_ _03716_ _03714_ VGND VGND VPWR VPWR _03813_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_139_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14452_ _06779_ _06782_ _06776_ VGND VGND VPWR VPWR _06850_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_37_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10615_ _02666_ _02667_ _02593_ _02594_ VGND VGND VPWR VPWR _02670_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_52_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13403_ _05573_ _05581_ _05538_ _05539_ VGND VGND VPWR VPWR _05708_ sky130_fd_sc_hd__o211a_1
X_11595_ _03670_ _03676_ VGND VGND VPWR VPWR _03738_ sky130_fd_sc_hd__and2_1
XFILLER_0_107_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14383_ _06772_ _06773_ _06695_ _06710_ VGND VGND VPWR VPWR _06775_ sky130_fd_sc_hd__o211a_1
X_10546_ _02528_ _02575_ VGND VGND VPWR VPWR _02594_ sky130_fd_sc_hd__nor2_1
XFILLER_0_51_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13334_ net657 net355 _05583_ _05587_ VGND VGND VPWR VPWR _05632_ sky130_fd_sc_hd__a211oi_1
X_10477_ _02416_ _02417_ _02415_ VGND VGND VPWR VPWR _02519_ sky130_fd_sc_hd__a21o_1
X_13265_ _05518_ _05515_ _05517_ VGND VGND VPWR VPWR _05557_ sky130_fd_sc_hd__a21o_1
X_12216_ _04310_ _04311_ _04313_ _04312_ VGND VGND VPWR VPWR _04415_ sky130_fd_sc_hd__a31o_1
XFILLER_0_121_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13196_ _05353_ _05357_ _05355_ _05356_ VGND VGND VPWR VPWR _05481_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_138_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12147_ _04335_ _04339_ VGND VGND VPWR VPWR _04340_ sky130_fd_sc_hd__xor2_2
XFILLER_0_47_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12078_ _04262_ _04263_ VGND VGND VPWR VPWR _04264_ sky130_fd_sc_hd__nor2_1
X_11029_ _02928_ _03117_ VGND VGND VPWR VPWR _03118_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14719_ clknet_3_2_0_clk _00020_ net314 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_74_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08240_ net311 net231 net588 VGND VGND VPWR VPWR _00292_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_28_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_37 net637 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_26 net287 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08171_ _00126_ _00143_ _00222_ _00223_ VGND VGND VPWR VPWR _00224_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_55_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_15 net482 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput100 net100 VGND VGND VPWR VPWR Q[16] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_42_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput111 net111 VGND VGND VPWR VPWR done sky130_fd_sc_hd__buf_2
XFILLER_0_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07955_ _07244_ _07248_ _07249_ VGND VGND VPWR VPWR _07250_ sky130_fd_sc_hd__and3_1
X_07886_ _07179_ _07180_ _07172_ VGND VGND VPWR VPWR _07182_ sky130_fd_sc_hd__a21o_1
X_09625_ net665 net359 net349 net674 VGND VGND VPWR VPWR _01626_ sky130_fd_sc_hd__a22o_1
XFILLER_0_78_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09556_ _01553_ _01556_ VGND VGND VPWR VPWR _01557_ sky130_fd_sc_hd__xnor2_1
X_08507_ _00554_ _00555_ VGND VGND VPWR VPWR _00556_ sky130_fd_sc_hd__or2_1
X_09487_ _01480_ _01481_ _01486_ VGND VGND VPWR VPWR _01488_ sky130_fd_sc_hd__a21o_1
XFILLER_0_136_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08438_ _00487_ VGND VGND VPWR VPWR _00006_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_34_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08369_ _00326_ _00325_ VGND VGND VPWR VPWR _00419_ sky130_fd_sc_hd__and2b_1
XFILLER_0_73_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11380_ _03487_ _03500_ VGND VGND VPWR VPWR _03501_ sky130_fd_sc_hd__xor2_1
X_10400_ _02433_ _02434_ VGND VGND VPWR VPWR _02435_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_12_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10331_ _02357_ _02358_ _02350_ VGND VGND VPWR VPWR _02360_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_21_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10262_ _02283_ _02284_ VGND VGND VPWR VPWR _02285_ sky130_fd_sc_hd__xnor2_2
X_13050_ net511 net356 net345 net519 VGND VGND VPWR VPWR _05320_ sky130_fd_sc_hd__a22oi_2
X_12001_ _04178_ _04179_ VGND VGND VPWR VPWR _04180_ sky130_fd_sc_hd__nor2_1
XFILLER_0_103_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10193_ _02105_ _02107_ _02208_ _02209_ VGND VGND VPWR VPWR _02210_ sky130_fd_sc_hd__o211a_1
Xfanout382 net383 VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__clkbuf_2
Xfanout371 net374 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__clkbuf_4
Xfanout360 net364 VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__buf_4
X_13952_ _06304_ _06305_ VGND VGND VPWR VPWR _06306_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout393 net394 VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__clkbuf_4
X_12903_ net259 _05049_ _05047_ VGND VGND VPWR VPWR _05159_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_21_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13883_ _06228_ _06229_ _06221_ VGND VGND VPWR VPWR _06231_ sky130_fd_sc_hd__a21oi_1
X_12834_ _05008_ _05023_ _05026_ VGND VGND VPWR VPWR _05085_ sky130_fd_sc_hd__a21o_1
X_12765_ net276 net252 net244 net378 VGND VGND VPWR VPWR _05011_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_69_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11716_ net739 net239 VGND VGND VPWR VPWR _03870_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14504_ _06903_ _06905_ VGND VGND VPWR VPWR _06906_ sky130_fd_sc_hd__xor2_1
X_12696_ _04922_ _04935_ VGND VGND VPWR VPWR _04936_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_37_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput13 alpha[4] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_1
X_11647_ _03793_ _03794_ VGND VGND VPWR VPWR _03795_ sky130_fd_sc_hd__nor2_1
XFILLER_0_83_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14435_ _06750_ _06756_ VGND VGND VPWR VPWR _06832_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_30_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11578_ _03711_ _03712_ _03718_ VGND VGND VPWR VPWR _03719_ sky130_fd_sc_hd__nand3_2
Xinput46 cos[1] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_1
X_14366_ _06750_ _06756_ VGND VGND VPWR VPWR _06757_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput35 beta[8] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_12
Xinput24 beta[14] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_25_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput57 sin[10] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_1
Xinput68 sin[4] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__clkbuf_1
X_10529_ _02528_ _02575_ VGND VGND VPWR VPWR _02576_ sky130_fd_sc_hd__xor2_1
XFILLER_0_40_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13317_ _05596_ _05612_ _05613_ VGND VGND VPWR VPWR _05614_ sky130_fd_sc_hd__and3_2
X_14297_ _06680_ _06681_ VGND VGND VPWR VPWR _06682_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13248_ _05504_ _05535_ _05533_ VGND VGND VPWR VPWR _05538_ sky130_fd_sc_hd__nand3_1
XFILLER_0_110_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13179_ _05220_ _05221_ _05236_ VGND VGND VPWR VPWR _05462_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_42_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07740_ _06189_ _06233_ _06244_ net124 VGND VGND VPWR VPWR _06255_ sky130_fd_sc_hd__a211o_1
XFILLER_0_74_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07671_ _05468_ _05479_ _05172_ VGND VGND VPWR VPWR _05501_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09410_ net717 net339 VGND VGND VPWR VPWR _01411_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09341_ a_sin\[14\] b_cos\[14\] VGND VGND VPWR VPWR _01347_ sky130_fd_sc_hd__or2b_1
XFILLER_0_47_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09272_ _01286_ _01287_ VGND VGND VPWR VPWR _01288_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08223_ _00273_ _00274_ VGND VGND VPWR VPWR _00275_ sky130_fd_sc_hd__nor2_1
XFILLER_0_132_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08154_ _00200_ _00203_ _00206_ VGND VGND VPWR VPWR _00207_ sky130_fd_sc_hd__nand3_1
XFILLER_0_16_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08085_ _00136_ _00138_ VGND VGND VPWR VPWR _00139_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08987_ _01027_ _01028_ VGND VGND VPWR VPWR _01029_ sky130_fd_sc_hd__xnor2_2
X_07938_ _07144_ _07145_ _07146_ VGND VGND VPWR VPWR _07233_ sky130_fd_sc_hd__o21bai_1
X_07869_ _07162_ _07163_ _07158_ VGND VGND VPWR VPWR _07165_ sky130_fd_sc_hd__a21o_1
XFILLER_0_98_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09608_ _01607_ _01608_ VGND VGND VPWR VPWR _01609_ sky130_fd_sc_hd__xnor2_1
X_10880_ _02955_ _02956_ VGND VGND VPWR VPWR _02957_ sky130_fd_sc_hd__nor2_1
X_09539_ _01534_ _01538_ _01539_ VGND VGND VPWR VPWR _01540_ sky130_fd_sc_hd__nand3_1
XFILLER_0_109_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12550_ _04775_ _04776_ _04704_ _04692_ VGND VGND VPWR VPWR _04778_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_93_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11501_ net221 net556 VGND VGND VPWR VPWR _03634_ sky130_fd_sc_hd__and2_1
X_12481_ _04692_ _04693_ _04695_ VGND VGND VPWR VPWR _04702_ sky130_fd_sc_hd__and3b_1
XFILLER_0_108_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11432_ _03433_ _03434_ _03439_ VGND VGND VPWR VPWR _03558_ sky130_fd_sc_hd__o21a_1
X_14220_ _06491_ _06495_ _06492_ VGND VGND VPWR VPWR _06598_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_110_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14151_ _06517_ _06522_ VGND VGND VPWR VPWR _06523_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_34_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11363_ _03480_ _03481_ VGND VGND VPWR VPWR _03482_ sky130_fd_sc_hd__nand2_1
XFILLER_0_104_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13102_ _05370_ _05371_ _05376_ VGND VGND VPWR VPWR _05377_ sky130_fd_sc_hd__nand3_2
XFILLER_0_34_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11294_ net220 net703 _03295_ _03294_ VGND VGND VPWR VPWR _03406_ sky130_fd_sc_hd__a22o_1
X_10314_ _02248_ _02250_ _02249_ VGND VGND VPWR VPWR _02341_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_21_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14082_ _06355_ _06352_ VGND VGND VPWR VPWR _06448_ sky130_fd_sc_hd__and2b_1
X_10245_ net553 net344 _02263_ _02264_ VGND VGND VPWR VPWR _02267_ sky130_fd_sc_hd__nand4_1
X_13033_ _05298_ _05299_ _05300_ VGND VGND VPWR VPWR _05301_ sky130_fd_sc_hd__nand3_1
X_10176_ _02038_ _02046_ _02045_ VGND VGND VPWR VPWR _02192_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_28_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout190 net191 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_135_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13935_ _06285_ _06286_ VGND VGND VPWR VPWR _06288_ sky130_fd_sc_hd__nor2_1
XFILLER_0_88_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13866_ _06122_ _06125_ _06123_ VGND VGND VPWR VPWR _06213_ sky130_fd_sc_hd__a21bo_1
X_12817_ _05063_ _05065_ _05066_ VGND VGND VPWR VPWR _05067_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_69_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13797_ net612 net360 net350 net621 VGND VGND VPWR VPWR _06138_ sky130_fd_sc_hd__a22o_1
X_12748_ net267 net144 net137 net285 VGND VGND VPWR VPWR _04992_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_84_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12679_ _04916_ _04851_ _04917_ VGND VGND VPWR VPWR _04918_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_72_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14418_ _06790_ _06812_ VGND VGND VPWR VPWR _06813_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_130_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14349_ _06736_ _06737_ VGND VGND VPWR VPWR _06738_ sky130_fd_sc_hd__xor2_1
X_08910_ _00890_ _00895_ VGND VGND VPWR VPWR _00953_ sky130_fd_sc_hd__and2b_1
X_09890_ net724 net733 net486 net408 VGND VGND VPWR VPWR _01891_ sky130_fd_sc_hd__and4_1
XFILLER_0_40_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08841_ _00864_ _00884_ VGND VGND VPWR VPWR _00885_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08772_ _00613_ _00754_ _00611_ VGND VGND VPWR VPWR _00817_ sky130_fd_sc_hd__a21o_1
XFILLER_0_109_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07723_ net218 net547 VGND VGND VPWR VPWR _06070_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07654_ _04804_ _04772_ _04793_ VGND VGND VPWR VPWR _05314_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07585_ _04554_ _04010_ VGND VGND VPWR VPWR _04565_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_48_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09324_ _01330_ _01332_ VGND VGND VPWR VPWR _01333_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09255_ _01273_ VGND VGND VPWR VPWR _00037_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_62_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08206_ net281 net263 net525 VGND VGND VPWR VPWR _00258_ sky130_fd_sc_hd__and3_1
XFILLER_0_62_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09186_ a_cos\[9\] b_sin\[9\] VGND VGND VPWR VPWR _01215_ sky130_fd_sc_hd__nand2_1
X_08137_ net160 net644 _00187_ _00188_ VGND VGND VPWR VPWR _00190_ sky130_fd_sc_hd__nand4_1
X_08068_ _07270_ _07331_ _00120_ _00121_ VGND VGND VPWR VPWR _00122_ sky130_fd_sc_hd__a211o_2
XFILLER_0_12_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10030_ _02023_ _02032_ VGND VGND VPWR VPWR _02033_ sky130_fd_sc_hd__xor2_1
X_11981_ _04157_ _04158_ VGND VGND VPWR VPWR _04159_ sky130_fd_sc_hd__nor2_1
X_10932_ net373 net466 net433 net425 VGND VGND VPWR VPWR _03013_ sky130_fd_sc_hd__and4_1
X_13720_ _06050_ _06053_ VGND VGND VPWR VPWR _06054_ sky130_fd_sc_hd__xor2_1
XFILLER_0_129_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10863_ net142 net471 VGND VGND VPWR VPWR _02938_ sky130_fd_sc_hd__nand2_1
X_13651_ _05809_ _05978_ VGND VGND VPWR VPWR _05979_ sky130_fd_sc_hd__xor2_1
XFILLER_0_38_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12602_ _04727_ _04818_ _04833_ VGND VGND VPWR VPWR _04834_ sky130_fd_sc_hd__nand3_1
XFILLER_0_94_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10794_ net463 net439 VGND VGND VPWR VPWR _02863_ sky130_fd_sc_hd__nand2_1
X_13582_ net621 net630 net368 net360 VGND VGND VPWR VPWR _05903_ sky130_fd_sc_hd__nand4_2
X_12533_ _04757_ _04758_ VGND VGND VPWR VPWR _04759_ sky130_fd_sc_hd__nor2_1
XFILLER_0_54_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12464_ _04681_ _04683_ VGND VGND VPWR VPWR _04684_ sky130_fd_sc_hd__xor2_1
XFILLER_0_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14203_ _06578_ VGND VGND VPWR VPWR _06579_ sky130_fd_sc_hd__buf_2
X_12395_ _04525_ _04450_ VGND VGND VPWR VPWR _04610_ sky130_fd_sc_hd__or2b_1
X_11415_ _03533_ _03526_ _03530_ VGND VGND VPWR VPWR _03540_ sky130_fd_sc_hd__or3_1
XFILLER_0_100_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11346_ net210 net201 net720 net730 VGND VGND VPWR VPWR _03464_ sky130_fd_sc_hd__and4_1
X_14134_ _06496_ _06503_ VGND VGND VPWR VPWR _06504_ sky130_fd_sc_hd__xnor2_1
X_14065_ _06336_ _06340_ VGND VGND VPWR VPWR _06430_ sky130_fd_sc_hd__and2_1
XFILLER_0_120_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11277_ _03386_ _03387_ net288 net745 VGND VGND VPWR VPWR _03388_ sky130_fd_sc_hd__and4bb_1
X_13016_ _05273_ _05275_ VGND VGND VPWR VPWR _05283_ sky130_fd_sc_hd__nor2_1
X_10228_ net649 net335 net480 net666 VGND VGND VPWR VPWR _02248_ sky130_fd_sc_hd__a22o_1
X_10159_ _02166_ _02172_ VGND VGND VPWR VPWR _02173_ sky130_fd_sc_hd__xor2_2
XFILLER_0_89_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13918_ _06092_ _06171_ VGND VGND VPWR VPWR _06270_ sky130_fd_sc_hd__or2_1
X_13849_ _06095_ _06100_ VGND VGND VPWR VPWR _06194_ sky130_fd_sc_hd__and2b_1
X_07370_ _02146_ _02201_ _02212_ VGND VGND VPWR VPWR _02222_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_127_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09040_ _00970_ _00979_ _01030_ _01031_ VGND VGND VPWR VPWR _01081_ sky130_fd_sc_hd__o31a_1
XFILLER_0_5_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap121 _01471_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__buf_1
XFILLER_0_4_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09942_ _01618_ _01620_ _01940_ VGND VGND VPWR VPWR _01942_ sky130_fd_sc_hd__and3_1
X_09873_ net716 net724 net486 net408 VGND VGND VPWR VPWR _01874_ sky130_fd_sc_hd__nand4_2
X_08824_ _00799_ _00867_ VGND VGND VPWR VPWR _00868_ sky130_fd_sc_hd__nor2_4
XFILLER_0_99_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08755_ _00750_ _00753_ _00799_ VGND VGND VPWR VPWR _00800_ sky130_fd_sc_hd__a21oi_2
X_07706_ _05391_ _05402_ _05424_ VGND VGND VPWR VPWR _05885_ sky130_fd_sc_hd__a21o_1
X_08686_ _00674_ _00680_ VGND VGND VPWR VPWR _00732_ sky130_fd_sc_hd__nand2_1
X_07637_ _05043_ _05118_ VGND VGND VPWR VPWR _05129_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_137_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07568_ _02397_ _02407_ _02549_ VGND VGND VPWR VPWR _04380_ sky130_fd_sc_hd__and3_1
XFILLER_0_91_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09307_ _01316_ _01317_ VGND VGND VPWR VPWR _01318_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07499_ _02777_ _02832_ VGND VGND VPWR VPWR _03627_ sky130_fd_sc_hd__or2b_1
XFILLER_0_63_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09238_ _01258_ _01259_ VGND VGND VPWR VPWR _01260_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_133_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09169_ net89 _01200_ net129 VGND VGND VPWR VPWR _01201_ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11200_ _03282_ _03283_ _03289_ VGND VGND VPWR VPWR _03303_ sky130_fd_sc_hd__a21o_1
X_12180_ net670 net282 net264 net679 VGND VGND VPWR VPWR _04375_ sky130_fd_sc_hd__a22oi_2
X_11131_ _03187_ _03190_ _03186_ VGND VGND VPWR VPWR _03228_ sky130_fd_sc_hd__a21o_1
XFILLER_0_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11062_ _03152_ _03153_ VGND VGND VPWR VPWR _03154_ sky130_fd_sc_hd__xor2_1
X_10013_ _01922_ _02014_ _01665_ VGND VGND VPWR VPWR _02015_ sky130_fd_sc_hd__a21o_1
XFILLER_0_116_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11964_ _04023_ _04036_ _04138_ _04139_ VGND VGND VPWR VPWR _04140_ sky130_fd_sc_hd__o211ai_2
X_14752_ clknet_3_5_0_clk _00053_ net325 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_59_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11895_ _03979_ _04042_ _04044_ VGND VGND VPWR VPWR _04065_ sky130_fd_sc_hd__nand3_1
XFILLER_0_58_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10915_ _02992_ _02993_ VGND VGND VPWR VPWR _02995_ sky130_fd_sc_hd__xor2_2
X_13703_ _06018_ _06033_ _06034_ VGND VGND VPWR VPWR _06035_ sky130_fd_sc_hd__and3_1
X_14683_ net27 net432 VGND VGND VPWR VPWR _07099_ sky130_fd_sc_hd__nand2_1
XFILLER_0_128_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10846_ _02882_ _02902_ VGND VGND VPWR VPWR _02920_ sky130_fd_sc_hd__nor2_1
X_13634_ _05933_ _05934_ _05958_ VGND VGND VPWR VPWR _05960_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_128_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10777_ _02811_ _02830_ VGND VGND VPWR VPWR _02845_ sky130_fd_sc_hd__or2_1
XFILLER_0_54_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13565_ _05799_ _05883_ _05884_ VGND VGND VPWR VPWR _05886_ sky130_fd_sc_hd__nand3_2
X_12516_ _04737_ _04738_ VGND VGND VPWR VPWR _04741_ sky130_fd_sc_hd__nand2_1
XFILLER_0_82_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13496_ _05801_ _05807_ VGND VGND VPWR VPWR _05810_ sky130_fd_sc_hd__or2_1
X_12447_ _04662_ _04664_ _04665_ _04599_ VGND VGND VPWR VPWR _04666_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_81_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12378_ _04584_ _04590_ VGND VGND VPWR VPWR _04591_ sky130_fd_sc_hd__xor2_1
XFILLER_0_50_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14117_ _06467_ _06485_ VGND VGND VPWR VPWR _06486_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11329_ net208 net199 net730 net737 VGND VGND VPWR VPWR _03445_ sky130_fd_sc_hd__and4_1
XFILLER_0_66_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14048_ _06311_ _06313_ VGND VGND VPWR VPWR _06411_ sky130_fd_sc_hd__nand2_1
XFILLER_0_82_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08540_ _00572_ _00587_ VGND VGND VPWR VPWR _00588_ sky130_fd_sc_hd__xnor2_1
X_08471_ net293 net634 _00517_ _00518_ VGND VGND VPWR VPWR _00520_ sky130_fd_sc_hd__nand4_2
XFILLER_0_82_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07422_ net157 net532 VGND VGND VPWR VPWR _02788_ sky130_fd_sc_hd__nand2_1
XFILLER_0_92_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07353_ _02027_ VGND VGND VPWR VPWR next_state sky130_fd_sc_hd__buf_4
XFILLER_0_9_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09023_ _01062_ _01063_ VGND VGND VPWR VPWR _01064_ sky130_fd_sc_hd__xor2_1
XFILLER_0_86_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout712 net715 VGND VGND VPWR VPWR net712 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout723 net12 VGND VGND VPWR VPWR net723 sky130_fd_sc_hd__clkbuf_2
X_09925_ _01925_ VGND VGND VPWR VPWR _00055_ sky130_fd_sc_hd__clkbuf_1
Xfanout701 net707 VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__clkbuf_4
Xfanout745 net1 VGND VGND VPWR VPWR net745 sky130_fd_sc_hd__buf_2
Xfanout734 net735 VGND VGND VPWR VPWR net734 sky130_fd_sc_hd__buf_2
X_09856_ _01855_ _01854_ _01849_ _01853_ VGND VGND VPWR VPWR _01857_ sky130_fd_sc_hd__a211o_1
X_08807_ _00850_ _00851_ VGND VGND VPWR VPWR _00852_ sky130_fd_sc_hd__nand2_1
X_09787_ _01727_ _01787_ VGND VGND VPWR VPWR _01788_ sky130_fd_sc_hd__nor2_1
X_08738_ _00765_ _00783_ VGND VGND VPWR VPWR _00784_ sky130_fd_sc_hd__xnor2_1
X_08669_ _00713_ _00714_ _00715_ VGND VGND VPWR VPWR _00716_ sky130_fd_sc_hd__and3_1
X_10700_ _02755_ _02761_ VGND VGND VPWR VPWR _02762_ sky130_fd_sc_hd__xnor2_1
X_11680_ net310 net188 net232 net274 VGND VGND VPWR VPWR _03831_ sky130_fd_sc_hd__and4_1
XFILLER_0_126_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10631_ _02646_ _02652_ VGND VGND VPWR VPWR _02686_ sky130_fd_sc_hd__nand2_1
XFILLER_0_134_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10562_ _02608_ _02610_ VGND VGND VPWR VPWR _02611_ sky130_fd_sc_hd__xor2_1
XFILLER_0_24_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13350_ _05637_ _05648_ VGND VGND VPWR VPWR _05650_ sky130_fd_sc_hd__or2_1
XFILLER_0_134_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12301_ _04505_ _04506_ VGND VGND VPWR VPWR _04507_ sky130_fd_sc_hd__nor2_1
XFILLER_0_133_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13281_ net656 net330 _05571_ _05572_ VGND VGND VPWR VPWR _05574_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_122_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12232_ _04428_ _04431_ VGND VGND VPWR VPWR _04432_ sky130_fd_sc_hd__xor2_1
X_10493_ _02534_ _02535_ VGND VGND VPWR VPWR _02536_ sky130_fd_sc_hd__xor2_1
XFILLER_0_32_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12163_ net697 net249 net240 net706 VGND VGND VPWR VPWR _04356_ sky130_fd_sc_hd__a22oi_1
X_12094_ net557 net653 net152 net300 VGND VGND VPWR VPWR _04281_ sky130_fd_sc_hd__nand4_2
X_11114_ _03151_ _03163_ _03208_ VGND VGND VPWR VPWR _03210_ sky130_fd_sc_hd__nor3_1
X_11045_ net374 net418 VGND VGND VPWR VPWR _03136_ sky130_fd_sc_hd__and2b_1
XFILLER_0_99_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14804_ clknet_3_4_0_clk _00105_ net322 VGND VGND VPWR VPWR b_cos\[14\] sky130_fd_sc_hd__dfrtp_1
X_12996_ net536 net338 VGND VGND VPWR VPWR _05261_ sky130_fd_sc_hd__nand2_1
X_11947_ net188 net274 net214 VGND VGND VPWR VPWR _04122_ sky130_fd_sc_hd__and3_1
X_14735_ clknet_3_0_0_clk _00036_ net314 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_129_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11878_ _03944_ _03947_ _04045_ _04046_ VGND VGND VPWR VPWR _04047_ sky130_fd_sc_hd__a211o_1
XFILLER_0_74_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14666_ _07075_ VGND VGND VPWR VPWR _07081_ sky130_fd_sc_hd__inv_2
X_10829_ _02900_ _02901_ VGND VGND VPWR VPWR _02902_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14597_ _06944_ _06945_ _06943_ VGND VGND VPWR VPWR _07007_ sky130_fd_sc_hd__a21oi_1
X_13617_ _05937_ _05941_ VGND VGND VPWR VPWR _05942_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_109_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13548_ _05857_ _05865_ _05866_ VGND VGND VPWR VPWR _05867_ sky130_fd_sc_hd__nand3_1
XFILLER_0_124_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13479_ _05714_ _05791_ VGND VGND VPWR VPWR _05792_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_140_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07971_ _07262_ _07263_ _07264_ VGND VGND VPWR VPWR _07266_ sky130_fd_sc_hd__a21o_1
X_09710_ _01704_ _01709_ _01710_ VGND VGND VPWR VPWR _01711_ sky130_fd_sc_hd__nand3_1
XFILLER_0_10_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09641_ _01639_ _01640_ _01641_ VGND VGND VPWR VPWR _01642_ sky130_fd_sc_hd__or3_1
XFILLER_0_78_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09572_ _01569_ _01572_ VGND VGND VPWR VPWR _01573_ sky130_fd_sc_hd__xnor2_1
X_08523_ _00502_ _00505_ VGND VGND VPWR VPWR _00571_ sky130_fd_sc_hd__or2_1
X_08454_ _00410_ _00415_ VGND VGND VPWR VPWR _00503_ sky130_fd_sc_hd__and2b_1
XFILLER_0_65_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07405_ net310 net232 net613 net624 VGND VGND VPWR VPWR _02603_ sky130_fd_sc_hd__nand4_2
X_08385_ _00431_ _00432_ _00433_ VGND VGND VPWR VPWR _00435_ sky130_fd_sc_hd__nand3_1
XFILLER_0_135_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09006_ _01037_ _01046_ VGND VGND VPWR VPWR _01047_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_76_Left_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout531 net32 VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__clkbuf_4
Xfanout542 net31 VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__buf_6
Xfanout520 net526 VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__clkbuf_4
Xfanout575 net576 VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__clkbuf_4
X_09908_ _01884_ _01887_ _01888_ _01907_ _01908_ VGND VGND VPWR VPWR _01909_ sky130_fd_sc_hd__a41o_1
Xfanout553 net560 VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__clkbuf_2
Xfanout564 net29 VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__clkbuf_4
Xfanout597 net601 VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__clkbuf_4
X_09839_ net733 net366 _01829_ _01827_ VGND VGND VPWR VPWR _01840_ sky130_fd_sc_hd__a31o_1
Xfanout586 net587 VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__buf_2
X_12850_ _04998_ _05101_ VGND VGND VPWR VPWR _05102_ sky130_fd_sc_hd__xor2_1
XFILLER_0_69_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11801_ _03949_ _03951_ VGND VGND VPWR VPWR _03962_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_85_Left_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12781_ _05006_ _05027_ VGND VGND VPWR VPWR _05028_ sky130_fd_sc_hd__xor2_1
XFILLER_0_84_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14520_ _06860_ _06864_ _06922_ VGND VGND VPWR VPWR _06923_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_139_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11732_ net731 net256 VGND VGND VPWR VPWR _03887_ sky130_fd_sc_hd__nand2_1
XFILLER_0_113_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11663_ net158 net695 _03729_ _03728_ VGND VGND VPWR VPWR _03812_ sky130_fd_sc_hd__a31o_1
X_14451_ _06847_ _06848_ VGND VGND VPWR VPWR _06849_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10614_ _02593_ _02594_ _02666_ _02667_ VGND VGND VPWR VPWR _02668_ sky130_fd_sc_hd__o211a_1
X_14382_ _06695_ _06710_ _06772_ _06773_ VGND VGND VPWR VPWR _06774_ sky130_fd_sc_hd__a211oi_4
X_13402_ _05698_ _05703_ _05705_ _05573_ _05706_ VGND VGND VPWR VPWR _05707_ sky130_fd_sc_hd__o221a_1
X_11594_ _03733_ _03734_ _03650_ _03702_ VGND VGND VPWR VPWR _03736_ sky130_fd_sc_hd__o211a_1
XFILLER_0_106_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13333_ _05627_ _05628_ _05626_ VGND VGND VPWR VPWR _05631_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_36_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_94_Left_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10545_ _02573_ _02574_ VGND VGND VPWR VPWR _02593_ sky130_fd_sc_hd__nor2_1
XFILLER_0_52_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10476_ _02511_ _02517_ VGND VGND VPWR VPWR _02518_ sky130_fd_sc_hd__xnor2_1
X_13264_ _05548_ _05553_ _05554_ VGND VGND VPWR VPWR _05555_ sky130_fd_sc_hd__a21bo_1
X_12215_ _04410_ _04411_ _04313_ VGND VGND VPWR VPWR _04414_ sky130_fd_sc_hd__a21o_1
X_13195_ _05476_ _05478_ VGND VGND VPWR VPWR _05480_ sky130_fd_sc_hd__nand2_1
X_12146_ _04336_ _04338_ VGND VGND VPWR VPWR _04339_ sky130_fd_sc_hd__nor2_1
X_12077_ _04169_ _04170_ _04168_ VGND VGND VPWR VPWR _04263_ sky130_fd_sc_hd__a21o_1
X_11028_ _03063_ _03116_ VGND VGND VPWR VPWR _03117_ sky130_fd_sc_hd__xor2_1
XFILLER_0_78_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12979_ net620 net629 net484 net406 VGND VGND VPWR VPWR _05242_ sky130_fd_sc_hd__nand4_1
X_14718_ clknet_3_2_0_clk _00019_ net314 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_129_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14649_ _07061_ _07062_ VGND VGND VPWR VPWR _07063_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_120_Right_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08170_ _00220_ _00221_ _00161_ VGND VGND VPWR VPWR _00223_ sky130_fd_sc_hd__o21a_1
XFILLER_0_43_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_16 net482 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_27 net397 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_103_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput101 net101 VGND VGND VPWR VPWR Q[17] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_30_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07954_ _07246_ _07247_ _07245_ VGND VGND VPWR VPWR _07249_ sky130_fd_sc_hd__a21bo_1
X_07885_ _07172_ _07179_ _07180_ VGND VGND VPWR VPWR _07181_ sky130_fd_sc_hd__nand3_2
XFILLER_0_97_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09624_ net683 net340 VGND VGND VPWR VPWR _01625_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09555_ _01554_ _01555_ VGND VGND VPWR VPWR _01556_ sky130_fd_sc_hd__nor2_1
XFILLER_0_93_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08506_ _00490_ _00491_ _00553_ VGND VGND VPWR VPWR _00555_ sky130_fd_sc_hd__nor3_1
XFILLER_0_78_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09486_ _01480_ _01481_ _01486_ VGND VGND VPWR VPWR _01487_ sky130_fd_sc_hd__nand3_1
X_08437_ b_sin\[6\] _00485_ _00486_ VGND VGND VPWR VPWR _00487_ sky130_fd_sc_hd__mux2_1
XFILLER_0_92_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08368_ _00416_ _00417_ VGND VGND VPWR VPWR _00418_ sky130_fd_sc_hd__xor2_1
X_08299_ _00347_ _00348_ _00340_ VGND VGND VPWR VPWR _00350_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_61_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10330_ _02350_ _02357_ _02358_ VGND VGND VPWR VPWR _02359_ sky130_fd_sc_hd__and3_1
XFILLER_0_104_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10261_ _02180_ _02188_ _02187_ VGND VGND VPWR VPWR _02284_ sky130_fd_sc_hd__a21bo_1
X_12000_ _04077_ _04076_ VGND VGND VPWR VPWR _04179_ sky130_fd_sc_hd__and2b_1
X_10192_ _02206_ _02207_ _02121_ VGND VGND VPWR VPWR _02209_ sky130_fd_sc_hd__o21ai_1
Xfanout350 net354 VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__buf_4
XFILLER_0_108_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout383 net49 VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__buf_4
Xfanout372 net374 VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__clkbuf_4
X_13951_ net495 net504 net452 net442 VGND VGND VPWR VPWR _06305_ sky130_fd_sc_hd__and4_1
Xfanout361 net364 VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__buf_2
X_12902_ _05115_ _05121_ _05123_ VGND VGND VPWR VPWR _05158_ sky130_fd_sc_hd__a21o_1
Xfanout394 net395 VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__clkbuf_4
X_13882_ _06221_ _06228_ _06229_ VGND VGND VPWR VPWR _06230_ sky130_fd_sc_hd__and3_1
XFILLER_0_124_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12833_ _05082_ _05083_ VGND VGND VPWR VPWR _05084_ sky130_fd_sc_hd__and2b_1
X_12764_ _04924_ _04927_ _04925_ VGND VGND VPWR VPWR _05009_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_84_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11715_ net738 net248 net239 net745 VGND VGND VPWR VPWR _03869_ sky130_fd_sc_hd__a22o_1
XFILLER_0_68_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14503_ _06818_ _06836_ _06904_ VGND VGND VPWR VPWR _06905_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_126_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12695_ _04863_ _04933_ VGND VGND VPWR VPWR _04935_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11646_ net722 net280 net262 net731 VGND VGND VPWR VPWR _03794_ sky130_fd_sc_hd__and4_1
XFILLER_0_64_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14434_ _06828_ _06829_ VGND VGND VPWR VPWR _06830_ sky130_fd_sc_hd__or2_1
XFILLER_0_25_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11577_ _03713_ _03717_ VGND VGND VPWR VPWR _03718_ sky130_fd_sc_hd__xnor2_2
Xinput14 alpha[5] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
Xinput36 beta[9] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_2
X_14365_ _06753_ _06754_ VGND VGND VPWR VPWR _06756_ sky130_fd_sc_hd__xor2_1
Xinput25 beta[15] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_1
Xinput58 sin[11] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
Xinput69 sin[5] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__clkbuf_1
X_10528_ _02573_ _02574_ VGND VGND VPWR VPWR _02575_ sky130_fd_sc_hd__xnor2_1
Xinput47 cos[2] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_1
X_14296_ net641 net496 net431 net423 VGND VGND VPWR VPWR _06681_ sky130_fd_sc_hd__and4_1
X_13316_ _05597_ _05610_ _05609_ VGND VGND VPWR VPWR _05613_ sky130_fd_sc_hd__a21o_1
XFILLER_0_40_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13247_ _05478_ _05486_ _05536_ VGND VGND VPWR VPWR _05537_ sky130_fd_sc_hd__a21oi_1
X_10459_ _02392_ _02393_ _02391_ VGND VGND VPWR VPWR _02500_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_58_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13178_ _05449_ _05450_ _05460_ VGND VGND VPWR VPWR _05461_ sky130_fd_sc_hd__nand3_1
X_12129_ _04314_ _04316_ _04318_ VGND VGND VPWR VPWR _04320_ sky130_fd_sc_hd__a21o_1
XFILLER_0_74_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07670_ _05172_ _05468_ _05479_ VGND VGND VPWR VPWR _05490_ sky130_fd_sc_hd__nand3_1
XFILLER_0_90_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09340_ net796 _01344_ _01345_ _01346_ VGND VGND VPWR VPWR _00049_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_48_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09271_ a_sin\[4\] b_cos\[4\] VGND VGND VPWR VPWR _01287_ sky130_fd_sc_hd__or2b_1
XFILLER_0_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08222_ _00271_ _00272_ _00257_ VGND VGND VPWR VPWR _00274_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_23_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08153_ _06928_ _00204_ _00205_ net580 VGND VGND VPWR VPWR _00206_ sky130_fd_sc_hd__or4b_1
XFILLER_0_99_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08084_ _00137_ _07290_ VGND VGND VPWR VPWR _00138_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08986_ _00941_ _00958_ _00961_ VGND VGND VPWR VPWR _01028_ sky130_fd_sc_hd__a21o_1
X_07937_ _07229_ _07230_ _07228_ VGND VGND VPWR VPWR _07232_ sky130_fd_sc_hd__o21ai_1
X_07868_ _07158_ _07162_ _07163_ VGND VGND VPWR VPWR _07164_ sky130_fd_sc_hd__and3_1
XFILLER_0_3_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07799_ _06690_ _06679_ VGND VGND VPWR VPWR _06896_ sky130_fd_sc_hd__and2b_1
X_09607_ net735 net436 VGND VGND VPWR VPWR _01608_ sky130_fd_sc_hd__nand2_1
X_09538_ _01536_ _01537_ _01535_ VGND VGND VPWR VPWR _01539_ sky130_fd_sc_hd__a21o_1
X_11500_ _03574_ _03576_ _03575_ VGND VGND VPWR VPWR _03633_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_108_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09469_ _01458_ _01469_ VGND VGND VPWR VPWR _01470_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_136_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12480_ _01926_ _04698_ _04700_ _04701_ VGND VGND VPWR VPWR _00082_ sky130_fd_sc_hd__a31o_1
XFILLER_0_136_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11431_ _03549_ _03552_ VGND VGND VPWR VPWR _03557_ sky130_fd_sc_hd__nand2_1
XFILLER_0_46_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11362_ _03468_ _03479_ _03478_ VGND VGND VPWR VPWR _03481_ sky130_fd_sc_hd__a21o_1
X_14150_ _06520_ _06521_ VGND VGND VPWR VPWR _06522_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_132_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10313_ _02336_ _02337_ _02338_ VGND VGND VPWR VPWR _02340_ sky130_fd_sc_hd__nand3_1
X_13101_ _05372_ _05375_ VGND VGND VPWR VPWR _05376_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11293_ _03295_ _03293_ _03294_ VGND VGND VPWR VPWR _03405_ sky130_fd_sc_hd__nand3_1
X_14081_ _06397_ _06446_ VGND VGND VPWR VPWR _06447_ sky130_fd_sc_hd__xor2_1
X_10244_ net553 net344 _02263_ _02264_ VGND VGND VPWR VPWR _02265_ sky130_fd_sc_hd__a22o_1
X_13032_ net611 net489 net412 net620 VGND VGND VPWR VPWR _05300_ sky130_fd_sc_hd__a22o_1
XFILLER_0_30_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10175_ _02187_ _02188_ _02180_ VGND VGND VPWR VPWR _02191_ sky130_fd_sc_hd__a21o_1
Xfanout180 net183 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__clkbuf_2
Xfanout191 net192 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__clkbuf_4
X_13934_ net521 net530 net428 net419 VGND VGND VPWR VPWR _06286_ sky130_fd_sc_hd__and4_1
X_13865_ _06207_ _06208_ _06209_ VGND VGND VPWR VPWR _06212_ sky130_fd_sc_hd__nand3_1
X_12816_ net378 net238 VGND VGND VPWR VPWR _05066_ sky130_fd_sc_hd__and2b_1
XFILLER_0_57_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13796_ net611 net368 _06052_ _06051_ net385 VGND VGND VPWR VPWR _06137_ sky130_fd_sc_hd__a32o_1
XFILLER_0_127_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12747_ _04928_ _04932_ _04990_ VGND VGND VPWR VPWR _04991_ sky130_fd_sc_hd__a21o_1
XFILLER_0_29_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12678_ _04846_ _04847_ VGND VGND VPWR VPWR _04917_ sky130_fd_sc_hd__and2b_1
XFILLER_0_84_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11629_ _03773_ _03774_ _03698_ VGND VGND VPWR VPWR _03775_ sky130_fd_sc_hd__a21o_1
X_14417_ _06792_ _06811_ VGND VGND VPWR VPWR _06812_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14348_ net604 net470 _06650_ _06649_ VGND VGND VPWR VPWR _06737_ sky130_fd_sc_hd__a31o_1
XFILLER_0_100_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14279_ net587 net342 _06579_ _06518_ VGND VGND VPWR VPWR _06662_ sky130_fd_sc_hd__a31o_1
XFILLER_0_21_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08840_ _00866_ _00883_ VGND VGND VPWR VPWR _00884_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08771_ _00797_ _00798_ _00814_ VGND VGND VPWR VPWR _00816_ sky130_fd_sc_hd__nor3_1
X_07722_ net218 net538 _05556_ _05545_ VGND VGND VPWR VPWR _06059_ sky130_fd_sc_hd__a22o_1
X_07653_ _05259_ _05281_ _05292_ VGND VGND VPWR VPWR _05303_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_79_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07584_ net157 net566 VGND VGND VPWR VPWR _04554_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09323_ _01331_ _01326_ VGND VGND VPWR VPWR _01332_ sky130_fd_sc_hd__or2_1
XFILLER_0_48_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09254_ net102 _01272_ net128 VGND VGND VPWR VPWR _01273_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08205_ _00185_ _00192_ _00191_ VGND VGND VPWR VPWR _00257_ sky130_fd_sc_hd__a21o_1
X_09185_ a_cos\[9\] b_sin\[9\] VGND VGND VPWR VPWR _01214_ sky130_fd_sc_hd__or2_1
XFILLER_0_62_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08136_ net160 net644 _00187_ _00188_ VGND VGND VPWR VPWR _00189_ sky130_fd_sc_hd__a22o_1
XFILLER_0_50_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08067_ _07348_ _00109_ _00119_ VGND VGND VPWR VPWR _00121_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_3_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08969_ _01009_ _01010_ VGND VGND VPWR VPWR _01011_ sky130_fd_sc_hd__nor2_1
X_11980_ _04156_ _04057_ _04060_ VGND VGND VPWR VPWR _04158_ sky130_fd_sc_hd__nor3_1
XFILLER_0_98_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10931_ net373 net433 net425 net466 VGND VGND VPWR VPWR _03012_ sky130_fd_sc_hd__a22oi_1
X_10862_ _02868_ _02869_ _02936_ VGND VGND VPWR VPWR _02937_ sky130_fd_sc_hd__o21a_1
XFILLER_0_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13650_ _05964_ _05977_ VGND VGND VPWR VPWR _05978_ sky130_fd_sc_hd__xnor2_1
X_12601_ _04830_ _04832_ VGND VGND VPWR VPWR _04833_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_109_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10793_ _02860_ _02861_ VGND VGND VPWR VPWR _02862_ sky130_fd_sc_hd__nor2_1
XFILLER_0_39_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13581_ net620 net368 net360 net630 VGND VGND VPWR VPWR _05902_ sky130_fd_sc_hd__a22o_1
X_12532_ _04673_ _04675_ _04672_ VGND VGND VPWR VPWR _04758_ sky130_fd_sc_hd__a21o_1
XFILLER_0_94_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12463_ _04547_ _04682_ VGND VGND VPWR VPWR _04683_ sky130_fd_sc_hd__nor2_1
XFILLER_0_53_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11414_ _03525_ _03534_ _03536_ _03537_ VGND VGND VPWR VPWR _03538_ sky130_fd_sc_hd__a31o_1
X_14202_ _06518_ net577 _02709_ VGND VGND VPWR VPWR _06578_ sky130_fd_sc_hd__and3b_1
X_12394_ _04521_ _04524_ VGND VGND VPWR VPWR _04608_ sky130_fd_sc_hd__nand2_1
XFILLER_0_111_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11345_ net194 net737 VGND VGND VPWR VPWR _03463_ sky130_fd_sc_hd__nand2_1
XFILLER_0_105_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14133_ _06501_ _06502_ VGND VGND VPWR VPWR _06503_ sky130_fd_sc_hd__xor2_1
X_11276_ net147 net729 net738 net295 VGND VGND VPWR VPWR _03387_ sky130_fd_sc_hd__a22oi_1
X_14064_ _06328_ _06330_ VGND VGND VPWR VPWR _06428_ sky130_fd_sc_hd__nand2_1
X_10227_ _02245_ _02246_ VGND VGND VPWR VPWR _02247_ sky130_fd_sc_hd__xnor2_2
X_13015_ net658 net451 VGND VGND VPWR VPWR _05282_ sky130_fd_sc_hd__nand2_1
X_10158_ _02170_ _02171_ VGND VGND VPWR VPWR _02172_ sky130_fd_sc_hd__xor2_2
X_10089_ _01932_ _01933_ _01935_ VGND VGND VPWR VPWR _02097_ sky130_fd_sc_hd__a21bo_1
X_13917_ _06092_ _06171_ VGND VGND VPWR VPWR _06269_ sky130_fd_sc_hd__and2_1
X_13848_ _06191_ _06192_ VGND VGND VPWR VPWR _06193_ sky130_fd_sc_hd__or2_1
XFILLER_0_128_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13779_ net512 net520 net452 net442 VGND VGND VPWR VPWR _06118_ sky130_fd_sc_hd__and4_1
XFILLER_0_85_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap122 _00823_ VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__buf_1
X_09941_ _01618_ _01620_ _01940_ VGND VGND VPWR VPWR _01941_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_40_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09872_ net716 net486 net408 net724 VGND VGND VPWR VPWR _01873_ sky130_fd_sc_hd__a22o_1
X_08823_ _00818_ _00753_ VGND VGND VPWR VPWR _00867_ sky130_fd_sc_hd__and2b_1
XFILLER_0_29_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08754_ _00615_ _00752_ VGND VGND VPWR VPWR _00799_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07705_ _05797_ _05808_ _05863_ VGND VGND VPWR VPWR _05874_ sky130_fd_sc_hd__nor3_4
XFILLER_0_136_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08685_ _00615_ _00679_ VGND VGND VPWR VPWR _00731_ sky130_fd_sc_hd__or2_1
X_07636_ _04609_ _05053_ VGND VGND VPWR VPWR _05118_ sky130_fd_sc_hd__nor2_4
XFILLER_0_138_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07567_ _02397_ _02407_ _02549_ VGND VGND VPWR VPWR _04369_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_76_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09306_ a_sin\[9\] b_cos\[9\] VGND VGND VPWR VPWR _01317_ sky130_fd_sc_hd__or2b_1
XFILLER_0_48_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07498_ _03146_ _03178_ VGND VGND VPWR VPWR _03616_ sky130_fd_sc_hd__and2_1
X_09237_ _01251_ _01253_ _01250_ VGND VGND VPWR VPWR _01259_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_118_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09168_ _01198_ _01199_ VGND VGND VPWR VPWR _01200_ sky130_fd_sc_hd__xnor2_2
X_09099_ _01134_ _01137_ VGND VGND VPWR VPWR _01138_ sky130_fd_sc_hd__xnor2_1
X_08119_ net151 net297 net499 net508 VGND VGND VPWR VPWR _00172_ sky130_fd_sc_hd__nand4_1
XFILLER_0_71_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11130_ _03223_ _03226_ VGND VGND VPWR VPWR _03227_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_102_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11061_ _03073_ _03087_ _03090_ VGND VGND VPWR VPWR _03153_ sky130_fd_sc_hd__a21bo_1
X_10012_ _01595_ _01715_ VGND VGND VPWR VPWR _02014_ sky130_fd_sc_hd__nor2_1
XFILLER_0_116_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11963_ _04136_ _04137_ _04120_ VGND VGND VPWR VPWR _04139_ sky130_fd_sc_hd__a21o_1
X_14751_ clknet_3_5_0_clk _00052_ net324 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dfrtp_1
X_11894_ _03874_ _03978_ _04062_ VGND VGND VPWR VPWR _04063_ sky130_fd_sc_hd__o21ai_1
X_10914_ net273 net439 VGND VGND VPWR VPWR _02993_ sky130_fd_sc_hd__nand2_1
X_13702_ _06031_ _06032_ _06023_ VGND VGND VPWR VPWR _06034_ sky130_fd_sc_hd__a21o_1
X_14682_ _07096_ _07097_ VGND VGND VPWR VPWR _07098_ sky130_fd_sc_hd__xnor2_1
X_10845_ _02918_ VGND VGND VPWR VPWR _00066_ sky130_fd_sc_hd__clkbuf_1
X_13633_ _05933_ _05934_ _05958_ VGND VGND VPWR VPWR _05959_ sky130_fd_sc_hd__nor3b_4
XFILLER_0_132_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10776_ _02844_ VGND VGND VPWR VPWR _00065_ sky130_fd_sc_hd__clkbuf_1
X_13564_ _05881_ _05882_ _05800_ _05785_ VGND VGND VPWR VPWR _05884_ sky130_fd_sc_hd__a211o_1
XFILLER_0_137_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12515_ _04737_ _04738_ VGND VGND VPWR VPWR _04740_ sky130_fd_sc_hd__or2_1
XFILLER_0_124_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13495_ _05801_ _05807_ VGND VGND VPWR VPWR _05809_ sky130_fd_sc_hd__nand2_1
XFILLER_0_140_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12446_ _04593_ _04595_ VGND VGND VPWR VPWR _04665_ sky130_fd_sc_hd__and2_1
XFILLER_0_112_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12377_ _04588_ _04589_ VGND VGND VPWR VPWR _04590_ sky130_fd_sc_hd__xor2_1
XFILLER_0_2_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11328_ _03402_ _03403_ _03443_ VGND VGND VPWR VPWR _03444_ sky130_fd_sc_hd__a21o_1
XFILLER_0_105_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14116_ _06482_ _06484_ VGND VGND VPWR VPWR _06485_ sky130_fd_sc_hd__and2_1
XFILLER_0_120_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11259_ net176 net165 net704 net712 VGND VGND VPWR VPWR _03368_ sky130_fd_sc_hd__and4_1
X_14047_ net631 net469 _06406_ _06408_ VGND VGND VPWR VPWR _06410_ sky130_fd_sc_hd__nand4_2
XPHY_EDGE_ROW_105_Left_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08470_ net293 net634 _00517_ _00518_ VGND VGND VPWR VPWR _00519_ sky130_fd_sc_hd__a22o_1
XFILLER_0_106_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07421_ _02320_ _02342_ _02331_ VGND VGND VPWR VPWR _02777_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_85_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07352_ _02017_ VGND VGND VPWR VPWR _02027_ sky130_fd_sc_hd__buf_4
XFILLER_0_9_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_114_Left_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09022_ _01006_ _01007_ _01005_ VGND VGND VPWR VPWR _01063_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_142_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout713 net714 VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_123_Left_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09924_ a_cos\[0\] _01924_ _00486_ VGND VGND VPWR VPWR _01925_ sky130_fd_sc_hd__mux2_1
Xfanout724 net726 VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__buf_2
Xfanout702 net707 VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__buf_1
XFILLER_0_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout735 net739 VGND VGND VPWR VPWR net735 sky130_fd_sc_hd__buf_4
X_09855_ _01853_ _01849_ _01854_ _01855_ VGND VGND VPWR VPWR _01856_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_99_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08806_ _00848_ _00849_ _00782_ _00796_ VGND VGND VPWR VPWR _00851_ sky130_fd_sc_hd__a211o_1
X_09786_ net740 net340 _01725_ _01726_ VGND VGND VPWR VPWR _01787_ sky130_fd_sc_hd__o2bb2a_1
XPHY_EDGE_ROW_134_Right_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08737_ _00781_ _00782_ VGND VGND VPWR VPWR _00783_ sky130_fd_sc_hd__or2_1
X_08668_ _00633_ _00635_ VGND VGND VPWR VPWR _00715_ sky130_fd_sc_hd__or2b_1
X_07619_ _04674_ _04923_ VGND VGND VPWR VPWR _04934_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_132_Left_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08599_ _00560_ _00638_ _00639_ VGND VGND VPWR VPWR _00646_ sky130_fd_sc_hd__or3_1
XFILLER_0_49_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10630_ _02626_ _02633_ VGND VGND VPWR VPWR _02685_ sky130_fd_sc_hd__and2_1
XFILLER_0_64_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10561_ _02609_ _02521_ VGND VGND VPWR VPWR _02610_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12300_ net190 net182 net172 net145 VGND VGND VPWR VPWR _04506_ sky130_fd_sc_hd__and4_1
XFILLER_0_91_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10492_ net675 net440 VGND VGND VPWR VPWR _02535_ sky130_fd_sc_hd__nand2_1
X_13280_ _05571_ _05572_ net656 net330 VGND VGND VPWR VPWR _05573_ sky130_fd_sc_hd__o211a_1
XFILLER_0_133_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12231_ _04272_ _04429_ _04430_ VGND VGND VPWR VPWR _04431_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_51_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_141_Left_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12162_ _04275_ _04278_ _04276_ VGND VGND VPWR VPWR _04355_ sky130_fd_sc_hd__o21ba_1
X_12093_ net557 net152 net300 net653 VGND VGND VPWR VPWR _04280_ sky130_fd_sc_hd__a22o_1
X_11113_ _03151_ _03163_ _03208_ VGND VGND VPWR VPWR _03209_ sky130_fd_sc_hd__o21a_1
X_11044_ net187 net273 net432 net424 VGND VGND VPWR VPWR _03134_ sky130_fd_sc_hd__nand4_1
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14803_ clknet_3_4_0_clk _00104_ net322 VGND VGND VPWR VPWR b_cos\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_59_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12995_ _05197_ _05199_ _05198_ VGND VGND VPWR VPWR _05260_ sky130_fd_sc_hd__o21ba_1
X_11946_ net375 net197 VGND VGND VPWR VPWR _04121_ sky130_fd_sc_hd__nand2_1
X_14734_ clknet_3_5_0_clk _00035_ net327 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dfrtp_1
X_11877_ _04042_ _04044_ _03979_ VGND VGND VPWR VPWR _04046_ sky130_fd_sc_hd__a21oi_1
X_14665_ _01926_ _07077_ _07078_ _07079_ VGND VGND VPWR VPWR _00107_ sky130_fd_sc_hd__a31o_1
XFILLER_0_55_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10828_ _02883_ _02793_ _02899_ VGND VGND VPWR VPWR _02901_ sky130_fd_sc_hd__o21a_1
X_13616_ _05938_ _05940_ VGND VGND VPWR VPWR _05941_ sky130_fd_sc_hd__nor2_1
X_14596_ _06998_ _07005_ VGND VGND VPWR VPWR _07006_ sky130_fd_sc_hd__xor2_1
X_10759_ _02825_ _02740_ VGND VGND VPWR VPWR _02826_ sky130_fd_sc_hd__nor2_1
X_13547_ _05861_ _05862_ _05864_ VGND VGND VPWR VPWR _05866_ sky130_fd_sc_hd__a21o_1
XFILLER_0_140_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13478_ _05423_ _05790_ VGND VGND VPWR VPWR _05791_ sky130_fd_sc_hd__xnor2_2
X_12429_ _04643_ _04644_ _04624_ _04625_ VGND VGND VPWR VPWR _04646_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_2_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07970_ _07262_ _07263_ _07264_ VGND VGND VPWR VPWR _07265_ sky130_fd_sc_hd__nand3_1
XFILLER_0_77_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09640_ net184 net490 net411 net270 VGND VGND VPWR VPWR _01641_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_93_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09571_ _01570_ _01571_ VGND VGND VPWR VPWR _01572_ sky130_fd_sc_hd__nor2_1
X_08522_ _00508_ _00552_ VGND VGND VPWR VPWR _00570_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08453_ _00500_ _00501_ VGND VGND VPWR VPWR _00502_ sky130_fd_sc_hd__xor2_1
XFILLER_0_77_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07404_ net224 net633 VGND VGND VPWR VPWR _02592_ sky130_fd_sc_hd__and2_1
XFILLER_0_93_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08384_ _00431_ _00432_ _00433_ VGND VGND VPWR VPWR _00434_ sky130_fd_sc_hd__a21o_1
XFILLER_0_46_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09005_ _01038_ _01045_ VGND VGND VPWR VPWR _01046_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout532 net32 VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__clkbuf_2
X_09907_ _01839_ _01885_ _01886_ VGND VGND VPWR VPWR _01908_ sky130_fd_sc_hd__and3_1
Xfanout521 net526 VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout510 net513 VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__clkbuf_4
Xfanout565 net566 VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__buf_2
Xfanout554 net560 VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__clkbuf_4
Xfanout543 net544 VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__clkbuf_4
Xfanout576 net28 VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__clkbuf_2
Xfanout598 net599 VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__clkbuf_4
X_09838_ _01833_ _01836_ _01837_ _01838_ VGND VGND VPWR VPWR _01839_ sky130_fd_sc_hd__nand4_2
Xfanout587 net592 VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__clkbuf_4
X_09769_ net708 net399 VGND VGND VPWR VPWR _01770_ sky130_fd_sc_hd__nand2_1
X_11800_ _03953_ VGND VGND VPWR VPWR _03961_ sky130_fd_sc_hd__inv_2
XFILLER_0_139_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12780_ _05025_ _05026_ VGND VGND VPWR VPWR _05027_ sky130_fd_sc_hd__nor2_1
X_11731_ _03884_ _03885_ VGND VGND VPWR VPWR _03886_ sky130_fd_sc_hd__or2_1
XFILLER_0_68_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11662_ _03721_ _03722_ _03732_ VGND VGND VPWR VPWR _03811_ sky130_fd_sc_hd__nand3_2
XFILLER_0_126_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14450_ _06773_ _06774_ _06845_ _06846_ VGND VGND VPWR VPWR _06848_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_138_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11593_ _03650_ _03702_ _03733_ _03734_ VGND VGND VPWR VPWR _03735_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_126_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10613_ _02664_ _02665_ _02616_ VGND VGND VPWR VPWR _02667_ sky130_fd_sc_hd__o21ai_1
X_14381_ _06675_ _06699_ _06770_ _06771_ VGND VGND VPWR VPWR _06773_ sky130_fd_sc_hd__o211a_2
X_13401_ _05700_ _05702_ VGND VGND VPWR VPWR _05706_ sky130_fd_sc_hd__or2_1
X_10544_ _02509_ _02526_ VGND VGND VPWR VPWR _02591_ sky130_fd_sc_hd__or2_1
XFILLER_0_52_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13332_ _05629_ VGND VGND VPWR VPWR _05630_ sky130_fd_sc_hd__inv_2
XFILLER_0_134_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10475_ _02514_ _02515_ VGND VGND VPWR VPWR _02517_ sky130_fd_sc_hd__xor2_1
X_13263_ _05541_ _05547_ _05542_ VGND VGND VPWR VPWR _05554_ sky130_fd_sc_hd__nand3_1
X_12214_ _04313_ _04410_ _04411_ VGND VGND VPWR VPWR _04412_ sky130_fd_sc_hd__nand3_2
X_13194_ _05471_ _05476_ _05477_ VGND VGND VPWR VPWR _05478_ sky130_fd_sc_hd__nand3_1
X_12145_ _04240_ _04164_ VGND VGND VPWR VPWR _04338_ sky130_fd_sc_hd__and2b_1
X_12076_ _04255_ _04261_ VGND VGND VPWR VPWR _04262_ sky130_fd_sc_hd__xnor2_1
X_11027_ net141 _03114_ _03115_ VGND VGND VPWR VPWR _03116_ sky130_fd_sc_hd__a21o_1
XFILLER_0_63_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12978_ net638 net404 VGND VGND VPWR VPWR _05241_ sky130_fd_sc_hd__and2_1
X_11929_ _04099_ _04100_ _04101_ VGND VGND VPWR VPWR _04102_ sky130_fd_sc_hd__nand3_1
X_14717_ clknet_3_2_0_clk _00018_ net314 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_137_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14648_ _07048_ _07060_ VGND VGND VPWR VPWR _07062_ sky130_fd_sc_hd__or2_1
XFILLER_0_129_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_17 net542 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_28 net466 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14579_ _06790_ _06985_ VGND VGND VPWR VPWR _06987_ sky130_fd_sc_hd__nor2_1
XFILLER_0_88_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput102 net102 VGND VGND VPWR VPWR Q[1] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07953_ _07245_ _07246_ _07247_ VGND VGND VPWR VPWR _07248_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_128_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07884_ _07176_ _07177_ _07178_ VGND VGND VPWR VPWR _07180_ sky130_fd_sc_hd__a21o_1
X_09623_ _01542_ _01544_ _01543_ VGND VGND VPWR VPWR _01624_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_37_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09554_ net674 net683 net359 net349 VGND VGND VPWR VPWR _01555_ sky130_fd_sc_hd__and4_1
X_08505_ _00490_ _00491_ _00553_ VGND VGND VPWR VPWR _00554_ sky130_fd_sc_hd__o21a_1
XFILLER_0_53_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09485_ _01482_ _01485_ VGND VGND VPWR VPWR _01486_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08436_ _02017_ VGND VGND VPWR VPWR _00486_ sky130_fd_sc_hd__buf_4
XFILLER_0_19_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08367_ _00322_ _00323_ _00321_ VGND VGND VPWR VPWR _00417_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_46_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08298_ _00340_ _00347_ _00348_ VGND VGND VPWR VPWR _00349_ sky130_fd_sc_hd__and3_1
XFILLER_0_18_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10260_ _02281_ _02282_ VGND VGND VPWR VPWR _02283_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10191_ _02121_ _02206_ _02207_ VGND VGND VPWR VPWR _02208_ sky130_fd_sc_hd__or3_1
Xfanout340 net341 VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__buf_2
Xfanout373 net374 VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__clkbuf_4
Xfanout362 net364 VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__clkbuf_4
Xfanout384 net385 VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__clkbuf_4
X_13950_ net495 net452 net442 net504 VGND VGND VPWR VPWR _06304_ sky130_fd_sc_hd__a22oi_2
Xfanout351 net354 VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__clkbuf_2
X_12901_ _05099_ _05105_ _05103_ VGND VGND VPWR VPWR _05157_ sky130_fd_sc_hd__a21o_1
Xfanout395 net396 VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_69_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13881_ _06226_ _06227_ _06223_ VGND VGND VPWR VPWR _06229_ sky130_fd_sc_hd__a21o_1
X_12832_ _05005_ _05045_ _05081_ VGND VGND VPWR VPWR _05083_ sky130_fd_sc_hd__a21o_1
XFILLER_0_139_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12763_ _04922_ _04935_ _05007_ VGND VGND VPWR VPWR _05008_ sky130_fd_sc_hd__a21o_1
XFILLER_0_69_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11714_ net256 net738 _03795_ _03794_ VGND VGND VPWR VPWR _03867_ sky130_fd_sc_hd__a31o_1
XFILLER_0_83_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14502_ _06816_ _06837_ VGND VGND VPWR VPWR _06904_ sky130_fd_sc_hd__or2_1
XFILLER_0_126_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12694_ _04928_ _04932_ VGND VGND VPWR VPWR _04933_ sky130_fd_sc_hd__xor2_1
X_14433_ _06826_ _06827_ VGND VGND VPWR VPWR _06829_ sky130_fd_sc_hd__and2_1
XFILLER_0_140_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11645_ net722 net280 net262 net731 VGND VGND VPWR VPWR _03793_ sky130_fd_sc_hd__a22oi_1
X_11576_ _03714_ _03716_ VGND VGND VPWR VPWR _03717_ sky130_fd_sc_hd__nor2_1
Xinput15 alpha[6] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput37 cos[0] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_1
X_14364_ net496 net417 VGND VGND VPWR VPWR _06754_ sky130_fd_sc_hd__and2b_1
Xinput26 beta[16] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput59 sin[12] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_1
Xinput48 cos[3] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_1
X_10527_ _02453_ _02482_ _02481_ VGND VGND VPWR VPWR _02574_ sky130_fd_sc_hd__o21ba_1
X_14295_ net641 net431 net423 net496 VGND VGND VPWR VPWR _06680_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_3_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13315_ _05597_ _05609_ _05610_ VGND VGND VPWR VPWR _05612_ sky130_fd_sc_hd__nand3_1
XFILLER_0_110_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10458_ _02398_ _02400_ VGND VGND VPWR VPWR _02499_ sky130_fd_sc_hd__nand2_1
X_13246_ _05504_ _05533_ _05535_ VGND VGND VPWR VPWR _05536_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_122_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10389_ _02420_ _02421_ VGND VGND VPWR VPWR _02423_ sky130_fd_sc_hd__and2_1
XFILLER_0_58_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13177_ _05454_ _05459_ VGND VGND VPWR VPWR _05460_ sky130_fd_sc_hd__xnor2_1
X_12128_ _04314_ _04316_ _04318_ VGND VGND VPWR VPWR _04319_ sky130_fd_sc_hd__nand3_1
X_12059_ _04149_ _04163_ _04241_ VGND VGND VPWR VPWR _04244_ sky130_fd_sc_hd__o21a_1
XFILLER_0_90_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09270_ b_cos\[4\] a_sin\[4\] VGND VGND VPWR VPWR _01286_ sky130_fd_sc_hd__or2b_1
XFILLER_0_114_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08221_ _00257_ _00271_ _00272_ VGND VGND VPWR VPWR _00273_ sky130_fd_sc_hd__and3_1
XFILLER_0_75_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08152_ net311 net231 VGND VGND VPWR VPWR _00205_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08083_ net115 _07206_ _07284_ _07285_ VGND VGND VPWR VPWR _00137_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_70_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08985_ _01025_ _01026_ VGND VGND VPWR VPWR _01027_ sky130_fd_sc_hd__and2b_1
X_07936_ _07228_ _07229_ _07230_ VGND VGND VPWR VPWR _07231_ sky130_fd_sc_hd__or3_1
X_07867_ _07160_ _07161_ _07159_ VGND VGND VPWR VPWR _07163_ sky130_fd_sc_hd__a21bo_1
X_07798_ net218 net574 VGND VGND VPWR VPWR _06885_ sky130_fd_sc_hd__nand2_1
X_09606_ _01605_ _01606_ VGND VGND VPWR VPWR _01607_ sky130_fd_sc_hd__nor2_1
X_09537_ _01535_ _01536_ _01537_ VGND VGND VPWR VPWR _01538_ sky130_fd_sc_hd__nand3_1
XFILLER_0_78_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09468_ _01459_ _01468_ VGND VGND VPWR VPWR _01469_ sky130_fd_sc_hd__xnor2_1
X_08419_ _00467_ _00468_ VGND VGND VPWR VPWR _00469_ sky130_fd_sc_hd__nor2_1
XFILLER_0_81_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09399_ _01396_ _01399_ VGND VGND VPWR VPWR _01400_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_19_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11430_ _03483_ _03503_ _03545_ _03555_ VGND VGND VPWR VPWR _03556_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_80_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11361_ _03468_ _03478_ _03479_ VGND VGND VPWR VPWR _03480_ sky130_fd_sc_hd__nand3_2
XFILLER_0_104_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10312_ _02336_ _02337_ _02338_ VGND VGND VPWR VPWR _02339_ sky130_fd_sc_hd__a21o_1
X_13100_ _05373_ _05374_ VGND VGND VPWR VPWR _05375_ sky130_fd_sc_hd__nor2_1
X_11292_ _03301_ _03298_ _03300_ VGND VGND VPWR VPWR _03404_ sky130_fd_sc_hd__nand3_1
XFILLER_0_104_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14080_ _06444_ _06445_ VGND VGND VPWR VPWR _06446_ sky130_fd_sc_hd__xnor2_1
X_10243_ net372 net459 net362 net352 VGND VGND VPWR VPWR _02264_ sky130_fd_sc_hd__nand4_2
X_13031_ net611 net620 net489 net412 VGND VGND VPWR VPWR _05299_ sky130_fd_sc_hd__nand4_1
X_10174_ _02180_ _02187_ _02188_ VGND VGND VPWR VPWR _02189_ sky130_fd_sc_hd__nand3_1
Xfanout170 net173 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__buf_2
Xfanout181 net183 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__buf_2
Xfanout192 net7 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__clkbuf_4
X_13933_ net521 net428 net419 net530 VGND VGND VPWR VPWR _06285_ sky130_fd_sc_hd__a22oi_1
X_13864_ _06207_ _06208_ _06209_ VGND VGND VPWR VPWR _06210_ sky130_fd_sc_hd__a21o_1
X_12815_ net189 net276 net252 net244 VGND VGND VPWR VPWR _05065_ sky130_fd_sc_hd__nand4_1
XFILLER_0_97_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13795_ _06044_ _06045_ _06043_ VGND VGND VPWR VPWR _06136_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_29_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12746_ net294 _04872_ VGND VGND VPWR VPWR _04990_ sky130_fd_sc_hd__and2_1
XFILLER_0_121_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12677_ _04849_ VGND VGND VPWR VPWR _04916_ sky130_fd_sc_hd__inv_2
XFILLER_0_84_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11628_ _03769_ _03771_ _03772_ VGND VGND VPWR VPWR _03774_ sky130_fd_sc_hd__a21o_1
X_14416_ _06794_ _06810_ VGND VGND VPWR VPWR _06811_ sky130_fd_sc_hd__xor2_1
XFILLER_0_142_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14347_ _06734_ _06735_ VGND VGND VPWR VPWR _06736_ sky130_fd_sc_hd__xor2_1
XFILLER_0_25_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11559_ _03694_ _03696_ _03695_ VGND VGND VPWR VPWR _03698_ sky130_fd_sc_hd__and3_1
XFILLER_0_12_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14278_ _06510_ _06512_ VGND VGND VPWR VPWR _06661_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13229_ _05489_ _05516_ VGND VGND VPWR VPWR _05517_ sky130_fd_sc_hd__nor2_1
X_08770_ _00797_ _00798_ _00814_ VGND VGND VPWR VPWR _00815_ sky130_fd_sc_hd__o21a_1
XFILLER_0_85_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07721_ _05556_ _05534_ net765 VGND VGND VPWR VPWR _06048_ sky130_fd_sc_hd__nand3_1
XFILLER_0_79_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07652_ _05193_ _05248_ _05204_ VGND VGND VPWR VPWR _05292_ sky130_fd_sc_hd__nand3_1
X_07583_ _04511_ _04522_ _04533_ VGND VGND VPWR VPWR _04543_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_88_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09322_ a_sin\[10\] b_cos\[10\] VGND VGND VPWR VPWR _01331_ sky130_fd_sc_hd__and2b_1
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09253_ _01266_ _01271_ VGND VGND VPWR VPWR _01272_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08204_ _00177_ _00179_ VGND VGND VPWR VPWR _00256_ sky130_fd_sc_hd__nand2_1
XFILLER_0_90_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09184_ _01213_ VGND VGND VPWR VPWR _00026_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08135_ net179 net169 net627 net635 VGND VGND VPWR VPWR _00188_ sky130_fd_sc_hd__nand4_1
XFILLER_0_43_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08066_ _07348_ _00109_ _00119_ VGND VGND VPWR VPWR _00120_ sky130_fd_sc_hd__nor3b_4
XFILLER_0_141_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08968_ _00924_ _00927_ _01008_ VGND VGND VPWR VPWR _01010_ sky130_fd_sc_hd__o21a_1
X_08899_ net244 net618 VGND VGND VPWR VPWR _00942_ sky130_fd_sc_hd__nand2_1
X_07919_ _07128_ _07213_ VGND VGND VPWR VPWR _07214_ sky130_fd_sc_hd__nand2_1
X_10930_ _02926_ _02945_ VGND VGND VPWR VPWR _03011_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12600_ _04831_ _04760_ VGND VGND VPWR VPWR _04832_ sky130_fd_sc_hd__nor2_1
XFILLER_0_94_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10861_ net142 _02866_ VGND VGND VPWR VPWR _02936_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10792_ net272 net373 net457 net447 VGND VGND VPWR VPWR _02861_ sky130_fd_sc_hd__and4_1
X_13580_ _05853_ _05855_ _05854_ net395 VGND VGND VPWR VPWR _05901_ sky130_fd_sc_hd__a22o_1
XFILLER_0_137_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12531_ _04751_ _04756_ VGND VGND VPWR VPWR _04757_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12462_ _04549_ _04548_ VGND VGND VPWR VPWR _04682_ sky130_fd_sc_hd__and2b_1
XFILLER_0_93_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11413_ _03499_ _03498_ _03489_ VGND VGND VPWR VPWR _03537_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_50_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14201_ _06519_ _06521_ _06576_ VGND VGND VPWR VPWR _06577_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_34_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12393_ _04604_ _04605_ _04534_ _04535_ VGND VGND VPWR VPWR _04607_ sky130_fd_sc_hd__o211a_1
XFILLER_0_104_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11344_ _03454_ _03459_ _03458_ VGND VGND VPWR VPWR _03461_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14132_ _06408_ _06410_ VGND VGND VPWR VPWR _06502_ sky130_fd_sc_hd__nand2_1
XFILLER_0_120_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11275_ net147 net295 net729 net736 VGND VGND VPWR VPWR _03386_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_18_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14063_ _06422_ _06426_ VGND VGND VPWR VPWR _06427_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_120_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10226_ net701 net436 VGND VGND VPWR VPWR _02246_ sky130_fd_sc_hd__nand2_1
X_13014_ _05225_ _05235_ _05233_ VGND VGND VPWR VPWR _05280_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_55_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10157_ net649 net344 VGND VGND VPWR VPWR _02171_ sky130_fd_sc_hd__nand2_1
X_10088_ _02094_ _02095_ VGND VGND VPWR VPWR _02096_ sky130_fd_sc_hd__nand2_1
X_13916_ _05989_ _05893_ _06086_ _06087_ _06267_ VGND VGND VPWR VPWR _06268_ sky130_fd_sc_hd__a311o_1
XFILLER_0_97_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13847_ _06188_ _06190_ VGND VGND VPWR VPWR _06192_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_27_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13778_ net512 net452 net442 net520 VGND VGND VPWR VPWR _06117_ sky130_fd_sc_hd__a22oi_2
X_12729_ _04909_ _04910_ _04970_ VGND VGND VPWR VPWR _04972_ sky130_fd_sc_hd__or3_1
XFILLER_0_84_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmax_cap123 _06527_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_40_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09940_ _01938_ _01939_ VGND VGND VPWR VPWR _01940_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_115_Right_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09871_ net733 net399 VGND VGND VPWR VPWR _01872_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08822_ _00805_ _00812_ _00865_ VGND VGND VPWR VPWR _00866_ sky130_fd_sc_hd__a21oi_1
X_08753_ _00737_ _00744_ VGND VGND VPWR VPWR _00798_ sky130_fd_sc_hd__and2_1
XFILLER_0_136_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07704_ _05841_ _05852_ VGND VGND VPWR VPWR _05863_ sky130_fd_sc_hd__or2_1
X_08684_ _00661_ _00668_ VGND VGND VPWR VPWR _00730_ sky130_fd_sc_hd__and2_1
X_07635_ _05075_ _05086_ _05096_ VGND VGND VPWR VPWR _05107_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_48_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07566_ _04326_ _04337_ _04347_ VGND VGND VPWR VPWR _04358_ sky130_fd_sc_hd__nand3_2
XFILLER_0_137_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09305_ b_cos\[9\] a_sin\[9\] VGND VGND VPWR VPWR _01316_ sky130_fd_sc_hd__or2b_1
XFILLER_0_63_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07497_ _03081_ _03135_ VGND VGND VPWR VPWR _03605_ sky130_fd_sc_hd__and2_1
X_09236_ _01256_ _01257_ VGND VGND VPWR VPWR _01258_ sky130_fd_sc_hd__nor2_1
XFILLER_0_35_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09167_ _01190_ _01193_ _01191_ VGND VGND VPWR VPWR _01199_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_133_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09098_ _01135_ _01136_ VGND VGND VPWR VPWR _01137_ sky130_fd_sc_hd__xnor2_1
X_08118_ net151 net499 net508 net297 VGND VGND VPWR VPWR _00171_ sky130_fd_sc_hd__a22o_1
XFILLER_0_9_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08049_ _07261_ _07337_ _07341_ _07342_ VGND VGND VPWR VPWR _07343_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_31_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11060_ _03150_ _03151_ VGND VGND VPWR VPWR _03152_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10011_ _02010_ _02011_ _01927_ _01928_ VGND VGND VPWR VPWR _02013_ sky130_fd_sc_hd__a211oi_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14750_ clknet_3_7_0_clk _00051_ net325 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dfrtp_1
X_11962_ _04120_ _04136_ _04137_ VGND VGND VPWR VPWR _04138_ sky130_fd_sc_hd__nand3_1
X_13701_ _06023_ _06031_ _06032_ VGND VGND VPWR VPWR _06033_ sky130_fd_sc_hd__nand3_1
X_11893_ _03963_ _03976_ VGND VGND VPWR VPWR _04062_ sky130_fd_sc_hd__nand2_1
X_10913_ _02990_ _02991_ VGND VGND VPWR VPWR _02992_ sky130_fd_sc_hd__or2_1
X_14681_ net596 net417 VGND VGND VPWR VPWR _07097_ sky130_fd_sc_hd__and2b_1
X_10844_ a_cos\[11\] _02917_ _02303_ VGND VGND VPWR VPWR _02918_ sky130_fd_sc_hd__mux2_1
X_13632_ _05956_ _05957_ VGND VGND VPWR VPWR _05958_ sky130_fd_sc_hd__and2_1
XFILLER_0_132_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13563_ _05800_ _05785_ _05881_ _05882_ VGND VGND VPWR VPWR _05883_ sky130_fd_sc_hd__o211ai_2
X_12514_ _04581_ _04655_ _04657_ VGND VGND VPWR VPWR _04738_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_81_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10775_ a_cos\[10\] _02842_ _02303_ VGND VGND VPWR VPWR _02844_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13494_ _05802_ _05806_ VGND VGND VPWR VPWR _05807_ sky130_fd_sc_hd__xnor2_1
X_12445_ _04661_ _04645_ _04646_ VGND VGND VPWR VPWR _04664_ sky130_fd_sc_hd__or3_1
XFILLER_0_81_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12376_ net190 net162 VGND VGND VPWR VPWR _04589_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11327_ _03433_ net120 _03442_ _03345_ VGND VGND VPWR VPWR _03443_ sky130_fd_sc_hd__o211a_1
XFILLER_0_1_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14115_ _06479_ _06481_ VGND VGND VPWR VPWR _06484_ sky130_fd_sc_hd__nand2_1
XFILLER_0_120_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11258_ net156 net11 _03334_ _03332_ VGND VGND VPWR VPWR _03367_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14046_ net631 net469 _06406_ _06408_ VGND VGND VPWR VPWR _06409_ sky130_fd_sc_hd__a22o_1
X_11189_ _03279_ _03277_ _03278_ VGND VGND VPWR VPWR _03291_ sky130_fd_sc_hd__nand3_1
XFILLER_0_66_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10209_ _02220_ _02226_ VGND VGND VPWR VPWR _02227_ sky130_fd_sc_hd__xnor2_1
X_07420_ net157 net540 _02505_ _02495_ VGND VGND VPWR VPWR _02766_ sky130_fd_sc_hd__a31o_1
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07351_ _02006_ VGND VGND VPWR VPWR _02017_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09021_ _01055_ _01061_ VGND VGND VPWR VPWR _01062_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout703 net707 VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__clkbuf_4
Xfanout714 net715 VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__clkbuf_2
X_09923_ _01666_ _01923_ VGND VGND VPWR VPWR _01924_ sky130_fd_sc_hd__xnor2_1
Xfanout736 net737 VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__buf_2
Xfanout725 net726 VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__clkbuf_2
X_09854_ _01783_ _01784_ _01790_ VGND VGND VPWR VPWR _01855_ sky130_fd_sc_hd__or3_1
X_08805_ _00782_ _00796_ _00848_ _00849_ VGND VGND VPWR VPWR _00850_ sky130_fd_sc_hd__o211ai_2
X_09785_ net725 net366 _01778_ _01777_ VGND VGND VPWR VPWR _01786_ sky130_fd_sc_hd__a31o_1
X_08736_ _00670_ _00766_ _00780_ VGND VGND VPWR VPWR _00782_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_95_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08667_ _00711_ _00712_ _00651_ VGND VGND VPWR VPWR _00714_ sky130_fd_sc_hd__o21ai_1
X_07618_ _04576_ _04641_ _04663_ VGND VGND VPWR VPWR _04923_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08598_ _00645_ VGND VGND VPWR VPWR _00008_ sky130_fd_sc_hd__clkbuf_1
X_07549_ _02212_ _02146_ _02201_ VGND VGND VPWR VPWR _04173_ sky130_fd_sc_hd__nand3_2
XFILLER_0_36_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10560_ _02511_ _02517_ VGND VGND VPWR VPWR _02609_ sky130_fd_sc_hd__and2b_1
XFILLER_0_8_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09219_ _01243_ VGND VGND VPWR VPWR _00031_ sky130_fd_sc_hd__clkbuf_1
X_10491_ _02532_ _02533_ VGND VGND VPWR VPWR _02534_ sky130_fd_sc_hd__or2_1
X_12230_ _04327_ _04329_ VGND VGND VPWR VPWR _04430_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12161_ _04273_ _04352_ _04353_ VGND VGND VPWR VPWR _04354_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_102_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12092_ _04277_ _04278_ VGND VGND VPWR VPWR _04279_ sky130_fd_sc_hd__xnor2_1
X_11112_ _03206_ _03207_ VGND VGND VPWR VPWR _03208_ sky130_fd_sc_hd__xnor2_1
X_11043_ net187 net432 net424 net273 VGND VGND VPWR VPWR _03133_ sky130_fd_sc_hd__a22o_1
X_14802_ clknet_3_4_0_clk _00103_ net321 VGND VGND VPWR VPWR b_cos\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_99_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12994_ _05227_ _05230_ VGND VGND VPWR VPWR _05258_ sky130_fd_sc_hd__or2b_1
X_11945_ _04111_ _04118_ VGND VGND VPWR VPWR _04120_ sky130_fd_sc_hd__xor2_2
XFILLER_0_99_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14733_ clknet_3_5_0_clk _00034_ net327 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dfrtp_1
X_14664_ b_cos\[16\] _00918_ VGND VGND VPWR VPWR _07079_ sky130_fd_sc_hd__and2_1
XFILLER_0_129_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11876_ _03979_ _04042_ _04044_ VGND VGND VPWR VPWR _04045_ sky130_fd_sc_hd__and3_1
XFILLER_0_67_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13615_ net520 net529 net468 net452 VGND VGND VPWR VPWR _05940_ sky130_fd_sc_hd__and4_1
X_10827_ _02883_ _02793_ _02899_ VGND VGND VPWR VPWR _02900_ sky130_fd_sc_hd__nor3_1
XFILLER_0_7_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14595_ _07002_ _07003_ VGND VGND VPWR VPWR _07005_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10758_ _02730_ _02736_ VGND VGND VPWR VPWR _02825_ sky130_fd_sc_hd__and2b_1
X_13546_ _05861_ _05862_ _05864_ VGND VGND VPWR VPWR _05865_ sky130_fd_sc_hd__nand3_1
X_13477_ _05788_ _05789_ VGND VGND VPWR VPWR _05790_ sky130_fd_sc_hd__xnor2_1
X_12428_ _04624_ _04625_ _04643_ _04644_ VGND VGND VPWR VPWR _04645_ sky130_fd_sc_hd__o211a_1
XFILLER_0_124_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10689_ _02664_ _02683_ _02748_ _02749_ VGND VGND VPWR VPWR _02750_ sky130_fd_sc_hd__o211a_1
XFILLER_0_23_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12359_ net464 net293 VGND VGND VPWR VPWR _04570_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14029_ _06284_ _06290_ VGND VGND VPWR VPWR _06390_ sky130_fd_sc_hd__and2b_1
XFILLER_0_117_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09570_ net701 net332 net475 net710 VGND VGND VPWR VPWR _01571_ sky130_fd_sc_hd__a22oi_2
X_08521_ _00550_ _00551_ VGND VGND VPWR VPWR _00569_ sky130_fd_sc_hd__and2_1
X_08452_ _00413_ _00414_ _00412_ VGND VGND VPWR VPWR _00501_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_133_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07403_ _02244_ _02266_ _02255_ VGND VGND VPWR VPWR _02582_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_93_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08383_ net293 net644 VGND VGND VPWR VPWR _00433_ sky130_fd_sc_hd__and2_1
XFILLER_0_92_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09004_ _00868_ _01044_ VGND VGND VPWR VPWR _01045_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_131_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout522 net526 VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__clkbuf_4
Xfanout533 net534 VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__buf_2
Xfanout500 net501 VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__clkbuf_2
X_09906_ _01895_ _01901_ _01903_ _01906_ VGND VGND VPWR VPWR _01907_ sky130_fd_sc_hd__a22o_1
Xfanout511 net513 VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_6_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout566 net568 VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_67_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout555 net560 VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__clkbuf_2
Xfanout544 net546 VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__clkbuf_4
Xfanout588 net592 VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__clkbuf_4
Xfanout599 net600 VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__clkbuf_4
X_09837_ _01831_ _01832_ _01820_ VGND VGND VPWR VPWR _01838_ sky130_fd_sc_hd__a21o_1
Xfanout577 net579 VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__buf_2
X_09768_ net699 net399 _01742_ _01741_ VGND VGND VPWR VPWR _01769_ sky130_fd_sc_hd__a22o_1
X_08719_ _00703_ _00705_ VGND VGND VPWR VPWR _00765_ sky130_fd_sc_hd__or2_1
X_11730_ net713 net722 net280 net262 VGND VGND VPWR VPWR _03885_ sky130_fd_sc_hd__and4_1
XFILLER_0_96_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09699_ _01690_ _01692_ VGND VGND VPWR VPWR _01700_ sky130_fd_sc_hd__or2b_1
XFILLER_0_96_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11661_ _03807_ _03808_ _03788_ _03789_ VGND VGND VPWR VPWR _03810_ sky130_fd_sc_hd__a211o_1
XFILLER_0_83_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11592_ _03721_ _03722_ _03732_ VGND VGND VPWR VPWR _03734_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_119_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10612_ _02616_ _02664_ _02665_ VGND VGND VPWR VPWR _02666_ sky130_fd_sc_hd__or3_1
X_14380_ _06770_ _06771_ _06675_ _06699_ VGND VGND VPWR VPWR _06772_ sky130_fd_sc_hd__a211oi_2
X_13400_ _05581_ _05704_ VGND VGND VPWR VPWR _05705_ sky130_fd_sc_hd__and2b_1
XFILLER_0_37_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10543_ _02525_ _02510_ VGND VGND VPWR VPWR _02590_ sky130_fd_sc_hd__or2b_1
X_13331_ _05626_ _05627_ _05628_ VGND VGND VPWR VPWR _05629_ sky130_fd_sc_hd__and3_1
XFILLER_0_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10474_ net702 net416 VGND VGND VPWR VPWR _02515_ sky130_fd_sc_hd__and2b_1
X_13262_ _05549_ _05552_ VGND VGND VPWR VPWR _05553_ sky130_fd_sc_hd__xnor2_1
X_12213_ net196 net146 _04408_ _04409_ VGND VGND VPWR VPWR _04411_ sky130_fd_sc_hd__nand4_2
XFILLER_0_121_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13193_ _05294_ _05475_ _05474_ _05464_ VGND VGND VPWR VPWR _05477_ sky130_fd_sc_hd__o211ai_1
X_12144_ _04237_ _04238_ VGND VGND VPWR VPWR _04336_ sky130_fd_sc_hd__nor2_1
XFILLER_0_102_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12075_ _04258_ _04259_ VGND VGND VPWR VPWR _04261_ sky130_fd_sc_hd__xor2_1
XFILLER_0_47_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11026_ net141 net439 _03112_ VGND VGND VPWR VPWR _03115_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12977_ _05189_ _05191_ _05190_ VGND VGND VPWR VPWR _05240_ sky130_fd_sc_hd__a21bo_1
X_11928_ _03989_ _03990_ _03991_ VGND VGND VPWR VPWR _04101_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_87_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14716_ clknet_3_7_0_clk _00017_ net325 VGND VGND VPWR VPWR b_sin\[17\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_28_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11859_ _03918_ _03920_ _03919_ net216 VGND VGND VPWR VPWR _04026_ sky130_fd_sc_hd__a22o_1
XFILLER_0_129_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14647_ _07048_ _07060_ VGND VGND VPWR VPWR _07061_ sky130_fd_sc_hd__nand2_1
XFILLER_0_55_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_29 net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_18 net637 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14578_ _06790_ _06985_ VGND VGND VPWR VPWR _06986_ sky130_fd_sc_hd__and2_1
XFILLER_0_6_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13529_ _05843_ _05844_ _05845_ VGND VGND VPWR VPWR _05846_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_70_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput103 net103 VGND VGND VPWR VPWR Q[2] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07952_ net179 net169 net774 net498 VGND VGND VPWR VPWR _07247_ sky130_fd_sc_hd__nand4_2
X_07883_ _07176_ _07177_ _07178_ VGND VGND VPWR VPWR _07179_ sky130_fd_sc_hd__nand3_1
X_09622_ net691 net340 _01556_ _01555_ VGND VGND VPWR VPWR _01623_ sky130_fd_sc_hd__a31o_1
X_09553_ net674 net359 net349 net683 VGND VGND VPWR VPWR _01554_ sky130_fd_sc_hd__a22oi_1
X_08504_ _00508_ _00552_ VGND VGND VPWR VPWR _00553_ sky130_fd_sc_hd__xor2_1
XFILLER_0_78_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09484_ _01483_ _01484_ VGND VGND VPWR VPWR _01485_ sky130_fd_sc_hd__nor2_1
X_08435_ _00482_ _00484_ VGND VGND VPWR VPWR _00485_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_136_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08366_ _00410_ _00415_ VGND VGND VPWR VPWR _00416_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_80_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08297_ _00344_ _00345_ _00346_ VGND VGND VPWR VPWR _00348_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10190_ _02204_ _02205_ _02084_ _02102_ VGND VGND VPWR VPWR _02207_ sky130_fd_sc_hd__a211oi_2
Xfanout341 net53 VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__clkbuf_4
Xfanout330 net332 VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__clkbuf_4
Xfanout352 net354 VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__clkbuf_4
Xfanout374 net5 VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__buf_2
Xfanout363 net364 VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_17_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12900_ _05111_ _05128_ _05132_ VGND VGND VPWR VPWR _05156_ sky130_fd_sc_hd__a21oi_1
Xfanout396 net397 VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__buf_4
X_13880_ _06223_ _06226_ _06227_ VGND VGND VPWR VPWR _06228_ sky130_fd_sc_hd__nand3_1
Xfanout385 net386 VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__buf_2
X_12831_ _05005_ _05045_ _05081_ VGND VGND VPWR VPWR _05082_ sky130_fd_sc_hd__and3_1
XFILLER_0_69_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12762_ _04787_ _04862_ _04933_ VGND VGND VPWR VPWR _05007_ sky130_fd_sc_hd__o21a_1
XFILLER_0_69_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12693_ _04873_ _04929_ _04931_ VGND VGND VPWR VPWR _04932_ sky130_fd_sc_hd__a21oi_1
X_11713_ _03851_ VGND VGND VPWR VPWR _03866_ sky130_fd_sc_hd__inv_2
XFILLER_0_56_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14501_ _06901_ _06902_ VGND VGND VPWR VPWR _06903_ sky130_fd_sc_hd__xor2_1
XFILLER_0_139_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11644_ _03723_ _03731_ VGND VGND VPWR VPWR _03791_ sky130_fd_sc_hd__nand2_1
XFILLER_0_127_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14432_ _06826_ _06827_ VGND VGND VPWR VPWR _06828_ sky130_fd_sc_hd__nor2_1
XFILLER_0_142_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11575_ net212 net556 net651 net203 VGND VGND VPWR VPWR _03716_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_135_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput16 alpha[7] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_92_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14363_ _06751_ _06752_ VGND VGND VPWR VPWR _06753_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput27 beta[17] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_2
Xinput49 cos[4] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_4
X_10526_ _02552_ _02572_ VGND VGND VPWR VPWR _02573_ sky130_fd_sc_hd__xnor2_1
X_14294_ _06557_ _06561_ _06558_ VGND VGND VPWR VPWR _06678_ sky130_fd_sc_hd__o21ba_1
Xinput38 cos[10] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__buf_1
X_13314_ _05554_ _05548_ _05553_ VGND VGND VPWR VPWR _05610_ sky130_fd_sc_hd__a21o_1
X_10457_ _02496_ _02497_ VGND VGND VPWR VPWR _02498_ sky130_fd_sc_hd__and2_1
XFILLER_0_52_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13245_ _05528_ _05532_ _05506_ _05505_ VGND VGND VPWR VPWR _05535_ sky130_fd_sc_hd__a211o_1
XFILLER_0_58_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10388_ _02420_ _02421_ VGND VGND VPWR VPWR _02422_ sky130_fd_sc_hd__nor2_1
X_13176_ _05455_ _05458_ VGND VGND VPWR VPWR _05459_ sky130_fd_sc_hd__xnor2_1
X_12127_ _04221_ _04222_ _04226_ _04317_ VGND VGND VPWR VPWR _04318_ sky130_fd_sc_hd__o31ai_2
X_12058_ _04242_ VGND VGND VPWR VPWR _04243_ sky130_fd_sc_hd__inv_2
XFILLER_0_74_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11009_ _03008_ _03034_ _03095_ VGND VGND VPWR VPWR _03097_ sky130_fd_sc_hd__a21o_1
XFILLER_0_74_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08220_ _00269_ _00270_ _00262_ VGND VGND VPWR VPWR _00272_ sky130_fd_sc_hd__a21o_1
XFILLER_0_90_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08151_ net222 net588 VGND VGND VPWR VPWR _00204_ sky130_fd_sc_hd__nand2_1
XFILLER_0_83_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08082_ _00134_ _00135_ VGND VGND VPWR VPWR _00136_ sky130_fd_sc_hd__nand2_2
XFILLER_0_70_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08984_ _00937_ _00983_ _01024_ VGND VGND VPWR VPWR _01026_ sky130_fd_sc_hd__a21o_1
X_07935_ net149 net297 net516 net524 VGND VGND VPWR VPWR _07230_ sky130_fd_sc_hd__and4_1
X_07866_ _07159_ _07160_ _07161_ VGND VGND VPWR VPWR _07162_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_98_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09605_ net718 net727 net451 net443 VGND VGND VPWR VPWR _01606_ sky130_fd_sc_hd__and4_1
X_07797_ net218 net660 _06863_ VGND VGND VPWR VPWR _06874_ sky130_fd_sc_hd__and3_1
X_09536_ net270 net491 net411 net371 VGND VGND VPWR VPWR _01537_ sky130_fd_sc_hd__a22o_1
XFILLER_0_65_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09467_ _01460_ _01467_ VGND VGND VPWR VPWR _01468_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08418_ _00465_ _00466_ _00375_ _00445_ VGND VGND VPWR VPWR _00468_ sky130_fd_sc_hd__o211a_1
XFILLER_0_108_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09398_ _01397_ _01398_ VGND VGND VPWR VPWR _01399_ sky130_fd_sc_hd__nor2_1
XFILLER_0_80_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08349_ b_sin\[5\] _00399_ _02027_ VGND VGND VPWR VPWR _00400_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_129_Right_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11360_ _03460_ _03461_ _03467_ VGND VGND VPWR VPWR _03479_ sky130_fd_sc_hd__a21o_1
XFILLER_0_116_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10311_ net666 net471 VGND VGND VPWR VPWR _02338_ sky130_fd_sc_hd__and2_1
XFILLER_0_22_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11291_ _03400_ _03401_ _03271_ VGND VGND VPWR VPWR _03403_ sky130_fd_sc_hd__a21o_1
X_13030_ net629 net402 VGND VGND VPWR VPWR _05298_ sky130_fd_sc_hd__and2_1
XFILLER_0_14_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10242_ net372 net362 net352 net459 VGND VGND VPWR VPWR _02263_ sky130_fd_sc_hd__a22o_1
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10173_ _02186_ _02184_ _02185_ VGND VGND VPWR VPWR _02188_ sky130_fd_sc_hd__nand3_1
Xfanout160 net163 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__clkbuf_4
Xfanout182 net183 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__buf_2
Xfanout171 net173 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__buf_2
XFILLER_0_135_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout193 net195 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__clkbuf_4
X_13932_ _06202_ _06205_ _06203_ VGND VGND VPWR VPWR _06284_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_88_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13863_ net495 net469 VGND VGND VPWR VPWR _06209_ sky130_fd_sc_hd__and2_1
X_12814_ net189 net252 net244 net276 VGND VGND VPWR VPWR _05063_ sky130_fd_sc_hd__a22o_1
X_13794_ _06114_ _06133_ VGND VGND VPWR VPWR _06134_ sky130_fd_sc_hd__xor2_2
X_12745_ _04987_ _04936_ VGND VGND VPWR VPWR _04989_ sky130_fd_sc_hd__nor2_1
XFILLER_0_97_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12676_ _04912_ _04914_ VGND VGND VPWR VPWR _04915_ sky130_fd_sc_hd__nor2_1
X_11627_ _03769_ _03771_ _03772_ VGND VGND VPWR VPWR _03773_ sky130_fd_sc_hd__nand3_2
XFILLER_0_65_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14415_ _06801_ _06808_ VGND VGND VPWR VPWR _06810_ sky130_fd_sc_hd__xnor2_1
X_11558_ _03694_ _03695_ _03696_ VGND VGND VPWR VPWR _03697_ sky130_fd_sc_hd__a21o_1
X_14346_ net596 net469 VGND VGND VPWR VPWR _06735_ sky130_fd_sc_hd__nand2_1
XFILLER_0_40_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10509_ net132 _02466_ _02467_ VGND VGND VPWR VPWR _02554_ sky130_fd_sc_hd__and3_1
X_11489_ _03381_ _03569_ _03619_ _03620_ VGND VGND VPWR VPWR _03621_ sky130_fd_sc_hd__a211o_1
X_14277_ _06656_ _06658_ _06638_ _06639_ VGND VGND VPWR VPWR _06660_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_0_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13228_ net543 net365 _05487_ _05488_ VGND VGND VPWR VPWR _05516_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_85_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13159_ net535 net365 VGND VGND VPWR VPWR _05440_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07720_ _05644_ _05578_ _05633_ VGND VGND VPWR VPWR _06037_ sky130_fd_sc_hd__nand3_1
XFILLER_0_79_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07651_ _05010_ _05270_ VGND VGND VPWR VPWR _05281_ sky130_fd_sc_hd__xnor2_1
X_07582_ net209 net200 net522 net532 VGND VGND VPWR VPWR _04533_ sky130_fd_sc_hd__and4_1
X_09321_ _01328_ _01329_ VGND VGND VPWR VPWR _01330_ sky130_fd_sc_hd__or2_1
XFILLER_0_48_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09252_ _01269_ _01270_ VGND VGND VPWR VPWR _01271_ sky130_fd_sc_hd__or2b_1
XFILLER_0_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08203_ _00157_ _00254_ VGND VGND VPWR VPWR _00255_ sky130_fd_sc_hd__xor2_2
X_09183_ net91 _01212_ net130 VGND VGND VPWR VPWR _01213_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08134_ net179 net627 net636 net169 VGND VGND VPWR VPWR _00187_ sky130_fd_sc_hd__a22o_1
XFILLER_0_71_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08065_ _00110_ _00118_ VGND VGND VPWR VPWR _00119_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08967_ _00924_ _00927_ _01008_ VGND VGND VPWR VPWR _01009_ sky130_fd_sc_hd__nor3_1
X_08898_ _00868_ _00882_ _00940_ VGND VGND VPWR VPWR _00941_ sky130_fd_sc_hd__o21ai_1
X_07918_ _07208_ _07212_ VGND VGND VPWR VPWR _07213_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07849_ net149 net524 net534 net297 VGND VGND VPWR VPWR _07145_ sky130_fd_sc_hd__a22oi_2
X_10860_ _02933_ _02934_ VGND VGND VPWR VPWR _02935_ sky130_fd_sc_hd__nor2_1
X_09519_ _01506_ _01507_ _01518_ VGND VGND VPWR VPWR _01520_ sky130_fd_sc_hd__and3_1
XFILLER_0_137_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10791_ net272 net456 net447 net373 VGND VGND VPWR VPWR _02860_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_38_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12530_ _04754_ _04755_ VGND VGND VPWR VPWR _04756_ sky130_fd_sc_hd__xor2_1
X_12461_ _04679_ _04680_ VGND VGND VPWR VPWR _04681_ sky130_fd_sc_hd__or2_1
XFILLER_0_47_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11412_ _00201_ _01898_ _03530_ _03535_ VGND VGND VPWR VPWR _03536_ sky130_fd_sc_hd__or4_1
X_14200_ net585 _06518_ VGND VGND VPWR VPWR _06576_ sky130_fd_sc_hd__nand2_1
X_12392_ _04534_ _04535_ _04604_ _04605_ VGND VGND VPWR VPWR _04606_ sky130_fd_sc_hd__a211oi_2
X_14131_ _06499_ _06500_ VGND VGND VPWR VPWR _06501_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_120_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11343_ _03454_ _03458_ _03459_ VGND VGND VPWR VPWR _03460_ sky130_fd_sc_hd__nand3_1
XFILLER_0_1_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11274_ _03328_ _03336_ VGND VGND VPWR VPWR _03384_ sky130_fd_sc_hd__or2b_1
X_14062_ _06239_ _06425_ VGND VGND VPWR VPWR _06426_ sky130_fd_sc_hd__xor2_1
X_10225_ _02242_ _02243_ VGND VGND VPWR VPWR _02245_ sky130_fd_sc_hd__nor2_1
X_13013_ _05277_ _05278_ VGND VGND VPWR VPWR _05279_ sky130_fd_sc_hd__and2_1
X_10156_ _02167_ _02169_ VGND VGND VPWR VPWR _02170_ sky130_fd_sc_hd__nand2_1
X_10087_ _01948_ _02088_ _02093_ VGND VGND VPWR VPWR _02095_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_89_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13915_ _06083_ _06084_ _06172_ VGND VGND VPWR VPWR _06267_ sky130_fd_sc_hd__or3_1
XFILLER_0_57_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13846_ _06188_ _06190_ VGND VGND VPWR VPWR _06191_ sky130_fd_sc_hd__nor2_1
X_10989_ net273 net432 net424 net374 VGND VGND VPWR VPWR _03075_ sky130_fd_sc_hd__a22oi_1
X_13777_ _06040_ _06047_ _06115_ VGND VGND VPWR VPWR _06116_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_127_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12728_ _04909_ _04910_ _04970_ VGND VGND VPWR VPWR _04971_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_84_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12659_ _04894_ _04895_ VGND VGND VPWR VPWR _04896_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmax_cap113 _04841_ VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__buf_1
XFILLER_0_111_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmax_cap124 _05776_ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__buf_1
XFILLER_0_4_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14329_ _06661_ _06715_ VGND VGND VPWR VPWR _06716_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_20_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09870_ net724 net399 _01811_ _01810_ VGND VGND VPWR VPWR _01871_ sky130_fd_sc_hd__a22o_1
XFILLER_0_110_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08821_ _00810_ _00811_ VGND VGND VPWR VPWR _00865_ sky130_fd_sc_hd__and2_1
X_08752_ _00743_ _00742_ VGND VGND VPWR VPWR _00797_ sky130_fd_sc_hd__and2b_1
X_08683_ _00667_ _00666_ VGND VGND VPWR VPWR _00729_ sky130_fd_sc_hd__and2b_1
X_07703_ net147 net661 _05819_ _05830_ VGND VGND VPWR VPWR _05852_ sky130_fd_sc_hd__a211oi_1
X_07634_ net174 net164 net566 net574 VGND VGND VPWR VPWR _05096_ sky130_fd_sc_hd__and4_1
XFILLER_0_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07565_ _04021_ _04097_ VGND VGND VPWR VPWR _04347_ sky130_fd_sc_hd__xor2_2
X_07496_ _03561_ _03572_ _02745_ _03253_ VGND VGND VPWR VPWR _03594_ sky130_fd_sc_hd__o211a_1
XFILLER_0_91_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09304_ _01315_ VGND VGND VPWR VPWR _00044_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_75_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09235_ a_cos\[16\] b_sin\[16\] VGND VGND VPWR VPWR _01257_ sky130_fd_sc_hd__nor2_1
XFILLER_0_134_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09166_ _01196_ _01197_ VGND VGND VPWR VPWR _01198_ sky130_fd_sc_hd__and2b_1
XFILLER_0_50_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09097_ _00993_ _01088_ _00984_ VGND VGND VPWR VPWR _01136_ sky130_fd_sc_hd__o21a_1
X_08117_ _00168_ _00169_ VGND VGND VPWR VPWR _00170_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_31_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08048_ _07339_ _07340_ _07338_ VGND VGND VPWR VPWR _07342_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_102_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10010_ _01927_ _01928_ _02010_ _02011_ VGND VGND VPWR VPWR _02012_ sky130_fd_sc_hd__o211a_1
X_09999_ _01997_ _01998_ _01650_ _01966_ VGND VGND VPWR VPWR _02000_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_99_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11961_ _04133_ _04134_ _04135_ VGND VGND VPWR VPWR _04137_ sky130_fd_sc_hd__a21o_1
XFILLER_0_86_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10912_ net186 net141 net457 net448 VGND VGND VPWR VPWR _02991_ sky130_fd_sc_hd__and4_1
X_13700_ _06028_ _06029_ _06030_ VGND VGND VPWR VPWR _06032_ sky130_fd_sc_hd__a21o_1
X_11892_ _04047_ VGND VGND VPWR VPWR _04061_ sky130_fd_sc_hd__inv_2
X_14680_ net587 net424 VGND VGND VPWR VPWR _07096_ sky130_fd_sc_hd__nand2_1
X_10843_ _02913_ _02916_ VGND VGND VPWR VPWR _02917_ sky130_fd_sc_hd__xor2_1
X_13631_ _05954_ _05955_ _05935_ VGND VGND VPWR VPWR _05957_ sky130_fd_sc_hd__a21o_1
XFILLER_0_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10774_ _02767_ _02841_ VGND VGND VPWR VPWR _02842_ sky130_fd_sc_hd__xnor2_1
X_13562_ _05879_ _05880_ _05814_ VGND VGND VPWR VPWR _05882_ sky130_fd_sc_hd__a21o_1
XFILLER_0_136_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12513_ _04582_ _04736_ VGND VGND VPWR VPWR _04737_ sky130_fd_sc_hd__xor2_1
XFILLER_0_54_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13493_ _05803_ _05805_ VGND VGND VPWR VPWR _05806_ sky130_fd_sc_hd__nand2_1
X_12444_ _04645_ _04646_ _04661_ VGND VGND VPWR VPWR _04662_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_23_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12375_ _04585_ _04586_ VGND VGND VPWR VPWR _04588_ sky130_fd_sc_hd__nor2_1
XFILLER_0_50_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11326_ _03340_ _03342_ _03344_ VGND VGND VPWR VPWR _03442_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14114_ _06479_ _06481_ VGND VGND VPWR VPWR _06482_ sky130_fd_sc_hd__or2_1
X_14045_ net615 net622 net333 net478 VGND VGND VPWR VPWR _06408_ sky130_fd_sc_hd__nand4_2
X_11257_ _03361_ _03364_ _03362_ VGND VGND VPWR VPWR _03366_ sky130_fd_sc_hd__a21o_1
X_11188_ _03282_ _03283_ _03289_ VGND VGND VPWR VPWR _03290_ sky130_fd_sc_hd__nand3_1
X_10208_ _02224_ _02225_ VGND VGND VPWR VPWR _02226_ sky130_fd_sc_hd__xor2_1
X_10139_ net666 net675 net335 net477 VGND VGND VPWR VPWR _02151_ sky130_fd_sc_hd__nand4_2
XFILLER_0_89_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13829_ _06084_ _06088_ _06083_ VGND VGND VPWR VPWR _06173_ sky130_fd_sc_hd__o21bai_1
X_07350_ net74 _01995_ VGND VGND VPWR VPWR _02006_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09020_ _01059_ net127 VGND VGND VPWR VPWR _01061_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout704 net707 VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__clkbuf_2
Xfanout715 net13 VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__clkbuf_8
X_09922_ _01715_ _01922_ VGND VGND VPWR VPWR _01923_ sky130_fd_sc_hd__and2b_1
XFILLER_0_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout737 net739 VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__buf_2
Xfanout726 net728 VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__buf_2
X_09853_ _01783_ _01784_ _01790_ VGND VGND VPWR VPWR _01854_ sky130_fd_sc_hd__o21ai_1
X_08804_ _00764_ net114 _00845_ _00846_ VGND VGND VPWR VPWR _00849_ sky130_fd_sc_hd__o211ai_4
X_09784_ net733 net740 net358 net348 VGND VGND VPWR VPWR _01785_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_0_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08735_ _00670_ _00766_ _00780_ VGND VGND VPWR VPWR _00781_ sky130_fd_sc_hd__and3_1
X_08666_ _00651_ _00711_ _00712_ VGND VGND VPWR VPWR _00713_ sky130_fd_sc_hd__or3_1
XFILLER_0_68_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07617_ _04891_ _04880_ _04869_ _04837_ VGND VGND VPWR VPWR _04913_ sky130_fd_sc_hd__o211ai_2
X_08597_ b_sin\[8\] _00644_ _00486_ VGND VGND VPWR VPWR _00645_ sky130_fd_sc_hd__mux2_1
X_07548_ _02897_ _02908_ _03221_ _03232_ VGND VGND VPWR VPWR _04162_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_48_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07479_ _03363_ _03396_ VGND VGND VPWR VPWR _03407_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_64_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_46_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09218_ net79 _01242_ net130 VGND VGND VPWR VPWR _01243_ sky130_fd_sc_hd__mux2_1
X_10490_ net649 net666 net454 net447 VGND VGND VPWR VPWR _02533_ sky130_fd_sc_hd__and4_1
XFILLER_0_23_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09149_ _01183_ VGND VGND VPWR VPWR _00021_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12160_ _04274_ _04291_ VGND VGND VPWR VPWR _04353_ sky130_fd_sc_hd__nor2_1
XFILLER_0_121_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11111_ _03085_ _03086_ _03147_ _03145_ _03129_ VGND VGND VPWR VPWR _03207_ sky130_fd_sc_hd__o32a_1
X_12091_ net697 net257 VGND VGND VPWR VPWR _04278_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11042_ _03058_ _03061_ _03131_ VGND VGND VPWR VPWR _03132_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_55_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14801_ clknet_3_6_0_clk _00102_ net321 VGND VGND VPWR VPWR b_cos\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_98_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12993_ _05254_ _05255_ _05239_ VGND VGND VPWR VPWR _05257_ sky130_fd_sc_hd__a21o_1
X_11944_ _04112_ _04117_ VGND VGND VPWR VPWR _04118_ sky130_fd_sc_hd__xor2_2
X_14732_ clknet_3_5_0_clk _00033_ net327 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_59_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11875_ _04040_ _04041_ _03980_ _03942_ VGND VGND VPWR VPWR _04044_ sky130_fd_sc_hd__a211o_1
XFILLER_0_98_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14663_ _07021_ _07024_ _07076_ VGND VGND VPWR VPWR _07078_ sky130_fd_sc_hd__or3_1
X_10826_ _02895_ _02898_ VGND VGND VPWR VPWR _02899_ sky130_fd_sc_hd__xor2_1
XFILLER_0_39_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13614_ net520 net468 net452 net529 VGND VGND VPWR VPWR _05938_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_27_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14594_ _06999_ _07000_ _07001_ VGND VGND VPWR VPWR _07003_ sky130_fd_sc_hd__and3_1
XFILLER_0_109_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10757_ _02822_ _02823_ VGND VGND VPWR VPWR _02824_ sky130_fd_sc_hd__or2_1
XFILLER_0_39_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13545_ _05762_ _05764_ _05763_ VGND VGND VPWR VPWR _05864_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_124_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10688_ _02726_ _02727_ _02747_ VGND VGND VPWR VPWR _02749_ sky130_fd_sc_hd__o21ai_1
X_13476_ _05422_ _05426_ _05421_ VGND VGND VPWR VPWR _05789_ sky130_fd_sc_hd__a21boi_2
X_12427_ _04626_ _04627_ _04642_ VGND VGND VPWR VPWR _04644_ sky130_fd_sc_hd__nand3_2
XFILLER_0_125_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12358_ _04567_ _04568_ VGND VGND VPWR VPWR _04569_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11309_ _03404_ _03421_ _03420_ VGND VGND VPWR VPWR _03423_ sky130_fd_sc_hd__a21oi_1
X_12289_ _04492_ _04493_ VGND VGND VPWR VPWR _04494_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14028_ _06387_ _06388_ VGND VGND VPWR VPWR _06389_ sky130_fd_sc_hd__or2_1
XFILLER_0_93_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08520_ _00492_ _00507_ VGND VGND VPWR VPWR _00568_ sky130_fd_sc_hd__or2_1
XFILLER_0_78_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08451_ _00494_ _00499_ VGND VGND VPWR VPWR _00500_ sky130_fd_sc_hd__xnor2_1
X_07402_ _02309_ _02364_ _02299_ VGND VGND VPWR VPWR _02571_ sky130_fd_sc_hd__a21bo_1
X_08382_ net151 net299 net625 net635 VGND VGND VPWR VPWR _00432_ sky130_fd_sc_hd__nand4_2
XFILLER_0_85_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09003_ _00993_ _01043_ VGND VGND VPWR VPWR _01044_ sky130_fd_sc_hd__xor2_1
XFILLER_0_84_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout523 net526 VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__clkbuf_2
X_09905_ _01901_ _01904_ _01905_ _01895_ _01880_ VGND VGND VPWR VPWR _01906_ sky130_fd_sc_hd__o221a_1
XFILLER_0_6_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout512 net513 VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__clkbuf_4
Xfanout501 net36 VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__buf_8
Xfanout556 net559 VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__clkbuf_4
Xfanout534 net32 VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__clkbuf_4
Xfanout545 net546 VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__clkbuf_4
Xfanout589 net591 VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__buf_2
Xfanout567 net568 VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__buf_2
X_09836_ net741 net358 _01816_ _01834_ VGND VGND VPWR VPWR _01837_ sky130_fd_sc_hd__a211o_1
Xfanout578 net579 VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__buf_4
X_09767_ _01742_ _01740_ _01741_ VGND VGND VPWR VPWR _01768_ sky130_fd_sc_hd__nand3_1
XFILLER_0_96_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08718_ _00686_ _00762_ _00760_ _00761_ VGND VGND VPWR VPWR _00764_ sky130_fd_sc_hd__o211a_2
XFILLER_0_69_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09698_ _01697_ _01696_ _01695_ _01684_ VGND VGND VPWR VPWR _01699_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_96_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08649_ net251 net500 net509 net243 VGND VGND VPWR VPWR _00696_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_139_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11660_ _03788_ _03789_ _03807_ _03808_ VGND VGND VPWR VPWR _03809_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_37_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11591_ _03721_ _03722_ _03732_ VGND VGND VPWR VPWR _03733_ sky130_fd_sc_hd__and3_1
XFILLER_0_107_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10611_ _02662_ _02663_ _02617_ _02618_ VGND VGND VPWR VPWR _02665_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_36_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10542_ _02589_ VGND VGND VPWR VPWR _00062_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_51_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13330_ _05608_ _05605_ _05607_ VGND VGND VPWR VPWR _05628_ sky130_fd_sc_hd__a21o_1
XFILLER_0_106_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13261_ _05550_ _05551_ VGND VGND VPWR VPWR _05552_ sky130_fd_sc_hd__nor2_1
X_12212_ net196 net143 _04408_ _04409_ VGND VGND VPWR VPWR _04410_ sky130_fd_sc_hd__a22o_1
XFILLER_0_122_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10473_ _02512_ _02513_ VGND VGND VPWR VPWR _02514_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13192_ _05464_ _05474_ _05475_ _05294_ VGND VGND VPWR VPWR _05476_ sky130_fd_sc_hd__a211o_1
X_12143_ _04251_ _04334_ VGND VGND VPWR VPWR _04335_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_63_Left_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12074_ net723 net235 VGND VGND VPWR VPWR _04259_ sky130_fd_sc_hd__and2b_1
XFILLER_0_47_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11025_ net439 _03112_ VGND VGND VPWR VPWR _03114_ sky130_fd_sc_hd__and2_1
XFILLER_0_2_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14715_ clknet_3_7_0_clk _00016_ net325 VGND VGND VPWR VPWR b_sin\[16\] sky130_fd_sc_hd__dfrtp_1
X_12976_ _05196_ _05201_ _05195_ VGND VGND VPWR VPWR _05239_ sky130_fd_sc_hd__a21bo_1
X_11927_ _04095_ _04096_ _04098_ VGND VGND VPWR VPWR _04100_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_72_Left_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11858_ _03910_ _03911_ VGND VGND VPWR VPWR _04025_ sky130_fd_sc_hd__nand2_1
X_14646_ _07057_ _07059_ VGND VGND VPWR VPWR _07060_ sky130_fd_sc_hd__nor2_1
XFILLER_0_138_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11789_ _03947_ _03948_ _03866_ _03853_ VGND VGND VPWR VPWR _03950_ sky130_fd_sc_hd__a211o_1
XFILLER_0_103_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_19 net655 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_10809_ _02846_ _02806_ _02879_ VGND VGND VPWR VPWR _02880_ sky130_fd_sc_hd__and3_1
XFILLER_0_6_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14577_ _06977_ _06984_ VGND VGND VPWR VPWR _06985_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_28_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13528_ net639 net494 net360 net346 VGND VGND VPWR VPWR _05845_ sky130_fd_sc_hd__nand4_1
XFILLER_0_12_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13459_ _05766_ _05767_ _05768_ VGND VGND VPWR VPWR _05770_ sky130_fd_sc_hd__a21o_1
XFILLER_0_113_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_81_Left_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput104 net104 VGND VGND VPWR VPWR Q[3] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_51_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07951_ net179 net774 net498 net169 VGND VGND VPWR VPWR _07246_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07882_ _03286_ _03308_ _03297_ VGND VGND VPWR VPWR _07178_ sky130_fd_sc_hd__a21bo_1
X_09621_ _01549_ _01550_ _01559_ VGND VGND VPWR VPWR _01622_ sky130_fd_sc_hd__nand3_2
X_09552_ net691 net340 VGND VGND VPWR VPWR _01553_ sky130_fd_sc_hd__nand2_1
X_08503_ _00550_ _00551_ VGND VGND VPWR VPWR _00552_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_90_Left_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09483_ net647 net392 net383 net664 VGND VGND VPWR VPWR _01484_ sky130_fd_sc_hd__a22oi_2
X_08434_ _00393_ _00398_ _00483_ VGND VGND VPWR VPWR _00484_ sky130_fd_sc_hd__o21ai_1
X_08365_ _00413_ _00414_ VGND VGND VPWR VPWR _00415_ sky130_fd_sc_hd__xor2_1
XFILLER_0_58_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08296_ _00344_ _00345_ _00346_ VGND VGND VPWR VPWR _00347_ sky130_fd_sc_hd__nand3_1
XFILLER_0_131_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout331 net332 VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__clkbuf_2
Xfanout320 net321 VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__clkbuf_4
Xfanout375 net376 VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__clkbuf_4
Xfanout364 net51 VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__buf_4
Xfanout353 net354 VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__clkbuf_2
Xfanout342 net343 VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_129_Left_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout397 net48 VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__buf_4
X_09819_ _01813_ _01818_ _01819_ VGND VGND VPWR VPWR _01820_ sky130_fd_sc_hd__a21bo_1
Xfanout386 net387 VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__buf_2
X_12830_ _05058_ _05080_ VGND VGND VPWR VPWR _05081_ sky130_fd_sc_hd__xor2_1
XFILLER_0_96_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12761_ _05004_ _05005_ VGND VGND VPWR VPWR _05006_ sky130_fd_sc_hd__nand2_1
XFILLER_0_139_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12692_ _04872_ _04930_ net291 VGND VGND VPWR VPWR _04931_ sky130_fd_sc_hd__o21a_1
X_11712_ _03764_ _03769_ _03853_ _03854_ VGND VGND VPWR VPWR _03865_ sky130_fd_sc_hd__a211oi_2
X_14500_ _06813_ _06814_ _06840_ VGND VGND VPWR VPWR _06902_ sky130_fd_sc_hd__o21ai_1
X_11643_ _03724_ _03730_ VGND VGND VPWR VPWR _03790_ sky130_fd_sc_hd__or2b_1
XFILLER_0_83_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14431_ _06753_ _06754_ _06752_ VGND VGND VPWR VPWR _06827_ sky130_fd_sc_hd__a21o_1
Xinput17 alpha[8] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_1
X_11574_ net212 net203 net556 net651 VGND VGND VPWR VPWR _03714_ sky130_fd_sc_hd__and4_1
XFILLER_0_141_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_138_Left_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput28 beta[1] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_2
X_14362_ net632 net641 net431 net423 VGND VGND VPWR VPWR _06752_ sky130_fd_sc_hd__and4_1
XFILLER_0_18_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10525_ _02569_ _02570_ VGND VGND VPWR VPWR _02572_ sky130_fd_sc_hd__xnor2_1
Xinput39 cos[11] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__buf_1
X_14293_ _06553_ _06554_ _06572_ _06573_ VGND VGND VPWR VPWR _06677_ sky130_fd_sc_hd__o211ai_1
X_13313_ _05605_ _05607_ _05608_ VGND VGND VPWR VPWR _05609_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_122_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10456_ _02404_ _02405_ _02494_ VGND VGND VPWR VPWR _02497_ sky130_fd_sc_hd__or3_1
X_13244_ _05505_ _05506_ _05532_ _05528_ VGND VGND VPWR VPWR _05533_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_33_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13175_ _05456_ _05224_ VGND VGND VPWR VPWR _05458_ sky130_fd_sc_hd__xnor2_1
X_12126_ _04312_ VGND VGND VPWR VPWR _04317_ sky130_fd_sc_hd__inv_2
XFILLER_0_103_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10387_ _02314_ _02315_ _02313_ VGND VGND VPWR VPWR _02421_ sky130_fd_sc_hd__a21o_1
XFILLER_0_20_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12057_ _04149_ _04163_ _04241_ VGND VGND VPWR VPWR _04242_ sky130_fd_sc_hd__or3_1
XFILLER_0_74_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11008_ _03008_ _03034_ _03095_ VGND VGND VPWR VPWR _03096_ sky130_fd_sc_hd__nand3_1
XFILLER_0_48_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12959_ _05202_ _05218_ _05219_ VGND VGND VPWR VPWR _05220_ sky130_fd_sc_hd__nand3_2
XFILLER_0_142_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14629_ _07030_ _06987_ _07040_ VGND VGND VPWR VPWR _07041_ sky130_fd_sc_hd__nor3_1
XFILLER_0_117_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08150_ net580 _00201_ _00202_ net588 net222 VGND VGND VPWR VPWR _00203_ sky130_fd_sc_hd__a32o_1
XFILLER_0_82_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08081_ _00132_ _00133_ _07293_ VGND VGND VPWR VPWR _00135_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_43_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08983_ _00937_ _00983_ _01024_ VGND VGND VPWR VPWR _01025_ sky130_fd_sc_hd__and3_1
X_07934_ net149 net516 net524 net297 VGND VGND VPWR VPWR _07229_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_48_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07865_ net177 net167 net498 net507 VGND VGND VPWR VPWR _07161_ sky130_fd_sc_hd__nand4_2
XFILLER_0_97_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09604_ net718 net451 net443 net727 VGND VGND VPWR VPWR _01605_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_3_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07796_ _06842_ _06853_ VGND VGND VPWR VPWR _06863_ sky130_fd_sc_hd__nor2_1
X_09535_ net270 net371 net491 net411 VGND VGND VPWR VPWR _01536_ sky130_fd_sc_hd__nand4_2
X_09466_ _01461_ _01466_ VGND VGND VPWR VPWR _01467_ sky130_fd_sc_hd__xnor2_1
X_08417_ _00375_ _00445_ _00465_ _00466_ VGND VGND VPWR VPWR _00467_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_65_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09397_ net682 net690 net391 net381 VGND VGND VPWR VPWR _01398_ sky130_fd_sc_hd__and4_1
XFILLER_0_19_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08348_ _00393_ _00398_ VGND VGND VPWR VPWR _00399_ sky130_fd_sc_hd__xor2_1
XFILLER_0_74_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08279_ _00328_ _00329_ VGND VGND VPWR VPWR _00330_ sky130_fd_sc_hd__nor2_1
XFILLER_0_61_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11290_ _03271_ _03400_ _03401_ VGND VGND VPWR VPWR _03402_ sky130_fd_sc_hd__nand3_1
XFILLER_0_61_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10310_ net554 net649 net335 net480 VGND VGND VPWR VPWR _02337_ sky130_fd_sc_hd__nand4_1
XFILLER_0_15_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10241_ net371 net370 _02177_ _02176_ net387 VGND VGND VPWR VPWR _02262_ sky130_fd_sc_hd__a32o_1
XFILLER_0_15_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10172_ _02184_ _02185_ _02186_ VGND VGND VPWR VPWR _02187_ sky130_fd_sc_hd__a21o_1
Xfanout172 net173 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__buf_2
Xfanout183 net70 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__buf_4
Xfanout150 net73 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__clkbuf_4
Xfanout161 net163 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__clkbuf_4
X_13931_ _06199_ _06281_ _06282_ VGND VGND VPWR VPWR _06283_ sky130_fd_sc_hd__a21oi_1
Xfanout194 net195 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__buf_2
X_13862_ net631 net640 net334 net478 VGND VGND VPWR VPWR _06208_ sky130_fd_sc_hd__nand4_1
X_12813_ _05009_ _05015_ VGND VGND VPWR VPWR _05062_ sky130_fd_sc_hd__and2b_1
X_13793_ _06116_ _06132_ VGND VGND VPWR VPWR _06133_ sky130_fd_sc_hd__xnor2_2
X_12744_ _04986_ VGND VGND VPWR VPWR _04987_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_97_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12675_ _04843_ _04844_ _04910_ _04911_ VGND VGND VPWR VPWR _04914_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_37_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11626_ _03691_ _03692_ _03689_ VGND VGND VPWR VPWR _03772_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_108_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14414_ _06803_ _06807_ VGND VGND VPWR VPWR _06808_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_142_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11557_ _03394_ _03622_ _03621_ VGND VGND VPWR VPWR _03696_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14345_ net587 _06731_ _06732_ VGND VGND VPWR VPWR _06734_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_25_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10508_ _02369_ _02468_ _02472_ _02372_ VGND VGND VPWR VPWR _02553_ sky130_fd_sc_hd__a31o_1
X_11488_ _03603_ _03604_ _03618_ VGND VGND VPWR VPWR _03620_ sky130_fd_sc_hd__nor3_2
XFILLER_0_100_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14276_ _06638_ _06639_ _06656_ _06658_ VGND VGND VPWR VPWR _06659_ sky130_fd_sc_hd__o211a_1
XFILLER_0_122_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10439_ _02474_ _02475_ _02476_ VGND VGND VPWR VPWR _02478_ sky130_fd_sc_hd__a21oi_1
X_13227_ _05508_ _05509_ _05514_ VGND VGND VPWR VPWR _05515_ sky130_fd_sc_hd__a21o_1
XFILLER_0_21_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13158_ _05432_ _05433_ _05438_ VGND VGND VPWR VPWR _05439_ sky130_fd_sc_hd__a21o_1
XFILLER_0_21_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12109_ net277 net376 net182 net170 VGND VGND VPWR VPWR _04298_ sky130_fd_sc_hd__nand4_2
X_13089_ _05298_ _05300_ _05299_ VGND VGND VPWR VPWR _05363_ sky130_fd_sc_hd__a21bo_1
X_07650_ _05021_ _05032_ VGND VGND VPWR VPWR _05270_ sky130_fd_sc_hd__nor2_1
XFILLER_0_125_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07581_ net209 net522 net532 net200 VGND VGND VPWR VPWR _04522_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_88_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09320_ b_cos\[11\] a_sin\[11\] VGND VGND VPWR VPWR _01329_ sky130_fd_sc_hd__and2b_1
XFILLER_0_48_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09251_ b_cos\[1\] a_sin\[1\] VGND VGND VPWR VPWR _01270_ sky130_fd_sc_hd__or2b_1
XFILLER_0_75_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08202_ _00239_ _00253_ VGND VGND VPWR VPWR _00254_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_75_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09182_ _01210_ _01211_ VGND VGND VPWR VPWR _01212_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_8_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08133_ _07332_ _07334_ _07333_ net606 VGND VGND VPWR VPWR _00186_ sky130_fd_sc_hd__a22o_1
XFILLER_0_105_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08064_ _00116_ _00117_ VGND VGND VPWR VPWR _00118_ sky130_fd_sc_hd__or2b_1
XFILLER_0_114_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08966_ _01006_ _01007_ VGND VGND VPWR VPWR _01008_ sky130_fd_sc_hd__xor2_1
X_08897_ _00866_ _00883_ VGND VGND VPWR VPWR _00940_ sky130_fd_sc_hd__or2b_1
X_07917_ _07209_ _07211_ VGND VGND VPWR VPWR _07212_ sky130_fd_sc_hd__nand2_1
X_07848_ net290 net540 VGND VGND VPWR VPWR _07144_ sky130_fd_sc_hd__nand2_1
X_07779_ net304 net547 net565 net225 VGND VGND VPWR VPWR _06679_ sky130_fd_sc_hd__a22o_1
XFILLER_0_66_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09518_ _01506_ _01507_ _01518_ VGND VGND VPWR VPWR _01519_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_78_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10790_ _02796_ _02857_ _02858_ VGND VGND VPWR VPWR _02859_ sky130_fd_sc_hd__a21o_1
X_09449_ _01404_ _01420_ _01448_ _01449_ VGND VGND VPWR VPWR _01450_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_136_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12460_ _04677_ _04678_ VGND VGND VPWR VPWR _04680_ sky130_fd_sc_hd__and2_1
XFILLER_0_81_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12391_ _04602_ _04603_ _04536_ _04519_ VGND VGND VPWR VPWR _04605_ sky130_fd_sc_hd__a211oi_2
X_11411_ net219 _03529_ VGND VGND VPWR VPWR _03535_ sky130_fd_sc_hd__nor2_1
X_11342_ _03410_ _03409_ _03408_ VGND VGND VPWR VPWR _03459_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_105_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14130_ net622 net469 VGND VGND VPWR VPWR _06500_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11273_ _03329_ _03335_ VGND VGND VPWR VPWR _03383_ sky130_fd_sc_hd__or2b_1
XFILLER_0_39_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14061_ _06423_ _06424_ VGND VGND VPWR VPWR _06425_ sky130_fd_sc_hd__xnor2_2
X_10224_ net686 net692 net453 net444 VGND VGND VPWR VPWR _02243_ sky130_fd_sc_hd__and4_1
X_13012_ net571 net658 net330 net475 VGND VGND VPWR VPWR _05278_ sky130_fd_sc_hd__and4_1
XFILLER_0_30_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10155_ net459 net553 net362 net352 VGND VGND VPWR VPWR _02169_ sky130_fd_sc_hd__nand4_1
X_10086_ _01948_ _02088_ _02093_ VGND VGND VPWR VPWR _02094_ sky130_fd_sc_hd__or3_1
X_13914_ _06261_ _06264_ VGND VGND VPWR VPWR _06265_ sky130_fd_sc_hd__xnor2_2
X_13845_ _06098_ _06099_ _06097_ VGND VGND VPWR VPWR _06190_ sky130_fd_sc_hd__a21o_1
XFILLER_0_128_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10988_ _02992_ _02993_ VGND VGND VPWR VPWR _03074_ sky130_fd_sc_hd__nor2_1
X_13776_ _06041_ _06046_ VGND VGND VPWR VPWR _06115_ sky130_fd_sc_hd__and2_1
XFILLER_0_29_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12727_ _04966_ _04969_ VGND VGND VPWR VPWR _04970_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_57_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12658_ _04822_ _04823_ _04821_ VGND VGND VPWR VPWR _04895_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11609_ _03752_ VGND VGND VPWR VPWR _03753_ sky130_fd_sc_hd__inv_2
XFILLER_0_111_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12589_ net559 net251 net243 net655 VGND VGND VPWR VPWR _04820_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_108_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap114 _00847_ VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__buf_1
Xmax_cap125 _06347_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__buf_1
X_14328_ _06665_ _06714_ VGND VGND VPWR VPWR _06715_ sky130_fd_sc_hd__xor2_2
XFILLER_0_40_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14259_ _06517_ _06582_ VGND VGND VPWR VPWR _06640_ sky130_fd_sc_hd__nand2_1
XFILLER_0_110_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08820_ _00862_ _00863_ VGND VGND VPWR VPWR _00864_ sky130_fd_sc_hd__nor2_4
XFILLER_0_0_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08751_ _00765_ _00783_ VGND VGND VPWR VPWR _00796_ sky130_fd_sc_hd__nor2_1
X_07702_ _05819_ _05830_ net147 net661 VGND VGND VPWR VPWR _05841_ sky130_fd_sc_hd__o211a_1
X_08682_ _00691_ _00692_ _00708_ VGND VGND VPWR VPWR _00728_ sky130_fd_sc_hd__nor3_1
XFILLER_0_136_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07633_ net174 net566 net574 net164 VGND VGND VPWR VPWR _05086_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_45_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07564_ _04173_ _04315_ _04304_ VGND VGND VPWR VPWR _04337_ sky130_fd_sc_hd__a21o_1
XFILLER_0_88_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07495_ _02745_ _03253_ _03561_ _03572_ VGND VGND VPWR VPWR _03583_ sky130_fd_sc_hd__a211oi_4
X_09303_ net109 _01314_ net129 VGND VGND VPWR VPWR _01315_ sky130_fd_sc_hd__mux2_1
XFILLER_0_63_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09234_ a_cos\[16\] b_sin\[16\] VGND VGND VPWR VPWR _01256_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09165_ a_cos\[6\] b_sin\[6\] VGND VGND VPWR VPWR _01197_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08116_ net255 net541 VGND VGND VPWR VPWR _00169_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09096_ net258 _01041_ _01039_ VGND VGND VPWR VPWR _01135_ sky130_fd_sc_hd__a21oi_1
X_08047_ _07338_ _07339_ _07340_ VGND VGND VPWR VPWR _07341_ sky130_fd_sc_hd__or3_1
XFILLER_0_101_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09998_ _01650_ _01966_ _01997_ _01998_ VGND VGND VPWR VPWR _01999_ sky130_fd_sc_hd__a211o_2
X_08949_ _00989_ _00990_ VGND VGND VPWR VPWR _00991_ sky130_fd_sc_hd__or2_1
X_11960_ _04133_ _04134_ _04135_ VGND VGND VPWR VPWR _04136_ sky130_fd_sc_hd__nand3_1
X_10911_ net141 net457 net448 net186 VGND VGND VPWR VPWR _02990_ sky130_fd_sc_hd__a22oi_1
X_11891_ net806 _04058_ _04059_ VGND VGND VPWR VPWR _04060_ sky130_fd_sc_hd__a21oi_4
X_10842_ _02761_ _02914_ _02915_ VGND VGND VPWR VPWR _02916_ sky130_fd_sc_hd__o21a_1
X_13630_ _05935_ _05954_ _05955_ VGND VGND VPWR VPWR _05956_ sky130_fd_sc_hd__nand3_1
X_10773_ _02839_ _02840_ VGND VGND VPWR VPWR _02841_ sky130_fd_sc_hd__and2b_1
XFILLER_0_39_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13561_ _05814_ _05879_ _05880_ VGND VGND VPWR VPWR _05881_ sky130_fd_sc_hd__nand3_2
X_12512_ _04732_ _04735_ VGND VGND VPWR VPWR _04736_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_109_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13492_ _05717_ _05804_ VGND VGND VPWR VPWR _05805_ sky130_fd_sc_hd__or2_1
XFILLER_0_136_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12443_ _04659_ _04660_ VGND VGND VPWR VPWR _04661_ sky130_fd_sc_hd__or2_1
XFILLER_0_62_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12374_ net182 net172 net145 net136 VGND VGND VPWR VPWR _04586_ sky130_fd_sc_hd__and4_1
XFILLER_0_34_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11325_ _03433_ _03434_ _03439_ VGND VGND VPWR VPWR _03441_ sky130_fd_sc_hd__nor3_1
XFILLER_0_105_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14113_ _06480_ _06388_ VGND VGND VPWR VPWR _06481_ sky130_fd_sc_hd__nor2_1
X_11256_ _03361_ _03362_ _03364_ VGND VGND VPWR VPWR _03365_ sky130_fd_sc_hd__nand3_4
XFILLER_0_120_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14044_ net615 net333 net478 net622 VGND VGND VPWR VPWR _06406_ sky130_fd_sc_hd__a22o_1
XFILLER_0_5_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11187_ _03284_ _03288_ VGND VGND VPWR VPWR _03289_ sky130_fd_sc_hd__xnor2_1
X_10207_ net728 net416 VGND VGND VPWR VPWR _02225_ sky130_fd_sc_hd__and2b_1
X_10138_ net666 net335 net477 net675 VGND VGND VPWR VPWR _02150_ sky130_fd_sc_hd__a22o_1
X_10069_ _02072_ _02073_ _02064_ VGND VGND VPWR VPWR _02075_ sky130_fd_sc_hd__a21o_1
XFILLER_0_82_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13828_ _06092_ _06171_ VGND VGND VPWR VPWR _06172_ sky130_fd_sc_hd__xnor2_1
X_13759_ net537 net427 net419 net546 VGND VGND VPWR VPWR _06096_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_45_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09921_ _01716_ _01717_ _01764_ _01921_ VGND VGND VPWR VPWR _01922_ sky130_fd_sc_hd__or4b_4
Xfanout705 net707 VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_111_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout738 net739 VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__buf_2
Xfanout727 net728 VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__clkbuf_4
X_09852_ _01847_ VGND VGND VPWR VPWR _01853_ sky130_fd_sc_hd__inv_2
Xfanout716 net717 VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__buf_2
X_08803_ _00845_ _00846_ _00764_ _00847_ VGND VGND VPWR VPWR _00848_ sky130_fd_sc_hd__a211o_1
X_09783_ _01767_ _01782_ _01781_ VGND VGND VPWR VPWR _01784_ sky130_fd_sc_hd__a21oi_1
X_08734_ _00776_ _00779_ VGND VGND VPWR VPWR _00780_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_56_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08665_ _00709_ _00710_ _00629_ _00652_ VGND VGND VPWR VPWR _00712_ sky130_fd_sc_hd__a211oi_2
X_07616_ _04837_ _04869_ _04880_ _04891_ VGND VGND VPWR VPWR _04902_ sky130_fd_sc_hd__a211o_1
X_08596_ _00640_ _00643_ VGND VGND VPWR VPWR _00644_ sky130_fd_sc_hd__xnor2_1
X_07547_ _03977_ _04130_ _04141_ VGND VGND VPWR VPWR _04152_ sky130_fd_sc_hd__a21o_1
XFILLER_0_64_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07478_ _03374_ _03385_ VGND VGND VPWR VPWR _03396_ sky130_fd_sc_hd__nor2_1
XFILLER_0_118_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_101_Left_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09217_ _01240_ _01241_ VGND VGND VPWR VPWR _01242_ sky130_fd_sc_hd__xnor2_1
X_09148_ net86 _01182_ net128 VGND VGND VPWR VPWR _01183_ sky130_fd_sc_hd__mux2_1
X_09079_ _01051_ _01069_ VGND VGND VPWR VPWR _01119_ sky130_fd_sc_hd__or2b_1
X_11110_ _03204_ _03205_ VGND VGND VPWR VPWR _03206_ sky130_fd_sc_hd__xor2_1
X_12090_ _04275_ _04276_ VGND VGND VPWR VPWR _04277_ sky130_fd_sc_hd__nor2_1
X_11041_ net141 _03057_ VGND VGND VPWR VPWR _03131_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_110_Left_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14800_ clknet_3_4_0_clk _00101_ net321 VGND VGND VPWR VPWR b_cos\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_99_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12992_ _05239_ _05254_ _05255_ VGND VGND VPWR VPWR _05256_ sky130_fd_sc_hd__nand3_2
X_11943_ _04115_ _04116_ VGND VGND VPWR VPWR _04117_ sky130_fd_sc_hd__xor2_2
X_14731_ clknet_3_5_0_clk _00032_ net324 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dfrtp_1
X_11874_ _03980_ _03942_ _04040_ _04041_ VGND VGND VPWR VPWR _04042_ sky130_fd_sc_hd__o211ai_4
X_14662_ _07021_ _07024_ _07076_ VGND VGND VPWR VPWR _07077_ sky130_fd_sc_hd__o21ai_1
X_10825_ _02896_ _02823_ VGND VGND VPWR VPWR _02898_ sky130_fd_sc_hd__nor2_1
X_13613_ net537 net441 VGND VGND VPWR VPWR _05937_ sky130_fd_sc_hd__nand2_1
XFILLER_0_109_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14593_ _06999_ _07000_ _07001_ VGND VGND VPWR VPWR _07002_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_109_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10756_ _02819_ _02820_ VGND VGND VPWR VPWR _02823_ sky130_fd_sc_hd__and2_1
X_13544_ _05859_ _05860_ _05858_ VGND VGND VPWR VPWR _05862_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_137_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10687_ _02726_ _02727_ _02747_ VGND VGND VPWR VPWR _02748_ sky130_fd_sc_hd__or3_4
X_13475_ _05785_ _05786_ VGND VGND VPWR VPWR _05788_ sky130_fd_sc_hd__or2_1
XFILLER_0_140_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12426_ _04626_ _04627_ _04642_ VGND VGND VPWR VPWR _04643_ sky130_fd_sc_hd__a21o_2
XFILLER_0_125_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12357_ net275 net377 net154 net302 VGND VGND VPWR VPWR _04568_ sky130_fd_sc_hd__and4_1
XFILLER_0_50_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11308_ _03404_ _03420_ _03421_ VGND VGND VPWR VPWR _03422_ sky130_fd_sc_hd__and3_1
X_12288_ _04490_ _04491_ _04471_ _04472_ VGND VGND VPWR VPWR _04493_ sky130_fd_sc_hd__a211o_1
X_11239_ _03326_ _03327_ _03337_ VGND VGND VPWR VPWR _03346_ sky130_fd_sc_hd__nand3_1
X_14027_ _06384_ _06386_ VGND VGND VPWR VPWR _06388_ sky130_fd_sc_hd__and2_1
XFILLER_0_89_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08450_ _00497_ _00498_ VGND VGND VPWR VPWR _00499_ sky130_fd_sc_hd__xor2_1
XFILLER_0_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07401_ _02397_ _02407_ _02549_ VGND VGND VPWR VPWR _02560_ sky130_fd_sc_hd__nand3_2
X_08381_ net151 net625 net635 net299 VGND VGND VPWR VPWR _00431_ sky130_fd_sc_hd__a22o_1
XFILLER_0_93_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09002_ _01041_ _01042_ VGND VGND VPWR VPWR _01043_ sky130_fd_sc_hd__xor2_1
XFILLER_0_60_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout524 net526 VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__clkbuf_4
X_09904_ _01896_ _01900_ VGND VGND VPWR VPWR _01905_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout502 net503 VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__clkbuf_4
Xfanout513 net34 VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__clkbuf_4
Xfanout557 net559 VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__buf_4
X_09835_ _01835_ VGND VGND VPWR VPWR _01836_ sky130_fd_sc_hd__inv_2
Xfanout546 net551 VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__clkbuf_4
Xfanout535 net537 VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__buf_2
Xfanout568 net29 VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__clkbuf_4
Xfanout579 net27 VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__clkbuf_4
X_09766_ _01747_ _01744_ _01746_ VGND VGND VPWR VPWR _01767_ sky130_fd_sc_hd__nand3_1
X_08717_ _00760_ _00761_ _00686_ _00762_ VGND VGND VPWR VPWR _00763_ sky130_fd_sc_hd__a211oi_2
X_09697_ _01684_ _01695_ _01696_ _01697_ VGND VGND VPWR VPWR _01698_ sky130_fd_sc_hd__a211o_1
XFILLER_0_139_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08648_ _00594_ _00597_ _00595_ VGND VGND VPWR VPWR _00695_ sky130_fd_sc_hd__o21ba_1
X_08579_ _00609_ _00610_ _00626_ VGND VGND VPWR VPWR _00627_ sky130_fd_sc_hd__o21a_1
XFILLER_0_83_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11590_ _03723_ _03731_ VGND VGND VPWR VPWR _03732_ sky130_fd_sc_hd__xor2_2
XFILLER_0_76_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10610_ _02617_ _02618_ _02662_ _02663_ VGND VGND VPWR VPWR _02664_ sky130_fd_sc_hd__o211a_4
XFILLER_0_36_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10541_ a_cos\[7\] _02588_ _02303_ VGND VGND VPWR VPWR _02589_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13260_ net535 net543 net388 net379 VGND VGND VPWR VPWR _05551_ sky130_fd_sc_hd__and4_1
X_12211_ net215 net205 net135 VGND VGND VPWR VPWR _04409_ sky130_fd_sc_hd__o21a_2
XFILLER_0_60_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10472_ net688 net693 net430 net422 VGND VGND VPWR VPWR _02513_ sky130_fd_sc_hd__and4_1
X_13191_ _05271_ _05272_ _05293_ VGND VGND VPWR VPWR _05475_ sky130_fd_sc_hd__o21a_1
X_12142_ _04331_ _04333_ VGND VGND VPWR VPWR _04334_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_32_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12073_ _04256_ _04257_ VGND VGND VPWR VPWR _04258_ sky130_fd_sc_hd__nor2_1
X_11024_ _03057_ _03111_ net134 VGND VGND VPWR VPWR _03112_ sky130_fd_sc_hd__and3b_1
X_12975_ _05220_ _05221_ _05236_ VGND VGND VPWR VPWR _05238_ sky130_fd_sc_hd__nand3_1
X_11926_ _04095_ _04096_ _04098_ VGND VGND VPWR VPWR _04099_ sky130_fd_sc_hd__a21o_1
XFILLER_0_99_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14714_ clknet_3_7_0_clk _00015_ net325 VGND VGND VPWR VPWR b_sin\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_59_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11857_ _04019_ _04020_ _04022_ VGND VGND VPWR VPWR _04024_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_28_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14645_ _07049_ _07003_ _07056_ VGND VGND VPWR VPWR _07059_ sky130_fd_sc_hd__nor3_1
X_11788_ _03866_ _03853_ _03947_ _03948_ VGND VGND VPWR VPWR _03949_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_67_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10808_ _02854_ _02878_ VGND VGND VPWR VPWR _02879_ sky130_fd_sc_hd__xnor2_1
X_14576_ _06794_ _06983_ VGND VGND VPWR VPWR _06984_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_137_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10739_ _02802_ _02803_ VGND VGND VPWR VPWR _02804_ sky130_fd_sc_hd__xnor2_1
X_13527_ net639 net360 net346 net494 VGND VGND VPWR VPWR _05844_ sky130_fd_sc_hd__a22o_1
XFILLER_0_27_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13458_ _05766_ _05767_ _05768_ VGND VGND VPWR VPWR _05769_ sky130_fd_sc_hd__nand3_1
X_12409_ _04571_ _04572_ VGND VGND VPWR VPWR _04624_ sky130_fd_sc_hd__and2_1
XFILLER_0_88_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput105 net105 VGND VGND VPWR VPWR Q[4] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_51_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13389_ _05659_ _05668_ _05691_ _05692_ VGND VGND VPWR VPWR _05693_ sky130_fd_sc_hd__o22a_1
XFILLER_0_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07950_ net158 net508 VGND VGND VPWR VPWR _07245_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07881_ _07174_ _07175_ _07173_ VGND VGND VPWR VPWR _07177_ sky130_fd_sc_hd__o21ai_1
X_09620_ _01618_ _01619_ _01601_ _01602_ VGND VGND VPWR VPWR _01621_ sky130_fd_sc_hd__a211o_1
XFILLER_0_37_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09551_ _01482_ _01484_ _01483_ VGND VGND VPWR VPWR _01552_ sky130_fd_sc_hd__o21ba_1
X_08502_ _00444_ _00468_ _00467_ VGND VGND VPWR VPWR _00551_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_77_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09482_ net647 net664 net392 net383 VGND VGND VPWR VPWR _01483_ sky130_fd_sc_hd__and4_1
XFILLER_0_93_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08433_ _00390_ _00392_ VGND VGND VPWR VPWR _00483_ sky130_fd_sc_hd__nand2_1
XFILLER_0_65_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08364_ net541 net236 VGND VGND VPWR VPWR _00414_ sky130_fd_sc_hd__and2b_1
XFILLER_0_46_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08295_ _00263_ _00265_ _00264_ VGND VGND VPWR VPWR _00346_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_116_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout310 net313 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__buf_4
Xfanout321 net328 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__clkbuf_2
Xfanout332 net337 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__buf_4
Xfanout354 net52 VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__clkbuf_8
Xfanout343 net53 VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__clkbuf_4
Xfanout365 net367 VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__buf_2
Xfanout376 net5 VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__clkbuf_2
X_09818_ _01812_ _01807_ _01808_ VGND VGND VPWR VPWR _01819_ sky130_fd_sc_hd__nand3_1
Xfanout387 net49 VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__clkbuf_4
Xfanout398 net404 VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__buf_2
X_09749_ _01737_ _01748_ _01749_ VGND VGND VPWR VPWR _01750_ sky130_fd_sc_hd__nand3_2
XFILLER_0_96_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12760_ _04856_ _04989_ _05003_ VGND VGND VPWR VPWR _05005_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_69_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12691_ net291 net144 _04873_ VGND VGND VPWR VPWR _04930_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_84_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11711_ _03864_ VGND VGND VPWR VPWR _00073_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_37_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11642_ _03749_ _03755_ VGND VGND VPWR VPWR _03789_ sky130_fd_sc_hd__and2_1
XFILLER_0_77_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14430_ _06819_ _06825_ VGND VGND VPWR VPWR _06826_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_107_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14361_ net632 net431 net423 net641 VGND VGND VPWR VPWR _06751_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_37_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput18 alpha[9] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__buf_1
X_11573_ net198 net668 VGND VGND VPWR VPWR _03713_ sky130_fd_sc_hd__nand2_1
XFILLER_0_107_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13312_ _05598_ _05604_ _05599_ VGND VGND VPWR VPWR _05608_ sky130_fd_sc_hd__nand3_1
XFILLER_0_37_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput29 beta[2] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_4
X_10524_ _02477_ _02479_ VGND VGND VPWR VPWR _02570_ sky130_fd_sc_hd__or2_1
X_14292_ _06609_ _06611_ VGND VGND VPWR VPWR _06676_ sky130_fd_sc_hd__or2_1
XFILLER_0_33_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10455_ _02404_ _02405_ _02494_ VGND VGND VPWR VPWR _02496_ sky130_fd_sc_hd__o21ai_1
X_13243_ _05528_ _05529_ _05531_ VGND VGND VPWR VPWR _05532_ sky130_fd_sc_hd__nand3_1
XFILLER_0_103_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13174_ net563 net338 VGND VGND VPWR VPWR _05456_ sky130_fd_sc_hd__nand2_1
X_12125_ _04310_ _04311_ _04313_ VGND VGND VPWR VPWR _04316_ sky130_fd_sc_hd__a21o_1
X_10386_ _02413_ _02419_ VGND VGND VPWR VPWR _02420_ sky130_fd_sc_hd__xnor2_1
X_12056_ _04164_ _04240_ VGND VGND VPWR VPWR _04241_ sky130_fd_sc_hd__xnor2_1
X_11007_ _03093_ _03094_ VGND VGND VPWR VPWR _03095_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12958_ _05195_ _05196_ _05201_ VGND VGND VPWR VPWR _05219_ sky130_fd_sc_hd__a21o_1
X_11909_ _04078_ _04079_ VGND VGND VPWR VPWR _04080_ sky130_fd_sc_hd__or2_2
XFILLER_0_114_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12889_ _05143_ _05144_ VGND VGND VPWR VPWR _05145_ sky130_fd_sc_hd__nor2_1
XFILLER_0_87_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14628_ _06790_ _07039_ VGND VGND VPWR VPWR _07040_ sky130_fd_sc_hd__xor2_1
XFILLER_0_55_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14559_ _06834_ _06897_ _06895_ VGND VGND VPWR VPWR _06966_ sky130_fd_sc_hd__o21ai_1
X_08080_ _07293_ _00132_ _00133_ VGND VGND VPWR VPWR _00134_ sky130_fd_sc_hd__or3_1
XFILLER_0_125_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08982_ _01001_ _01023_ VGND VGND VPWR VPWR _01024_ sky130_fd_sc_hd__xor2_1
X_07933_ net290 net534 VGND VGND VPWR VPWR _07228_ sky130_fd_sc_hd__nand2_1
X_07864_ net177 net498 net507 net167 VGND VGND VPWR VPWR _07160_ sky130_fd_sc_hd__a22o_1
X_09603_ _01551_ _01558_ VGND VGND VPWR VPWR _01604_ sky130_fd_sc_hd__or2b_1
X_07795_ net304 net566 net574 net225 VGND VGND VPWR VPWR _06853_ sky130_fd_sc_hd__a22oi_1
X_09534_ net460 net402 VGND VGND VPWR VPWR _01535_ sky130_fd_sc_hd__and2_1
XFILLER_0_78_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09465_ _01462_ _01465_ VGND VGND VPWR VPWR _01466_ sky130_fd_sc_hd__xnor2_1
X_08416_ _00454_ _00455_ _00463_ _00464_ VGND VGND VPWR VPWR _00466_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_66_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09396_ net682 net391 net381 net690 VGND VGND VPWR VPWR _01397_ sky130_fd_sc_hd__a22oi_1
X_08347_ _00395_ _00397_ VGND VGND VPWR VPWR _00398_ sky130_fd_sc_hd__nand2b_1
XFILLER_0_74_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08278_ _00249_ _00248_ VGND VGND VPWR VPWR _00329_ sky130_fd_sc_hd__and2b_1
XFILLER_0_22_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10240_ _02170_ _02171_ _02169_ VGND VGND VPWR VPWR _02261_ sky130_fd_sc_hd__o21ai_2
X_10171_ _02040_ _02041_ _02042_ VGND VGND VPWR VPWR _02186_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_110_Right_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout140 net8 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__clkbuf_2
Xfanout173 net71 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__clkbuf_4
Xfanout162 net163 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__clkbuf_4
Xfanout151 net155 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__clkbuf_4
X_13930_ _06201_ _06218_ VGND VGND VPWR VPWR _06282_ sky130_fd_sc_hd__nor2_1
Xfanout195 net198 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__clkbuf_4
Xfanout184 net192 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__clkbuf_4
X_13861_ net631 net334 net478 net640 VGND VGND VPWR VPWR _06207_ sky130_fd_sc_hd__a22o_1
X_12812_ _04991_ _05001_ _05060_ VGND VGND VPWR VPWR _05061_ sky130_fd_sc_hd__a21oi_1
X_13792_ _06121_ _06131_ VGND VGND VPWR VPWR _06132_ sky130_fd_sc_hd__xor2_2
X_12743_ _04856_ _04857_ VGND VGND VPWR VPWR _04986_ sky130_fd_sc_hd__or2_1
XFILLER_0_97_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12674_ _04910_ _04911_ _04843_ _04844_ VGND VGND VPWR VPWR _04912_ sky130_fd_sc_hd__o211a_1
XFILLER_0_72_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14413_ _06804_ _06806_ VGND VGND VPWR VPWR _06807_ sky130_fd_sc_hd__xnor2_1
X_11625_ _03764_ _03765_ _03768_ VGND VGND VPWR VPWR _03771_ sky130_fd_sc_hd__a21o_1
X_11556_ _03689_ _03692_ _03691_ VGND VGND VPWR VPWR _03695_ sky130_fd_sc_hd__a21o_1
XFILLER_0_107_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14344_ net579 net333 net479 net587 VGND VGND VPWR VPWR _06732_ sky130_fd_sc_hd__a22o_1
XFILLER_0_107_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10507_ _02550_ _02551_ VGND VGND VPWR VPWR _02552_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14275_ _06640_ _06641_ _06655_ VGND VGND VPWR VPWR _06658_ sky130_fd_sc_hd__nand3_1
XFILLER_0_25_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11487_ _03603_ _03604_ _03618_ VGND VGND VPWR VPWR _03619_ sky130_fd_sc_hd__o21a_1
X_13226_ _05510_ _05511_ _05513_ VGND VGND VPWR VPWR _05514_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_21_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10438_ _02474_ _02475_ _02476_ VGND VGND VPWR VPWR _02477_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10369_ _02395_ _02401_ VGND VGND VPWR VPWR _02402_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13157_ _05434_ _05436_ _05437_ VGND VGND VPWR VPWR _05438_ sky130_fd_sc_hd__a21bo_1
X_12108_ net277 net180 net170 net376 VGND VGND VPWR VPWR _04297_ sky130_fd_sc_hd__a22o_1
XFILLER_0_109_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13088_ _05305_ _05310_ _05304_ VGND VGND VPWR VPWR _05362_ sky130_fd_sc_hd__a21bo_1
X_12039_ _04218_ _04219_ _04220_ VGND VGND VPWR VPWR _04222_ sky130_fd_sc_hd__and3_1
XFILLER_0_18_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07580_ net193 net539 VGND VGND VPWR VPWR _04511_ sky130_fd_sc_hd__nand2_1
XFILLER_0_88_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09250_ a_sin\[1\] b_cos\[1\] VGND VGND VPWR VPWR _01269_ sky130_fd_sc_hd__and2b_1
XFILLER_0_47_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08201_ _00251_ _00252_ VGND VGND VPWR VPWR _00253_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09181_ _01202_ _01205_ _01203_ VGND VGND VPWR VPWR _01211_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_56_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08132_ _00113_ _00115_ VGND VGND VPWR VPWR _00185_ sky130_fd_sc_hd__nand2_1
XFILLER_0_114_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08063_ _00114_ _00115_ _00111_ VGND VGND VPWR VPWR _00117_ sky130_fd_sc_hd__a21o_1
XFILLER_0_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08965_ net626 net237 VGND VGND VPWR VPWR _01007_ sky130_fd_sc_hd__and2b_1
X_07916_ _07129_ _07210_ VGND VGND VPWR VPWR _07211_ sky130_fd_sc_hd__or2_1
X_08896_ _00899_ _00902_ VGND VGND VPWR VPWR _00939_ sky130_fd_sc_hd__or2_1
XFILLER_0_75_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07847_ _07141_ _07142_ VGND VGND VPWR VPWR _07143_ sky130_fd_sc_hd__xnor2_1
X_07778_ _06418_ _06407_ _06396_ VGND VGND VPWR VPWR _06668_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_94_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09517_ _01514_ _01517_ VGND VGND VPWR VPWR _01518_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_109_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09448_ _01437_ _01438_ _01447_ VGND VGND VPWR VPWR _01449_ sky130_fd_sc_hd__and3_1
XFILLER_0_93_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09379_ _01377_ _01378_ _01376_ VGND VGND VPWR VPWR _01380_ sky130_fd_sc_hd__a21o_1
XFILLER_0_35_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12390_ _04536_ _04519_ _04602_ _04603_ VGND VGND VPWR VPWR _04604_ sky130_fd_sc_hd__o211a_1
X_11410_ _03526_ _03530_ _03533_ VGND VGND VPWR VPWR _03534_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_117_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11341_ _03455_ _03456_ _03457_ VGND VGND VPWR VPWR _03458_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_104_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11272_ _03380_ _03379_ _03346_ _03326_ VGND VGND VPWR VPWR _03382_ sky130_fd_sc_hd__o211ai_2
X_14060_ net577 net369 VGND VGND VPWR VPWR _06424_ sky130_fd_sc_hd__nand2_1
X_10223_ net686 net453 net444 net692 VGND VGND VPWR VPWR _02242_ sky130_fd_sc_hd__a22oi_2
X_13011_ _05275_ _05276_ VGND VGND VPWR VPWR _05277_ sky130_fd_sc_hd__nor2_1
X_10154_ net459 net362 net352 net553 VGND VGND VPWR VPWR _02167_ sky130_fd_sc_hd__a22o_1
XFILLER_0_100_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10085_ _01934_ _02091_ VGND VGND VPWR VPWR _02093_ sky130_fd_sc_hd__xnor2_1
X_13913_ _06262_ _06263_ VGND VGND VPWR VPWR _06264_ sky130_fd_sc_hd__nor2_1
X_13844_ _06182_ _06187_ VGND VGND VPWR VPWR _06188_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_97_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10987_ _02989_ _03000_ _03072_ VGND VGND VPWR VPWR _03073_ sky130_fd_sc_hd__a21o_1
X_13775_ _06031_ _06033_ VGND VGND VPWR VPWR _06114_ sky130_fd_sc_hd__and2_1
X_12726_ _04886_ _04904_ _04968_ VGND VGND VPWR VPWR _04969_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_85_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12657_ _04887_ _04893_ VGND VGND VPWR VPWR _04894_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_44_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11608_ net280 net262 net731 net738 VGND VGND VPWR VPWR _03752_ sky130_fd_sc_hd__and4_1
XFILLER_0_4_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12588_ _04713_ _04716_ _04714_ VGND VGND VPWR VPWR _04819_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14327_ net578 net343 _02709_ _06518_ VGND VGND VPWR VPWR _06714_ sky130_fd_sc_hd__a31o_1
X_11539_ _03672_ _03675_ VGND VGND VPWR VPWR _03676_ sky130_fd_sc_hd__xnor2_1
Xmax_cap115 _07197_ VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__buf_6
XFILLER_0_52_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap126 _02479_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_40_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14258_ _06562_ _06569_ VGND VGND VPWR VPWR _06639_ sky130_fd_sc_hd__and2_1
XFILLER_0_96_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13209_ net563 net357 net347 net572 VGND VGND VPWR VPWR _05495_ sky130_fd_sc_hd__a22oi_1
X_14189_ net596 net604 net333 net479 VGND VGND VPWR VPWR _06564_ sky130_fd_sc_hd__and4_1
XFILLER_0_0_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08750_ _00795_ VGND VGND VPWR VPWR _00010_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_136_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07701_ _05710_ _05754_ VGND VGND VPWR VPWR _05830_ sky130_fd_sc_hd__and2_1
X_08681_ _00693_ _00707_ VGND VGND VPWR VPWR _00727_ sky130_fd_sc_hd__or2_1
X_07632_ net157 net661 VGND VGND VPWR VPWR _05075_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07563_ _04173_ _04304_ _04315_ VGND VGND VPWR VPWR _04326_ sky130_fd_sc_hd__nand3_4
X_09302_ _01312_ _01313_ VGND VGND VPWR VPWR _01314_ sky130_fd_sc_hd__xnor2_2
X_07494_ _03440_ _03451_ _03550_ VGND VGND VPWR VPWR _03572_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_36_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09233_ _01255_ VGND VGND VPWR VPWR _00033_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09164_ a_cos\[6\] b_sin\[6\] VGND VGND VPWR VPWR _01196_ sky130_fd_sc_hd__nor2_1
X_08115_ _00166_ _00167_ VGND VGND VPWR VPWR _00168_ sky130_fd_sc_hd__nor2_1
XFILLER_0_90_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09095_ _01100_ _01106_ _01108_ VGND VGND VPWR VPWR _01134_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_43_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08046_ net311 net235 net580 VGND VGND VPWR VPWR _07340_ sky130_fd_sc_hd__and3_1
XFILLER_0_12_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09997_ _01994_ _01996_ _01977_ VGND VGND VPWR VPWR _01998_ sky130_fd_sc_hd__a21oi_2
X_08948_ net258 net600 _00988_ VGND VGND VPWR VPWR _00990_ sky130_fd_sc_hd__and3_1
X_08879_ _00874_ _00881_ _00921_ VGND VGND VPWR VPWR _00922_ sky130_fd_sc_hd__a21oi_1
X_10910_ _02935_ _02943_ _02988_ VGND VGND VPWR VPWR _02989_ sky130_fd_sc_hd__a21o_1
X_11890_ _03949_ _03951_ _04051_ VGND VGND VPWR VPWR _04059_ sky130_fd_sc_hd__and3_1
XFILLER_0_79_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10841_ _02765_ _02839_ _02840_ VGND VGND VPWR VPWR _02915_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_137_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10772_ _02837_ _02838_ _02750_ _02768_ VGND VGND VPWR VPWR _02840_ sky130_fd_sc_hd__a211o_1
X_13560_ _05877_ _05878_ _05779_ _05781_ VGND VGND VPWR VPWR _05880_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_137_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12511_ _04584_ _04734_ VGND VGND VPWR VPWR _04735_ sky130_fd_sc_hd__xnor2_4
X_13491_ net572 net419 VGND VGND VPWR VPWR _05804_ sky130_fd_sc_hd__nand2_1
XFILLER_0_125_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12442_ _04656_ _04658_ VGND VGND VPWR VPWR _04660_ sky130_fd_sc_hd__and2_1
XFILLER_0_109_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12373_ net172 net145 net136 net182 VGND VGND VPWR VPWR _04585_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_2_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11324_ _03437_ _03438_ VGND VGND VPWR VPWR _03439_ sky130_fd_sc_hd__or2_1
XFILLER_0_50_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14112_ _06378_ _06383_ VGND VGND VPWR VPWR _06480_ sky130_fd_sc_hd__and2b_1
X_11255_ _03354_ _03355_ _03360_ VGND VGND VPWR VPWR _03364_ sky130_fd_sc_hd__a21o_1
XFILLER_0_120_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14043_ _06403_ _06404_ VGND VGND VPWR VPWR _06405_ sky130_fd_sc_hd__xor2_1
X_10206_ _02221_ _02223_ VGND VGND VPWR VPWR _02224_ sky130_fd_sc_hd__nor2_1
X_11186_ _03285_ _03287_ VGND VGND VPWR VPWR _03288_ sky130_fd_sc_hd__nor2_1
X_10137_ _02147_ _02148_ VGND VGND VPWR VPWR _02149_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10068_ _02064_ _02072_ _02073_ VGND VGND VPWR VPWR _02074_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13827_ _06093_ _06170_ VGND VGND VPWR VPWR _06171_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_128_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13758_ _06019_ _06022_ _06020_ VGND VGND VPWR VPWR _06095_ sky130_fd_sc_hd__o21ba_1
X_12709_ _04865_ _04868_ _04949_ VGND VGND VPWR VPWR _04950_ sky130_fd_sc_hd__nor3_1
XFILLER_0_57_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13689_ net520 net529 net452 net442 VGND VGND VPWR VPWR _06020_ sky130_fd_sc_hd__and4_1
XFILLER_0_26_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09920_ _01803_ _01914_ _01917_ _01918_ _01920_ VGND VGND VPWR VPWR _01921_ sky130_fd_sc_hd__a311o_1
XFILLER_0_1_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout706 net707 VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_0_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout739 net10 VGND VGND VPWR VPWR net739 sky130_fd_sc_hd__buf_4
Xfanout728 net11 VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__buf_2
Xfanout717 net719 VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__clkbuf_4
X_09851_ _01842_ _01840_ VGND VGND VPWR VPWR _01852_ sky130_fd_sc_hd__and2b_1
X_08802_ _00763_ _00764_ _00784_ VGND VGND VPWR VPWR _00847_ sky130_fd_sc_hd__nor3_1
X_09782_ _01767_ _01781_ _01782_ VGND VGND VPWR VPWR _01783_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08733_ _00777_ _00778_ VGND VGND VPWR VPWR _00779_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08664_ _00629_ _00652_ _00709_ _00710_ VGND VGND VPWR VPWR _00711_ sky130_fd_sc_hd__o211a_1
X_07615_ _04326_ _04337_ _04347_ VGND VGND VPWR VPWR _04891_ sky130_fd_sc_hd__and3_1
XFILLER_0_95_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08595_ _00641_ _00642_ VGND VGND VPWR VPWR _00643_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07546_ _04108_ _04119_ VGND VGND VPWR VPWR _04141_ sky130_fd_sc_hd__and2b_1
XFILLER_0_72_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07477_ net211 net633 net769 net202 VGND VGND VPWR VPWR _03385_ sky130_fd_sc_hd__a22oi_1
X_09216_ _01233_ _01235_ _01232_ VGND VGND VPWR VPWR _01241_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09147_ _01180_ _01181_ VGND VGND VPWR VPWR _01182_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_44_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09078_ _01095_ _01117_ VGND VGND VPWR VPWR _01118_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_31_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08029_ _07320_ _07321_ _07322_ VGND VGND VPWR VPWR _07323_ sky130_fd_sc_hd__nand3_1
XFILLER_0_20_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11040_ _03084_ _03083_ VGND VGND VPWR VPWR _03130_ sky130_fd_sc_hd__and2b_1
XFILLER_0_99_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12991_ _05246_ _05247_ _05253_ VGND VGND VPWR VPWR _05255_ sky130_fd_sc_hd__a21o_1
X_11942_ net653 net160 VGND VGND VPWR VPWR _04116_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14730_ clknet_3_5_0_clk _00031_ net324 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfrtp_1
X_11873_ _04002_ _04003_ _04038_ _04039_ VGND VGND VPWR VPWR _04041_ sky130_fd_sc_hd__a22o_1
XFILLER_0_39_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14661_ _07074_ _07075_ VGND VGND VPWR VPWR _07076_ sky130_fd_sc_hd__nor2_1
X_10824_ _02813_ _02818_ VGND VGND VPWR VPWR _02896_ sky130_fd_sc_hd__and2b_1
X_13612_ _05840_ _05849_ _05848_ VGND VGND VPWR VPWR _05936_ sky130_fd_sc_hd__a21o_1
X_14592_ net616 net417 VGND VGND VPWR VPWR _07001_ sky130_fd_sc_hd__and2b_1
XFILLER_0_39_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13543_ _05858_ _05859_ _05860_ VGND VGND VPWR VPWR _05861_ sky130_fd_sc_hd__or3_1
XFILLER_0_94_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10755_ _02819_ _02820_ VGND VGND VPWR VPWR _02822_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10686_ _02728_ _02746_ VGND VGND VPWR VPWR _02747_ sky130_fd_sc_hd__xnor2_1
X_13474_ _05783_ _05784_ _05719_ VGND VGND VPWR VPWR _05786_ sky130_fd_sc_hd__a21oi_1
X_12425_ _04633_ _04640_ VGND VGND VPWR VPWR _04642_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_113_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12356_ net275 net154 net302 net377 VGND VGND VPWR VPWR _04567_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_50_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11307_ _03301_ _03298_ _03300_ VGND VGND VPWR VPWR _03421_ sky130_fd_sc_hd__a21o_1
XFILLER_0_105_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12287_ _04471_ _04472_ _04490_ _04491_ VGND VGND VPWR VPWR _04492_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_120_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11238_ _03340_ _03342_ _03344_ VGND VGND VPWR VPWR _03345_ sky130_fd_sc_hd__nand3_2
X_14026_ _06384_ _06386_ VGND VGND VPWR VPWR _06387_ sky130_fd_sc_hd__nor2_1
X_11169_ net148 net736 net743 net797 VGND VGND VPWR VPWR _03269_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_117_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07400_ _02462_ _02538_ VGND VGND VPWR VPWR _02549_ sky130_fd_sc_hd__xnor2_2
X_08380_ _00428_ _00429_ VGND VGND VPWR VPWR _00430_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09001_ net258 net590 VGND VGND VPWR VPWR _01042_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout514 net515 VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__buf_4
X_09903_ _01889_ _01890_ _01894_ VGND VGND VPWR VPWR _01904_ sky130_fd_sc_hd__a21o_1
Xfanout503 net505 VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__clkbuf_4
Xfanout547 net551 VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__clkbuf_4
Xfanout525 net526 VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__clkbuf_2
X_09834_ _01816_ _01834_ net741 net358 VGND VGND VPWR VPWR _01835_ sky130_fd_sc_hd__o211a_1
XFILLER_0_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout536 net537 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__buf_2
Xfanout558 net559 VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__clkbuf_2
Xfanout569 net571 VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__buf_2
X_09765_ _01762_ _01761_ _01734_ VGND VGND VPWR VPWR _01766_ sky130_fd_sc_hd__a21o_1
Xrebuffer30 net774 VGND VGND VPWR VPWR net775 sky130_fd_sc_hd__buf_1
X_08716_ _00687_ _00672_ _00673_ VGND VGND VPWR VPWR _00762_ sky130_fd_sc_hd__nor3_1
X_09696_ _01404_ _01405_ _01419_ VGND VGND VPWR VPWR _01697_ sky130_fd_sc_hd__and3_1
X_08647_ _00607_ _00609_ VGND VGND VPWR VPWR _00694_ sky130_fd_sc_hd__or2_1
XFILLER_0_83_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08578_ _00623_ _00625_ VGND VGND VPWR VPWR _00626_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_95_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07529_ _02940_ _03945_ VGND VGND VPWR VPWR _03956_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10540_ _02584_ _02587_ VGND VGND VPWR VPWR _02588_ sky130_fd_sc_hd__xnor2_1
X_10471_ net686 net430 net422 net693 VGND VGND VPWR VPWR _02512_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_17_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12210_ net215 net205 net135 VGND VGND VPWR VPWR _04408_ sky130_fd_sc_hd__nand3_2
XFILLER_0_134_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13190_ _05464_ _05465_ _05473_ VGND VGND VPWR VPWR _05474_ sky130_fd_sc_hd__nand3_1
XFILLER_0_130_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12141_ _04183_ _04236_ _04332_ VGND VGND VPWR VPWR _04333_ sky130_fd_sc_hd__a21o_1
X_12072_ net706 net714 net248 net240 VGND VGND VPWR VPWR _04257_ sky130_fd_sc_hd__and4_1
X_11023_ net457 net448 VGND VGND VPWR VPWR _03111_ sky130_fd_sc_hd__or2_1
XFILLER_0_99_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12974_ _05225_ _05235_ VGND VGND VPWR VPWR _05236_ sky130_fd_sc_hd__xor2_1
X_11925_ net687 net290 VGND VGND VPWR VPWR _04098_ sky130_fd_sc_hd__and2_1
X_14713_ clknet_3_7_0_clk _00014_ net322 VGND VGND VPWR VPWR b_sin\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_86_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11856_ _04019_ _04020_ _04022_ VGND VGND VPWR VPWR _04023_ sky130_fd_sc_hd__and3_2
XFILLER_0_74_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14644_ _07049_ _07003_ _07056_ VGND VGND VPWR VPWR _07057_ sky130_fd_sc_hd__o21a_1
X_11787_ _03944_ _03946_ _03880_ VGND VGND VPWR VPWR _03948_ sky130_fd_sc_hd__a21o_1
XFILLER_0_95_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10807_ _02876_ _02877_ VGND VGND VPWR VPWR _02878_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14575_ _06930_ _06981_ VGND VGND VPWR VPWR _06983_ sky130_fd_sc_hd__xor2_1
XFILLER_0_43_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10738_ _02795_ _02716_ _02640_ VGND VGND VPWR VPWR _02803_ sky130_fd_sc_hd__a21o_1
X_13526_ net503 net341 VGND VGND VPWR VPWR _05843_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13457_ _05364_ _05366_ _05365_ VGND VGND VPWR VPWR _05768_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_124_Right_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12408_ _04556_ _04600_ _04601_ VGND VGND VPWR VPWR _04623_ sky130_fd_sc_hd__nor3_1
XFILLER_0_113_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10669_ _02608_ _02610_ VGND VGND VPWR VPWR _02728_ sky130_fd_sc_hd__or2_1
XFILLER_0_23_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput106 net106 VGND VGND VPWR VPWR Q[5] sky130_fd_sc_hd__clkbuf_4
X_13388_ _05678_ _05681_ _05684_ VGND VGND VPWR VPWR _05692_ sky130_fd_sc_hd__or3_1
XFILLER_0_2_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12339_ _04546_ _04547_ VGND VGND VPWR VPWR _04548_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14009_ _06366_ _06368_ VGND VGND VPWR VPWR _06369_ sky130_fd_sc_hd__xor2_1
X_07880_ _07173_ _07174_ _07175_ VGND VGND VPWR VPWR _07176_ sky130_fd_sc_hd__or3_1
XFILLER_0_37_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09550_ _01493_ _01495_ _01494_ VGND VGND VPWR VPWR _01551_ sky130_fd_sc_hd__o21ba_1
X_08501_ _00530_ _00549_ VGND VGND VPWR VPWR _00550_ sky130_fd_sc_hd__xnor2_1
X_09481_ net674 net367 VGND VGND VPWR VPWR _01482_ sky130_fd_sc_hd__nand2_1
X_08432_ _00480_ _00481_ VGND VGND VPWR VPWR _00482_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08363_ _00411_ _00412_ VGND VGND VPWR VPWR _00413_ sky130_fd_sc_hd__nor2_1
XFILLER_0_135_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08294_ _00341_ _00342_ _00343_ VGND VGND VPWR VPWR _00345_ sky130_fd_sc_hd__nand3_1
XFILLER_0_18_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout311 net313 VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__clkbuf_4
Xfanout300 net303 VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__clkbuf_2
Xfanout322 net328 VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__clkbuf_4
Xfanout366 net367 VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__clkbuf_4
Xfanout344 net53 VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__clkbuf_4
Xfanout333 net334 VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__clkbuf_4
Xfanout355 net364 VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__clkbuf_4
Xfanout377 net5 VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__buf_4
X_09817_ _01814_ _01817_ VGND VGND VPWR VPWR _01818_ sky130_fd_sc_hd__xor2_2
Xfanout399 net400 VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__buf_2
Xfanout388 net389 VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__buf_2
XFILLER_0_94_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09748_ _01681_ _01675_ _01680_ VGND VGND VPWR VPWR _01749_ sky130_fd_sc_hd__a21o_1
X_11710_ a_sin\[0\] _03863_ _02303_ VGND VGND VPWR VPWR _03864_ sky130_fd_sc_hd__mux2_1
X_09679_ _01676_ _01679_ VGND VGND VPWR VPWR _01680_ sky130_fd_sc_hd__xnor2_1
X_12690_ net291 net137 VGND VGND VPWR VPWR _04929_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11641_ _03742_ _03747_ VGND VGND VPWR VPWR _03788_ sky130_fd_sc_hd__and2_1
X_11572_ _03709_ _03710_ _03705_ VGND VGND VPWR VPWR _03712_ sky130_fd_sc_hd__a21o_1
XFILLER_0_119_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14360_ _06642_ _06645_ _06643_ VGND VGND VPWR VPWR _06750_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_135_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput19 beta[0] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_80_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10523_ _02558_ _02568_ VGND VGND VPWR VPWR _02569_ sky130_fd_sc_hd__xor2_1
XFILLER_0_25_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13311_ _05606_ _05592_ VGND VGND VPWR VPWR _05607_ sky130_fd_sc_hd__xnor2_1
X_14291_ _06589_ _06593_ _06673_ VGND VGND VPWR VPWR _06675_ sky130_fd_sc_hd__o21a_1
X_10454_ _02408_ _02493_ VGND VGND VPWR VPWR _02494_ sky130_fd_sc_hd__xnor2_1
X_13242_ _05504_ _05530_ VGND VGND VPWR VPWR _05531_ sky130_fd_sc_hd__nor2_1
X_10385_ _02416_ _02417_ VGND VGND VPWR VPWR _02419_ sky130_fd_sc_hd__xor2_1
XFILLER_0_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13173_ _05440_ _05441_ _05442_ VGND VGND VPWR VPWR _05455_ sky130_fd_sc_hd__o21ba_1
X_12124_ _04310_ _04311_ _04313_ VGND VGND VPWR VPWR _04314_ sky130_fd_sc_hd__nand3_1
XFILLER_0_20_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12055_ _04237_ _04238_ VGND VGND VPWR VPWR _04240_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_74_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11006_ _03071_ _03091_ VGND VGND VPWR VPWR _03094_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12957_ _05210_ _05216_ _05217_ VGND VGND VPWR VPWR _05218_ sky130_fd_sc_hd__a21bo_1
X_11908_ _03871_ _03972_ _03971_ VGND VGND VPWR VPWR _04079_ sky130_fd_sc_hd__a21bo_1
X_12888_ _05083_ _05097_ _05142_ VGND VGND VPWR VPWR _05144_ sky130_fd_sc_hd__and3_1
X_11839_ _03917_ _03936_ _03937_ VGND VGND VPWR VPWR _04004_ sky130_fd_sc_hd__nand3_1
XFILLER_0_74_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14627_ _07031_ _07038_ VGND VGND VPWR VPWR _07039_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_138_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14558_ _06963_ _06964_ VGND VGND VPWR VPWR _06965_ sky130_fd_sc_hd__nand2_1
XFILLER_0_130_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14489_ _06889_ _06829_ VGND VGND VPWR VPWR _06890_ sky130_fd_sc_hd__nor2_1
X_13509_ net529 net468 VGND VGND VPWR VPWR _05824_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08981_ _00956_ _01022_ VGND VGND VPWR VPWR _01023_ sky130_fd_sc_hd__xor2_1
XFILLER_0_139_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07932_ _07225_ _07226_ VGND VGND VPWR VPWR _07227_ sky130_fd_sc_hd__xor2_1
X_07863_ net158 net516 VGND VGND VPWR VPWR _07159_ sky130_fd_sc_hd__nand2_1
X_09602_ _01552_ _01557_ VGND VGND VPWR VPWR _01603_ sky130_fd_sc_hd__or2b_1
X_07794_ net304 net225 net565 net573 VGND VGND VPWR VPWR _06842_ sky130_fd_sc_hd__and4_1
X_09533_ _01475_ _01477_ _01476_ VGND VGND VPWR VPWR _01534_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_3_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09464_ _01463_ _01464_ VGND VGND VPWR VPWR _01465_ sky130_fd_sc_hd__nor2_1
XFILLER_0_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08415_ _00454_ _00455_ _00463_ _00464_ VGND VGND VPWR VPWR _00465_ sky130_fd_sc_hd__and4_1
X_09395_ net700 net366 VGND VGND VPWR VPWR _01396_ sky130_fd_sc_hd__nand2_1
X_08346_ _07290_ _00136_ _00310_ _00396_ _00234_ VGND VGND VPWR VPWR _00397_ sky130_fd_sc_hd__o221ai_4
XFILLER_0_80_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08277_ _00242_ _00247_ VGND VGND VPWR VPWR _00328_ sky130_fd_sc_hd__and2b_1
XFILLER_0_132_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10170_ net133 _01897_ _02182_ _02183_ VGND VGND VPWR VPWR _02185_ sky130_fd_sc_hd__a31o_1
Xfanout130 net131 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__clkbuf_4
Xfanout163 net72 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__buf_2
Xfanout152 net155 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__clkbuf_2
Xfanout174 net175 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__clkbuf_4
Xfanout141 net142 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__buf_2
Xfanout196 net197 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__clkbuf_4
Xfanout185 net192 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_88_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13860_ _06204_ _06205_ VGND VGND VPWR VPWR _06206_ sky130_fd_sc_hd__xnor2_1
X_12811_ _04787_ _04862_ _05000_ VGND VGND VPWR VPWR _05060_ sky130_fd_sc_hd__o21a_1
XFILLER_0_69_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13791_ _06129_ _06130_ VGND VGND VPWR VPWR _06131_ sky130_fd_sc_hd__nand2_1
XFILLER_0_139_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12742_ _04941_ _04962_ VGND VGND VPWR VPWR _04985_ sky130_fd_sc_hd__or2b_1
XFILLER_0_96_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12673_ _04908_ _04909_ _04835_ _04854_ VGND VGND VPWR VPWR _04911_ sky130_fd_sc_hd__o211a_1
XFILLER_0_96_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11624_ _03764_ _03765_ _03768_ VGND VGND VPWR VPWR _03769_ sky130_fd_sc_hd__nand3_2
XFILLER_0_65_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14412_ _06731_ _06805_ VGND VGND VPWR VPWR _06806_ sky130_fd_sc_hd__and2b_1
XFILLER_0_65_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11555_ _03689_ _03691_ _03692_ VGND VGND VPWR VPWR _03694_ sky130_fd_sc_hd__nand3_1
XFILLER_0_80_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14343_ net579 net333 net479 VGND VGND VPWR VPWR _06731_ sky130_fd_sc_hd__and3_2
X_11486_ _03391_ _03617_ VGND VGND VPWR VPWR _03618_ sky130_fd_sc_hd__xnor2_1
X_10506_ _02547_ _02548_ _02529_ _02530_ VGND VGND VPWR VPWR _02551_ sky130_fd_sc_hd__a211o_1
XFILLER_0_40_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14274_ _06640_ _06641_ _06655_ VGND VGND VPWR VPWR _06656_ sky130_fd_sc_hd__a21o_1
X_10437_ _02366_ _02367_ _02369_ _02372_ VGND VGND VPWR VPWR _02476_ sky130_fd_sc_hd__a31o_1
X_13225_ net510 net518 net483 net405 VGND VGND VPWR VPWR _05513_ sky130_fd_sc_hd__nand4_1
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10368_ _02398_ _02400_ VGND VGND VPWR VPWR _02401_ sky130_fd_sc_hd__and2_1
X_13156_ net503 net510 net483 net405 VGND VGND VPWR VPWR _05437_ sky130_fd_sc_hd__nand4_1
X_12107_ _04218_ _04220_ _04219_ VGND VGND VPWR VPWR _04296_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_85_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10299_ _02322_ _02324_ VGND VGND VPWR VPWR _02325_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_20_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13087_ _05313_ _05315_ _05324_ VGND VGND VPWR VPWR _05361_ sky130_fd_sc_hd__nand3_1
X_12038_ _04218_ _04219_ _04220_ VGND VGND VPWR VPWR _04221_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_69_Left_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13989_ _06334_ _06335_ _06345_ _06346_ VGND VGND VPWR VPWR _06347_ sky130_fd_sc_hd__nor4_1
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08200_ _00240_ _00241_ _00250_ VGND VGND VPWR VPWR _00252_ sky130_fd_sc_hd__and3_1
XFILLER_0_28_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_78_Left_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09180_ _01208_ _01209_ VGND VGND VPWR VPWR _01210_ sky130_fd_sc_hd__and2b_1
XFILLER_0_50_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08131_ _00164_ _00183_ VGND VGND VPWR VPWR _00184_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_71_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08062_ _00111_ _00114_ _00115_ VGND VGND VPWR VPWR _00116_ sky130_fd_sc_hd__and3_1
XFILLER_0_141_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08964_ _00942_ _01004_ _01005_ VGND VGND VPWR VPWR _01006_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_52_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_87_Left_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07915_ net239 net575 VGND VGND VPWR VPWR _07210_ sky130_fd_sc_hd__nand2_1
X_08895_ _00936_ _00937_ VGND VGND VPWR VPWR _00938_ sky130_fd_sc_hd__nand2_1
XFILLER_0_98_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07846_ net255 net575 VGND VGND VPWR VPWR _07142_ sky130_fd_sc_hd__nand2_1
X_07777_ _06418_ _06396_ _06407_ VGND VGND VPWR VPWR _06657_ sky130_fd_sc_hd__or3_4
X_09516_ _01515_ _01516_ VGND VGND VPWR VPWR _01517_ sky130_fd_sc_hd__or2_1
XFILLER_0_39_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09447_ _01437_ _01438_ _01447_ VGND VGND VPWR VPWR _01448_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_38_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09378_ _01376_ _01377_ _01378_ VGND VGND VPWR VPWR _01379_ sky130_fd_sc_hd__nand3_1
X_08329_ _00286_ _00299_ _00379_ VGND VGND VPWR VPWR _00380_ sky130_fd_sc_hd__o21a_1
XFILLER_0_61_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11340_ net305 net227 net703 net711 VGND VGND VPWR VPWR _03457_ sky130_fd_sc_hd__nand4_1
XFILLER_0_62_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11271_ _03326_ _03346_ _03379_ _03380_ VGND VGND VPWR VPWR _03381_ sky130_fd_sc_hd__a211o_1
X_13010_ net658 net467 _05273_ _05274_ VGND VGND VPWR VPWR _05276_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_104_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10222_ _02165_ _02173_ _02240_ VGND VGND VPWR VPWR _02241_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_100_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10153_ _02034_ _02036_ _02035_ net396 VGND VGND VPWR VPWR _02166_ sky130_fd_sc_hd__a22o_1
X_10084_ _02089_ _02090_ VGND VGND VPWR VPWR _02091_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13912_ _06170_ _06093_ VGND VGND VPWR VPWR _06263_ sky130_fd_sc_hd__and2b_1
X_13843_ _06185_ _06186_ VGND VGND VPWR VPWR _06187_ sky130_fd_sc_hd__xor2_1
XFILLER_0_84_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10986_ _02858_ _02927_ _02999_ VGND VGND VPWR VPWR _03072_ sky130_fd_sc_hd__o21a_1
XFILLER_0_29_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13774_ _06011_ _06111_ VGND VGND VPWR VPWR _06112_ sky130_fd_sc_hd__xor2_1
XFILLER_0_128_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12725_ _04885_ _04905_ VGND VGND VPWR VPWR _04968_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12656_ _04890_ _04892_ VGND VGND VPWR VPWR _04893_ sky130_fd_sc_hd__xor2_1
XFILLER_0_37_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12587_ _04709_ _04710_ _04727_ _04729_ VGND VGND VPWR VPWR _04818_ sky130_fd_sc_hd__o211ai_2
X_11607_ net280 net731 net738 net262 VGND VGND VPWR VPWR _03751_ sky130_fd_sc_hd__a22o_1
XFILLER_0_65_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14326_ _06514_ _06666_ _06586_ VGND VGND VPWR VPWR _06713_ sky130_fd_sc_hd__o21ai_1
X_11538_ _03673_ _03674_ VGND VGND VPWR VPWR _03675_ sky130_fd_sc_hd__and2b_1
XFILLER_0_111_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap116 _05980_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__clkbuf_1
X_11469_ _03592_ _03598_ VGND VGND VPWR VPWR _03599_ sky130_fd_sc_hd__xnor2_1
Xmax_cap127 _01060_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__buf_1
XFILLER_0_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14257_ _06568_ _06567_ VGND VGND VPWR VPWR _06638_ sky130_fd_sc_hd__and2b_1
XFILLER_0_21_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13208_ net561 net571 net357 net347 VGND VGND VPWR VPWR _05494_ sky130_fd_sc_hd__and4_1
XFILLER_0_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14188_ net596 net333 net479 net604 VGND VGND VPWR VPWR _06563_ sky130_fd_sc_hd__a22oi_2
X_13139_ _05415_ _05416_ _05396_ _05397_ VGND VGND VPWR VPWR _05418_ sky130_fd_sc_hd__a211o_1
XFILLER_0_29_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07700_ _05721_ _05743_ VGND VGND VPWR VPWR _05819_ sky130_fd_sc_hd__and2_1
X_08680_ _00694_ _00706_ VGND VGND VPWR VPWR _00726_ sky130_fd_sc_hd__nand2_1
X_07631_ _04609_ _05043_ _05053_ VGND VGND VPWR VPWR _05064_ sky130_fd_sc_hd__or3_1
XFILLER_0_45_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07562_ _02212_ _02146_ _02201_ VGND VGND VPWR VPWR _04315_ sky130_fd_sc_hd__a21o_1
XFILLER_0_75_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09301_ _01304_ _01307_ _01305_ VGND VGND VPWR VPWR _01313_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_119_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07493_ _03440_ _03451_ _03550_ VGND VGND VPWR VPWR _03561_ sky130_fd_sc_hd__and3_1
XFILLER_0_91_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09232_ net81 _01254_ net130 VGND VGND VPWR VPWR _01255_ sky130_fd_sc_hd__mux2_1
XFILLER_0_134_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09163_ _01195_ VGND VGND VPWR VPWR _00023_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08114_ net281 net263 net524 net533 VGND VGND VPWR VPWR _00167_ sky130_fd_sc_hd__and4_1
XFILLER_0_126_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09094_ _01118_ _01120_ _01132_ VGND VGND VPWR VPWR _01133_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_141_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08045_ net311 net580 net235 VGND VGND VPWR VPWR _07339_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_4_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09996_ _01977_ _01994_ _01996_ VGND VGND VPWR VPWR _01997_ sky130_fd_sc_hd__and3_2
X_08947_ net258 net598 _00988_ VGND VGND VPWR VPWR _00989_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_99_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08878_ _00875_ _00880_ VGND VGND VPWR VPWR _00921_ sky130_fd_sc_hd__and2b_1
X_07829_ _04467_ _04478_ _04999_ VGND VGND VPWR VPWR _07125_ sky130_fd_sc_hd__nand3_1
X_10840_ _02755_ _02841_ VGND VGND VPWR VPWR _02914_ sky130_fd_sc_hd__nand2_1
XFILLER_0_94_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10771_ _02750_ _02768_ _02837_ _02838_ VGND VGND VPWR VPWR _02839_ sky130_fd_sc_hd__o211a_1
X_12510_ _04650_ _04733_ VGND VGND VPWR VPWR _04734_ sky130_fd_sc_hd__xor2_4
XFILLER_0_54_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13490_ net572 net427 net419 net659 VGND VGND VPWR VPWR _05803_ sky130_fd_sc_hd__a22o_1
X_12441_ _04656_ _04658_ VGND VGND VPWR VPWR _04659_ sky130_fd_sc_hd__nor2_1
XFILLER_0_75_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12372_ _04409_ _04496_ _04408_ VGND VGND VPWR VPWR _04584_ sky130_fd_sc_hd__a21boi_4
XFILLER_0_35_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11323_ net148 net744 _03435_ _03436_ VGND VGND VPWR VPWR _03438_ sky130_fd_sc_hd__a211oi_1
X_14111_ _06477_ _06478_ VGND VGND VPWR VPWR _06479_ sky130_fd_sc_hd__xor2_1
XFILLER_0_1_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11254_ _03316_ _03322_ _03315_ VGND VGND VPWR VPWR _03362_ sky130_fd_sc_hd__a21bo_1
X_14042_ net504 net437 VGND VGND VPWR VPWR _06404_ sky130_fd_sc_hd__nand2_1
X_10205_ net710 net719 net429 net421 VGND VGND VPWR VPWR _02223_ sky130_fd_sc_hd__and4_1
X_11185_ net210 net201 net694 net703 VGND VGND VPWR VPWR _03287_ sky130_fd_sc_hd__and4_1
X_10136_ net710 net436 VGND VGND VPWR VPWR _02148_ sky130_fd_sc_hd__nand2_1
X_10067_ _02068_ _02069_ _02071_ VGND VGND VPWR VPWR _02073_ sky130_fd_sc_hd__a21o_1
XFILLER_0_89_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13826_ _06167_ _06169_ VGND VGND VPWR VPWR _06170_ sky130_fd_sc_hd__xnor2_1
X_10969_ _03035_ _03036_ VGND VGND VPWR VPWR _03053_ sky130_fd_sc_hd__or2b_1
XFILLER_0_58_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13757_ _06017_ _06036_ _06035_ VGND VGND VPWR VPWR _06094_ sky130_fd_sc_hd__a21o_1
XFILLER_0_122_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12708_ _04947_ _04948_ VGND VGND VPWR VPWR _04949_ sky130_fd_sc_hd__xor2_1
X_13688_ net520 net452 net441 net529 VGND VGND VPWR VPWR _06019_ sky130_fd_sc_hd__a22oi_2
X_12639_ net291 net144 _04872_ _04873_ VGND VGND VPWR VPWR _04874_ sky130_fd_sc_hd__a211o_1
XFILLER_0_127_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14309_ _06572_ _06677_ _06693_ VGND VGND VPWR VPWR _06695_ sky130_fd_sc_hd__a21o_1
XFILLER_0_25_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout707 net14 VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__clkbuf_8
Xfanout729 net730 VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__buf_2
X_09850_ _01833_ _01839_ _01849_ _01850_ VGND VGND VPWR VPWR _01851_ sky130_fd_sc_hd__a211oi_2
Xfanout718 net719 VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__buf_2
XFILLER_0_0_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08801_ _00824_ _00825_ _00844_ VGND VGND VPWR VPWR _00846_ sky130_fd_sc_hd__or3_2
X_09781_ _01747_ _01744_ _01746_ VGND VGND VPWR VPWR _01782_ sky130_fd_sc_hd__a21o_1
X_08732_ _00702_ _00701_ VGND VGND VPWR VPWR _00778_ sky130_fd_sc_hd__and2b_1
X_08663_ _00691_ _00692_ _00708_ VGND VGND VPWR VPWR _00710_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07614_ _04326_ _04337_ _04347_ VGND VGND VPWR VPWR _04880_ sky130_fd_sc_hd__a21oi_1
X_08594_ _00562_ _00563_ _00560_ VGND VGND VPWR VPWR _00642_ sky130_fd_sc_hd__a21o_1
XFILLER_0_72_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_138_Right_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07545_ _04108_ _04119_ VGND VGND VPWR VPWR _04130_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_88_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07476_ net211 net202 net633 net769 VGND VGND VPWR VPWR _03374_ sky130_fd_sc_hd__and4_1
XFILLER_0_91_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09215_ _01238_ _01239_ VGND VGND VPWR VPWR _01240_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09146_ _01172_ _01173_ _01174_ VGND VGND VPWR VPWR _01181_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_72_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09077_ _01115_ _01116_ VGND VGND VPWR VPWR _01117_ sky130_fd_sc_hd__nor2_1
XFILLER_0_71_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_15_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08028_ _07228_ _07229_ _07230_ VGND VGND VPWR VPWR _07322_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09979_ net371 net459 net387 VGND VGND VPWR VPWR _01979_ sky130_fd_sc_hd__and3_1
X_12990_ _05246_ _05247_ _05253_ VGND VGND VPWR VPWR _05254_ sky130_fd_sc_hd__nand3_1
X_11941_ _04113_ _04114_ VGND VGND VPWR VPWR _04115_ sky130_fd_sc_hd__nand2_2
XPHY_EDGE_ROW_24_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11872_ _04002_ _04003_ _04038_ _04039_ VGND VGND VPWR VPWR _04040_ sky130_fd_sc_hd__nand4_2
X_14660_ _07017_ _07029_ _07073_ VGND VGND VPWR VPWR _07075_ sky130_fd_sc_hd__nor3_1
XPHY_EDGE_ROW_105_Right_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10823_ _02893_ _02894_ VGND VGND VPWR VPWR _02895_ sky130_fd_sc_hd__or2_1
XFILLER_0_39_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13611_ _05831_ _05833_ VGND VGND VPWR VPWR _05935_ sky130_fd_sc_hd__nand2_1
X_14591_ net595 net605 net434 net426 VGND VGND VPWR VPWR _07000_ sky130_fd_sc_hd__nand4_1
XFILLER_0_94_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13542_ net593 net584 net489 net412 VGND VGND VPWR VPWR _05860_ sky130_fd_sc_hd__and4_2
XFILLER_0_27_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10754_ _02733_ _02735_ _02732_ VGND VGND VPWR VPWR _02820_ sky130_fd_sc_hd__a21o_1
XFILLER_0_55_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10685_ _02729_ _02744_ VGND VGND VPWR VPWR _02746_ sky130_fd_sc_hd__xnor2_1
X_13473_ _05719_ _05783_ _05784_ VGND VGND VPWR VPWR _05785_ sky130_fd_sc_hd__and3_1
X_12424_ _04638_ _04639_ VGND VGND VPWR VPWR _04640_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_124_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_33_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12355_ _04563_ _04564_ VGND VGND VPWR VPWR _04566_ sky130_fd_sc_hd__xnor2_1
X_11306_ _03412_ _03417_ _03419_ VGND VGND VPWR VPWR _03420_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_77_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12286_ _04487_ _04488_ _04473_ VGND VGND VPWR VPWR _04491_ sky130_fd_sc_hd__a21o_1
X_11237_ _03271_ _03343_ VGND VGND VPWR VPWR _03344_ sky130_fd_sc_hd__nor2_1
X_14025_ _06288_ _06289_ _06286_ VGND VGND VPWR VPWR _06386_ sky130_fd_sc_hd__a21o_1
X_11168_ net148 net797 net736 net743 VGND VGND VPWR VPWR _03268_ sky130_fd_sc_hd__and4_1
XFILLER_0_93_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10119_ _02127_ _02128_ VGND VGND VPWR VPWR _02129_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_42_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11099_ _03183_ _03138_ _03192_ VGND VGND VPWR VPWR _03194_ sky130_fd_sc_hd__nor3_1
XFILLER_0_117_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13809_ _06147_ _06148_ _06149_ VGND VGND VPWR VPWR _06151_ sky130_fd_sc_hd__nand3_1
X_14789_ clknet_3_7_0_clk _00090_ net323 VGND VGND VPWR VPWR a_sin\[17\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_128_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09000_ _01039_ _01040_ VGND VGND VPWR VPWR _01041_ sky130_fd_sc_hd__nor2_2
XFILLER_0_73_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_51_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_7_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_14_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout515 net34 VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__buf_2
X_09902_ _01877_ _01879_ _01902_ VGND VGND VPWR VPWR _01903_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout504 net505 VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__clkbuf_4
Xfanout548 net551 VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__buf_1
X_09833_ _01814_ _01817_ VGND VGND VPWR VPWR _01834_ sky130_fd_sc_hd__nor2_1
Xfanout537 net542 VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__buf_4
Xfanout526 net33 VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__clkbuf_8
Xfanout559 net560 VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__clkbuf_4
X_09764_ _01734_ _01762_ _01761_ VGND VGND VPWR VPWR _01765_ sky130_fd_sc_hd__nand3_1
Xrebuffer20 _05545_ VGND VGND VPWR VPWR net765 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_96_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08715_ _00759_ _00748_ _00749_ VGND VGND VPWR VPWR _00761_ sky130_fd_sc_hd__or3_4
X_09695_ _01404_ _01405_ _01419_ VGND VGND VPWR VPWR _01696_ sky130_fd_sc_hd__a21oi_1
Xrebuffer31 _04582_ VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_95_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08646_ _00583_ _00586_ VGND VGND VPWR VPWR _00693_ sky130_fd_sc_hd__or2_1
XFILLER_0_139_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08577_ _00537_ _00546_ _00624_ VGND VGND VPWR VPWR _00625_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_37_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07528_ net288 net663 _02919_ _02929_ VGND VGND VPWR VPWR _03945_ sky130_fd_sc_hd__o2bb2a_1
X_07459_ _03146_ _03178_ VGND VGND VPWR VPWR _03189_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_91_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10470_ _02433_ _02436_ _02434_ VGND VGND VPWR VPWR _02511_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_122_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09129_ net796 net794 _01165_ _01166_ VGND VGND VPWR VPWR _00018_ sky130_fd_sc_hd__a22o_1
XFILLER_0_32_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12140_ _04234_ _04235_ VGND VGND VPWR VPWR _04332_ sky130_fd_sc_hd__and2b_1
X_12071_ net706 net249 net240 net714 VGND VGND VPWR VPWR _04256_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11022_ _03062_ _03063_ _03055_ VGND VGND VPWR VPWR _03110_ sky130_fd_sc_hd__o21ai_1
X_12973_ _05233_ _05234_ VGND VGND VPWR VPWR _05235_ sky130_fd_sc_hd__nor2_1
X_11924_ net670 net679 net150 net298 VGND VGND VPWR VPWR _04096_ sky130_fd_sc_hd__nand4_1
X_14712_ clknet_3_7_0_clk _00013_ net322 VGND VGND VPWR VPWR b_sin\[13\] sky130_fd_sc_hd__dfrtp_1
X_14643_ _07050_ _07055_ VGND VGND VPWR VPWR _07056_ sky130_fd_sc_hd__xor2_1
X_11855_ _03922_ _03931_ _03930_ VGND VGND VPWR VPWR _04022_ sky130_fd_sc_hd__a21bo_1
X_11786_ _03880_ _03944_ _03946_ VGND VGND VPWR VPWR _03947_ sky130_fd_sc_hd__nand3_2
X_10806_ _02855_ _02856_ _02874_ VGND VGND VPWR VPWR _02877_ sky130_fd_sc_hd__nor3_1
X_14574_ net586 _06979_ _06980_ VGND VGND VPWR VPWR _06981_ sky130_fd_sc_hd__a21o_1
XFILLER_0_138_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10737_ _02795_ _02801_ VGND VGND VPWR VPWR _02802_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13525_ _05757_ _05759_ _05758_ VGND VGND VPWR VPWR _05842_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_12_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13456_ _05763_ _05764_ _05762_ VGND VGND VPWR VPWR _05767_ sky130_fd_sc_hd__o21ai_1
X_12407_ _04537_ _04555_ VGND VGND VPWR VPWR _04622_ sky130_fd_sc_hd__nor2_1
XFILLER_0_106_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10668_ _02660_ _02663_ _02724_ _02725_ VGND VGND VPWR VPWR _02727_ sky130_fd_sc_hd__a211oi_2
Xoutput107 net107 VGND VGND VPWR VPWR Q[6] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_51_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13387_ net656 net391 _05689_ VGND VGND VPWR VPWR _05691_ sky130_fd_sc_hd__and3_1
X_10599_ _02650_ _02651_ VGND VGND VPWR VPWR _02652_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12338_ _04475_ _04539_ _04545_ VGND VGND VPWR VPWR _04547_ sky130_fd_sc_hd__o21a_1
XFILLER_0_50_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12269_ _04379_ _04387_ _04388_ VGND VGND VPWR VPWR _04472_ sky130_fd_sc_hd__and3_1
XFILLER_0_128_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14008_ _06265_ _06272_ _06367_ VGND VGND VPWR VPWR _06368_ sky130_fd_sc_hd__a21bo_1
X_08500_ _00547_ _00548_ VGND VGND VPWR VPWR _00549_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09480_ _01478_ _01479_ _01474_ VGND VGND VPWR VPWR _01481_ sky130_fd_sc_hd__a21o_1
X_08431_ _00401_ _00402_ _00479_ VGND VGND VPWR VPWR _00481_ sky130_fd_sc_hd__or3_1
XFILLER_0_77_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08362_ net249 net241 net525 net533 VGND VGND VPWR VPWR _00412_ sky130_fd_sc_hd__and4_1
XFILLER_0_18_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08293_ _00341_ _00342_ _00343_ VGND VGND VPWR VPWR _00344_ sky130_fd_sc_hd__a21o_1
XFILLER_0_73_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout312 net313 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_111_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout301 net303 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__clkbuf_4
Xfanout323 net328 VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__clkbuf_2
Xfanout334 net337 VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__buf_4
Xfanout356 net364 VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__clkbuf_2
Xfanout345 net354 VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__clkbuf_4
Xfanout378 net5 VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__clkbuf_2
X_09816_ _01815_ _01816_ VGND VGND VPWR VPWR _01817_ sky130_fd_sc_hd__or2_1
Xfanout367 net50 VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__buf_4
Xfanout389 net397 VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__clkbuf_4
X_09747_ _01744_ _01746_ _01747_ VGND VGND VPWR VPWR _01748_ sky130_fd_sc_hd__a21bo_1
X_09678_ _01677_ _01678_ VGND VGND VPWR VPWR _01679_ sky130_fd_sc_hd__nor2_1
XFILLER_0_139_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08629_ net181 net171 net581 VGND VGND VPWR VPWR _00676_ sky130_fd_sc_hd__o21a_1
X_11640_ _03785_ _03786_ VGND VGND VPWR VPWR _03787_ sky130_fd_sc_hd__nor2_1
XFILLER_0_83_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11571_ _03705_ _03709_ _03710_ VGND VGND VPWR VPWR _03711_ sky130_fd_sc_hd__nand3_1
XFILLER_0_135_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10522_ _02559_ _02567_ VGND VGND VPWR VPWR _02568_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_18_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13310_ net569 net365 VGND VGND VPWR VPWR _05606_ sky130_fd_sc_hd__nand2_1
XFILLER_0_134_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14290_ _06589_ _06593_ _06673_ VGND VGND VPWR VPWR _06674_ sky130_fd_sc_hd__nor3_1
XFILLER_0_122_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10453_ _02489_ _02492_ VGND VGND VPWR VPWR _02493_ sky130_fd_sc_hd__xor2_1
X_13241_ _05493_ _05500_ _05503_ VGND VGND VPWR VPWR _05530_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_107_Left_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10384_ net715 net416 VGND VGND VPWR VPWR _02417_ sky130_fd_sc_hd__and2b_1
XFILLER_0_20_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13172_ _05451_ _05453_ VGND VGND VPWR VPWR _05454_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12123_ _04225_ _04312_ VGND VGND VPWR VPWR _04313_ sky130_fd_sc_hd__nor2_2
XFILLER_0_103_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12054_ _04084_ _04146_ _04145_ VGND VGND VPWR VPWR _04238_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_74_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11005_ _03071_ _03091_ VGND VGND VPWR VPWR _03093_ sky130_fd_sc_hd__or2_1
XFILLER_0_99_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12956_ _05203_ _05209_ _05205_ VGND VGND VPWR VPWR _05217_ sky130_fd_sc_hd__nand3_1
X_11907_ _04076_ _04077_ VGND VGND VPWR VPWR _04078_ sky130_fd_sc_hd__xor2_1
X_12887_ _05083_ _05097_ _05142_ VGND VGND VPWR VPWR _05143_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_23_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11838_ _04000_ _04001_ _03981_ VGND VGND VPWR VPWR _04003_ sky130_fd_sc_hd__a21o_1
XFILLER_0_68_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14626_ _07035_ _07037_ VGND VGND VPWR VPWR _07038_ sky130_fd_sc_hd__nor2_1
XFILLER_0_117_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14557_ _06873_ _06900_ _06962_ VGND VGND VPWR VPWR _06964_ sky130_fd_sc_hd__a21o_1
X_11769_ _03925_ _03926_ _03924_ VGND VGND VPWR VPWR _03928_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_126_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13508_ _05821_ _05822_ VGND VGND VPWR VPWR _05823_ sky130_fd_sc_hd__xor2_1
XFILLER_0_28_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14488_ _06819_ _06825_ VGND VGND VPWR VPWR _06889_ sky130_fd_sc_hd__and2b_1
X_13439_ net494 net356 net346 net503 VGND VGND VPWR VPWR _05748_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08980_ _01003_ _01021_ VGND VGND VPWR VPWR _01022_ sky130_fd_sc_hd__xnor2_1
X_07931_ net255 net567 VGND VGND VPWR VPWR _07226_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07862_ _03363_ _03385_ _03374_ VGND VGND VPWR VPWR _07158_ sky130_fd_sc_hd__o21bai_1
X_09601_ _01574_ _01579_ VGND VGND VPWR VPWR _01602_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07793_ net208 net660 VGND VGND VPWR VPWR _06831_ sky130_fd_sc_hd__nand2_1
X_09532_ _01481_ _01486_ _01480_ VGND VGND VPWR VPWR _01533_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_3_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09463_ net717 net331 net476 net727 VGND VGND VPWR VPWR _01464_ sky130_fd_sc_hd__a22oi_1
X_08414_ _00460_ _00461_ _00462_ VGND VGND VPWR VPWR _00464_ sky130_fd_sc_hd__a21o_1
X_09394_ _01389_ _01390_ _01394_ VGND VGND VPWR VPWR _01395_ sky130_fd_sc_hd__a21o_1
XFILLER_0_93_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08345_ _00229_ _00311_ VGND VGND VPWR VPWR _00396_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08276_ _00325_ _00326_ VGND VGND VPWR VPWR _00327_ sky130_fd_sc_hd__xor2_2
XFILLER_0_131_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout131 state VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__clkbuf_2
Xfanout153 net154 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__clkbuf_4
Xfanout164 net166 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__clkbuf_4
Xfanout142 net8 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__clkbuf_4
Xfanout197 net198 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__buf_4
Xfanout175 net183 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__clkbuf_4
Xfanout186 net192 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__clkbuf_4
X_12810_ _05020_ _05022_ VGND VGND VPWR VPWR _05059_ sky130_fd_sc_hd__or2_1
XFILLER_0_69_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13790_ _06126_ _06127_ _06128_ VGND VGND VPWR VPWR _06130_ sky130_fd_sc_hd__a21o_1
X_12741_ _04969_ _04966_ VGND VGND VPWR VPWR _04984_ sky130_fd_sc_hd__and2b_1
XFILLER_0_69_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12672_ _04835_ _04854_ _04908_ _04909_ VGND VGND VPWR VPWR _04910_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_56_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11623_ _03766_ _03767_ VGND VGND VPWR VPWR _03768_ sky130_fd_sc_hd__and2_1
X_14411_ net334 net479 net579 VGND VGND VPWR VPWR _06805_ sky130_fd_sc_hd__o21a_1
XFILLER_0_37_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11554_ _03688_ _03687_ _03620_ _03603_ VGND VGND VPWR VPWR _03692_ sky130_fd_sc_hd__a211o_1
XFILLER_0_108_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14342_ _06728_ _06729_ VGND VGND VPWR VPWR _06730_ sky130_fd_sc_hd__xnor2_2
X_11485_ _03606_ _03615_ VGND VGND VPWR VPWR _03617_ sky130_fd_sc_hd__xnor2_1
X_10505_ _02529_ _02530_ _02547_ _02548_ VGND VGND VPWR VPWR _02550_ sky130_fd_sc_hd__o211ai_1
X_14273_ _06647_ _06654_ VGND VGND VPWR VPWR _06655_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_123_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10436_ _02468_ _02472_ _02369_ VGND VGND VPWR VPWR _02475_ sky130_fd_sc_hd__a21o_1
X_13224_ net510 net483 net405 net518 VGND VGND VPWR VPWR _05511_ sky130_fd_sc_hd__a22o_1
XFILLER_0_33_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10367_ _02210_ _02399_ _02297_ VGND VGND VPWR VPWR _02400_ sky130_fd_sc_hd__o21ai_2
X_13155_ net502 net483 net405 net510 VGND VGND VPWR VPWR _05436_ sky130_fd_sc_hd__a22o_1
X_12106_ _04210_ _04212_ VGND VGND VPWR VPWR _04295_ sky130_fd_sc_hd__nand2_1
X_10298_ _02323_ _02230_ VGND VGND VPWR VPWR _02324_ sky130_fd_sc_hd__nor2_1
X_13086_ _05256_ _05295_ _05326_ _05327_ VGND VGND VPWR VPWR _05360_ sky130_fd_sc_hd__a211o_1
X_12037_ net274 net196 VGND VGND VPWR VPWR _04220_ sky130_fd_sc_hd__and2_1
XFILLER_0_18_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13988_ _06341_ _06343_ _06344_ VGND VGND VPWR VPWR _06346_ sky130_fd_sc_hd__a21oi_1
X_12939_ net502 net510 net389 net380 VGND VGND VPWR VPWR _05198_ sky130_fd_sc_hd__and4_1
XFILLER_0_34_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14609_ _07018_ _07019_ VGND VGND VPWR VPWR _07020_ sky130_fd_sc_hd__xor2_1
X_08130_ _00181_ _00182_ VGND VGND VPWR VPWR _00183_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08061_ net169 net775 _00112_ _00113_ VGND VGND VPWR VPWR _00115_ sky130_fd_sc_hd__nand4_1
XFILLER_0_71_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08963_ net252 net244 net607 net618 VGND VGND VPWR VPWR _01005_ sky130_fd_sc_hd__and4_1
X_07914_ net247 net575 net662 net239 VGND VGND VPWR VPWR _07209_ sky130_fd_sc_hd__a22o_1
XFILLER_0_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08894_ _00935_ _00920_ VGND VGND VPWR VPWR _00937_ sky130_fd_sc_hd__or2b_1
X_07845_ _07139_ _07140_ VGND VGND VPWR VPWR _07141_ sky130_fd_sc_hd__nor2_1
X_07776_ _06603_ _06635_ VGND VGND VPWR VPWR _06646_ sky130_fd_sc_hd__nor2_1
X_09515_ net735 net451 net443 net742 VGND VGND VPWR VPWR _01516_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_66_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09446_ _01439_ _01446_ VGND VGND VPWR VPWR _01447_ sky130_fd_sc_hd__xor2_1
XFILLER_0_81_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09377_ net552 net488 net410 net647 VGND VGND VPWR VPWR _01378_ sky130_fd_sc_hd__a22o_1
X_08328_ _00297_ _00298_ VGND VGND VPWR VPWR _00379_ sky130_fd_sc_hd__or2b_1
XFILLER_0_62_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08259_ _00224_ _00226_ _00309_ VGND VGND VPWR VPWR _00311_ sky130_fd_sc_hd__o21a_1
XFILLER_0_7_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11270_ _03365_ _03366_ _03378_ VGND VGND VPWR VPWR _03380_ sky130_fd_sc_hd__and3_1
XFILLER_0_104_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10221_ _02166_ _02172_ VGND VGND VPWR VPWR _02240_ sky130_fd_sc_hd__and2_1
X_10152_ _02026_ _02029_ VGND VGND VPWR VPWR _02165_ sky130_fd_sc_hd__nand2_1
X_10083_ net718 net727 net436 net429 VGND VGND VPWR VPWR _02090_ sky130_fd_sc_hd__and4_1
X_13911_ _06167_ _06169_ VGND VGND VPWR VPWR _06262_ sky130_fd_sc_hd__nor2_1
X_13842_ net546 net415 VGND VGND VPWR VPWR _06186_ sky130_fd_sc_hd__and2b_1
X_13773_ _06094_ _06110_ VGND VGND VPWR VPWR _06111_ sky130_fd_sc_hd__xnor2_1
X_12724_ _04963_ _04965_ VGND VGND VPWR VPWR _04966_ sky130_fd_sc_hd__xnor2_2
X_10985_ _03068_ _03069_ VGND VGND VPWR VPWR _03071_ sky130_fd_sc_hd__and2b_1
XFILLER_0_139_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12655_ net654 net238 VGND VGND VPWR VPWR _04892_ sky130_fd_sc_hd__and2b_1
XFILLER_0_72_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11606_ net255 net745 VGND VGND VPWR VPWR _03750_ sky130_fd_sc_hd__nand2_1
X_12586_ _04762_ _04764_ VGND VGND VPWR VPWR _04817_ sky130_fd_sc_hd__or2_1
XFILLER_0_65_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11537_ net148 net713 net722 net797 VGND VGND VPWR VPWR _03674_ sky130_fd_sc_hd__a22o_1
XFILLER_0_123_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14325_ _06667_ _06669_ VGND VGND VPWR VPWR _06712_ sky130_fd_sc_hd__nand2_1
XFILLER_0_80_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap117 _05294_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__buf_1
X_11468_ _03593_ _03597_ VGND VGND VPWR VPWR _03598_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14256_ _06596_ VGND VGND VPWR VPWR _06637_ sky130_fd_sc_hd__inv_2
XFILLER_0_123_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11399_ _03520_ _03521_ _03450_ VGND VGND VPWR VPWR _03522_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_110_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10419_ _02362_ _02365_ _02363_ VGND VGND VPWR VPWR _02456_ sky130_fd_sc_hd__a21bo_1
X_14187_ _06560_ _06561_ VGND VGND VPWR VPWR _06562_ sky130_fd_sc_hd__xnor2_1
X_13207_ _05453_ _05491_ _05492_ VGND VGND VPWR VPWR _05493_ sky130_fd_sc_hd__or3_1
XFILLER_0_0_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13138_ _05396_ _05397_ _05415_ _05416_ VGND VGND VPWR VPWR _05417_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_29_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13069_ _05334_ _05340_ VGND VGND VPWR VPWR _05341_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_29_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_119_Right_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07630_ net157 net574 _04587_ _04598_ VGND VGND VPWR VPWR _05053_ sky130_fd_sc_hd__o2bb2a_2
X_07561_ net747 _04282_ _04293_ VGND VGND VPWR VPWR _04304_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_45_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09300_ _01310_ _01311_ VGND VGND VPWR VPWR _01312_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07492_ _03462_ _03539_ VGND VGND VPWR VPWR _03550_ sky130_fd_sc_hd__xor2_2
XFILLER_0_29_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09231_ _01252_ _01253_ VGND VGND VPWR VPWR _01254_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_61_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09162_ net88 _01194_ net129 VGND VGND VPWR VPWR _01195_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08113_ net281 net524 net533 net263 VGND VGND VPWR VPWR _00166_ sky130_fd_sc_hd__a22oi_2
X_09093_ _01122_ _01121_ VGND VGND VPWR VPWR _01132_ sky130_fd_sc_hd__or2b_1
XFILLER_0_44_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08044_ net231 net588 VGND VGND VPWR VPWR _07338_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09995_ _01991_ _01992_ _01993_ VGND VGND VPWR VPWR _01996_ sky130_fd_sc_hd__a21o_1
X_08946_ _00986_ _00987_ VGND VGND VPWR VPWR _00988_ sky130_fd_sc_hd__nor2_1
XFILLER_0_86_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08877_ _00864_ _00884_ _00862_ VGND VGND VPWR VPWR _00920_ sky130_fd_sc_hd__a21o_1
X_07828_ _07122_ _07123_ VGND VGND VPWR VPWR _07124_ sky130_fd_sc_hd__nand2_1
XFILLER_0_98_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07759_ _06374_ _06429_ _06385_ VGND VGND VPWR VPWR _06462_ sky130_fd_sc_hd__nand3_1
XFILLER_0_66_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10770_ _02835_ _02836_ _02769_ _02770_ VGND VGND VPWR VPWR _02838_ sky130_fd_sc_hd__a211o_1
XFILLER_0_39_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09429_ net682 net367 VGND VGND VPWR VPWR _01430_ sky130_fd_sc_hd__nand2_1
X_12440_ _04581_ _04592_ _04657_ VGND VGND VPWR VPWR _04658_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_47_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12371_ net275 net162 _04507_ _04506_ VGND VGND VPWR VPWR _04583_ sky130_fd_sc_hd__a31o_1
X_14110_ _06381_ _06382_ _06380_ VGND VGND VPWR VPWR _06478_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_22_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11322_ _03435_ _03436_ net148 net743 VGND VGND VPWR VPWR _03437_ sky130_fd_sc_hd__o211a_1
XFILLER_0_105_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11253_ _03354_ _03355_ _03360_ VGND VGND VPWR VPWR _03361_ sky130_fd_sc_hd__nand3_2
X_14041_ _06401_ _06402_ VGND VGND VPWR VPWR _06403_ sky130_fd_sc_hd__or2_1
XFILLER_0_120_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10204_ net710 net429 net421 net718 VGND VGND VPWR VPWR _02221_ sky130_fd_sc_hd__a22oi_1
X_11184_ net210 net694 net703 net201 VGND VGND VPWR VPWR _03285_ sky130_fd_sc_hd__a22oi_2
X_10135_ _02144_ _02145_ VGND VGND VPWR VPWR _02147_ sky130_fd_sc_hd__nor2_1
X_10066_ _02068_ _02069_ _02071_ VGND VGND VPWR VPWR _02072_ sky130_fd_sc_hd__nand3_1
XFILLER_0_82_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13825_ _06016_ _06075_ _06074_ VGND VGND VPWR VPWR _06169_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_97_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10968_ _03041_ _03042_ VGND VGND VPWR VPWR _03052_ sky130_fd_sc_hd__and2b_1
XFILLER_0_15_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13756_ _05999_ _06011_ _06012_ _06014_ _05998_ VGND VGND VPWR VPWR _06093_ sky130_fd_sc_hd__a32o_1
XFILLER_0_128_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12707_ net558 net238 VGND VGND VPWR VPWR _04948_ sky130_fd_sc_hd__and2b_1
XFILLER_0_45_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13687_ _05900_ _05908_ _05907_ VGND VGND VPWR VPWR _06018_ sky130_fd_sc_hd__a21o_1
X_12638_ net155 net302 net136 VGND VGND VPWR VPWR _04873_ sky130_fd_sc_hd__o21ai_2
X_10899_ _02881_ _02976_ _02974_ _02975_ VGND VGND VPWR VPWR _02978_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_5_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12569_ _04795_ _04796_ net190 net291 VGND VGND VPWR VPWR _04798_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_108_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14308_ _06572_ _06677_ _06693_ VGND VGND VPWR VPWR _06694_ sky130_fd_sc_hd__nand3_1
XFILLER_0_111_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14239_ _06616_ _06617_ _06532_ _06552_ VGND VGND VPWR VPWR _06619_ sky130_fd_sc_hd__a211o_1
XFILLER_0_1_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08800_ _00824_ _00825_ _00844_ VGND VGND VPWR VPWR _00845_ sky130_fd_sc_hd__o21ai_2
Xfanout719 net12 VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__buf_2
Xfanout708 net709 VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_21_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09780_ _01774_ _01779_ _01780_ VGND VGND VPWR VPWR _01781_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08731_ _00695_ _00700_ VGND VGND VPWR VPWR _00777_ sky130_fd_sc_hd__and2b_1
X_08662_ _00691_ _00692_ _00708_ VGND VGND VPWR VPWR _00709_ sky130_fd_sc_hd__or3_1
XFILLER_0_56_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07613_ _04837_ net750 _04858_ VGND VGND VPWR VPWR _04869_ sky130_fd_sc_hd__nand3_1
X_08593_ _00557_ _00559_ VGND VGND VPWR VPWR _00641_ sky130_fd_sc_hd__nand2_1
X_07544_ _03027_ _03038_ VGND VGND VPWR VPWR _04119_ sky130_fd_sc_hd__xnor2_1
X_07475_ net195 net497 VGND VGND VPWR VPWR _03363_ sky130_fd_sc_hd__nand2_1
XFILLER_0_64_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09214_ a_cos\[13\] b_sin\[13\] VGND VGND VPWR VPWR _01239_ sky130_fd_sc_hd__or2_1
XFILLER_0_118_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09145_ _01178_ _01179_ VGND VGND VPWR VPWR _01180_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09076_ _01065_ _01114_ VGND VGND VPWR VPWR _01116_ sky130_fd_sc_hd__nor2_1
X_08027_ _07318_ _07319_ _07317_ VGND VGND VPWR VPWR _07321_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_32_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09978_ net552 net369 VGND VGND VPWR VPWR _01978_ sky130_fd_sc_hd__and2_1
X_08929_ _00970_ _00971_ VGND VGND VPWR VPWR _00972_ sky130_fd_sc_hd__or2_1
X_11940_ net462 net557 net180 net170 VGND VGND VPWR VPWR _04114_ sky130_fd_sc_hd__nand4_2
XFILLER_0_99_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11871_ _04036_ _04037_ _03936_ _04004_ VGND VGND VPWR VPWR _04039_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_79_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10822_ _02891_ _02892_ VGND VGND VPWR VPWR _02894_ sky130_fd_sc_hd__and2_1
X_13610_ _05931_ _05932_ _05899_ _05872_ VGND VGND VPWR VPWR _05934_ sky130_fd_sc_hd__a211oi_2
X_14590_ net595 net434 net426 net605 VGND VGND VPWR VPWR _06999_ sky130_fd_sc_hd__a22o_1
XFILLER_0_82_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10753_ _02813_ _02818_ VGND VGND VPWR VPWR _02819_ sky130_fd_sc_hd__xnor2_1
X_13541_ net584 net489 net412 net593 VGND VGND VPWR VPWR _05859_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_109_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10684_ _02741_ _02743_ VGND VGND VPWR VPWR _02744_ sky130_fd_sc_hd__xor2_1
X_13472_ _05781_ _05782_ _05394_ _05419_ VGND VGND VPWR VPWR _05784_ sky130_fd_sc_hd__a211o_1
X_12423_ _04567_ _04570_ _04568_ VGND VGND VPWR VPWR _04639_ sky130_fd_sc_hd__o21ba_1
X_12354_ net671 net260 VGND VGND VPWR VPWR _04564_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11305_ _03405_ _03411_ _03406_ VGND VGND VPWR VPWR _03419_ sky130_fd_sc_hd__nand3_1
XFILLER_0_11_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12285_ _04473_ _04487_ _04488_ VGND VGND VPWR VPWR _04490_ sky130_fd_sc_hd__nand3_1
X_14024_ _06378_ _06383_ VGND VGND VPWR VPWR _06384_ sky130_fd_sc_hd__xnor2_1
X_11236_ _03259_ _03267_ _03270_ VGND VGND VPWR VPWR _03343_ sky130_fd_sc_hd__and3_1
X_11167_ _03263_ _03266_ VGND VGND VPWR VPWR _03267_ sky130_fd_sc_hd__or2b_1
X_10118_ net718 net728 net429 net421 VGND VGND VPWR VPWR _02128_ sky130_fd_sc_hd__and4_1
X_11098_ _03183_ _03138_ _03192_ VGND VGND VPWR VPWR _03193_ sky130_fd_sc_hd__o21a_1
X_10049_ _02033_ _02051_ _02052_ VGND VGND VPWR VPWR _02053_ sky130_fd_sc_hd__nand3_2
XFILLER_0_58_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14788_ clknet_3_7_0_clk _00089_ net323 VGND VGND VPWR VPWR a_sin\[16\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13808_ _06147_ _06148_ _06149_ VGND VGND VPWR VPWR _06150_ sky130_fd_sc_hd__a21o_1
XFILLER_0_128_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13739_ _06072_ _06073_ _05933_ _05959_ VGND VGND VPWR VPWR _06075_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_73_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09901_ _01867_ _01878_ VGND VGND VPWR VPWR _01902_ sky130_fd_sc_hd__nor2_1
XFILLER_0_41_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout505 net35 VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__clkbuf_4
Xfanout538 net542 VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__clkbuf_4
Xfanout516 net517 VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__clkbuf_4
X_09832_ _01820_ _01831_ _01832_ VGND VGND VPWR VPWR _01833_ sky130_fd_sc_hd__nand3_2
Xfanout527 net530 VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__buf_2
Xfanout549 net551 VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__buf_2
X_09763_ _01711_ _01718_ _01763_ VGND VGND VPWR VPWR _01764_ sky130_fd_sc_hd__a21oi_1
X_08714_ _00748_ _00749_ _00759_ VGND VGND VPWR VPWR _00760_ sky130_fd_sc_hd__o21ai_1
Xrebuffer10 net754 VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__clkbuf_1
Xrebuffer21 _04739_ VGND VGND VPWR VPWR net766 sky130_fd_sc_hd__clkbuf_1
X_09694_ _01684_ _01685_ _01694_ VGND VGND VPWR VPWR _01695_ sky130_fd_sc_hd__nand3_1
Xrebuffer32 _04582_ VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__dlygate4sd1_1
X_08645_ _00690_ _00628_ _00688_ _00689_ VGND VGND VPWR VPWR _00692_ sky130_fd_sc_hd__o211a_1
X_08576_ _00531_ _00536_ VGND VGND VPWR VPWR _00624_ sky130_fd_sc_hd__nand2_1
X_07527_ _03868_ _03879_ _03912_ VGND VGND VPWR VPWR _03934_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07458_ _03157_ _03167_ VGND VGND VPWR VPWR _03178_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07389_ net157 net547 VGND VGND VPWR VPWR _02429_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09128_ a_cos\[0\] b_sin\[0\] net128 VGND VGND VPWR VPWR _01166_ sky130_fd_sc_hd__o21a_1
XFILLER_0_115_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09059_ _01055_ _01059_ net127 _01098_ VGND VGND VPWR VPWR _01099_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_60_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12070_ _04188_ _04191_ _04189_ VGND VGND VPWR VPWR _04255_ sky130_fd_sc_hd__o21ba_1
X_11021_ _02924_ _03066_ VGND VGND VPWR VPWR _03109_ sky130_fd_sc_hd__or2_1
X_12972_ _05230_ _05232_ _05231_ VGND VGND VPWR VPWR _05234_ sky130_fd_sc_hd__a21oi_1
X_11923_ net670 net150 net298 net679 VGND VGND VPWR VPWR _04095_ sky130_fd_sc_hd__a22o_1
XFILLER_0_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14711_ clknet_3_6_0_clk _00012_ net320 VGND VGND VPWR VPWR b_sin\[12\] sky130_fd_sc_hd__dfrtp_1
X_11854_ _04017_ _04018_ _04009_ VGND VGND VPWR VPWR _04020_ sky130_fd_sc_hd__a21o_1
X_14642_ _07053_ _07054_ VGND VGND VPWR VPWR _07055_ sky130_fd_sc_hd__xor2_1
X_10805_ _02855_ _02856_ _02874_ VGND VGND VPWR VPWR _02876_ sky130_fd_sc_hd__o21a_1
XFILLER_0_28_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11785_ _03942_ _03943_ _03846_ _03849_ VGND VGND VPWR VPWR _03946_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_94_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14573_ net586 net438 _06978_ VGND VGND VPWR VPWR _06980_ sky130_fd_sc_hd__a21oi_1
X_10736_ _02796_ _02800_ VGND VGND VPWR VPWR _02801_ sky130_fd_sc_hd__xor2_1
X_13524_ _05749_ _05750_ VGND VGND VPWR VPWR _05840_ sky130_fd_sc_hd__nand2_1
X_10667_ _02724_ _02725_ _02660_ _02663_ VGND VGND VPWR VPWR _02726_ sky130_fd_sc_hd__o211a_1
X_13455_ _05762_ _05763_ _05764_ VGND VGND VPWR VPWR _05766_ sky130_fd_sc_hd__or3_1
X_12406_ _04553_ _04538_ VGND VGND VPWR VPWR _04621_ sky130_fd_sc_hd__and2b_1
XFILLER_0_3_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13386_ net656 net391 _05685_ _05689_ VGND VGND VPWR VPWR _05690_ sky130_fd_sc_hd__a211o_1
X_10598_ net185 net53 VGND VGND VPWR VPWR _02651_ sky130_fd_sc_hd__nand2_1
X_12337_ _04475_ _04539_ _04545_ VGND VGND VPWR VPWR _04546_ sky130_fd_sc_hd__nor3_1
Xoutput108 net108 VGND VGND VPWR VPWR Q[7] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12268_ _04387_ VGND VGND VPWR VPWR _04471_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11219_ _03283_ _03289_ _03282_ VGND VGND VPWR VPWR _03324_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_120_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14007_ _06262_ _06263_ _06261_ VGND VGND VPWR VPWR _06367_ sky130_fd_sc_hd__o21ai_1
X_12199_ _04303_ _04305_ _04319_ _04320_ VGND VGND VPWR VPWR _04396_ sky130_fd_sc_hd__or4bb_1
Xoutput90 net90 VGND VGND VPWR VPWR D[7] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_128_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08430_ _00401_ _00402_ _00479_ VGND VGND VPWR VPWR _00480_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_59_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08361_ net249 net525 net533 net241 VGND VGND VPWR VPWR _00411_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_129_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08292_ net293 net499 VGND VGND VPWR VPWR _00343_ sky130_fd_sc_hd__and2_1
XFILLER_0_34_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout313 net56 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__buf_6
Xfanout302 net303 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_1_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout357 net359 VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__buf_2
X_09815_ net725 net734 net390 net382 VGND VGND VPWR VPWR _01816_ sky130_fd_sc_hd__and4_1
Xfanout324 net327 VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__clkbuf_4
Xfanout335 net337 VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__clkbuf_4
Xfanout346 net354 VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__clkbuf_2
Xfanout368 net369 VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__clkbuf_4
Xfanout379 net380 VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__buf_2
X_09746_ _01738_ _01743_ _01739_ VGND VGND VPWR VPWR _01747_ sky130_fd_sc_hd__nand3_1
X_09677_ net690 net699 net390 net381 VGND VGND VPWR VPWR _01678_ sky130_fd_sc_hd__and4_1
X_08628_ net181 net171 net581 VGND VGND VPWR VPWR _00675_ sky130_fd_sc_hd__and3_1
XFILLER_0_68_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08559_ _00592_ _00593_ _00606_ VGND VGND VPWR VPWR _00607_ sky130_fd_sc_hd__a21oi_1
X_11570_ _03707_ _03708_ _03706_ VGND VGND VPWR VPWR _03710_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_92_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10521_ _02561_ _02566_ VGND VGND VPWR VPWR _02567_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_9_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13240_ _05527_ _05526_ _05525_ _05521_ VGND VGND VPWR VPWR _05529_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_33_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10452_ _02327_ _02490_ _02491_ VGND VGND VPWR VPWR _02492_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_33_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10383_ _02414_ _02415_ VGND VGND VPWR VPWR _02416_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13171_ _05451_ _05452_ net569 net338 VGND VGND VPWR VPWR _05453_ sky130_fd_sc_hd__and4bb_1
X_12122_ net312 net233 net223 net135 VGND VGND VPWR VPWR _04312_ sky130_fd_sc_hd__and4_1
X_12053_ _04183_ _04236_ VGND VGND VPWR VPWR _04237_ sky130_fd_sc_hd__xnor2_1
X_11004_ _03089_ _03090_ VGND VGND VPWR VPWR _03091_ sky130_fd_sc_hd__and2_1
Xclkbuf_3_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_6_0_clk sky130_fd_sc_hd__clkbuf_8
X_12955_ _05211_ _05214_ VGND VGND VPWR VPWR _05216_ sky130_fd_sc_hd__xnor2_1
X_11906_ _03870_ _03967_ _03968_ VGND VGND VPWR VPWR _04077_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_87_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12886_ _05139_ _05141_ VGND VGND VPWR VPWR _05142_ sky130_fd_sc_hd__nand2_1
XFILLER_0_90_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11837_ _03981_ _04000_ _04001_ VGND VGND VPWR VPWR _04002_ sky130_fd_sc_hd__nand3_2
XFILLER_0_55_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14625_ _07034_ _06794_ VGND VGND VPWR VPWR _07037_ sky130_fd_sc_hd__and2b_1
X_11768_ _03924_ _03925_ _03926_ VGND VGND VPWR VPWR _03927_ sky130_fd_sc_hd__or3_1
XFILLER_0_83_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14556_ _06873_ _06900_ _06962_ VGND VGND VPWR VPWR _06963_ sky130_fd_sc_hd__nand3_1
XFILLER_0_82_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10719_ net142 net336 net481 net186 VGND VGND VPWR VPWR _02782_ sky130_fd_sc_hd__a22oi_1
X_13507_ net564 net437 VGND VGND VPWR VPWR _05822_ sky130_fd_sc_hd__nand2_1
XFILLER_0_125_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11699_ _03849_ _03850_ _03735_ _03762_ VGND VGND VPWR VPWR _03852_ sky130_fd_sc_hd__a211o_1
XFILLER_0_15_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14487_ _06886_ _06887_ VGND VGND VPWR VPWR _06888_ sky130_fd_sc_hd__xor2_1
XFILLER_0_125_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer1 _04249_ VGND VGND VPWR VPWR net746 sky130_fd_sc_hd__clkbuf_1
X_13438_ net511 net338 VGND VGND VPWR VPWR _05747_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13369_ _05657_ _05669_ VGND VGND VPWR VPWR _05671_ sky130_fd_sc_hd__nor2_1
XFILLER_0_139_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07930_ _07223_ _07224_ VGND VGND VPWR VPWR _07225_ sky130_fd_sc_hd__or2_1
X_07861_ net158 net524 _03517_ _03506_ VGND VGND VPWR VPWR _07157_ sky130_fd_sc_hd__a31o_1
XFILLER_0_3_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07792_ _06646_ _06809_ VGND VGND VPWR VPWR _06820_ sky130_fd_sc_hd__and2_1
X_09600_ _01568_ _01573_ VGND VGND VPWR VPWR _01601_ sky130_fd_sc_hd__and2b_1
X_09531_ _01489_ _01490_ _01499_ VGND VGND VPWR VPWR _01532_ sky130_fd_sc_hd__nand3_1
XFILLER_0_78_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09462_ net717 net727 net330 net475 VGND VGND VPWR VPWR _01463_ sky130_fd_sc_hd__and4_1
X_08413_ _00460_ _00461_ _00462_ VGND VGND VPWR VPWR _00463_ sky130_fd_sc_hd__nand3_1
XFILLER_0_47_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09393_ _01391_ _01392_ _01393_ VGND VGND VPWR VPWR _01394_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_86_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08344_ _00231_ _00394_ _00310_ VGND VGND VPWR VPWR _00395_ sky130_fd_sc_hd__a21o_1
XFILLER_0_74_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08275_ _00245_ _00246_ _00244_ VGND VGND VPWR VPWR _00326_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_6_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout143 net146 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__clkbuf_4
Xfanout154 net155 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__clkbuf_4
Xfanout165 net166 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__buf_2
Xfanout132 net133 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__buf_2
Xfanout198 net69 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__buf_2
Xfanout176 net183 VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__clkbuf_2
Xfanout187 net192 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__clkbuf_2
X_09729_ _01722_ _01729_ VGND VGND VPWR VPWR _01730_ sky130_fd_sc_hd__xnor2_1
X_12740_ _04965_ _04963_ VGND VGND VPWR VPWR _04983_ sky130_fd_sc_hd__and2b_1
X_12671_ _04855_ _04840_ _04907_ VGND VGND VPWR VPWR _04909_ sky130_fd_sc_hd__a21oi_4
X_11622_ _03678_ _03683_ _03685_ VGND VGND VPWR VPWR _03767_ sky130_fd_sc_hd__or3_1
XFILLER_0_49_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14410_ net587 net470 VGND VGND VPWR VPWR _06804_ sky130_fd_sc_hd__nand2_1
XFILLER_0_65_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14341_ net622 net438 VGND VGND VPWR VPWR _06729_ sky130_fd_sc_hd__nand2_1
X_11553_ _03391_ _03617_ _03690_ VGND VGND VPWR VPWR _03691_ sky130_fd_sc_hd__a21o_1
XFILLER_0_92_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11484_ _03607_ _03614_ VGND VGND VPWR VPWR _03615_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_108_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10504_ _02545_ _02546_ _02531_ VGND VGND VPWR VPWR _02548_ sky130_fd_sc_hd__a21o_1
X_14272_ _06652_ _06653_ VGND VGND VPWR VPWR _06654_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_122_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10435_ _02369_ _02468_ _02472_ VGND VGND VPWR VPWR _02474_ sky130_fd_sc_hd__nand3_1
X_13223_ net527 net398 VGND VGND VPWR VPWR _05510_ sky130_fd_sc_hd__and2_1
XFILLER_0_21_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13154_ net518 net398 VGND VGND VPWR VPWR _05434_ sky130_fd_sc_hd__and2_1
XFILLER_0_21_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12105_ _04273_ _04292_ VGND VGND VPWR VPWR _04294_ sky130_fd_sc_hd__xnor2_2
X_10366_ _02217_ _02296_ VGND VGND VPWR VPWR _02399_ sky130_fd_sc_hd__and2_1
XFILLER_0_21_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10297_ _02220_ _02226_ VGND VGND VPWR VPWR _02323_ sky130_fd_sc_hd__and2b_1
X_13085_ _05355_ _05356_ _05353_ _05357_ VGND VGND VPWR VPWR _05359_ sky130_fd_sc_hd__a211o_1
X_12036_ net188 net215 net205 net143 VGND VGND VPWR VPWR _04219_ sky130_fd_sc_hd__nand4_1
XFILLER_0_18_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13987_ _06341_ _06343_ _06344_ VGND VGND VPWR VPWR _06345_ sky130_fd_sc_hd__and3_1
X_12938_ net518 net365 VGND VGND VPWR VPWR _05197_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12869_ _05114_ _05068_ _05122_ VGND VGND VPWR VPWR _05123_ sky130_fd_sc_hd__o21a_1
XFILLER_0_56_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14608_ _06940_ _06954_ _06957_ VGND VGND VPWR VPWR _07019_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_71_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14539_ _06942_ _06943_ VGND VGND VPWR VPWR _06944_ sky130_fd_sc_hd__nor2_1
XFILLER_0_114_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08060_ net169 net775 _00112_ _00113_ VGND VGND VPWR VPWR _00114_ sky130_fd_sc_hd__a22o_1
XFILLER_0_3_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08962_ net252 net607 VGND VGND VPWR VPWR _01004_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_126_Left_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07913_ net255 net575 _07141_ _07140_ VGND VGND VPWR VPWR _07208_ sky130_fd_sc_hd__a31o_1
X_08893_ _00920_ _00935_ VGND VGND VPWR VPWR _00936_ sky130_fd_sc_hd__or2b_1
X_07844_ net279 net261 net549 net567 VGND VGND VPWR VPWR _07140_ sky130_fd_sc_hd__and4_1
XFILLER_0_75_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07775_ net208 net573 net660 net199 VGND VGND VPWR VPWR _06635_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_79_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09514_ net734 net742 net450 net443 VGND VGND VPWR VPWR _01515_ sky130_fd_sc_hd__and4_1
X_09445_ _01440_ _01445_ VGND VGND VPWR VPWR _01446_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_137_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_135_Left_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09376_ net552 net647 net488 net410 VGND VGND VPWR VPWR _01377_ sky130_fd_sc_hd__nand4_2
X_08327_ _00364_ _00377_ VGND VGND VPWR VPWR _00378_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_47_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08258_ _00224_ _00226_ _00309_ VGND VGND VPWR VPWR _00310_ sky130_fd_sc_hd__nor3_2
XFILLER_0_62_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08189_ _00154_ _00153_ VGND VGND VPWR VPWR _00241_ sky130_fd_sc_hd__or2b_1
XFILLER_0_61_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10220_ _02156_ _02159_ VGND VGND VPWR VPWR _02239_ sky130_fd_sc_hd__and2_1
X_10151_ _02142_ _02163_ VGND VGND VPWR VPWR _02164_ sky130_fd_sc_hd__xor2_1
XFILLER_0_30_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10082_ net718 net436 net429 net727 VGND VGND VPWR VPWR _02089_ sky130_fd_sc_hd__a22oi_2
X_13910_ _06177_ _06260_ VGND VGND VPWR VPWR _06261_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_97_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13841_ _06183_ _06184_ VGND VGND VPWR VPWR _06185_ sky130_fd_sc_hd__nor2_1
X_10984_ _02922_ _03003_ _03067_ VGND VGND VPWR VPWR _03069_ sky130_fd_sc_hd__a21o_1
X_13772_ _06106_ _06109_ VGND VGND VPWR VPWR _06110_ sky130_fd_sc_hd__xor2_1
XFILLER_0_139_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12723_ _04884_ _04906_ _04964_ VGND VGND VPWR VPWR _04965_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_85_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12654_ _04888_ _04889_ VGND VGND VPWR VPWR _04890_ sky130_fd_sc_hd__nor2_1
XFILLER_0_53_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12585_ _04741_ _04744_ _04812_ net118 VGND VGND VPWR VPWR _04816_ sky130_fd_sc_hd__a211oi_2
X_11605_ _03742_ _03747_ VGND VGND VPWR VPWR _03749_ sky130_fd_sc_hd__xor2_1
XFILLER_0_108_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11536_ net148 net797 net713 net722 VGND VGND VPWR VPWR _03673_ sky130_fd_sc_hd__and4_1
XFILLER_0_52_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14324_ _06676_ _06696_ VGND VGND VPWR VPWR _06710_ sky130_fd_sc_hd__or2_1
XFILLER_0_52_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14255_ _06482_ _06613_ VGND VGND VPWR VPWR _06636_ sky130_fd_sc_hd__nor2_1
Xmax_cap118 _04813_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__buf_1
X_11467_ _03595_ _03596_ VGND VGND VPWR VPWR _03597_ sky130_fd_sc_hd__and2b_1
XFILLER_0_110_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13206_ net569 net338 _05451_ _05452_ VGND VGND VPWR VPWR _05492_ sky130_fd_sc_hd__o2bb2a_1
X_11398_ _03480_ _03519_ _03518_ _03516_ VGND VGND VPWR VPWR _03521_ sky130_fd_sc_hd__a211o_1
XFILLER_0_110_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10418_ _02354_ _02356_ VGND VGND VPWR VPWR _02455_ sky130_fd_sc_hd__nand2_1
X_14186_ net641 net438 VGND VGND VPWR VPWR _06561_ sky130_fd_sc_hd__nand2_1
X_10349_ _02271_ _02285_ _02379_ VGND VGND VPWR VPWR _02380_ sky130_fd_sc_hd__o21a_1
X_13137_ _05398_ _05399_ _05414_ VGND VGND VPWR VPWR _05416_ sky130_fd_sc_hd__nand3_1
X_13068_ _05335_ _05339_ VGND VGND VPWR VPWR _05340_ sky130_fd_sc_hd__xnor2_1
X_12019_ _04197_ _04198_ _04199_ VGND VGND VPWR VPWR _04200_ sky130_fd_sc_hd__nand3_1
XFILLER_0_136_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07560_ _04184_ _04239_ _04195_ VGND VGND VPWR VPWR _04293_ sky130_fd_sc_hd__nand3_1
XFILLER_0_119_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07491_ _03473_ _03528_ VGND VGND VPWR VPWR _03539_ sky130_fd_sc_hd__xnor2_2
X_09230_ _01245_ _01247_ _01244_ VGND VGND VPWR VPWR _01253_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_8_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09161_ _01192_ _01193_ VGND VGND VPWR VPWR _01194_ sky130_fd_sc_hd__xnor2_2
X_08112_ _00110_ _00117_ _00116_ VGND VGND VPWR VPWR _00165_ sky130_fd_sc_hd__a21o_1
X_09092_ _00919_ _01129_ _01130_ _01131_ VGND VGND VPWR VPWR _00016_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_44_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08043_ _07259_ _07260_ _07261_ VGND VGND VPWR VPWR _07337_ sky130_fd_sc_hd__nor3_1
XFILLER_0_43_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09994_ _01991_ _01992_ _01993_ VGND VGND VPWR VPWR _01994_ sky130_fd_sc_hd__nand3_1
XFILLER_0_86_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08945_ net284 net266 net590 net582 VGND VGND VPWR VPWR _00987_ sky130_fd_sc_hd__and4_1
X_08876_ _00918_ VGND VGND VPWR VPWR _00919_ sky130_fd_sc_hd__buf_4
X_07827_ _07116_ _07118_ _07117_ VGND VGND VPWR VPWR _07123_ sky130_fd_sc_hd__a21o_1
X_07758_ _06309_ _06331_ VGND VGND VPWR VPWR _06451_ sky130_fd_sc_hd__xor2_1
XFILLER_0_79_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07689_ _05666_ _05677_ _05655_ VGND VGND VPWR VPWR _05699_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_137_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09428_ _01426_ _01427_ _01422_ VGND VGND VPWR VPWR _01429_ sky130_fd_sc_hd__a21o_1
XFILLER_0_125_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09359_ _01356_ _01360_ _01362_ VGND VGND VPWR VPWR _01363_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_47_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12370_ _04581_ _04580_ VGND VGND VPWR VPWR _04582_ sky130_fd_sc_hd__nor2_4
XFILLER_0_132_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11321_ _03424_ _03428_ VGND VGND VPWR VPWR _03436_ sky130_fd_sc_hd__and2_1
XFILLER_0_117_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11252_ _03356_ _03359_ VGND VGND VPWR VPWR _03360_ sky130_fd_sc_hd__xnor2_1
X_14040_ net640 net495 net454 net445 VGND VGND VPWR VPWR _06402_ sky130_fd_sc_hd__and4_1
X_11183_ net194 net711 VGND VGND VPWR VPWR _03284_ sky130_fd_sc_hd__nand2_1
X_10203_ _02144_ _02148_ _02145_ VGND VGND VPWR VPWR _02220_ sky130_fd_sc_hd__o21ba_1
X_10134_ net692 net701 net453 net444 VGND VGND VPWR VPWR _02145_ sky130_fd_sc_hd__and4_1
X_10065_ _01952_ _01953_ _01954_ VGND VGND VPWR VPWR _02071_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_89_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13824_ _06112_ _06166_ VGND VGND VPWR VPWR _06167_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10967_ _00919_ _03048_ _03050_ _03051_ VGND VGND VPWR VPWR _00068_ sky130_fd_sc_hd__o31ai_1
X_13755_ _05996_ _06079_ _06078_ VGND VGND VPWR VPWR _06092_ sky130_fd_sc_hd__o21bai_1
X_12706_ _04944_ _04946_ VGND VGND VPWR VPWR _04947_ sky130_fd_sc_hd__nor2_1
X_10898_ _02974_ _02975_ _02881_ _02976_ VGND VGND VPWR VPWR _02977_ sky130_fd_sc_hd__a211o_1
X_13686_ _05949_ _05952_ VGND VGND VPWR VPWR _06017_ sky130_fd_sc_hd__nand2_1
X_12637_ net155 net302 net136 VGND VGND VPWR VPWR _04872_ sky130_fd_sc_hd__and3_1
XFILLER_0_26_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12568_ net190 net291 _04795_ _04796_ VGND VGND VPWR VPWR _04797_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_14_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12499_ net275 net291 VGND VGND VPWR VPWR _04722_ sky130_fd_sc_hd__nand2_1
X_11519_ net156 net704 VGND VGND VPWR VPWR _03654_ sky130_fd_sc_hd__nand2_1
XFILLER_0_41_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14307_ _06689_ _06692_ VGND VGND VPWR VPWR _06693_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14238_ _06532_ _06552_ _06616_ _06617_ VGND VGND VPWR VPWR _06618_ sky130_fd_sc_hd__o211a_1
XFILLER_0_0_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14169_ _06539_ _06540_ _06541_ _06542_ VGND VGND VPWR VPWR _06543_ sky130_fd_sc_hd__o211a_1
Xfanout709 net715 VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__buf_2
XFILLER_0_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08730_ _00774_ _00775_ VGND VGND VPWR VPWR _00776_ sky130_fd_sc_hd__xor2_1
X_08661_ _00693_ _00707_ VGND VGND VPWR VPWR _00708_ sky130_fd_sc_hd__xnor2_1
X_07612_ _04619_ _04630_ VGND VGND VPWR VPWR _04858_ sky130_fd_sc_hd__xnor2_1
X_08592_ _00638_ _00639_ VGND VGND VPWR VPWR _00640_ sky130_fd_sc_hd__or2_1
X_07543_ _04021_ _04097_ _04075_ VGND VGND VPWR VPWR _04108_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07474_ _03319_ _03330_ _03275_ VGND VGND VPWR VPWR _03352_ sky130_fd_sc_hd__a21o_1
XFILLER_0_91_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09213_ a_cos\[13\] b_sin\[13\] VGND VGND VPWR VPWR _01238_ sky130_fd_sc_hd__nand2_1
XFILLER_0_17_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09144_ a_cos\[3\] b_sin\[3\] VGND VGND VPWR VPWR _01179_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09075_ _01065_ _01114_ VGND VGND VPWR VPWR _01115_ sky130_fd_sc_hd__and2_1
X_08026_ _07317_ _07318_ _07319_ VGND VGND VPWR VPWR _07320_ sky130_fd_sc_hd__or3_1
Xfanout1 _01164_ VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__buf_4
XFILLER_0_31_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09977_ _01967_ _01976_ VGND VGND VPWR VPWR _01977_ sky130_fd_sc_hd__xor2_1
X_08928_ _00908_ _00909_ _00969_ VGND VGND VPWR VPWR _00971_ sky130_fd_sc_hd__nor3_1
XFILLER_0_98_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08859_ _00899_ _00902_ VGND VGND VPWR VPWR _00903_ sky130_fd_sc_hd__xor2_1
X_11870_ _03936_ _04004_ _04036_ _04037_ VGND VGND VPWR VPWR _04038_ sky130_fd_sc_hd__a211o_1
XFILLER_0_95_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10821_ _02891_ _02892_ VGND VGND VPWR VPWR _02893_ sky130_fd_sc_hd__nor2_1
XFILLER_0_39_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10752_ _02816_ _02817_ VGND VGND VPWR VPWR _02818_ sky130_fd_sc_hd__xor2_1
X_13540_ net602 net402 VGND VGND VPWR VPWR _05858_ sky130_fd_sc_hd__nand2_1
XFILLER_0_82_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13471_ _05394_ _05419_ _05781_ _05782_ VGND VGND VPWR VPWR _05783_ sky130_fd_sc_hd__o211ai_2
X_12422_ _04636_ _04637_ VGND VGND VPWR VPWR _04638_ sky130_fd_sc_hd__xnor2_1
X_10683_ _02605_ _02742_ VGND VGND VPWR VPWR _02743_ sky130_fd_sc_hd__nor2_1
XFILLER_0_63_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12353_ _04561_ _04562_ VGND VGND VPWR VPWR _04563_ sky130_fd_sc_hd__nor2_1
XFILLER_0_62_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11304_ _03413_ _03416_ VGND VGND VPWR VPWR _03417_ sky130_fd_sc_hd__xnor2_1
X_12284_ _04485_ _04486_ _04479_ VGND VGND VPWR VPWR _04488_ sky130_fd_sc_hd__a21o_1
X_11235_ _03339_ _03338_ _03307_ _03304_ VGND VGND VPWR VPWR _03342_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_120_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14023_ _06381_ _06382_ VGND VGND VPWR VPWR _06383_ sky130_fd_sc_hd__xor2_1
XFILLER_0_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11166_ _03257_ _03265_ VGND VGND VPWR VPWR _03266_ sky130_fd_sc_hd__xnor2_1
X_10117_ net718 net429 net421 net728 VGND VGND VPWR VPWR _02127_ sky130_fd_sc_hd__a22oi_1
X_11097_ _03184_ _03191_ VGND VGND VPWR VPWR _03192_ sky130_fd_sc_hd__xor2_1
X_10048_ _02047_ _02049_ _02050_ VGND VGND VPWR VPWR _02052_ sky130_fd_sc_hd__a21o_1
XFILLER_0_89_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14787_ clknet_3_7_0_clk _00088_ net323 VGND VGND VPWR VPWR a_sin\[15\] sky130_fd_sc_hd__dfrtp_1
X_13807_ net602 net368 VGND VGND VPWR VPWR _06149_ sky130_fd_sc_hd__and2_1
XFILLER_0_133_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11999_ _04069_ _04074_ VGND VGND VPWR VPWR _04178_ sky130_fd_sc_hd__and2b_1
XFILLER_0_97_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13738_ _05933_ _05959_ _06072_ _06073_ VGND VGND VPWR VPWR _06074_ sky130_fd_sc_hd__o211a_1
XFILLER_0_45_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13669_ _05997_ _05971_ _05973_ _05976_ _05965_ VGND VGND VPWR VPWR _05998_ sky130_fd_sc_hd__a32o_1
XFILLER_0_116_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09900_ _01896_ _01900_ VGND VGND VPWR VPWR _01901_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout506 net507 VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__buf_8
Xfanout539 net542 VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__clkbuf_2
Xfanout517 net34 VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__buf_2
X_09831_ _01824_ _01825_ _01830_ VGND VGND VPWR VPWR _01832_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout528 net530 VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__buf_2
X_09762_ _01734_ _01761_ _01762_ VGND VGND VPWR VPWR _01763_ sky130_fd_sc_hd__a21bo_1
X_08713_ _00757_ _00758_ VGND VGND VPWR VPWR _00759_ sky130_fd_sc_hd__nand2_1
Xrebuffer11 net802 VGND VGND VPWR VPWR net756 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09693_ _01689_ _01693_ VGND VGND VPWR VPWR _01694_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_20_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer33 _04654_ VGND VGND VPWR VPWR net800 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer22 net642 VGND VGND VPWR VPWR net767 sky130_fd_sc_hd__clkbuf_2
X_08644_ _00688_ _00689_ _00690_ _00628_ VGND VGND VPWR VPWR _00691_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_83_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08575_ _00613_ _00622_ VGND VGND VPWR VPWR _00623_ sky130_fd_sc_hd__xnor2_1
X_07526_ _03868_ _03879_ _03912_ VGND VGND VPWR VPWR _03923_ sky130_fd_sc_hd__nand3_1
XFILLER_0_76_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07457_ net279 net576 net662 net261 VGND VGND VPWR VPWR _03167_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07388_ net174 net164 net531 net538 VGND VGND VPWR VPWR _02418_ sky130_fd_sc_hd__and4_1
XFILLER_0_91_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09127_ a_cos\[0\] b_sin\[0\] VGND VGND VPWR VPWR _01165_ sky130_fd_sc_hd__nand2_1
XFILLER_0_103_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09058_ _01063_ _01062_ VGND VGND VPWR VPWR _01098_ sky130_fd_sc_hd__or2b_1
XFILLER_0_130_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08009_ _07301_ _07302_ VGND VGND VPWR VPWR _07303_ sky130_fd_sc_hd__nand2_1
X_11020_ _03098_ _03099_ VGND VGND VPWR VPWR _03108_ sky130_fd_sc_hd__or2b_1
XFILLER_0_99_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12971_ _05230_ _05231_ _05232_ VGND VGND VPWR VPWR _05233_ sky130_fd_sc_hd__and3_1
X_11922_ _04092_ _04093_ VGND VGND VPWR VPWR _04094_ sky130_fd_sc_hd__xnor2_1
X_14710_ clknet_3_6_0_clk _00011_ net320 VGND VGND VPWR VPWR b_sin\[11\] sky130_fd_sc_hd__dfrtp_1
X_11853_ _04009_ _04017_ _04018_ VGND VGND VPWR VPWR _04019_ sky130_fd_sc_hd__nand3_1
XFILLER_0_86_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14641_ _01104_ net418 VGND VGND VPWR VPWR _07054_ sky130_fd_sc_hd__and2_1
X_10804_ _02859_ _02873_ VGND VGND VPWR VPWR _02874_ sky130_fd_sc_hd__xnor2_1
X_11784_ _03846_ _03849_ _03942_ _03943_ VGND VGND VPWR VPWR _03944_ sky130_fd_sc_hd__a211o_1
XFILLER_0_95_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14572_ net438 _06978_ VGND VGND VPWR VPWR _06979_ sky130_fd_sc_hd__and2_1
XFILLER_0_138_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13523_ _05756_ _05774_ _05775_ VGND VGND VPWR VPWR _05839_ sky130_fd_sc_hd__nand3_2
X_10735_ _02646_ _02798_ VGND VGND VPWR VPWR _02800_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_125_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10666_ _02722_ _02705_ _02706_ VGND VGND VPWR VPWR _02725_ sky130_fd_sc_hd__nor3_2
XFILLER_0_42_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13454_ net593 net489 net412 net602 VGND VGND VPWR VPWR _05764_ sky130_fd_sc_hd__a22oi_2
X_12405_ _04529_ _04611_ _04612_ _04617_ VGND VGND VPWR VPWR _04620_ sky130_fd_sc_hd__o31a_1
XFILLER_0_70_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13385_ _05681_ _05686_ _05687_ VGND VGND VPWR VPWR _05689_ sky130_fd_sc_hd__and3b_1
XFILLER_0_35_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10597_ net140 _02648_ _02649_ VGND VGND VPWR VPWR _02650_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_2_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12336_ _04542_ _04544_ VGND VGND VPWR VPWR _04545_ sky130_fd_sc_hd__xor2_1
Xoutput109 net109 VGND VGND VPWR VPWR Q[8] sky130_fd_sc_hd__buf_2
XFILLER_0_10_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12267_ _04451_ _04469_ VGND VGND VPWR VPWR _04470_ sky130_fd_sc_hd__xnor2_1
X_11218_ _03315_ _03316_ _03322_ VGND VGND VPWR VPWR _03323_ sky130_fd_sc_hd__nand3_1
X_12198_ _04373_ _04394_ VGND VGND VPWR VPWR _04395_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_121_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14006_ _06363_ _06365_ VGND VGND VPWR VPWR _06366_ sky130_fd_sc_hd__and2_1
Xoutput91 net91 VGND VGND VPWR VPWR D[8] sky130_fd_sc_hd__buf_2
Xoutput80 net80 VGND VGND VPWR VPWR D[14] sky130_fd_sc_hd__clkbuf_4
X_11149_ _03159_ _03212_ _03247_ _03245_ VGND VGND VPWR VPWR _03248_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_37_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08360_ _00336_ _00339_ _00337_ VGND VGND VPWR VPWR _00410_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_58_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08291_ net151 net299 net635 net644 VGND VGND VPWR VPWR _00342_ sky130_fd_sc_hd__nand4_2
XFILLER_0_27_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout303 net57 VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__buf_2
Xfanout314 net316 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__clkbuf_4
Xfanout325 net327 VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__clkbuf_4
X_09814_ net725 net390 net382 net734 VGND VGND VPWR VPWR _01815_ sky130_fd_sc_hd__a22oi_1
Xfanout347 net349 VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__clkbuf_4
Xfanout336 net337 VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout358 net359 VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__clkbuf_2
Xfanout369 net50 VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__buf_4
X_09745_ _01721_ _01745_ VGND VGND VPWR VPWR _01746_ sky130_fd_sc_hd__nor2_1
X_09676_ net690 net390 net381 net699 VGND VGND VPWR VPWR _01677_ sky130_fd_sc_hd__a22oi_2
X_08627_ net161 net599 _00618_ _00617_ VGND VGND VPWR VPWR _00674_ sky130_fd_sc_hd__a31o_1
XFILLER_0_96_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08558_ _00598_ _00605_ VGND VGND VPWR VPWR _00606_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08489_ _00449_ _00451_ VGND VGND VPWR VPWR _00538_ sky130_fd_sc_hd__nand2_1
X_07509_ net279 net568 net575 net261 VGND VGND VPWR VPWR _03737_ sky130_fd_sc_hd__a22o_1
XFILLER_0_135_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10520_ _02564_ _02565_ VGND VGND VPWR VPWR _02566_ sky130_fd_sc_hd__xnor2_1
X_10451_ _02382_ _02384_ VGND VGND VPWR VPWR _02491_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10382_ net693 net702 net430 net421 VGND VGND VPWR VPWR _02415_ sky130_fd_sc_hd__and4_1
XFILLER_0_20_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13170_ net543 net355 net345 net561 VGND VGND VPWR VPWR _05452_ sky130_fd_sc_hd__a22oi_1
X_12121_ _04307_ _04308_ _04309_ VGND VGND VPWR VPWR _04311_ sky130_fd_sc_hd__nand3_1
XFILLER_0_20_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12052_ _04234_ _04235_ VGND VGND VPWR VPWR _04236_ sky130_fd_sc_hd__xnor2_1
X_11003_ _03025_ _03088_ VGND VGND VPWR VPWR _03090_ sky130_fd_sc_hd__or2_1
X_12954_ _05212_ _05213_ VGND VGND VPWR VPWR _05214_ sky130_fd_sc_hd__nor2_1
X_11905_ _04069_ _04074_ VGND VGND VPWR VPWR _04076_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_90_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12885_ _05138_ _05137_ VGND VGND VPWR VPWR _05141_ sky130_fd_sc_hd__or2b_1
XFILLER_0_59_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11836_ _03997_ _03998_ _03982_ VGND VGND VPWR VPWR _04001_ sky130_fd_sc_hd__a21o_1
XFILLER_0_74_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14624_ _06724_ _06793_ _07034_ VGND VGND VPWR VPWR _07035_ sky130_fd_sc_hd__o21a_1
X_11767_ net311 net188 net231 net143 VGND VGND VPWR VPWR _03926_ sky130_fd_sc_hd__and4_2
XFILLER_0_126_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14555_ _06959_ _06960_ VGND VGND VPWR VPWR _06962_ sky130_fd_sc_hd__nand2_1
X_10718_ _02779_ _02780_ VGND VGND VPWR VPWR _02781_ sky130_fd_sc_hd__xnor2_1
X_13506_ _05818_ _05820_ VGND VGND VPWR VPWR _05821_ sky130_fd_sc_hd__or2_1
XFILLER_0_130_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11698_ _03735_ _03762_ _03849_ _03850_ VGND VGND VPWR VPWR _03851_ sky130_fd_sc_hd__o211ai_4
X_14486_ _06823_ _06824_ _06822_ VGND VGND VPWR VPWR _06887_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_141_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer2 _04249_ VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__clkbuf_1
X_10649_ _02703_ _02704_ _02684_ _02685_ VGND VGND VPWR VPWR _02706_ sky130_fd_sc_hd__a211oi_2
X_13437_ _05372_ _05374_ _05373_ VGND VGND VPWR VPWR _05746_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_24_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13368_ _05657_ _05669_ VGND VGND VPWR VPWR _05670_ sky130_fd_sc_hd__xor2_1
XFILLER_0_121_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12319_ _04447_ _04448_ _04526_ VGND VGND VPWR VPWR _04527_ sky130_fd_sc_hd__o21ai_2
XPHY_EDGE_ROW_39_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13299_ net569 net357 net347 net656 VGND VGND VPWR VPWR _05594_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_139_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07860_ _03440_ _03451_ _03550_ VGND VGND VPWR VPWR _07156_ sky130_fd_sc_hd__nand3_2
X_07791_ _06722_ _06711_ VGND VGND VPWR VPWR _06809_ sky130_fd_sc_hd__and2b_1
X_09530_ _01437_ _01472_ _01500_ _01501_ VGND VGND VPWR VPWR _01531_ sky130_fd_sc_hd__a211o_1
XFILLER_0_64_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09461_ net735 net467 VGND VGND VPWR VPWR _01462_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_48_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08412_ _00368_ _00369_ _00371_ _00370_ VGND VGND VPWR VPWR _00462_ sky130_fd_sc_hd__a31o_1
XFILLER_0_93_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09392_ net664 net673 net486 net408 VGND VGND VPWR VPWR _01393_ sky130_fd_sc_hd__and4_1
X_08343_ _00311_ VGND VGND VPWR VPWR _00394_ sky130_fd_sc_hd__inv_2
XFILLER_0_117_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08274_ _00319_ _00324_ VGND VGND VPWR VPWR _00325_ sky130_fd_sc_hd__xor2_2
XFILLER_0_80_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout155 net73 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__buf_2
Xfanout144 net145 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__clkbuf_4
Xfanout133 net134 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__clkbuf_4
Xfanout188 net191 VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__clkbuf_4
Xfanout177 net183 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__clkbuf_4
Xfanout166 net173 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__buf_4
Xfanout199 net200 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__buf_4
X_07989_ _07132_ _07282_ _07283_ VGND VGND VPWR VPWR _07284_ sky130_fd_sc_hd__nand3_1
X_09728_ _01688_ _01723_ VGND VGND VPWR VPWR _01729_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09659_ _01600_ _01658_ _01659_ VGND VGND VPWR VPWR _01660_ sky130_fd_sc_hd__and3_2
X_12670_ _04855_ _04840_ _04907_ VGND VGND VPWR VPWR _04908_ sky130_fd_sc_hd__and3_1
XFILLER_0_96_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11621_ _03683_ _03685_ _03678_ VGND VGND VPWR VPWR _03766_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_64_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14340_ _06726_ _06727_ VGND VGND VPWR VPWR _06728_ sky130_fd_sc_hd__nor2_1
X_11552_ _03606_ _03615_ VGND VGND VPWR VPWR _03690_ sky130_fd_sc_hd__and2b_1
XFILLER_0_92_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11483_ _03608_ _03613_ VGND VGND VPWR VPWR _03614_ sky130_fd_sc_hd__xnor2_1
X_10503_ _02531_ _02545_ _02546_ VGND VGND VPWR VPWR _02547_ sky130_fd_sc_hd__nand3_1
X_14271_ _06563_ _06566_ _06564_ VGND VGND VPWR VPWR _06653_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_100_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13222_ net518 net398 _05437_ _05436_ VGND VGND VPWR VPWR _05509_ sky130_fd_sc_hd__a22o_1
X_10434_ _02469_ _02470_ _02471_ net132 VGND VGND VPWR VPWR _02472_ sky130_fd_sc_hd__or4b_4
X_10365_ _02115_ _02018_ _02110_ _02111_ _02396_ VGND VGND VPWR VPWR _02398_ sky130_fd_sc_hd__a311o_1
X_13153_ _05208_ _05207_ _05206_ VGND VGND VPWR VPWR _05433_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_33_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12104_ _04274_ _04291_ VGND VGND VPWR VPWR _04292_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10296_ _02319_ _02321_ VGND VGND VPWR VPWR _02322_ sky130_fd_sc_hd__or2_1
X_13084_ _05352_ _05351_ net117 _05271_ VGND VGND VPWR VPWR _05357_ sky130_fd_sc_hd__a211oi_1
X_12035_ net188 net205 net143 net215 VGND VGND VPWR VPWR _04218_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13986_ _06237_ _06238_ _06239_ _06242_ VGND VGND VPWR VPWR _06344_ sky130_fd_sc_hd__a31o_1
X_12937_ _05192_ _05194_ _05188_ VGND VGND VPWR VPWR _05196_ sky130_fd_sc_hd__a21o_1
X_12868_ _05115_ _05121_ VGND VGND VPWR VPWR _05122_ sky130_fd_sc_hd__xor2_1
X_11819_ _03906_ _03915_ _03914_ VGND VGND VPWR VPWR _03982_ sky130_fd_sc_hd__a21o_1
XFILLER_0_87_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14607_ _07016_ _07017_ VGND VGND VPWR VPWR _07018_ sky130_fd_sc_hd__or2_1
XFILLER_0_141_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12799_ net286 net268 net137 VGND VGND VPWR VPWR _05047_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14538_ net605 net616 net434 net423 VGND VGND VPWR VPWR _06943_ sky130_fd_sc_hd__and4_1
XFILLER_0_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14469_ _06790_ _06867_ VGND VGND VPWR VPWR _06868_ sky130_fd_sc_hd__nand2_1
XFILLER_0_141_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08961_ _00868_ _00932_ _01002_ VGND VGND VPWR VPWR _01003_ sky130_fd_sc_hd__o21bai_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07912_ _07192_ VGND VGND VPWR VPWR _07207_ sky130_fd_sc_hd__inv_2
X_08892_ _00864_ _00934_ VGND VGND VPWR VPWR _00935_ sky130_fd_sc_hd__xnor2_1
X_07843_ net279 net550 net567 net261 VGND VGND VPWR VPWR _07139_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_75_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07774_ _06462_ _06440_ _06451_ VGND VGND VPWR VPWR _06625_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09513_ _01508_ _01513_ VGND VGND VPWR VPWR _01514_ sky130_fd_sc_hd__xnor2_2
X_09444_ _01441_ _01444_ VGND VGND VPWR VPWR _01445_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09375_ net664 net401 VGND VGND VPWR VPWR _01376_ sky130_fd_sc_hd__and2_1
XFILLER_0_19_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08326_ _00375_ _00376_ VGND VGND VPWR VPWR _00377_ sky130_fd_sc_hd__and2_1
XFILLER_0_34_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08257_ _00238_ _00308_ VGND VGND VPWR VPWR _00309_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_74_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08188_ _00147_ _00152_ VGND VGND VPWR VPWR _00240_ sky130_fd_sc_hd__nand2_1
Xclkbuf_3_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_5_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_6_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10150_ _02161_ _02162_ VGND VGND VPWR VPWR _02163_ sky130_fd_sc_hd__and2b_1
X_10081_ _01949_ _01950_ VGND VGND VPWR VPWR _02088_ sky130_fd_sc_hd__nor2_1
X_13840_ net529 net542 net427 net419 VGND VGND VPWR VPWR _06184_ sky130_fd_sc_hd__and4_1
X_10983_ _02922_ _03003_ _03067_ VGND VGND VPWR VPWR _03068_ sky130_fd_sc_hd__and3_1
X_13771_ _06107_ _06108_ VGND VGND VPWR VPWR _06109_ sky130_fd_sc_hd__nor2_1
X_12722_ _04882_ _04883_ VGND VGND VPWR VPWR _04964_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_133_Right_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12653_ net465 net558 net254 net246 VGND VGND VPWR VPWR _04889_ sky130_fd_sc_hd__and4_1
XFILLER_0_37_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11604_ _03743_ _03746_ VGND VGND VPWR VPWR _03747_ sky130_fd_sc_hd__xnor2_1
X_12584_ _04812_ net118 _04741_ _04744_ VGND VGND VPWR VPWR _04814_ sky130_fd_sc_hd__o211a_1
XFILLER_0_93_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11535_ net289 net731 VGND VGND VPWR VPWR _03672_ sky130_fd_sc_hd__nand2_1
XFILLER_0_111_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14323_ _06709_ VGND VGND VPWR VPWR _00101_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14254_ _06597_ _06612_ VGND VGND VPWR VPWR _06634_ sky130_fd_sc_hd__and2_1
X_11466_ net177 net695 net704 net166 VGND VGND VPWR VPWR _03596_ sky130_fd_sc_hd__a22o_1
Xmax_cap119 _04599_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_111_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13205_ _05487_ _05489_ VGND VGND VPWR VPWR _05491_ sky130_fd_sc_hd__nor2_1
X_11397_ _03516_ _03518_ _03519_ _03480_ VGND VGND VPWR VPWR _03520_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_96_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10417_ _02359_ _02360_ _02374_ _02376_ VGND VGND VPWR VPWR _02454_ sky130_fd_sc_hd__or4bb_1
X_14185_ _06557_ _06558_ VGND VGND VPWR VPWR _06560_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10348_ _02283_ _02284_ VGND VGND VPWR VPWR _02379_ sky130_fd_sc_hd__nand2_1
X_13136_ _05398_ _05399_ _05414_ VGND VGND VPWR VPWR _05415_ sky130_fd_sc_hd__a21o_1
XFILLER_0_29_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10279_ a_cos\[4\] _02302_ _02303_ VGND VGND VPWR VPWR _02304_ sky130_fd_sc_hd__mux2_1
X_13067_ _05337_ _05338_ VGND VGND VPWR VPWR _05339_ sky130_fd_sc_hd__nor2_1
X_12018_ _04095_ _04098_ _04096_ VGND VGND VPWR VPWR _04199_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_45_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13969_ _06225_ _06227_ VGND VGND VPWR VPWR _06325_ sky130_fd_sc_hd__nand2_1
X_07490_ _03484_ _03517_ VGND VGND VPWR VPWR _03528_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_61_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09160_ _01184_ _01187_ _01185_ VGND VGND VPWR VPWR _01193_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_44_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08111_ _07323_ _07325_ VGND VGND VPWR VPWR _00164_ sky130_fd_sc_hd__and2_1
X_09091_ net786 _00919_ VGND VGND VPWR VPWR _01131_ sky130_fd_sc_hd__nand2_1
XFILLER_0_71_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08042_ _07332_ _07335_ VGND VGND VPWR VPWR _07336_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_114_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09993_ _01638_ _01646_ _01645_ VGND VGND VPWR VPWR _01993_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_3_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08944_ net266 net590 net582 net284 VGND VGND VPWR VPWR _00986_ sky130_fd_sc_hd__a22oi_1
X_08875_ _02006_ VGND VGND VPWR VPWR _00918_ sky130_fd_sc_hd__clkbuf_4
X_07826_ _04500_ _04988_ _04978_ VGND VGND VPWR VPWR _07122_ sky130_fd_sc_hd__a21o_1
X_07757_ _06374_ _06385_ _06429_ VGND VGND VPWR VPWR _06440_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07688_ _05655_ _05666_ _05677_ VGND VGND VPWR VPWR _05688_ sky130_fd_sc_hd__and3_4
XFILLER_0_47_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09427_ _01422_ _01426_ _01427_ VGND VGND VPWR VPWR _01428_ sky130_fd_sc_hd__nand3_1
XFILLER_0_136_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09358_ b_cos\[16\] a_sin\[16\] VGND VGND VPWR VPWR _01362_ sky130_fd_sc_hd__xnor2_1
X_08309_ _00355_ _00358_ _00359_ VGND VGND VPWR VPWR _00360_ sky130_fd_sc_hd__nand3_1
XFILLER_0_90_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11320_ _03425_ _03427_ VGND VGND VPWR VPWR _03435_ sky130_fd_sc_hd__and2_1
X_09289_ net107 _01302_ net128 VGND VGND VPWR VPWR _01303_ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11251_ _03357_ _03358_ VGND VGND VPWR VPWR _03359_ sky130_fd_sc_hd__nor2_1
X_11182_ _03276_ _03281_ _03280_ VGND VGND VPWR VPWR _03283_ sky130_fd_sc_hd__a21o_1
XFILLER_0_101_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10202_ _02142_ _02162_ _02161_ VGND VGND VPWR VPWR _02219_ sky130_fd_sc_hd__a21o_1
XFILLER_0_30_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10133_ net692 net453 net443 net701 VGND VGND VPWR VPWR _02144_ sky130_fd_sc_hd__a22oi_2
X_10064_ _02066_ _02067_ _02065_ VGND VGND VPWR VPWR _02069_ sky130_fd_sc_hd__o21ai_1
X_13823_ _06164_ _06165_ VGND VGND VPWR VPWR _06166_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13754_ _06090_ VGND VGND VPWR VPWR _00094_ sky130_fd_sc_hd__clkbuf_1
X_10966_ net776 _07291_ VGND VGND VPWR VPWR _03051_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12705_ net378 net465 net252 net244 VGND VGND VPWR VPWR _04946_ sky130_fd_sc_hd__and4_1
X_10897_ _02880_ _02881_ _02903_ VGND VGND VPWR VPWR _02976_ sky130_fd_sc_hd__nor3_1
X_13685_ _05998_ _06014_ VGND VGND VPWR VPWR _06016_ sky130_fd_sc_hd__xnor2_1
X_12636_ _04796_ _04798_ VGND VGND VPWR VPWR _04871_ sky130_fd_sc_hd__nor2_1
XFILLER_0_122_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12567_ net155 net302 net144 net136 VGND VGND VPWR VPWR _04796_ sky130_fd_sc_hd__and4_1
XFILLER_0_124_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14306_ _06691_ _06608_ VGND VGND VPWR VPWR _06692_ sky130_fd_sc_hd__nor2_1
X_12498_ _04719_ _04720_ VGND VGND VPWR VPWR _04721_ sky130_fd_sc_hd__nor2_1
X_11518_ _03581_ _03584_ _03582_ VGND VGND VPWR VPWR _03653_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_123_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11449_ _03574_ _03575_ _03576_ VGND VGND VPWR VPWR _03577_ sky130_fd_sc_hd__nand3_1
XFILLER_0_111_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14237_ _06595_ _06596_ _06615_ VGND VGND VPWR VPWR _06617_ sky130_fd_sc_hd__o21ai_1
X_14168_ _06450_ _06375_ VGND VGND VPWR VPWR _06542_ sky130_fd_sc_hd__or2b_1
X_13119_ _05334_ _05340_ VGND VGND VPWR VPWR _05396_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14099_ _06389_ _06391_ VGND VGND VPWR VPWR _06466_ sky130_fd_sc_hd__or2_1
X_08660_ _00694_ _00706_ VGND VGND VPWR VPWR _00707_ sky130_fd_sc_hd__xnor2_1
X_07611_ _04696_ _04826_ _04815_ VGND VGND VPWR VPWR _04848_ sky130_fd_sc_hd__a21o_1
XFILLER_0_88_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08591_ _00554_ _00637_ _00635_ _00636_ VGND VGND VPWR VPWR _00639_ sky130_fd_sc_hd__o211a_1
X_07542_ _04075_ _04086_ VGND VGND VPWR VPWR _04097_ sky130_fd_sc_hd__nor2_1
XFILLER_0_88_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07473_ _03275_ _03319_ _03330_ VGND VGND VPWR VPWR _03341_ sky130_fd_sc_hd__nand3_1
XFILLER_0_76_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09212_ _01237_ VGND VGND VPWR VPWR _00030_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09143_ a_cos\[3\] b_sin\[3\] VGND VGND VPWR VPWR _01178_ sky130_fd_sc_hd__or2_1
XFILLER_0_57_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09074_ _01097_ _01113_ VGND VGND VPWR VPWR _01114_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_142_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout2 net296 VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__clkbuf_4
X_08025_ net158 net149 net498 net508 VGND VGND VPWR VPWR _07319_ sky130_fd_sc_hd__and4_1
XFILLER_0_4_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09976_ _01974_ _01975_ VGND VGND VPWR VPWR _01976_ sky130_fd_sc_hd__and2b_1
X_08927_ _00908_ _00909_ _00969_ VGND VGND VPWR VPWR _00970_ sky130_fd_sc_hd__o21a_2
X_08858_ _00900_ _00901_ VGND VGND VPWR VPWR _00902_ sky130_fd_sc_hd__nor2_1
X_07809_ _06831_ _06918_ _06950_ VGND VGND VPWR VPWR _07004_ sky130_fd_sc_hd__or3_1
X_08789_ _00828_ _00833_ VGND VGND VPWR VPWR _00834_ sky130_fd_sc_hd__xnor2_1
X_10820_ _02816_ _02817_ _02815_ VGND VGND VPWR VPWR _02892_ sky130_fd_sc_hd__a21o_1
XFILLER_0_137_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10751_ net676 net417 VGND VGND VPWR VPWR _02817_ sky130_fd_sc_hd__and2b_1
XFILLER_0_48_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13470_ _05741_ _05742_ _05779_ _05780_ VGND VGND VPWR VPWR _05782_ sky130_fd_sc_hd__a22o_1
X_12421_ net377 net291 VGND VGND VPWR VPWR _04637_ sky130_fd_sc_hd__nand2_1
XFILLER_0_109_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10682_ _02607_ _02606_ VGND VGND VPWR VPWR _02742_ sky130_fd_sc_hd__and2b_1
XFILLER_0_124_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12352_ net558 net653 net283 net265 VGND VGND VPWR VPWR _04562_ sky130_fd_sc_hd__and4_1
XFILLER_0_105_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11303_ _03414_ _03415_ VGND VGND VPWR VPWR _03416_ sky130_fd_sc_hd__and2b_1
X_12283_ _04479_ _04485_ _04486_ VGND VGND VPWR VPWR _04487_ sky130_fd_sc_hd__nand3_2
XFILLER_0_121_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11234_ _03304_ _03307_ _03338_ _03339_ VGND VGND VPWR VPWR _03340_ sky130_fd_sc_hd__a211o_1
X_14022_ net530 net415 VGND VGND VPWR VPWR _06382_ sky130_fd_sc_hd__and2b_1
X_11165_ _03252_ _03258_ VGND VGND VPWR VPWR _03265_ sky130_fd_sc_hd__nor2_1
XFILLER_0_93_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10116_ _02060_ _02061_ _02062_ VGND VGND VPWR VPWR _02126_ sky130_fd_sc_hd__o21ba_1
X_11096_ _03187_ _03190_ VGND VGND VPWR VPWR _03191_ sky130_fd_sc_hd__xor2_2
X_10047_ _02047_ _02049_ _02050_ VGND VGND VPWR VPWR _02051_ sky130_fd_sc_hd__nand3_2
X_11998_ _04175_ _04176_ VGND VGND VPWR VPWR _04177_ sky130_fd_sc_hd__or2_1
XFILLER_0_98_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14786_ clknet_3_7_0_clk _00087_ net323 VGND VGND VPWR VPWR a_sin\[14\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_11_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13806_ net593 net584 net393 net384 VGND VGND VPWR VPWR _06148_ sky130_fd_sc_hd__nand4_1
X_10949_ _02968_ _03031_ VGND VGND VPWR VPWR _03032_ sky130_fd_sc_hd__xor2_1
X_13737_ _06069_ _06071_ _06039_ VGND VGND VPWR VPWR _06073_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13668_ _05802_ _05803_ _05805_ VGND VGND VPWR VPWR _05997_ sky130_fd_sc_hd__and3_1
X_12619_ a_sin\[11\] _04852_ _04160_ VGND VGND VPWR VPWR _04853_ sky130_fd_sc_hd__mux2_1
X_13599_ _05919_ _05920_ _05918_ VGND VGND VPWR VPWR _05922_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_124_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_20_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout507 net35 VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__buf_8
X_09830_ _01824_ _01825_ _01830_ VGND VGND VPWR VPWR _01831_ sky130_fd_sc_hd__nand3_1
Xfanout518 net519 VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__buf_2
Xfanout529 net530 VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__clkbuf_4
X_09761_ _01756_ _01760_ _01736_ _01735_ VGND VGND VPWR VPWR _01762_ sky130_fd_sc_hd__a211o_1
X_08712_ _00755_ _00756_ VGND VGND VPWR VPWR _00758_ sky130_fd_sc_hd__nand2_1
Xrebuffer12 _05391_ VGND VGND VPWR VPWR net757 sky130_fd_sc_hd__buf_6
X_09692_ _01690_ _01692_ VGND VGND VPWR VPWR _01693_ sky130_fd_sc_hd__xnor2_1
Xrebuffer23 net767 VGND VGND VPWR VPWR net768 sky130_fd_sc_hd__clkbuf_2
X_08643_ _00623_ _00625_ VGND VGND VPWR VPWR _00690_ sky130_fd_sc_hd__and2_1
Xrebuffer34 _02082_ VGND VGND VPWR VPWR net801 sky130_fd_sc_hd__buf_4
XFILLER_0_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08574_ _00614_ _00621_ VGND VGND VPWR VPWR _00622_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07525_ _03890_ _03901_ VGND VGND VPWR VPWR _03912_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07456_ net279 net261 net576 net662 VGND VGND VPWR VPWR _03157_ sky130_fd_sc_hd__and4_1
XFILLER_0_76_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07387_ _02375_ _02386_ _02222_ VGND VGND VPWR VPWR _02407_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09126_ _01995_ VGND VGND VPWR VPWR _01164_ sky130_fd_sc_hd__buf_4
XFILLER_0_115_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09057_ _01052_ _01044_ _01096_ VGND VGND VPWR VPWR _01097_ sky130_fd_sc_hd__a21o_1
X_08008_ _07224_ _07296_ _07300_ VGND VGND VPWR VPWR _07302_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_102_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09959_ _01955_ _01956_ _01957_ VGND VGND VPWR VPWR _01959_ sky130_fd_sc_hd__a21o_1
X_12970_ _05227_ _05229_ _05228_ VGND VGND VPWR VPWR _05232_ sky130_fd_sc_hd__o21ai_1
X_11921_ net713 net256 VGND VGND VPWR VPWR _04093_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11852_ _04015_ _04016_ _03926_ _04011_ VGND VGND VPWR VPWR _04018_ sky130_fd_sc_hd__a211o_1
X_14640_ _07051_ _07052_ VGND VGND VPWR VPWR _07053_ sky130_fd_sc_hd__nor2_1
XFILLER_0_95_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10803_ _02865_ _02872_ VGND VGND VPWR VPWR _02873_ sky130_fd_sc_hd__xnor2_1
X_14571_ _06924_ net579 _03111_ VGND VGND VPWR VPWR _06978_ sky130_fd_sc_hd__and3b_1
XFILLER_0_137_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11783_ _03903_ _03904_ _03940_ _03941_ VGND VGND VPWR VPWR _03943_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_95_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13522_ _05835_ _05836_ _05815_ _05816_ VGND VGND VPWR VPWR _05838_ sky130_fd_sc_hd__a211o_1
XFILLER_0_138_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10734_ _02711_ _02797_ VGND VGND VPWR VPWR _02798_ sky130_fd_sc_hd__xnor2_4
X_10665_ _02705_ _02706_ _02722_ VGND VGND VPWR VPWR _02724_ sky130_fd_sc_hd__o21a_1
XFILLER_0_12_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13453_ net593 net602 net489 net412 VGND VGND VPWR VPWR _05763_ sky130_fd_sc_hd__and4_1
X_12404_ _04446_ _04617_ VGND VGND VPWR VPWR _04618_ sky130_fd_sc_hd__and2_1
XFILLER_0_88_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13384_ net570 net657 net487 net409 VGND VGND VPWR VPWR _05687_ sky130_fd_sc_hd__and4_1
XFILLER_0_133_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12335_ net697 net64 VGND VGND VPWR VPWR _04544_ sky130_fd_sc_hd__and2b_1
XFILLER_0_112_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10596_ net132 net363 net353 net140 VGND VGND VPWR VPWR _02649_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_51_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12266_ _04452_ _04468_ VGND VGND VPWR VPWR _04469_ sky130_fd_sc_hd__xor2_1
XFILLER_0_50_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11217_ _03317_ _03321_ VGND VGND VPWR VPWR _03322_ sky130_fd_sc_hd__xor2_1
X_12197_ _04392_ _04393_ VGND VGND VPWR VPWR _04394_ sky130_fd_sc_hd__nand2_1
X_14005_ _06275_ _06277_ _06362_ VGND VGND VPWR VPWR _06365_ sky130_fd_sc_hd__or3_1
Xoutput81 net81 VGND VGND VPWR VPWR D[15] sky130_fd_sc_hd__clkbuf_4
X_11148_ _03155_ _03209_ _03216_ VGND VGND VPWR VPWR _03247_ sky130_fd_sc_hd__o21a_1
Xoutput92 net92 VGND VGND VPWR VPWR D[9] sky130_fd_sc_hd__clkbuf_4
X_11079_ _03170_ _03171_ VGND VGND VPWR VPWR _03172_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14769_ clknet_3_5_0_clk _00070_ net324 VGND VGND VPWR VPWR a_cos\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08290_ net151 net635 net644 net299 VGND VGND VPWR VPWR _00341_ sky130_fd_sc_hd__a22o_1
XFILLER_0_73_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout304 net305 VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__buf_6
Xfanout315 net316 VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__buf_2
Xfanout348 net349 VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__clkbuf_2
Xfanout326 net327 VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__buf_2
X_09813_ net740 net366 VGND VGND VPWR VPWR _01814_ sky130_fd_sc_hd__nand2_1
Xfanout337 net54 VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__buf_4
Xfanout359 net364 VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__clkbuf_4
X_09744_ net716 net366 _01719_ _01720_ VGND VGND VPWR VPWR _01745_ sky130_fd_sc_hd__o2bb2a_1
X_09675_ net708 net366 VGND VGND VPWR VPWR _01676_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08626_ _00670_ _00671_ _00653_ _00654_ VGND VGND VPWR VPWR _00673_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_139_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08557_ _00603_ _00604_ VGND VGND VPWR VPWR _00605_ sky130_fd_sc_hd__xor2_1
XFILLER_0_77_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08488_ _00531_ _00536_ VGND VGND VPWR VPWR _00537_ sky130_fd_sc_hd__xnor2_1
X_07508_ net255 net662 VGND VGND VPWR VPWR _03726_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07439_ net147 net295 net549 net567 VGND VGND VPWR VPWR _02973_ sky130_fd_sc_hd__and4_1
XFILLER_0_18_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10450_ _02382_ _02384_ VGND VGND VPWR VPWR _02490_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09109_ _01139_ _01147_ VGND VGND VPWR VPWR _01148_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10381_ net693 net430 net421 net702 VGND VGND VPWR VPWR _02414_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_32_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12120_ _04307_ _04308_ _04309_ VGND VGND VPWR VPWR _04310_ sky130_fd_sc_hd__a21o_1
XFILLER_0_32_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12051_ _04110_ _04142_ _04140_ VGND VGND VPWR VPWR _04235_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_103_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11002_ _03025_ _03088_ VGND VGND VPWR VPWR _03089_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12953_ net510 net518 net388 net379 VGND VGND VPWR VPWR _05213_ sky130_fd_sc_hd__and4_1
X_11904_ _04072_ _04073_ VGND VGND VPWR VPWR _04074_ sky130_fd_sc_hd__xor2_1
X_12884_ _05137_ _05138_ VGND VGND VPWR VPWR _05139_ sky130_fd_sc_hd__or2b_1
XFILLER_0_87_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14623_ _06930_ _07033_ VGND VGND VPWR VPWR _07034_ sky130_fd_sc_hd__xor2_1
X_11835_ _03982_ _03997_ _03998_ VGND VGND VPWR VPWR _04000_ sky130_fd_sc_hd__nand3_1
XFILLER_0_68_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11766_ net188 net231 net143 net313 VGND VGND VPWR VPWR _03925_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_95_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14554_ _06937_ _06958_ VGND VGND VPWR VPWR _06960_ sky130_fd_sc_hd__nand2_1
XFILLER_0_83_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10717_ net555 net439 VGND VGND VPWR VPWR _02780_ sky130_fd_sc_hd__nand2_1
X_14485_ _06883_ _06884_ VGND VGND VPWR VPWR _06886_ sky130_fd_sc_hd__nor2_1
X_13505_ net537 net545 net450 net441 VGND VGND VPWR VPWR _05820_ sky130_fd_sc_hd__and4_1
XFILLER_0_141_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11697_ _03809_ _03810_ _03846_ _03848_ VGND VGND VPWR VPWR _03850_ sky130_fd_sc_hd__a22o_1
XFILLER_0_82_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13436_ net519 net338 _05387_ _05386_ VGND VGND VPWR VPWR _05745_ sky130_fd_sc_hd__a31o_1
XFILLER_0_125_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10648_ _02684_ _02685_ _02703_ _02704_ VGND VGND VPWR VPWR _02705_ sky130_fd_sc_hd__o211a_1
Xrebuffer3 net646 VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__clkbuf_2
X_10579_ net463 net471 VGND VGND VPWR VPWR _02630_ sky130_fd_sc_hd__nand2_1
X_13367_ _05659_ _05668_ _05665_ VGND VGND VPWR VPWR _05669_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_3_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12318_ _04450_ _04525_ VGND VGND VPWR VPWR _04526_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13298_ net569 net365 _05592_ _05590_ VGND VGND VPWR VPWR _05593_ sky130_fd_sc_hd__a31o_1
XFILLER_0_139_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12249_ _04351_ _04371_ _04449_ VGND VGND VPWR VPWR _04450_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_139_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07790_ _06603_ _06766_ VGND VGND VPWR VPWR _06798_ sky130_fd_sc_hd__or2_1
XFILLER_0_3_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09460_ _01452_ _01454_ VGND VGND VPWR VPWR _01461_ sky130_fd_sc_hd__nor2_1
X_08411_ _00458_ _00459_ _00371_ VGND VGND VPWR VPWR _00461_ sky130_fd_sc_hd__a21o_1
XFILLER_0_47_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09391_ net664 net486 net408 net673 VGND VGND VPWR VPWR _01392_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_19_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08342_ _00390_ _00392_ VGND VGND VPWR VPWR _00393_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_58_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08273_ _00322_ _00323_ VGND VGND VPWR VPWR _00324_ sky130_fd_sc_hd__xor2_2
XFILLER_0_73_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout156 net157 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__buf_2
Xfanout145 net146 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__clkbuf_4
Xfanout134 net9 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__clkbuf_4
Xfanout178 net183 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__buf_2
Xfanout167 net173 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__clkbuf_4
Xfanout189 net190 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__clkbuf_4
X_07988_ _07280_ _07281_ _07207_ _07194_ VGND VGND VPWR VPWR _07283_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_114_Right_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09727_ _01725_ _01727_ VGND VGND VPWR VPWR _01728_ sky130_fd_sc_hd__nor2_1
XFILLER_0_69_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09658_ _01656_ _01657_ _01562_ _01585_ VGND VGND VPWR VPWR _01659_ sky130_fd_sc_hd__a211o_1
X_08609_ _00614_ _00621_ VGND VGND VPWR VPWR _00656_ sky130_fd_sc_hd__nand2_1
X_09589_ _01515_ _01519_ _01521_ VGND VGND VPWR VPWR _01590_ sky130_fd_sc_hd__or3_1
X_11620_ _03762_ _03763_ _03701_ _03688_ VGND VGND VPWR VPWR _03765_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_65_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11551_ _03603_ _03620_ _03687_ _03688_ VGND VGND VPWR VPWR _03689_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_108_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10502_ _02543_ _02544_ _02536_ VGND VGND VPWR VPWR _02546_ sky130_fd_sc_hd__a21o_1
XFILLER_0_9_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11482_ _03609_ _03612_ VGND VGND VPWR VPWR _03613_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_64_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14270_ _06650_ _06651_ VGND VGND VPWR VPWR _06652_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_116_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13221_ _05437_ _05434_ _05436_ VGND VGND VPWR VPWR _05508_ sky130_fd_sc_hd__nand3_1
XFILLER_0_33_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10433_ net140 net368 VGND VGND VPWR VPWR _02471_ sky130_fd_sc_hd__nand2_1
X_10364_ _02210_ _02211_ _02297_ _02298_ VGND VGND VPWR VPWR _02396_ sky130_fd_sc_hd__or4bb_1
X_13152_ _05208_ _05206_ _05207_ VGND VGND VPWR VPWR _05432_ sky130_fd_sc_hd__or3_1
XFILLER_0_131_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12103_ _04289_ _04290_ VGND VGND VPWR VPWR _04291_ sky130_fd_sc_hd__or2_1
XFILLER_0_20_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10295_ _02317_ _02318_ VGND VGND VPWR VPWR _02321_ sky130_fd_sc_hd__and2_1
X_13083_ _05279_ _05291_ VGND VGND VPWR VPWR _05356_ sky130_fd_sc_hd__nand2_1
X_12034_ _04207_ _04215_ VGND VGND VPWR VPWR _04216_ sky130_fd_sc_hd__xnor2_1
Xfanout690 net698 VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__buf_2
X_13985_ _06337_ _06340_ _06239_ VGND VGND VPWR VPWR _06343_ sky130_fd_sc_hd__a21o_1
XFILLER_0_87_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12936_ _05188_ _05192_ _05194_ VGND VGND VPWR VPWR _05195_ sky130_fd_sc_hd__nand3_1
X_12867_ _05119_ _05120_ VGND VGND VPWR VPWR _05121_ sky130_fd_sc_hd__xor2_1
XFILLER_0_75_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11818_ _03896_ _03898_ VGND VGND VPWR VPWR _03981_ sky130_fd_sc_hd__nand2_1
X_14606_ _06936_ _06960_ _07014_ VGND VGND VPWR VPWR _07017_ sky130_fd_sc_hd__a21oi_1
X_12798_ _04997_ _04998_ _04990_ VGND VGND VPWR VPWR _05046_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_55_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14537_ net605 net431 net423 net616 VGND VGND VPWR VPWR _06942_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_138_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11749_ _03817_ _03818_ VGND VGND VPWR VPWR _03906_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14468_ _06855_ _06866_ VGND VGND VPWR VPWR _06867_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_114_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14399_ _06736_ _06737_ _06791_ VGND VGND VPWR VPWR _06792_ sky130_fd_sc_hd__a21bo_1
X_13419_ net545 net564 net450 net441 VGND VGND VPWR VPWR _05726_ sky130_fd_sc_hd__and4_1
XFILLER_0_3_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08960_ _00922_ _00933_ VGND VGND VPWR VPWR _01002_ sky130_fd_sc_hd__and2b_1
XFILLER_0_59_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08891_ _00922_ _00933_ VGND VGND VPWR VPWR _00934_ sky130_fd_sc_hd__xnor2_1
X_07911_ _03868_ _07205_ _07197_ _03890_ VGND VGND VPWR VPWR _07206_ sky130_fd_sc_hd__a211oi_2
X_07842_ _03462_ _03539_ VGND VGND VPWR VPWR _07138_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07773_ _06462_ _06440_ _06451_ VGND VGND VPWR VPWR _06614_ sky130_fd_sc_hd__nand3_1
X_09512_ _01509_ _01512_ VGND VGND VPWR VPWR _01513_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_3_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09443_ _01442_ _01443_ VGND VGND VPWR VPWR _01444_ sky130_fd_sc_hd__nor2_1
XFILLER_0_115_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09374_ _01372_ _01373_ _01374_ VGND VGND VPWR VPWR _01375_ sky130_fd_sc_hd__a21bo_1
X_08325_ _00372_ _00373_ _00374_ VGND VGND VPWR VPWR _00376_ sky130_fd_sc_hd__a21o_1
XFILLER_0_117_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08256_ _00306_ _00307_ VGND VGND VPWR VPWR _00308_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08187_ _00164_ _00182_ _00181_ VGND VGND VPWR VPWR _00239_ sky130_fd_sc_hd__o21bai_4
XFILLER_0_104_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10080_ net742 net416 VGND VGND VPWR VPWR _02087_ sky130_fd_sc_hd__and2b_1
X_10982_ _02924_ _03066_ VGND VGND VPWR VPWR _03067_ sky130_fd_sc_hd__xnor2_1
X_13770_ _06008_ _06007_ VGND VGND VPWR VPWR _06108_ sky130_fd_sc_hd__and2b_1
X_12721_ _04941_ _04962_ VGND VGND VPWR VPWR _04963_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_97_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12652_ net465 net254 net246 net558 VGND VGND VPWR VPWR _04888_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_38_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11603_ _03744_ _03745_ VGND VGND VPWR VPWR _03746_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12583_ _04811_ _04805_ _04806_ VGND VGND VPWR VPWR _04813_ sky130_fd_sc_hd__nor3_1
X_11534_ net288 net738 _03611_ _03610_ VGND VGND VPWR VPWR _03670_ sky130_fd_sc_hd__a31o_1
XFILLER_0_108_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14322_ b_cos\[10\] _06708_ _05794_ VGND VGND VPWR VPWR _06709_ sky130_fd_sc_hd__mux2_1
X_11465_ net177 net166 net695 net704 VGND VGND VPWR VPWR _03595_ sky130_fd_sc_hd__and4_1
XFILLER_0_123_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14253_ _06551_ _06618_ _06619_ VGND VGND VPWR VPWR _06633_ sky130_fd_sc_hd__nor3b_1
XFILLER_0_123_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10416_ _02431_ _02452_ VGND VGND VPWR VPWR _02453_ sky130_fd_sc_hd__xnor2_1
X_13204_ _05487_ _05488_ net543 net365 VGND VGND VPWR VPWR _05489_ sky130_fd_sc_hd__and4bb_1
X_11396_ _03453_ _03481_ _03480_ VGND VGND VPWR VPWR _03519_ sky130_fd_sc_hd__nand3b_2
XFILLER_0_104_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14184_ net622 net631 net454 net445 VGND VGND VPWR VPWR _06558_ sky130_fd_sc_hd__and4_1
XFILLER_0_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10347_ _02361_ _02377_ VGND VGND VPWR VPWR _02378_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13135_ _05407_ _05412_ VGND VGND VPWR VPWR _05414_ sky130_fd_sc_hd__xnor2_1
X_10278_ _02017_ VGND VGND VPWR VPWR _02303_ sky130_fd_sc_hd__buf_4
X_13066_ net536 net329 net474 net545 VGND VGND VPWR VPWR _05338_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12017_ _04193_ _04194_ _04196_ VGND VGND VPWR VPWR _04198_ sky130_fd_sc_hd__nand3_1
XFILLER_0_136_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13968_ _06230_ _06231_ _06245_ _06246_ VGND VGND VPWR VPWR _06324_ sky130_fd_sc_hd__or4bb_1
X_12919_ _05155_ _05176_ VGND VGND VPWR VPWR _05177_ sky130_fd_sc_hd__xnor2_1
X_13899_ _06158_ _06159_ VGND VGND VPWR VPWR _06249_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08110_ _07329_ _07330_ _00122_ _00123_ VGND VGND VPWR VPWR _00163_ sky130_fd_sc_hd__and4_1
X_09090_ _01084_ _01080_ _01128_ VGND VGND VPWR VPWR _01130_ sky130_fd_sc_hd__and3_1
XFILLER_0_56_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08041_ net606 _07333_ _07334_ VGND VGND VPWR VPWR _07335_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_71_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09992_ _01989_ _01990_ _01982_ VGND VGND VPWR VPWR _01992_ sky130_fd_sc_hd__a21o_1
XFILLER_0_110_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08943_ _00928_ _00931_ _00984_ VGND VGND VPWR VPWR _00985_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_86_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08874_ _00917_ VGND VGND VPWR VPWR _00012_ sky130_fd_sc_hd__clkbuf_1
X_07825_ _05906_ _07112_ _07119_ _07120_ VGND VGND VPWR VPWR _07121_ sky130_fd_sc_hd__o211a_1
X_07756_ _06396_ _06407_ _06418_ VGND VGND VPWR VPWR _06429_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_79_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07687_ _05292_ _05259_ _05281_ VGND VGND VPWR VPWR _05677_ sky130_fd_sc_hd__a21o_1
XFILLER_0_66_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09426_ _01424_ _01425_ _01423_ VGND VGND VPWR VPWR _01427_ sky130_fd_sc_hd__a21o_1
XFILLER_0_136_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09357_ net129 net783 _01361_ VGND VGND VPWR VPWR _00051_ sky130_fd_sc_hd__o21a_1
X_08308_ net160 net625 _00356_ _00357_ VGND VGND VPWR VPWR _00359_ sky130_fd_sc_hd__nand4_1
X_09288_ _01300_ _01301_ VGND VGND VPWR VPWR _01302_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_35_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08239_ _00287_ _00288_ _00289_ VGND VGND VPWR VPWR _00291_ sky130_fd_sc_hd__nand3_1
XFILLER_0_62_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11250_ net212 net677 net684 net203 VGND VGND VPWR VPWR _03358_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_42_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11181_ _03276_ _03280_ _03281_ VGND VGND VPWR VPWR _03282_ sky130_fd_sc_hd__nand3_1
XFILLER_0_120_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10201_ _02125_ _02137_ _02138_ _02140_ _02123_ VGND VGND VPWR VPWR _02218_ sky130_fd_sc_hd__a32o_1
X_10132_ _02023_ _02031_ _02030_ VGND VGND VPWR VPWR _02143_ sky130_fd_sc_hd__a21o_1
XFILLER_0_30_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_66_Left_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10063_ _02065_ _02066_ _02067_ VGND VGND VPWR VPWR _02068_ sky130_fd_sc_hd__or3_1
X_13822_ _06039_ _06071_ _06069_ VGND VGND VPWR VPWR _06165_ sky130_fd_sc_hd__a21bo_1
X_13753_ b_cos\[3\] _06089_ _05794_ VGND VGND VPWR VPWR _06090_ sky130_fd_sc_hd__mux2_1
X_12704_ net378 net252 net244 net465 VGND VGND VPWR VPWR _04944_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_97_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10965_ _03046_ _03047_ _03043_ VGND VGND VPWR VPWR _03050_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_128_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_75_Left_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10896_ _02949_ _02972_ VGND VGND VPWR VPWR _02975_ sky130_fd_sc_hd__nand2_1
X_13684_ _05999_ _06013_ VGND VGND VPWR VPWR _06014_ sky130_fd_sc_hd__xnor2_1
X_12635_ _04867_ _04868_ VGND VGND VPWR VPWR _04870_ sky130_fd_sc_hd__nor2_1
X_12566_ net302 net144 net136 net154 VGND VGND VPWR VPWR _04795_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_81_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11517_ net156 net712 _03596_ _03595_ VGND VGND VPWR VPWR _03652_ sky130_fd_sc_hd__a31o_1
XFILLER_0_108_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14305_ _06598_ _06604_ VGND VGND VPWR VPWR _06691_ sky130_fd_sc_hd__and2b_1
X_12497_ net190 net154 net302 net145 VGND VGND VPWR VPWR _04720_ sky130_fd_sc_hd__and4_1
XFILLER_0_40_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11448_ net309 net461 net556 net230 VGND VGND VPWR VPWR _03576_ sky130_fd_sc_hd__a22o_1
XFILLER_0_0_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14236_ _06595_ _06596_ _06615_ VGND VGND VPWR VPWR _06616_ sky130_fd_sc_hd__or3_4
X_11379_ _03489_ _03498_ _03499_ VGND VGND VPWR VPWR _03500_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_1_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14167_ _06447_ _06449_ VGND VGND VPWR VPWR _06541_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_84_Left_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13118_ _05392_ _05393_ _05313_ _05361_ VGND VGND VPWR VPWR _05395_ sky130_fd_sc_hd__o211a_1
X_14098_ _06397_ _06446_ VGND VGND VPWR VPWR _06465_ sky130_fd_sc_hd__nor2_1
X_13049_ net510 net519 net356 net345 VGND VGND VPWR VPWR _05319_ sky130_fd_sc_hd__and4_1
X_07610_ _04696_ _04815_ net752 VGND VGND VPWR VPWR _04837_ sky130_fd_sc_hd__nand3_4
X_08590_ _00635_ _00636_ _00554_ _00637_ VGND VGND VPWR VPWR _00638_ sky130_fd_sc_hd__a211oi_1
X_07541_ _02451_ _04064_ _04054_ VGND VGND VPWR VPWR _04086_ sky130_fd_sc_hd__a21oi_1
Xclkbuf_3_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_4_0_clk sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_93_Left_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07472_ _03297_ _03308_ _03286_ VGND VGND VPWR VPWR _03330_ sky130_fd_sc_hd__a21o_1
XFILLER_0_9_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09211_ net78 _01236_ net130 VGND VGND VPWR VPWR _01237_ sky130_fd_sc_hd__mux2_1
XFILLER_0_29_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09142_ _01177_ VGND VGND VPWR VPWR _00020_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09073_ _01111_ _01112_ VGND VGND VPWR VPWR _01113_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08024_ net158 net499 net508 net149 VGND VGND VPWR VPWR _07318_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_25_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09975_ _01972_ _01973_ _01968_ VGND VGND VPWR VPWR _01975_ sky130_fd_sc_hd__a21o_1
X_08926_ _00966_ _00968_ VGND VGND VPWR VPWR _00969_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08857_ _00835_ _00834_ VGND VGND VPWR VPWR _00901_ sky130_fd_sc_hd__and2b_1
X_07808_ _06831_ _06950_ _06982_ VGND VGND VPWR VPWR _06993_ sky130_fd_sc_hd__o21ba_1
X_08788_ _00831_ _00832_ VGND VGND VPWR VPWR _00833_ sky130_fd_sc_hd__xor2_1
X_07739_ _05688_ _05699_ _05765_ VGND VGND VPWR VPWR _06244_ sky130_fd_sc_hd__o21a_1
XFILLER_0_67_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10750_ _02814_ _02815_ VGND VGND VPWR VPWR _02816_ sky130_fd_sc_hd__nor2_1
XFILLER_0_109_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10681_ _02739_ _02740_ VGND VGND VPWR VPWR _02741_ sky130_fd_sc_hd__or2_1
X_09409_ net699 net709 net357 net347 VGND VGND VPWR VPWR _01410_ sky130_fd_sc_hd__and4_1
XFILLER_0_48_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12420_ _04634_ _04635_ VGND VGND VPWR VPWR _04636_ sky130_fd_sc_hd__nor2_1
XFILLER_0_82_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12351_ net557 net283 net265 net653 VGND VGND VPWR VPWR _04561_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_23_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11302_ net210 net711 net720 net201 VGND VGND VPWR VPWR _03415_ sky130_fd_sc_hd__a22o_1
X_12282_ _04482_ _04483_ _04484_ VGND VGND VPWR VPWR _04486_ sky130_fd_sc_hd__a21o_1
XFILLER_0_105_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11233_ _03326_ _03327_ _03337_ VGND VGND VPWR VPWR _03339_ sky130_fd_sc_hd__and3_1
X_14021_ _06379_ _06380_ VGND VGND VPWR VPWR _06381_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11164_ _03260_ _03262_ VGND VGND VPWR VPWR _03263_ sky130_fd_sc_hd__nor2_1
X_11095_ _03188_ net418 VGND VGND VPWR VPWR _03190_ sky130_fd_sc_hd__and2_1
X_10115_ _02076_ _02078_ VGND VGND VPWR VPWR _02125_ sky130_fd_sc_hd__nand2_1
X_10046_ _01982_ _01990_ _01989_ VGND VGND VPWR VPWR _02050_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_89_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11997_ _04172_ _04174_ VGND VGND VPWR VPWR _04176_ sky130_fd_sc_hd__and2_1
XFILLER_0_98_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14785_ clknet_3_6_0_clk _00086_ net323 VGND VGND VPWR VPWR a_sin\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13805_ net584 net393 net384 net593 VGND VGND VPWR VPWR _06147_ sky130_fd_sc_hd__a22o_1
X_10948_ _03029_ _03030_ VGND VGND VPWR VPWR _03031_ sky130_fd_sc_hd__nand2_1
X_13736_ _06039_ _06069_ _06071_ VGND VGND VPWR VPWR _06072_ sky130_fd_sc_hd__nand3_1
XFILLER_0_85_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10879_ net463 net555 net433 net425 VGND VGND VPWR VPWR _02956_ sky130_fd_sc_hd__and4_1
X_13667_ _05995_ VGND VGND VPWR VPWR _05996_ sky130_fd_sc_hd__inv_2
XFILLER_0_115_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12618_ _04849_ _04851_ VGND VGND VPWR VPWR _04852_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13598_ _05918_ _05919_ _05920_ VGND VGND VPWR VPWR _05921_ sky130_fd_sc_hd__or3_1
XFILLER_0_124_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12549_ _04704_ _04692_ _04775_ _04776_ VGND VGND VPWR VPWR _04777_ sky130_fd_sc_hd__o211a_1
XFILLER_0_81_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_1 _01104_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_111_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14219_ _06506_ _06508_ VGND VGND VPWR VPWR _06597_ sky130_fd_sc_hd__or2_1
XFILLER_0_22_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout508 net509 VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__clkbuf_4
Xfanout519 net526 VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_67_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09760_ _01735_ _01736_ _01760_ _01756_ VGND VGND VPWR VPWR _01761_ sky130_fd_sc_hd__o211ai_2
X_08711_ _00755_ _00756_ VGND VGND VPWR VPWR _00757_ sky130_fd_sc_hd__or2_1
X_09691_ _01691_ _01408_ VGND VGND VPWR VPWR _01692_ sky130_fd_sc_hd__xnor2_1
X_08642_ _00687_ _00672_ _00673_ VGND VGND VPWR VPWR _00689_ sky130_fd_sc_hd__or3_1
Xrebuffer24 net768 VGND VGND VPWR VPWR net769 sky130_fd_sc_hd__buf_1
Xrebuffer13 net757 VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__buf_1
Xrebuffer35 _05928_ VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__clkbuf_1
X_08573_ _00615_ _00620_ VGND VGND VPWR VPWR _00621_ sky130_fd_sc_hd__xor2_1
XFILLER_0_83_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07524_ _03157_ _03200_ _03221_ VGND VGND VPWR VPWR _03901_ sky130_fd_sc_hd__or3_1
XFILLER_0_49_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07455_ _03081_ _03135_ VGND VGND VPWR VPWR _03146_ sky130_fd_sc_hd__xor2_1
XFILLER_0_9_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07386_ _02222_ _02375_ _02386_ VGND VGND VPWR VPWR _02397_ sky130_fd_sc_hd__nand3_4
XFILLER_0_72_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09125_ next_state _01160_ _01162_ _01163_ VGND VGND VPWR VPWR _00017_ sky130_fd_sc_hd__a31o_1
XFILLER_0_17_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09056_ _01038_ _01045_ VGND VGND VPWR VPWR _01096_ sky130_fd_sc_hd__and2_1
X_08007_ _07224_ _07296_ _07300_ VGND VGND VPWR VPWR _07301_ sky130_fd_sc_hd__or3_1
XFILLER_0_60_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09958_ _01955_ _01956_ _01957_ VGND VGND VPWR VPWR _01958_ sky130_fd_sc_hd__nand3_1
X_08909_ _00950_ _00951_ VGND VGND VPWR VPWR _00952_ sky130_fd_sc_hd__xor2_1
X_09889_ _01874_ _01873_ _01872_ VGND VGND VPWR VPWR _01890_ sky130_fd_sc_hd__a21o_1
X_11920_ _04090_ _04091_ VGND VGND VPWR VPWR _04092_ sky130_fd_sc_hd__nor2_1
X_11851_ _03926_ _04011_ _04015_ _04016_ VGND VGND VPWR VPWR _04017_ sky130_fd_sc_hd__o211ai_2
X_11782_ _03903_ _03904_ _03940_ _03941_ VGND VGND VPWR VPWR _03942_ sky130_fd_sc_hd__and4_2
X_10802_ _02870_ _02871_ VGND VGND VPWR VPWR _02872_ sky130_fd_sc_hd__xor2_1
X_14570_ _06929_ _06930_ _06922_ VGND VGND VPWR VPWR _06977_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_138_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13521_ _05815_ _05816_ _05835_ _05836_ VGND VGND VPWR VPWR _05837_ sky130_fd_sc_hd__o211ai_4
X_10733_ net134 net342 VGND VGND VPWR VPWR _02797_ sky130_fd_sc_hd__nand2_2
XFILLER_0_95_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10664_ _02720_ _02721_ VGND VGND VPWR VPWR _02722_ sky130_fd_sc_hd__or2_1
X_13452_ net611 net402 VGND VGND VPWR VPWR _05762_ sky130_fd_sc_hd__nand2_1
XFILLER_0_118_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12403_ _04527_ _04611_ _04612_ VGND VGND VPWR VPWR _04617_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_63_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13383_ net656 net400 _05679_ _05680_ VGND VGND VPWR VPWR _05686_ sky130_fd_sc_hd__a22o_1
X_10595_ net132 net363 net350 VGND VGND VPWR VPWR _02648_ sky130_fd_sc_hd__and3_1
XFILLER_0_3_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12334_ _04540_ _04541_ VGND VGND VPWR VPWR _04542_ sky130_fd_sc_hd__nor2_1
XFILLER_0_105_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_128_Right_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12265_ _04464_ _04466_ VGND VGND VPWR VPWR _04468_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_50_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14004_ _06275_ _06277_ _06362_ VGND VGND VPWR VPWR _06363_ sky130_fd_sc_hd__o21ai_1
X_11216_ net694 _03318_ _03320_ VGND VGND VPWR VPWR _03321_ sky130_fd_sc_hd__a21bo_1
X_12196_ _04389_ _04390_ _04374_ VGND VGND VPWR VPWR _04393_ sky130_fd_sc_hd__a21o_1
XFILLER_0_31_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput93 net93 VGND VGND VPWR VPWR Q[0] sky130_fd_sc_hd__clkbuf_4
Xoutput82 net82 VGND VGND VPWR VPWR D[16] sky130_fd_sc_hd__clkbuf_4
X_11147_ _03155_ _03159_ _03209_ _03216_ _03245_ VGND VGND VPWR VPWR _03246_ sky130_fd_sc_hd__o311a_1
XFILLER_0_128_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11078_ _03169_ _02928_ VGND VGND VPWR VPWR _03171_ sky130_fd_sc_hd__and2b_1
X_10029_ _02030_ _02031_ VGND VGND VPWR VPWR _02032_ sky130_fd_sc_hd__and2b_1
XFILLER_0_59_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14768_ clknet_3_5_0_clk _00069_ net322 VGND VGND VPWR VPWR a_cos\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_85_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14699_ clknet_3_2_0_clk _00000_ net314 VGND VGND VPWR VPWR b_sin\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_46_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13719_ net385 _06051_ _06052_ VGND VGND VPWR VPWR _06053_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_6_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout305 net306 VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__buf_6
XFILLER_0_100_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout316 net318 VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__clkbuf_4
Xfanout327 net328 VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__clkbuf_2
X_09812_ _01807_ _01808_ _01812_ VGND VGND VPWR VPWR _01813_ sky130_fd_sc_hd__a21o_1
Xfanout338 net341 VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__clkbuf_4
Xfanout349 net354 VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__clkbuf_4
X_09743_ _01738_ _01739_ _01743_ VGND VGND VPWR VPWR _01744_ sky130_fd_sc_hd__a21o_1
X_09674_ _01669_ _01670_ _01674_ VGND VGND VPWR VPWR _01675_ sky130_fd_sc_hd__a21o_1
X_08625_ _00653_ _00654_ _00670_ _00671_ VGND VGND VPWR VPWR _00672_ sky130_fd_sc_hd__o211a_1
XFILLER_0_96_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08556_ _00518_ _00520_ VGND VGND VPWR VPWR _00604_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07507_ _03649_ _03704_ VGND VGND VPWR VPWR _03715_ sky130_fd_sc_hd__xor2_1
X_08487_ _00371_ _00535_ VGND VGND VPWR VPWR _00536_ sky130_fd_sc_hd__xor2_1
XFILLER_0_64_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07438_ net288 net575 VGND VGND VPWR VPWR _02962_ sky130_fd_sc_hd__nand2_1
XFILLER_0_135_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07369_ _02135_ _02081_ _02092_ VGND VGND VPWR VPWR _02212_ sky130_fd_sc_hd__nand3_1
XFILLER_0_80_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09108_ _01090_ _01146_ VGND VGND VPWR VPWR _01147_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_33_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10380_ _02330_ _02334_ _02332_ VGND VGND VPWR VPWR _02413_ sky130_fd_sc_hd__o21ba_1
X_09039_ _00970_ _00979_ _01030_ _01031_ _01079_ VGND VGND VPWR VPWR _01080_ sky130_fd_sc_hd__o311ai_4
X_12050_ _04205_ _04233_ VGND VGND VPWR VPWR _04234_ sky130_fd_sc_hd__xnor2_1
X_11001_ _03073_ _03087_ VGND VGND VPWR VPWR _03088_ sky130_fd_sc_hd__xnor2_1
X_12952_ net510 net388 net379 net518 VGND VGND VPWR VPWR _05212_ sky130_fd_sc_hd__a22oi_2
X_11903_ net739 net235 VGND VGND VPWR VPWR _04073_ sky130_fd_sc_hd__and2b_1
XFILLER_0_87_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12883_ _05020_ _05022_ _05079_ _05078_ _05061_ VGND VGND VPWR VPWR _05138_ sky130_fd_sc_hd__o32a_1
X_14622_ _06979_ _07032_ VGND VGND VPWR VPWR _07033_ sky130_fd_sc_hd__or2_1
X_11834_ _03995_ _03996_ _03987_ VGND VGND VPWR VPWR _03998_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11765_ net274 net224 VGND VGND VPWR VPWR _03924_ sky130_fd_sc_hd__nand2_1
XFILLER_0_83_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14553_ _06937_ _06958_ VGND VGND VPWR VPWR _06959_ sky130_fd_sc_hd__or2_1
X_11696_ _03809_ _03810_ _03846_ _03848_ VGND VGND VPWR VPWR _03849_ sky130_fd_sc_hd__nand4_4
XFILLER_0_82_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10716_ _02776_ _02778_ VGND VGND VPWR VPWR _02779_ sky130_fd_sc_hd__nor2_1
X_14484_ _06796_ _06800_ _06882_ VGND VGND VPWR VPWR _06884_ sky130_fd_sc_hd__o21a_1
X_13504_ net537 net450 net441 net545 VGND VGND VPWR VPWR _05818_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_83_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10647_ _02686_ _02687_ _02702_ VGND VGND VPWR VPWR _02704_ sky130_fd_sc_hd__nand3_2
X_13435_ _05379_ _05381_ _05390_ VGND VGND VPWR VPWR _05744_ sky130_fd_sc_hd__nand3_2
XFILLER_0_36_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer4 net646 VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10578_ _02627_ _02628_ VGND VGND VPWR VPWR _02629_ sky130_fd_sc_hd__nor2_1
X_13366_ _05665_ _05667_ VGND VGND VPWR VPWR _05668_ sky130_fd_sc_hd__nor2_1
X_12317_ _04521_ _04524_ VGND VGND VPWR VPWR _04525_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13297_ _05590_ _05591_ VGND VGND VPWR VPWR _05592_ sky130_fd_sc_hd__nor2_1
XFILLER_0_121_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12248_ _04354_ _04370_ VGND VGND VPWR VPWR _04449_ sky130_fd_sc_hd__or2_1
XFILLER_0_48_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12179_ _04295_ _04302_ _04301_ VGND VGND VPWR VPWR _04374_ sky130_fd_sc_hd__a21bo_1
X_08410_ _00371_ _00458_ _00459_ VGND VGND VPWR VPWR _00460_ sky130_fd_sc_hd__nand3_1
XFILLER_0_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09390_ net682 net400 VGND VGND VPWR VPWR _01391_ sky130_fd_sc_hd__nand2_1
XFILLER_0_129_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08341_ _00306_ _00307_ _00391_ VGND VGND VPWR VPWR _00392_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_74_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08272_ net550 net236 VGND VGND VPWR VPWR _00323_ sky130_fd_sc_hd__and2b_1
XFILLER_0_74_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout146 net8 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__buf_4
Xfanout135 net138 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__buf_4
Xfanout168 net173 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__clkbuf_2
Xfanout179 net183 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__buf_4
Xfanout157 net159 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__clkbuf_4
X_07987_ _07207_ _07194_ _07280_ _07281_ VGND VGND VPWR VPWR _07282_ sky130_fd_sc_hd__o211ai_2
X_09726_ _01725_ _01726_ net740 net339 VGND VGND VPWR VPWR _01727_ sky130_fd_sc_hd__and4bb_1
X_09657_ _01562_ _01585_ _01656_ _01657_ VGND VGND VPWR VPWR _01658_ sky130_fd_sc_hd__o211ai_2
X_08608_ _00615_ _00620_ VGND VGND VPWR VPWR _00655_ sky130_fd_sc_hd__or2_1
X_09588_ _01519_ _01521_ _01515_ VGND VGND VPWR VPWR _01589_ sky130_fd_sc_hd__o21ai_4
X_08539_ _00583_ _00586_ VGND VGND VPWR VPWR _00587_ sky130_fd_sc_hd__xor2_1
XFILLER_0_49_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11550_ _03664_ _03665_ _03685_ _03686_ VGND VGND VPWR VPWR _03688_ sky130_fd_sc_hd__or4_4
XFILLER_0_65_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10501_ _02536_ _02543_ _02544_ VGND VGND VPWR VPWR _02545_ sky130_fd_sc_hd__nand3_2
XFILLER_0_122_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11481_ _03610_ _03611_ VGND VGND VPWR VPWR _03612_ sky130_fd_sc_hd__and2b_1
X_13220_ _05445_ _05439_ _05444_ VGND VGND VPWR VPWR _05507_ sky130_fd_sc_hd__nand3_1
XFILLER_0_21_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10432_ net393 net384 VGND VGND VPWR VPWR _02470_ sky130_fd_sc_hd__nor2_1
X_10363_ _02391_ _02394_ VGND VGND VPWR VPWR _02395_ sky130_fd_sc_hd__xnor2_2
X_13151_ _05217_ _05210_ _05216_ VGND VGND VPWR VPWR _05431_ sky130_fd_sc_hd__nand3_1
XFILLER_0_131_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12102_ _04287_ _04288_ _04279_ VGND VGND VPWR VPWR _04290_ sky130_fd_sc_hd__a21oi_1
X_13082_ _05280_ _05290_ VGND VGND VPWR VPWR _05355_ sky130_fd_sc_hd__or2b_1
X_12033_ _04213_ _04214_ VGND VGND VPWR VPWR _04215_ sky130_fd_sc_hd__nor2_1
X_10294_ _02317_ _02318_ VGND VGND VPWR VPWR _02319_ sky130_fd_sc_hd__nor2_1
XFILLER_0_18_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout680 net681 VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout691 net698 VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__buf_2
X_13984_ _06239_ _06337_ _06340_ VGND VGND VPWR VPWR _06341_ sky130_fd_sc_hd__nand3_1
XFILLER_0_125_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12935_ _05190_ _05191_ _05189_ VGND VGND VPWR VPWR _05194_ sky130_fd_sc_hd__a21o_1
X_12866_ _03188_ net238 VGND VGND VPWR VPWR _05120_ sky130_fd_sc_hd__and2_1
XFILLER_0_34_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11817_ _03842_ _03905_ _03938_ _03939_ VGND VGND VPWR VPWR _03980_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_96_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14605_ _06936_ _06960_ _07014_ VGND VGND VPWR VPWR _07016_ sky130_fd_sc_hd__and3_1
X_12797_ _05006_ _05027_ VGND VGND VPWR VPWR _05045_ sky130_fd_sc_hd__or2b_1
XFILLER_0_56_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14536_ _06858_ _06859_ VGND VGND VPWR VPWR _06941_ sky130_fd_sc_hd__nor2_1
X_11748_ _03823_ _03842_ _03843_ VGND VGND VPWR VPWR _03905_ sky130_fd_sc_hd__nand3_2
XFILLER_0_126_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11679_ net224 net375 VGND VGND VPWR VPWR _03830_ sky130_fd_sc_hd__nand2_1
XFILLER_0_55_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14467_ _06794_ _06865_ VGND VGND VPWR VPWR _06866_ sky130_fd_sc_hd__xnor2_1
X_14398_ _06730_ _06738_ VGND VGND VPWR VPWR _06791_ sky130_fd_sc_hd__nand2_1
X_13418_ net545 net450 net441 net564 VGND VGND VPWR VPWR _05725_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_141_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13349_ _05646_ _05648_ _05637_ VGND VGND VPWR VPWR _05649_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_122_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08890_ _00868_ _00932_ VGND VGND VPWR VPWR _00933_ sky130_fd_sc_hd__xor2_1
X_07910_ _07194_ _07195_ VGND VGND VPWR VPWR _07205_ sky130_fd_sc_hd__or2_1
X_07841_ _03473_ _03528_ VGND VGND VPWR VPWR _07137_ sky130_fd_sc_hd__or2b_1
X_07772_ net208 net199 net573 net660 VGND VGND VPWR VPWR _06603_ sky130_fd_sc_hd__and4_1
XFILLER_0_75_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09511_ _01510_ _01511_ VGND VGND VPWR VPWR _01512_ sky130_fd_sc_hd__nor2_1
XFILLER_0_79_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09442_ net691 net359 net347 net700 VGND VGND VPWR VPWR _01443_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_137_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09373_ net647 net664 net488 net410 VGND VGND VPWR VPWR _01374_ sky130_fd_sc_hd__nand4_1
X_08324_ _00372_ _00373_ _00374_ VGND VGND VPWR VPWR _00375_ sky130_fd_sc_hd__nand3_1
XFILLER_0_47_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08255_ _00161_ _00221_ _00220_ VGND VGND VPWR VPWR _00307_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_61_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_104_Left_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08186_ _00146_ _00157_ _00158_ _00160_ _00145_ VGND VGND VPWR VPWR _00238_ sky130_fd_sc_hd__a32o_1
XFILLER_0_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_113_Left_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09709_ _01471_ _01708_ _01707_ _01698_ VGND VGND VPWR VPWR _01710_ sky130_fd_sc_hd__o211ai_1
X_10981_ _03056_ _03065_ VGND VGND VPWR VPWR _03066_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_139_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12720_ _04901_ _04961_ VGND VGND VPWR VPWR _04962_ sky130_fd_sc_hd__xor2_2
XFILLER_0_57_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12651_ _04789_ _04792_ _04790_ VGND VGND VPWR VPWR _04887_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_84_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11602_ net705 net150 net296 net713 VGND VGND VPWR VPWR _03745_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_65_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12582_ _04805_ _04806_ _04811_ VGND VGND VPWR VPWR _04812_ sky130_fd_sc_hd__o21a_1
XFILLER_0_108_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11533_ _03591_ _03599_ VGND VGND VPWR VPWR _03669_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_122_Left_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14321_ _06632_ _06707_ VGND VGND VPWR VPWR _06708_ sky130_fd_sc_hd__xnor2_1
X_11464_ net156 net712 VGND VGND VPWR VPWR _03593_ sky130_fd_sc_hd__nand2_1
X_14252_ _06623_ _06628_ _06631_ VGND VGND VPWR VPWR _06632_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_104_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10415_ _02449_ _02450_ VGND VGND VPWR VPWR _02452_ sky130_fd_sc_hd__nand2_1
X_13203_ net527 net388 net379 net535 VGND VGND VPWR VPWR _05488_ sky130_fd_sc_hd__a22oi_1
X_11395_ _03508_ _03515_ _03514_ VGND VGND VPWR VPWR _03518_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_110_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14183_ net622 net454 net445 net631 VGND VGND VPWR VPWR _06557_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_0_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10346_ _02374_ _02376_ VGND VGND VPWR VPWR _02377_ sky130_fd_sc_hd__and2_1
XFILLER_0_21_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13134_ _05408_ _05411_ VGND VGND VPWR VPWR _05412_ sky130_fd_sc_hd__xnor2_1
X_10277_ _02300_ _02301_ VGND VGND VPWR VPWR _02302_ sky130_fd_sc_hd__xnor2_1
X_13065_ net536 net544 net329 net474 VGND VGND VPWR VPWR _05337_ sky130_fd_sc_hd__and4_1
X_12016_ _04193_ _04194_ _04196_ VGND VGND VPWR VPWR _04197_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_131_Left_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13967_ _06302_ _06322_ VGND VGND VPWR VPWR _06323_ sky130_fd_sc_hd__xnor2_1
X_12918_ _05156_ _05175_ VGND VGND VPWR VPWR _05176_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_88_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13898_ _06232_ _06247_ VGND VGND VPWR VPWR _06248_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_131_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12849_ net259 _05049_ _05100_ VGND VGND VPWR VPWR _05101_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_8_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_140_Left_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14519_ net470 _06731_ VGND VGND VPWR VPWR _06922_ sky130_fd_sc_hd__nand2_2
XFILLER_0_114_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08040_ net222 net597 net606 net213 VGND VGND VPWR VPWR _07334_ sky130_fd_sc_hd__a22o_1
XFILLER_0_71_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09991_ _01982_ _01989_ _01990_ VGND VGND VPWR VPWR _01991_ sky130_fd_sc_hd__nand3_1
XFILLER_0_10_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08942_ net292 _00877_ VGND VGND VPWR VPWR _00984_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08873_ b_sin\[12\] _00916_ _00486_ VGND VGND VPWR VPWR _00917_ sky130_fd_sc_hd__mux2_1
XFILLER_0_98_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07824_ _05896_ _05939_ _05501_ _05490_ VGND VGND VPWR VPWR _07120_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_79_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07755_ net304 net225 net538 net547 VGND VGND VPWR VPWR _06418_ sky130_fd_sc_hd__and4_1
X_07686_ _05292_ _05259_ _05281_ VGND VGND VPWR VPWR _05666_ sky130_fd_sc_hd__nand3_1
XFILLER_0_67_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09425_ _01423_ _01424_ _01425_ VGND VGND VPWR VPWR _01426_ sky130_fd_sc_hd__nand3_1
XFILLER_0_137_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09356_ _01359_ _01360_ net131 VGND VGND VPWR VPWR _01361_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_62_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08307_ net160 net625 _00356_ _00357_ VGND VGND VPWR VPWR _00358_ sky130_fd_sc_hd__a22o_1
XFILLER_0_90_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09287_ _01292_ _01295_ _01293_ VGND VGND VPWR VPWR _01301_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_19_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08238_ _00287_ _00288_ _00289_ VGND VGND VPWR VPWR _00290_ sky130_fd_sc_hd__a21o_1
XFILLER_0_7_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08169_ _00161_ _00220_ _00221_ VGND VGND VPWR VPWR _00222_ sky130_fd_sc_hd__nor3_2
X_10200_ _02121_ _02207_ _02206_ VGND VGND VPWR VPWR _02217_ sky130_fd_sc_hd__o21bai_1
X_11180_ _03272_ _03274_ _03273_ VGND VGND VPWR VPWR _03281_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_113_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10131_ _02072_ _02074_ VGND VGND VPWR VPWR _02142_ sky130_fd_sc_hd__nand2_1
X_10062_ net665 net674 net340 net332 VGND VGND VPWR VPWR _02067_ sky130_fd_sc_hd__and4_1
X_13821_ _06134_ _06163_ VGND VGND VPWR VPWR _06164_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13752_ _06085_ _06088_ VGND VGND VPWR VPWR _06089_ sky130_fd_sc_hd__xnor2_1
X_12703_ _04863_ _04878_ _04942_ VGND VGND VPWR VPWR _04943_ sky130_fd_sc_hd__o21ai_2
X_10964_ _03043_ _03046_ _03047_ VGND VGND VPWR VPWR _03048_ sky130_fd_sc_hd__and3_1
X_10895_ _02949_ _02972_ VGND VGND VPWR VPWR _02974_ sky130_fd_sc_hd__or2_1
X_13683_ _06011_ _06012_ VGND VGND VPWR VPWR _06013_ sky130_fd_sc_hd__nand2_1
X_12634_ _04864_ _04865_ _04866_ VGND VGND VPWR VPWR _04868_ sky130_fd_sc_hd__nor3_1
XFILLER_0_66_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12565_ _04791_ _04792_ VGND VGND VPWR VPWR _04794_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_81_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11516_ _03647_ _03648_ _03632_ VGND VGND VPWR VPWR _03651_ sky130_fd_sc_hd__a21o_1
XFILLER_0_81_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14304_ _06687_ _06688_ VGND VGND VPWR VPWR _06689_ sky130_fd_sc_hd__or2_1
X_12496_ net189 net302 net145 net154 VGND VGND VPWR VPWR _04719_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_22_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11447_ net309 net230 net461 net556 VGND VGND VPWR VPWR _03575_ sky130_fd_sc_hd__nand4_2
X_14235_ _06482_ _06613_ VGND VGND VPWR VPWR _06615_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_33_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11378_ _03491_ _03493_ _03497_ VGND VGND VPWR VPWR _03499_ sky130_fd_sc_hd__nand3_1
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14166_ _06536_ _06537_ _06463_ _06395_ VGND VGND VPWR VPWR _06540_ sky130_fd_sc_hd__o211a_1
X_10329_ _02355_ _02356_ _02351_ VGND VGND VPWR VPWR _02358_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13117_ _05313_ _05361_ _05392_ _05393_ VGND VGND VPWR VPWR _05394_ sky130_fd_sc_hd__a211oi_2
X_14097_ _06444_ _06445_ VGND VGND VPWR VPWR _06464_ sky130_fd_sc_hd__nor2_1
X_13048_ net528 net338 VGND VGND VPWR VPWR _05318_ sky130_fd_sc_hd__nand2_1
X_07540_ _02451_ _04054_ _04064_ VGND VGND VPWR VPWR _04075_ sky130_fd_sc_hd__and3_1
XFILLER_0_72_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07471_ _03286_ _03297_ _03308_ VGND VGND VPWR VPWR _03319_ sky130_fd_sc_hd__nand3_1
X_09210_ _01234_ _01235_ VGND VGND VPWR VPWR _01236_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_57_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09141_ net85 _01176_ net128 VGND VGND VPWR VPWR _01177_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09072_ _01099_ _01110_ VGND VGND VPWR VPWR _01112_ sky130_fd_sc_hd__or2_1
X_08023_ net297 net516 VGND VGND VPWR VPWR _07317_ sky130_fd_sc_hd__nand2_1
XFILLER_0_142_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09974_ _01968_ _01972_ _01973_ VGND VGND VPWR VPWR _01974_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08925_ _00889_ _00903_ _00967_ VGND VGND VPWR VPWR _00968_ sky130_fd_sc_hd__a21oi_1
X_08856_ _00828_ _00833_ VGND VGND VPWR VPWR _00900_ sky130_fd_sc_hd__and2b_1
X_07807_ _06907_ _06842_ _06874_ VGND VGND VPWR VPWR _06982_ sky130_fd_sc_hd__or3_1
XFILLER_0_98_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08787_ net500 net237 VGND VGND VPWR VPWR _00832_ sky130_fd_sc_hd__and2b_1
XFILLER_0_95_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07738_ _06189_ _06211_ _06222_ VGND VGND VPWR VPWR _06233_ sky130_fd_sc_hd__nand3_2
XFILLER_0_79_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07669_ _05457_ _05446_ net773 net759 VGND VGND VPWR VPWR _05479_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_67_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09408_ net726 net339 _01408_ _01406_ VGND VGND VPWR VPWR _01409_ sky130_fd_sc_hd__a31o_1
X_10680_ _02737_ _02738_ VGND VGND VPWR VPWR _02740_ sky130_fd_sc_hd__and2_1
XFILLER_0_125_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09339_ net796 net97 VGND VGND VPWR VPWR _01346_ sky130_fd_sc_hd__nand2_1
XFILLER_0_63_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_109_Right_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12350_ _04503_ _04510_ VGND VGND VPWR VPWR _04560_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11301_ net210 net201 net711 net720 VGND VGND VPWR VPWR _03414_ sky130_fd_sc_hd__and4_1
X_12281_ _04482_ _04483_ _04484_ VGND VGND VPWR VPWR _04485_ sky130_fd_sc_hd__nand3_2
XFILLER_0_120_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11232_ _03326_ _03327_ _03337_ VGND VGND VPWR VPWR _03338_ sky130_fd_sc_hd__a21oi_1
X_14020_ net512 net521 net428 net420 VGND VGND VPWR VPWR _06380_ sky130_fd_sc_hd__and4_1
X_11163_ _03260_ _03261_ net156 net743 VGND VGND VPWR VPWR _03262_ sky130_fd_sc_hd__and4bb_1
X_10114_ _02122_ _02094_ _02095_ _02098_ _02087_ VGND VGND VPWR VPWR _02123_ sky130_fd_sc_hd__a32o_1
X_11094_ net273 VGND VGND VPWR VPWR _03188_ sky130_fd_sc_hd__inv_2
X_10045_ _02045_ _02046_ _02038_ VGND VGND VPWR VPWR _02049_ sky130_fd_sc_hd__a21o_1
XFILLER_0_26_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13804_ _06136_ _06144_ VGND VGND VPWR VPWR _06145_ sky130_fd_sc_hd__xnor2_2
X_11996_ _04172_ _04174_ VGND VGND VPWR VPWR _04175_ sky130_fd_sc_hd__nor2_1
XFILLER_0_86_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14784_ clknet_3_6_0_clk _00085_ net320 VGND VGND VPWR VPWR a_sin\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_133_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10947_ _03010_ _03011_ _03028_ VGND VGND VPWR VPWR _03030_ sky130_fd_sc_hd__a21o_1
X_13735_ _06067_ _06068_ _05929_ _05931_ VGND VGND VPWR VPWR _06071_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_45_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13666_ _05809_ _05978_ _05994_ VGND VGND VPWR VPWR _05995_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_128_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12617_ _04698_ _04850_ _04778_ VGND VGND VPWR VPWR _04851_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10878_ net463 net433 net425 net555 VGND VGND VPWR VPWR _02955_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_38_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13597_ net578 net489 net415 VGND VGND VPWR VPWR _05920_ sky130_fd_sc_hd__and3_1
XFILLER_0_26_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12548_ _04773_ _04774_ _04705_ _04707_ VGND VGND VPWR VPWR _04776_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_124_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12479_ a_sin\[9\] _00918_ VGND VGND VPWR VPWR _04701_ sky130_fd_sc_hd__and2_1
XANTENNA_2 net796 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_123_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14218_ _06594_ _06531_ _06591_ _06593_ VGND VGND VPWR VPWR _06596_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_1_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout509 net35 VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__buf_2
XFILLER_0_6_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14149_ net596 net342 VGND VGND VPWR VPWR _06521_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08710_ _00612_ _00681_ _00683_ VGND VGND VPWR VPWR _00756_ sky130_fd_sc_hd__o21ai_1
X_09690_ net724 net339 VGND VGND VPWR VPWR _01691_ sky130_fd_sc_hd__nand2_1
X_08641_ _00672_ _00673_ _00687_ VGND VGND VPWR VPWR _00688_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_83_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer25 net769 VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__clkbuf_1
Xrebuffer36 _02864_ VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__dlymetal6s2s_1
Xrebuffer14 net758 VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_83_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08572_ _00618_ _00619_ VGND VGND VPWR VPWR _00620_ sky130_fd_sc_hd__xor2_1
XFILLER_0_89_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07523_ _03200_ _03221_ _03157_ VGND VGND VPWR VPWR _03890_ sky130_fd_sc_hd__o21ai_2
X_07454_ _03092_ _03124_ VGND VGND VPWR VPWR _03135_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_64_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07385_ _02299_ _02309_ _02364_ VGND VGND VPWR VPWR _02386_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09124_ b_sin\[17\] _00918_ VGND VGND VPWR VPWR _01163_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09055_ _01093_ _01094_ VGND VGND VPWR VPWR _01095_ sky130_fd_sc_hd__nor2_1
XFILLER_0_142_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08006_ _07210_ _07299_ VGND VGND VPWR VPWR _07300_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09957_ _01610_ _01611_ _01612_ VGND VGND VPWR VPWR _01957_ sky130_fd_sc_hd__o21bai_1
X_08908_ _00893_ _00894_ _00892_ VGND VGND VPWR VPWR _00951_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_99_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09888_ _01874_ _01872_ _01873_ VGND VGND VPWR VPWR _01889_ sky130_fd_sc_hd__nand3_1
X_08839_ _00868_ _00882_ VGND VGND VPWR VPWR _00883_ sky130_fd_sc_hd__xor2_1
X_11850_ _04013_ _04014_ _04012_ VGND VGND VPWR VPWR _04016_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_95_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11781_ _03938_ _03939_ _03842_ _03905_ VGND VGND VPWR VPWR _03941_ sky130_fd_sc_hd__o211ai_2
X_10801_ net272 net471 _02784_ _02783_ VGND VGND VPWR VPWR _02871_ sky130_fd_sc_hd__a31o_1
XFILLER_0_83_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10732_ net142 net342 _02711_ _02648_ VGND VGND VPWR VPWR _02796_ sky130_fd_sc_hd__a31o_1
X_13520_ _05833_ _05834_ _05817_ VGND VGND VPWR VPWR _05836_ sky130_fd_sc_hd__a21o_1
XFILLER_0_137_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10663_ _02717_ _02719_ VGND VGND VPWR VPWR _02721_ sky130_fd_sc_hd__and2_1
X_13451_ _05757_ _05760_ VGND VGND VPWR VPWR _05761_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_36_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12402_ _04616_ VGND VGND VPWR VPWR _00081_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_51_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13382_ _05678_ _05681_ _05684_ VGND VGND VPWR VPWR _05685_ sky130_fd_sc_hd__o21a_1
XFILLER_0_36_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10594_ net132 net370 _02467_ _02469_ VGND VGND VPWR VPWR _02646_ sky130_fd_sc_hd__a31o_4
XFILLER_0_121_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12333_ net680 net688 net250 net241 VGND VGND VPWR VPWR _04541_ sky130_fd_sc_hd__and4_1
XFILLER_0_2_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_3_0_clk sky130_fd_sc_hd__clkbuf_8
X_12264_ _04465_ _04365_ VGND VGND VPWR VPWR _04466_ sky130_fd_sc_hd__nor2_1
XFILLER_0_105_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14003_ _06279_ _06361_ VGND VGND VPWR VPWR _06362_ sky130_fd_sc_hd__xnor2_1
X_11215_ net210 net684 net694 net201 VGND VGND VPWR VPWR _03320_ sky130_fd_sc_hd__a22o_1
X_12195_ _04374_ _04389_ _04390_ VGND VGND VPWR VPWR _04392_ sky130_fd_sc_hd__nand3_1
Xoutput94 net94 VGND VGND VPWR VPWR Q[10] sky130_fd_sc_hd__clkbuf_4
Xoutput83 net83 VGND VGND VPWR VPWR D[17] sky130_fd_sc_hd__buf_2
X_11146_ _03218_ _03244_ VGND VGND VPWR VPWR _03245_ sky130_fd_sc_hd__xnor2_1
X_11077_ _02858_ _02927_ _03169_ VGND VGND VPWR VPWR _03170_ sky130_fd_sc_hd__o21a_1
X_10028_ _02028_ _02029_ _02024_ VGND VGND VPWR VPWR _02031_ sky130_fd_sc_hd__a21o_1
XFILLER_0_53_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14767_ clknet_3_4_0_clk _00068_ net322 VGND VGND VPWR VPWR a_cos\[13\] sky130_fd_sc_hd__dfrtp_1
X_11979_ _04057_ _04060_ _04156_ VGND VGND VPWR VPWR _04157_ sky130_fd_sc_hd__o21a_1
X_13718_ net593 net394 net385 net602 VGND VGND VPWR VPWR _06052_ sky130_fd_sc_hd__a22o_1
XFILLER_0_129_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14698_ _00919_ _07111_ _07114_ _07115_ VGND VGND VPWR VPWR _00108_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_73_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13649_ _05965_ _05976_ VGND VGND VPWR VPWR _05977_ sky130_fd_sc_hd__xor2_1
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout306 net307 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__buf_6
Xfanout317 net318 VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__clkbuf_4
Xfanout339 net340 VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__clkbuf_4
Xfanout328 net55 VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__buf_2
X_09811_ _01809_ _01810_ _01811_ VGND VGND VPWR VPWR _01812_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_10_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09742_ _01740_ _01741_ _01742_ VGND VGND VPWR VPWR _01743_ sky130_fd_sc_hd__a21bo_1
X_09673_ _01671_ _01672_ _01673_ VGND VGND VPWR VPWR _01674_ sky130_fd_sc_hd__a21bo_1
X_08624_ _00655_ _00656_ _00669_ VGND VGND VPWR VPWR _00671_ sky130_fd_sc_hd__nand3_2
X_08555_ _00601_ _00602_ VGND VGND VPWR VPWR _00603_ sky130_fd_sc_hd__xnor2_1
X_07506_ _03660_ _03693_ VGND VGND VPWR VPWR _03704_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_92_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08486_ _00533_ _00534_ VGND VGND VPWR VPWR _00535_ sky130_fd_sc_hd__nor2_1
XFILLER_0_135_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07437_ _02919_ _02940_ VGND VGND VPWR VPWR _02951_ sky130_fd_sc_hd__nor2_1
XFILLER_0_91_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07368_ _02157_ _02190_ VGND VGND VPWR VPWR _02201_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_18_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09107_ _01142_ _01145_ VGND VGND VPWR VPWR _01146_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_18_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09038_ _01076_ _01078_ VGND VGND VPWR VPWR _01079_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_20_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11000_ _03085_ _03086_ VGND VGND VPWR VPWR _03087_ sky130_fd_sc_hd__xor2_1
X_12951_ net528 net365 VGND VGND VPWR VPWR _05211_ sky130_fd_sc_hd__nand2_1
X_11902_ _04070_ _04071_ VGND VGND VPWR VPWR _04072_ sky130_fd_sc_hd__nor2_1
X_12882_ _05134_ _05136_ VGND VGND VPWR VPWR _05137_ sky130_fd_sc_hd__xor2_1
X_11833_ _03987_ _03995_ _03996_ VGND VGND VPWR VPWR _03997_ sky130_fd_sc_hd__nand3_1
X_14621_ net579 net438 _06978_ VGND VGND VPWR VPWR _07032_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_23_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11764_ _03918_ _03921_ VGND VGND VPWR VPWR _03922_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_83_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14552_ _06956_ _06957_ VGND VGND VPWR VPWR _06958_ sky130_fd_sc_hd__and2_1
X_11695_ _03844_ _03845_ _03721_ _03811_ VGND VGND VPWR VPWR _03848_ sky130_fd_sc_hd__o211ai_4
X_10715_ net373 net463 net455 net447 VGND VGND VPWR VPWR _02778_ sky130_fd_sc_hd__and4_1
X_13503_ _05745_ _05753_ _05752_ VGND VGND VPWR VPWR _05817_ sky130_fd_sc_hd__a21o_1
X_14483_ _06796_ _06800_ _06882_ VGND VGND VPWR VPWR _06883_ sky130_fd_sc_hd__nor3_1
XFILLER_0_138_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10646_ _02686_ _02687_ _02702_ VGND VGND VPWR VPWR _02703_ sky130_fd_sc_hd__a21o_1
X_13434_ _05739_ _05740_ _05720_ _05722_ VGND VGND VPWR VPWR _05742_ sky130_fd_sc_hd__a211o_1
XFILLER_0_141_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer5 _04848_ VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_82_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10577_ net271 net373 net336 net480 VGND VGND VPWR VPWR _02628_ sky130_fd_sc_hd__and4_1
X_13365_ _05660_ _05661_ _05664_ VGND VGND VPWR VPWR _05667_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_2_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12316_ _04372_ _04427_ _04523_ VGND VGND VPWR VPWR _04524_ sky130_fd_sc_hd__a21o_1
XFILLER_0_11_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13296_ net543 net389 net380 net561 VGND VGND VPWR VPWR _05591_ sky130_fd_sc_hd__a22oi_1
X_12247_ _04432_ _04350_ VGND VGND VPWR VPWR _04448_ sky130_fd_sc_hd__and2b_1
XFILLER_0_48_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12178_ _04279_ _04288_ _04287_ VGND VGND VPWR VPWR _04373_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_48_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11129_ _03224_ _03225_ VGND VGND VPWR VPWR _03226_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_80_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08340_ _00308_ _00238_ VGND VGND VPWR VPWR _00391_ sky130_fd_sc_hd__and2b_1
X_08271_ _00320_ _00321_ VGND VGND VPWR VPWR _00322_ sky130_fd_sc_hd__nor2_1
XFILLER_0_80_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_17_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout136 net138 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__buf_4
Xfanout147 net148 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__buf_2
Xfanout169 net173 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__buf_4
Xfanout158 net159 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__clkbuf_4
X_07986_ _07278_ _07279_ _07219_ VGND VGND VPWR VPWR _07281_ sky130_fd_sc_hd__a21o_1
XFILLER_0_38_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09725_ net725 net358 net348 net733 VGND VGND VPWR VPWR _01726_ sky130_fd_sc_hd__a22oi_1
X_09656_ _01620_ _01621_ _01654_ _01655_ VGND VGND VPWR VPWR _01657_ sky130_fd_sc_hd__a22o_1
X_08607_ _00598_ _00605_ VGND VGND VPWR VPWR _00654_ sky130_fd_sc_hd__and2_1
X_09587_ _01585_ _01586_ _01531_ _01524_ VGND VGND VPWR VPWR _01588_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_49_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08538_ _00584_ _00585_ VGND VGND VPWR VPWR _00586_ sky130_fd_sc_hd__nor2_1
X_08469_ net153 net299 net617 net625 VGND VGND VPWR VPWR _00518_ sky130_fd_sc_hd__nand4_2
XFILLER_0_92_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10500_ _02540_ _02541_ _02542_ VGND VGND VPWR VPWR _02544_ sky130_fd_sc_hd__a21o_1
XFILLER_0_9_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11480_ net148 net722 net731 net295 VGND VGND VPWR VPWR _03611_ sky130_fd_sc_hd__a22o_1
XFILLER_0_92_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10431_ net132 net393 net384 VGND VGND VPWR VPWR _02469_ sky130_fd_sc_hd__and3_1
XFILLER_0_131_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10362_ _02392_ _02393_ VGND VGND VPWR VPWR _02394_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13150_ _05427_ _05428_ _05354_ _05359_ VGND VGND VPWR VPWR _05430_ sky130_fd_sc_hd__o211ai_1
X_12101_ _04279_ _04287_ _04288_ VGND VGND VPWR VPWR _04289_ sky130_fd_sc_hd__and3_1
X_10293_ _02224_ _02225_ _02223_ VGND VGND VPWR VPWR _02318_ sky130_fd_sc_hd__a21o_1
X_13081_ _05353_ VGND VGND VPWR VPWR _05354_ sky130_fd_sc_hd__inv_2
X_12032_ _04211_ _04212_ _04208_ VGND VGND VPWR VPWR _04214_ sky130_fd_sc_hd__a21oi_1
Xfanout681 net17 VGND VGND VPWR VPWR net681 sky130_fd_sc_hd__clkbuf_4
Xfanout670 net672 VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__clkbuf_4
Xfanout692 net698 VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__clkbuf_4
X_13983_ _02470_ _06338_ _06339_ net577 VGND VGND VPWR VPWR _06340_ sky130_fd_sc_hd__or4b_2
X_12934_ _05189_ _05190_ _05191_ VGND VGND VPWR VPWR _05192_ sky130_fd_sc_hd__nand3_1
XFILLER_0_87_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12865_ _05116_ _05117_ VGND VGND VPWR VPWR _05119_ sky130_fd_sc_hd__nor2_1
X_11816_ _03874_ _03978_ VGND VGND VPWR VPWR _03979_ sky130_fd_sc_hd__xor2_1
X_12796_ _05034_ _05031_ VGND VGND VPWR VPWR _05044_ sky130_fd_sc_hd__or2b_1
X_14604_ _06991_ _07013_ VGND VGND VPWR VPWR _07014_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_141_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11747_ _03900_ _03902_ _03881_ _03882_ VGND VGND VPWR VPWR _03904_ sky130_fd_sc_hd__a211o_1
XFILLER_0_95_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14535_ _06855_ _06866_ _06938_ VGND VGND VPWR VPWR _06940_ sky130_fd_sc_hd__a21o_1
XFILLER_0_126_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11678_ _03824_ _03828_ VGND VGND VPWR VPWR _03829_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_83_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14466_ _06860_ _06864_ VGND VGND VPWR VPWR _06865_ sky130_fd_sc_hd__xor2_1
XFILLER_0_36_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10629_ _02631_ _02632_ VGND VGND VPWR VPWR _02684_ sky130_fd_sc_hd__and2_1
XFILLER_0_12_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13417_ _05382_ _05389_ VGND VGND VPWR VPWR _05724_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14397_ _06788_ _06789_ VGND VGND VPWR VPWR _06790_ sky130_fd_sc_hd__nand2_4
XFILLER_0_59_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13348_ _05643_ _05645_ _05639_ VGND VGND VPWR VPWR _05648_ sky130_fd_sc_hd__a21o_1
XFILLER_0_122_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13279_ _05560_ _05564_ VGND VGND VPWR VPWR _05572_ sky130_fd_sc_hd__and2_1
X_07840_ _03715_ _03781_ VGND VGND VPWR VPWR _07136_ sky130_fd_sc_hd__and2_1
XFILLER_0_75_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07771_ net753 _06581_ VGND VGND VPWR VPWR _06592_ sky130_fd_sc_hd__nor2_1
XFILLER_0_79_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09510_ net709 net331 net476 net717 VGND VGND VPWR VPWR _01511_ sky130_fd_sc_hd__a22oi_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09441_ net691 net700 net359 net347 VGND VGND VPWR VPWR _01442_ sky130_fd_sc_hd__and4_1
X_09372_ net647 net488 net410 net664 VGND VGND VPWR VPWR _01373_ sky130_fd_sc_hd__a22o_1
XFILLER_0_136_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08323_ _00290_ _00291_ _00294_ _00370_ VGND VGND VPWR VPWR _00374_ sky130_fd_sc_hd__a31o_1
XFILLER_0_87_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08254_ _00255_ _00305_ VGND VGND VPWR VPWR _00306_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08185_ _00237_ VGND VGND VPWR VPWR _00003_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07969_ _07173_ _07175_ _07174_ VGND VGND VPWR VPWR _07264_ sky130_fd_sc_hd__o21bai_1
X_09708_ _01698_ _01707_ _01708_ _01471_ VGND VGND VPWR VPWR _01709_ sky130_fd_sc_hd__a211o_1
XFILLER_0_69_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10980_ _02928_ _03064_ VGND VGND VPWR VPWR _03065_ sky130_fd_sc_hd__xnor2_1
X_09639_ net184 net270 net490 net411 VGND VGND VPWR VPWR _01640_ sky130_fd_sc_hd__and4_1
X_12650_ _04788_ _04802_ _04805_ VGND VGND VPWR VPWR _04886_ sky130_fd_sc_hd__o21bai_4
XFILLER_0_139_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11601_ net705 net150 net797 net713 VGND VGND VPWR VPWR _03744_ sky130_fd_sc_hd__and4_1
XFILLER_0_93_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12581_ _04807_ _04810_ VGND VGND VPWR VPWR _04811_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14320_ _06705_ _06706_ VGND VGND VPWR VPWR _06707_ sky130_fd_sc_hd__and2b_1
XFILLER_0_37_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11532_ _03592_ _03598_ VGND VGND VPWR VPWR _03668_ sky130_fd_sc_hd__or2b_1
XFILLER_0_111_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11463_ _03356_ _03358_ _03357_ VGND VGND VPWR VPWR _03592_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_108_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14251_ _06621_ _06622_ VGND VGND VPWR VPWR _06631_ sky130_fd_sc_hd__and2b_1
XFILLER_0_123_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10414_ _02447_ _02448_ _02432_ VGND VGND VPWR VPWR _02450_ sky130_fd_sc_hd__a21o_1
XFILLER_0_21_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13202_ net527 net535 net388 net379 VGND VGND VPWR VPWR _05487_ sky130_fd_sc_hd__and4_1
X_14182_ _06523_ _06515_ VGND VGND VPWR VPWR _06556_ sky130_fd_sc_hd__or2b_1
X_11394_ _03508_ _03514_ _03515_ VGND VGND VPWR VPWR _03516_ sky130_fd_sc_hd__and3_2
XFILLER_0_60_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13133_ _05409_ _05410_ VGND VGND VPWR VPWR _05411_ sky130_fd_sc_hd__nor2_1
X_10345_ _02370_ _02371_ _02373_ VGND VGND VPWR VPWR _02376_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10276_ _02211_ _02214_ _02210_ VGND VGND VPWR VPWR _02301_ sky130_fd_sc_hd__o21ba_1
X_13064_ net564 net468 VGND VGND VPWR VPWR _05335_ sky130_fd_sc_hd__nand2_1
X_12015_ net679 net294 VGND VGND VPWR VPWR _04196_ sky130_fd_sc_hd__and2_1
XFILLER_0_45_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13966_ _06319_ _06321_ VGND VGND VPWR VPWR _06322_ sky130_fd_sc_hd__nand2_1
X_12917_ _05157_ _05174_ VGND VGND VPWR VPWR _05175_ sky130_fd_sc_hd__xnor2_1
X_13897_ _06245_ _06246_ VGND VGND VPWR VPWR _06247_ sky130_fd_sc_hd__and2_1
X_12848_ net259 net137 _05049_ VGND VGND VPWR VPWR _05100_ sky130_fd_sc_hd__a21o_1
XFILLER_0_69_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12779_ _04958_ _05024_ VGND VGND VPWR VPWR _05026_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14518_ _06903_ _06905_ VGND VGND VPWR VPWR _06921_ sky130_fd_sc_hd__or2b_1
XFILLER_0_142_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14449_ _06845_ _06846_ _06773_ _06774_ VGND VGND VPWR VPWR _06847_ sky130_fd_sc_hd__a211o_1
XFILLER_0_114_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09990_ _01986_ _01987_ _01988_ VGND VGND VPWR VPWR _01990_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08941_ _00938_ _00962_ VGND VGND VPWR VPWR _00983_ sky130_fd_sc_hd__or2b_1
X_08872_ _00913_ _00915_ VGND VGND VPWR VPWR _00916_ sky130_fd_sc_hd__xnor2_1
X_07823_ _07116_ _07117_ _07118_ VGND VGND VPWR VPWR _07119_ sky130_fd_sc_hd__nand3_1
X_07754_ net304 net538 net547 net225 VGND VGND VPWR VPWR _06407_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_79_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07685_ _05578_ _05633_ _05644_ VGND VGND VPWR VPWR _05655_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_79_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09424_ net460 net488 net410 net552 VGND VGND VPWR VPWR _01425_ sky130_fd_sc_hd__a22o_1
XFILLER_0_59_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09355_ _01354_ _01355_ _01358_ VGND VGND VPWR VPWR _01360_ sky130_fd_sc_hd__o21a_1
XFILLER_0_142_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08306_ net181 net171 net609 net614 VGND VGND VPWR VPWR _00357_ sky130_fd_sc_hd__nand4_1
XFILLER_0_74_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09286_ _01298_ _01299_ VGND VGND VPWR VPWR _01300_ sky130_fd_sc_hd__nand2_1
XFILLER_0_105_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08237_ net196 net609 VGND VGND VPWR VPWR _00289_ sky130_fd_sc_hd__and2_1
XFILLER_0_74_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08168_ _00218_ _00219_ _00162_ _00163_ VGND VGND VPWR VPWR _00221_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_43_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08099_ _00150_ _00151_ VGND VGND VPWR VPWR _00152_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10130_ _02123_ _02140_ VGND VGND VPWR VPWR _02141_ sky130_fd_sc_hd__xnor2_1
X_10061_ net665 net344 net332 net674 VGND VGND VPWR VPWR _02066_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_98_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13820_ _06161_ _06162_ VGND VGND VPWR VPWR _06163_ sky130_fd_sc_hd__xor2_2
XFILLER_0_97_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10963_ _02758_ _02760_ _02914_ _03044_ VGND VGND VPWR VPWR _03047_ sky130_fd_sc_hd__a211o_1
XFILLER_0_58_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13751_ _05989_ _05893_ _06086_ _06087_ VGND VGND VPWR VPWR _06088_ sky130_fd_sc_hd__a31o_1
X_12702_ _04861_ _04879_ VGND VGND VPWR VPWR _04942_ sky130_fd_sc_hd__or2b_1
XFILLER_0_85_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10894_ _02950_ _02971_ VGND VGND VPWR VPWR _02972_ sky130_fd_sc_hd__xor2_1
XFILLER_0_38_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13682_ _06009_ _06010_ VGND VGND VPWR VPWR _06012_ sky130_fd_sc_hd__nand2_1
X_12633_ _04864_ _04865_ _04866_ VGND VGND VPWR VPWR _04867_ sky130_fd_sc_hd__o21a_1
XFILLER_0_122_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12564_ net465 net260 VGND VGND VPWR VPWR _04792_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11515_ _03632_ _03647_ _03648_ VGND VGND VPWR VPWR _03650_ sky130_fd_sc_hd__nand3_4
XFILLER_0_80_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14303_ _06685_ _06686_ VGND VGND VPWR VPWR _06688_ sky130_fd_sc_hd__and2_1
XFILLER_0_25_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12495_ _04715_ _04716_ VGND VGND VPWR VPWR _04718_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_81_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14234_ _06597_ _06612_ VGND VGND VPWR VPWR _06613_ sky130_fd_sc_hd__xnor2_1
X_11446_ net221 net651 VGND VGND VPWR VPWR _03574_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11377_ _03491_ _03493_ _03497_ VGND VGND VPWR VPWR _03498_ sky130_fd_sc_hd__a21o_1
X_14165_ _06463_ _06395_ _06536_ _06537_ VGND VGND VPWR VPWR _06539_ sky130_fd_sc_hd__a211oi_4
X_10328_ _02351_ _02355_ _02356_ VGND VGND VPWR VPWR _02357_ sky130_fd_sc_hd__nand3_1
X_14096_ _06392_ _06377_ VGND VGND VPWR VPWR _06463_ sky130_fd_sc_hd__or2b_1
X_13116_ _05379_ _05381_ _05390_ VGND VGND VPWR VPWR _05393_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_21_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13047_ _05249_ _05251_ _05250_ VGND VGND VPWR VPWR _05317_ sky130_fd_sc_hd__o21ba_1
X_10259_ _02275_ _02276_ _02280_ VGND VGND VPWR VPWR _02282_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_88_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13949_ _06221_ _06229_ _06228_ VGND VGND VPWR VPWR _06303_ sky130_fd_sc_hd__a21bo_1
X_07470_ net310 net606 net613 net232 VGND VGND VPWR VPWR _03308_ sky130_fd_sc_hd__a22o_1
XFILLER_0_118_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09140_ _01172_ _01175_ VGND VGND VPWR VPWR _01176_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_57_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09071_ _01099_ _01110_ VGND VGND VPWR VPWR _01111_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08022_ _07314_ _07315_ VGND VGND VPWR VPWR _07316_ sky130_fd_sc_hd__nor2_1
XFILLER_0_141_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09973_ _01970_ _01971_ _01969_ VGND VGND VPWR VPWR _01973_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_40_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08924_ _00888_ _00904_ VGND VGND VPWR VPWR _00967_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08855_ _00896_ _00898_ VGND VGND VPWR VPWR _00899_ sky130_fd_sc_hd__xor2_1
XFILLER_0_137_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07806_ _06831_ _06918_ _06950_ _06961_ VGND VGND VPWR VPWR _06972_ sky130_fd_sc_hd__a31o_1
X_08786_ _00769_ _00829_ _00830_ VGND VGND VPWR VPWR _00831_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07737_ _06037_ _06178_ _06168_ VGND VGND VPWR VPWR _06222_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07668_ net758 _05435_ _05446_ _05457_ VGND VGND VPWR VPWR _05468_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_9_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07599_ _04228_ _04217_ _04206_ VGND VGND VPWR VPWR _04717_ sky130_fd_sc_hd__o21ai_1
X_09407_ _01406_ _01407_ VGND VGND VPWR VPWR _01408_ sky130_fd_sc_hd__nor2_1
X_09338_ _01335_ _01342_ _01343_ VGND VGND VPWR VPWR _01345_ sky130_fd_sc_hd__o21a_1
XFILLER_0_124_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11300_ net194 net730 VGND VGND VPWR VPWR _03413_ sky130_fd_sc_hd__nand2_1
XFILLER_0_90_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09269_ state net104 _01284_ _01285_ VGND VGND VPWR VPWR _00039_ sky130_fd_sc_hd__o22a_1
X_12280_ _04381_ _04383_ _04382_ VGND VGND VPWR VPWR _04484_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_121_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11231_ _03328_ _03336_ VGND VGND VPWR VPWR _03337_ sky130_fd_sc_hd__xnor2_1
X_11162_ net175 net729 net737 net165 VGND VGND VPWR VPWR _03261_ sky130_fd_sc_hd__a22oi_1
X_10113_ _01932_ _01933_ _01935_ VGND VGND VPWR VPWR _02122_ sky130_fd_sc_hd__and3_1
X_11093_ _03185_ _03186_ VGND VGND VPWR VPWR _03187_ sky130_fd_sc_hd__nor2_1
Xhold50 net111 VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__dlygate4sd3_1
X_10044_ _02038_ _02045_ _02046_ VGND VGND VPWR VPWR _02047_ sky130_fd_sc_hd__nand3_1
X_13803_ _06142_ _06143_ VGND VGND VPWR VPWR _06144_ sky130_fd_sc_hd__nor2_1
X_11995_ _04072_ _04073_ _04071_ VGND VGND VPWR VPWR _04174_ sky130_fd_sc_hd__a21o_1
XFILLER_0_98_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14783_ clknet_3_6_0_clk _00084_ net320 VGND VGND VPWR VPWR a_sin\[11\] sky130_fd_sc_hd__dfrtp_1
X_10946_ _03010_ _03011_ _03028_ VGND VGND VPWR VPWR _03029_ sky130_fd_sc_hd__nand3_1
X_13734_ _05929_ _05931_ _06067_ _06068_ VGND VGND VPWR VPWR _06069_ sky130_fd_sc_hd__a211o_1
X_10877_ _02860_ _02863_ _02861_ VGND VGND VPWR VPWR _02954_ sky130_fd_sc_hd__o21ba_1
X_13665_ _05964_ _05977_ VGND VGND VPWR VPWR _05994_ sky130_fd_sc_hd__nand2_1
X_12616_ _04702_ _04777_ VGND VGND VPWR VPWR _04850_ sky130_fd_sc_hd__nor2_1
XFILLER_0_39_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13596_ net578 net489 net415 VGND VGND VPWR VPWR _05919_ sky130_fd_sc_hd__a21oi_1
X_12547_ _04705_ _04707_ _04773_ _04774_ VGND VGND VPWR VPWR _04775_ sky130_fd_sc_hd__a211o_1
XANTENNA_3 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_12478_ _04697_ _04699_ VGND VGND VPWR VPWR _04700_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11429_ _03552_ _03553_ _03554_ VGND VGND VPWR VPWR _03555_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_1_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14217_ _06591_ _06593_ _06594_ _06531_ VGND VGND VPWR VPWR _06595_ sky130_fd_sc_hd__o211a_1
XFILLER_0_6_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14148_ net585 _06518_ _06519_ VGND VGND VPWR VPWR _06520_ sky130_fd_sc_hd__a21oi_1
X_14079_ _06323_ _06350_ _06349_ VGND VGND VPWR VPWR _06445_ sky130_fd_sc_hd__o21ba_1
X_08640_ _00685_ _00686_ VGND VGND VPWR VPWR _00687_ sky130_fd_sc_hd__or2_1
XFILLER_0_83_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer15 _04734_ VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__buf_1
Xrebuffer26 _05358_ VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__buf_1
Xrebuffer37 net506 VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__dlygate4sd1_1
X_08571_ net161 net599 VGND VGND VPWR VPWR _00619_ sky130_fd_sc_hd__nand2_1
XFILLER_0_88_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07522_ _03847_ _03858_ _02886_ _03243_ VGND VGND VPWR VPWR _03879_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_16_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07453_ _03103_ _03113_ VGND VGND VPWR VPWR _03124_ sky130_fd_sc_hd__and2b_1
XFILLER_0_8_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07384_ _02299_ _02309_ _02364_ VGND VGND VPWR VPWR _02375_ sky130_fd_sc_hd__nand3_2
X_09123_ _01080_ _01128_ _01161_ _01159_ VGND VGND VPWR VPWR _01162_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_9_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09054_ _00862_ _01048_ _01092_ VGND VGND VPWR VPWR _01094_ sky130_fd_sc_hd__o21a_1
XFILLER_0_142_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08005_ _07297_ _07298_ VGND VGND VPWR VPWR _07299_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09956_ _01953_ _01954_ _01952_ VGND VGND VPWR VPWR _01956_ sky130_fd_sc_hd__o21ai_1
X_08907_ _00948_ _00949_ VGND VGND VPWR VPWR _00950_ sky130_fd_sc_hd__and2_1
X_09887_ _01882_ _01883_ _01867_ VGND VGND VPWR VPWR _01888_ sky130_fd_sc_hd__a21o_1
X_08838_ _00874_ _00881_ VGND VGND VPWR VPWR _00882_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_142_Right_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08769_ _00800_ _00813_ VGND VGND VPWR VPWR _00814_ sky130_fd_sc_hd__xor2_1
X_11780_ _03842_ _03905_ _03938_ _03939_ VGND VGND VPWR VPWR _03940_ sky130_fd_sc_hd__a211o_1
X_10800_ _02868_ _02869_ VGND VGND VPWR VPWR _02870_ sky130_fd_sc_hd__xor2_1
XFILLER_0_137_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10731_ _02640_ _02642_ VGND VGND VPWR VPWR _02795_ sky130_fd_sc_hd__nor2_1
XFILLER_0_138_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13450_ _05758_ _05759_ VGND VGND VPWR VPWR _05760_ sky130_fd_sc_hd__nor2_1
X_12401_ a_sin\[8\] _04615_ _04160_ VGND VGND VPWR VPWR _04616_ sky130_fd_sc_hd__mux2_1
X_10662_ _02717_ _02719_ VGND VGND VPWR VPWR _02720_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13381_ _05682_ _05683_ VGND VGND VPWR VPWR _05684_ sky130_fd_sc_hd__xnor2_1
X_10593_ net272 net344 _02564_ _02563_ VGND VGND VPWR VPWR _02645_ sky130_fd_sc_hd__a31o_1
X_12332_ net680 net250 net241 net688 VGND VGND VPWR VPWR _04540_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_133_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12263_ _04355_ _04361_ VGND VGND VPWR VPWR _04465_ sky130_fd_sc_hd__and2b_1
XFILLER_0_105_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11214_ net210 net201 net684 VGND VGND VPWR VPWR _03318_ sky130_fd_sc_hd__and3_1
X_14002_ _06357_ _06360_ VGND VGND VPWR VPWR _06361_ sky130_fd_sc_hd__xnor2_1
X_12194_ _04387_ _04388_ _04379_ VGND VGND VPWR VPWR _04390_ sky130_fd_sc_hd__a21o_1
XFILLER_0_121_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput84 net84 VGND VGND VPWR VPWR D[1] sky130_fd_sc_hd__clkbuf_4
X_11145_ _03219_ _03242_ VGND VGND VPWR VPWR _03244_ sky130_fd_sc_hd__xnor2_1
Xoutput95 net95 VGND VGND VPWR VPWR Q[11] sky130_fd_sc_hd__clkbuf_4
X_11076_ _03063_ _03168_ VGND VGND VPWR VPWR _03169_ sky130_fd_sc_hd__xor2_1
X_10027_ _02024_ _02028_ _02029_ VGND VGND VPWR VPWR _02030_ sky130_fd_sc_hd__and3_1
X_11978_ _04154_ _04155_ VGND VGND VPWR VPWR _04156_ sky130_fd_sc_hd__and2b_1
X_14766_ clknet_3_4_0_clk _00067_ net320 VGND VGND VPWR VPWR a_cos\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_85_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10929_ _02928_ _02944_ VGND VGND VPWR VPWR _03010_ sky130_fd_sc_hd__or2_1
X_13717_ net593 net602 net394 VGND VGND VPWR VPWR _06051_ sky130_fd_sc_hd__and3_1
XFILLER_0_73_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14697_ net782 _07291_ VGND VGND VPWR VPWR _07115_ sky130_fd_sc_hd__nand2_1
XFILLER_0_129_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13648_ _05974_ _05975_ VGND VGND VPWR VPWR _05976_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13579_ _05845_ _05846_ VGND VGND VPWR VPWR _05900_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout307 net313 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__buf_8
Xfanout318 net328 VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__clkbuf_4
X_09810_ net708 net716 net486 net408 VGND VGND VPWR VPWR _01811_ sky130_fd_sc_hd__nand4_2
Xfanout329 net337 VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__clkbuf_4
X_09741_ net682 net690 net485 net407 VGND VGND VPWR VPWR _01742_ sky130_fd_sc_hd__nand4_1
XFILLER_0_94_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09672_ net673 net682 net486 net408 VGND VGND VPWR VPWR _01673_ sky130_fd_sc_hd__nand4_1
XFILLER_0_96_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08623_ _00655_ _00656_ _00669_ VGND VGND VPWR VPWR _00670_ sky130_fd_sc_hd__a21o_1
X_08554_ net292 net625 VGND VGND VPWR VPWR _00602_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07505_ _03671_ _03682_ VGND VGND VPWR VPWR _03693_ sky130_fd_sc_hd__nor2_1
XFILLER_0_134_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08485_ _00456_ _00457_ _00532_ VGND VGND VPWR VPWR _00534_ sky130_fd_sc_hd__and3_1
XFILLER_0_77_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_99_Left_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07436_ _02919_ _02929_ net288 net662 VGND VGND VPWR VPWR _02940_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_64_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07367_ _02168_ _02179_ VGND VGND VPWR VPWR _02190_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09106_ _01143_ _01144_ VGND VGND VPWR VPWR _01145_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09037_ _01026_ _01077_ VGND VGND VPWR VPWR _01078_ sky130_fd_sc_hd__nand2_1
XFILLER_0_142_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09939_ _01931_ _01937_ VGND VGND VPWR VPWR _01939_ sky130_fd_sc_hd__or2_1
X_12950_ _05203_ _05205_ _05209_ VGND VGND VPWR VPWR _05210_ sky130_fd_sc_hd__a21o_1
X_11901_ net723 net732 net248 net240 VGND VGND VPWR VPWR _04071_ sky130_fd_sc_hd__and4_1
X_12881_ _05056_ _05057_ _05135_ VGND VGND VPWR VPWR _05136_ sky130_fd_sc_hd__o21a_1
X_11832_ _03992_ _03993_ _03994_ VGND VGND VPWR VPWR _03996_ sky130_fd_sc_hd__a21o_1
X_14620_ _06930_ _06981_ _06922_ VGND VGND VPWR VPWR _07031_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_67_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14551_ _06891_ _06955_ VGND VGND VPWR VPWR _06957_ sky130_fd_sc_hd__or2_1
X_11763_ net213 _03919_ _03920_ VGND VGND VPWR VPWR _03921_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_67_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11694_ _03721_ _03811_ _03844_ _03845_ VGND VGND VPWR VPWR _03846_ sky130_fd_sc_hd__a211o_2
XFILLER_0_83_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10714_ net373 net455 net447 net463 VGND VGND VPWR VPWR _02776_ sky130_fd_sc_hd__a22oi_2
X_14482_ _06880_ _06881_ VGND VGND VPWR VPWR _06882_ sky130_fd_sc_hd__xor2_1
X_13502_ _05729_ _05737_ VGND VGND VPWR VPWR _05816_ sky130_fd_sc_hd__and2_1
XFILLER_0_82_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10645_ _02693_ _02700_ VGND VGND VPWR VPWR _02702_ sky130_fd_sc_hd__xnor2_1
X_13433_ _05720_ _05722_ _05739_ _05740_ VGND VGND VPWR VPWR _05741_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_130_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13364_ _05660_ _05661_ _05664_ VGND VGND VPWR VPWR _05665_ sky130_fd_sc_hd__and3_1
X_12315_ _04426_ _04423_ VGND VGND VPWR VPWR _04523_ sky130_fd_sc_hd__and2b_1
XFILLER_0_90_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer6 _05885_ VGND VGND VPWR VPWR net751 sky130_fd_sc_hd__clkbuf_1
X_10576_ net272 net336 net480 net373 VGND VGND VPWR VPWR _02627_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_133_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13295_ net543 net561 net389 net380 VGND VGND VPWR VPWR _05590_ sky130_fd_sc_hd__and4_1
XFILLER_0_139_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12246_ _04431_ _04428_ VGND VGND VPWR VPWR _04447_ sky130_fd_sc_hd__and2b_1
X_12177_ _04351_ _04371_ VGND VGND VPWR VPWR _04372_ sky130_fd_sc_hd__xor2_1
X_11128_ _03063_ _03168_ _03055_ VGND VGND VPWR VPWR _03225_ sky130_fd_sc_hd__o21a_1
XFILLER_0_3_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11059_ _03069_ _03094_ _03149_ VGND VGND VPWR VPWR _03151_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_80_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14749_ clknet_3_7_0_clk _00050_ net325 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dfrtp_1
X_08270_ net247 net239 net533 net541 VGND VGND VPWR VPWR _00321_ sky130_fd_sc_hd__and4_1
XFILLER_0_74_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout137 net138 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_10_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout159 net163 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__buf_2
XFILLER_0_129_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout148 net73 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__buf_2
X_07985_ _07219_ _07278_ _07279_ VGND VGND VPWR VPWR _07280_ sky130_fd_sc_hd__nand3_2
X_09724_ net724 net733 net358 net348 VGND VGND VPWR VPWR _01725_ sky130_fd_sc_hd__and4_1
XFILLER_0_69_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09655_ _01620_ _01621_ _01654_ _01655_ VGND VGND VPWR VPWR _01656_ sky130_fd_sc_hd__nand4_4
X_08606_ _00603_ _00604_ VGND VGND VPWR VPWR _00653_ sky130_fd_sc_hd__and2_1
Xclkbuf_3_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_2_0_clk sky130_fd_sc_hd__clkbuf_8
X_09586_ _01531_ _01524_ _01585_ _01586_ VGND VGND VPWR VPWR _01587_ sky130_fd_sc_hd__a211o_1
XFILLER_0_49_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08537_ _00501_ _00500_ VGND VGND VPWR VPWR _00585_ sky130_fd_sc_hd__and2b_1
XFILLER_0_77_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08468_ net153 net617 net625 net299 VGND VGND VPWR VPWR _00517_ sky130_fd_sc_hd__a22o_1
XFILLER_0_77_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_07419_ _02723_ _02734_ _02571_ VGND VGND VPWR VPWR _02756_ sky130_fd_sc_hd__a21o_1
XFILLER_0_92_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08399_ net181 net171 net599 net608 VGND VGND VPWR VPWR _00449_ sky130_fd_sc_hd__nand4_1
X_10430_ net132 _02466_ _02467_ net370 net139 VGND VGND VPWR VPWR _02468_ sky130_fd_sc_hd__a32o_1
XFILLER_0_116_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10361_ _02295_ _02218_ VGND VGND VPWR VPWR _02393_ sky130_fd_sc_hd__and2b_1
XFILLER_0_131_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12100_ _04284_ _04285_ _04286_ VGND VGND VPWR VPWR _04288_ sky130_fd_sc_hd__a21o_1
X_10292_ _02311_ _02316_ VGND VGND VPWR VPWR _02317_ sky130_fd_sc_hd__xnor2_1
X_13080_ _05271_ net117 _05351_ _05352_ VGND VGND VPWR VPWR _05353_ sky130_fd_sc_hd__o211a_1
X_12031_ _04208_ _04211_ _04212_ VGND VGND VPWR VPWR _04213_ sky130_fd_sc_hd__and3_1
XFILLER_0_103_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout660 net663 VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__buf_2
Xfanout671 net672 VGND VGND VPWR VPWR net671 sky130_fd_sc_hd__clkbuf_2
Xfanout693 net698 VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__clkbuf_2
Xfanout682 net689 VGND VGND VPWR VPWR net682 sky130_fd_sc_hd__clkbuf_4
X_13982_ net585 net369 VGND VGND VPWR VPWR _06339_ sky130_fd_sc_hd__nand2_1
X_12933_ net629 net484 net406 net638 VGND VGND VPWR VPWR _05191_ sky130_fd_sc_hd__a22o_1
X_12864_ net191 net253 net146 net245 VGND VGND VPWR VPWR _05117_ sky130_fd_sc_hd__and4_1
X_11815_ _03963_ _03976_ VGND VGND VPWR VPWR _03978_ sky130_fd_sc_hd__xnor2_1
X_12795_ _05042_ VGND VGND VPWR VPWR _00087_ sky130_fd_sc_hd__clkbuf_1
X_14603_ _06992_ _07012_ VGND VGND VPWR VPWR _07013_ sky130_fd_sc_hd__xor2_1
X_11746_ _03881_ _03882_ _03900_ _03902_ VGND VGND VPWR VPWR _03903_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14534_ _06724_ _06793_ _06865_ VGND VGND VPWR VPWR _06938_ sky130_fd_sc_hd__o21a_1
XFILLER_0_138_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11677_ _03826_ _03827_ VGND VGND VPWR VPWR _03828_ sky130_fd_sc_hd__nor2_1
X_14465_ net470 _06861_ _06862_ VGND VGND VPWR VPWR _06864_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_141_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10628_ _02616_ _02664_ _02665_ VGND VGND VPWR VPWR _02683_ sky130_fd_sc_hd__nor3_1
X_13416_ _05383_ _05388_ VGND VGND VPWR VPWR _05723_ sky130_fd_sc_hd__or2b_1
XFILLER_0_3_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14396_ _06512_ _06715_ VGND VGND VPWR VPWR _06789_ sky130_fd_sc_hd__nand2_2
XFILLER_0_36_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10559_ _02606_ _02607_ VGND VGND VPWR VPWR _02608_ sky130_fd_sc_hd__xor2_1
XFILLER_0_3_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13347_ _05638_ _05646_ VGND VGND VPWR VPWR _05647_ sky130_fd_sc_hd__and2b_1
XFILLER_0_122_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13278_ _05561_ _05563_ VGND VGND VPWR VPWR _05571_ sky130_fd_sc_hd__and2_1
XFILLER_0_121_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12229_ _04327_ _04329_ VGND VGND VPWR VPWR _04429_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07770_ _06353_ _06505_ _06516_ net761 VGND VGND VPWR VPWR _06581_ sky130_fd_sc_hd__o22a_1
XFILLER_0_75_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09440_ net709 net339 VGND VGND VPWR VPWR _01441_ sky130_fd_sc_hd__nand2_1
XFILLER_0_115_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09371_ net673 net401 VGND VGND VPWR VPWR _01372_ sky130_fd_sc_hd__and2_1
XFILLER_0_19_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08322_ _00368_ _00369_ _00371_ VGND VGND VPWR VPWR _00373_ sky130_fd_sc_hd__a21o_1
X_08253_ _00303_ _00304_ VGND VGND VPWR VPWR _00305_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_47_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08184_ b_sin\[3\] _00236_ _02027_ VGND VGND VPWR VPWR _00237_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_07968_ _07260_ _07261_ _07259_ VGND VGND VPWR VPWR _07263_ sky130_fd_sc_hd__o21ai_1
X_09707_ _01450_ _01451_ _01470_ VGND VGND VPWR VPWR _01708_ sky130_fd_sc_hd__o21a_1
X_07899_ _07192_ _07193_ _07134_ VGND VGND VPWR VPWR _07195_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_69_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09638_ net371 net402 VGND VGND VPWR VPWR _01639_ sky130_fd_sc_hd__nand2_1
XFILLER_0_139_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09569_ net701 net710 net332 net475 VGND VGND VPWR VPWR _01570_ sky130_fd_sc_hd__and4_1
X_12580_ net798 _04809_ VGND VGND VPWR VPWR _04810_ sky130_fd_sc_hd__xnor2_1
X_11600_ net289 net722 VGND VGND VPWR VPWR _03743_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11531_ _03607_ _03614_ VGND VGND VPWR VPWR _03667_ sky130_fd_sc_hd__or2b_1
XFILLER_0_65_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11462_ _03368_ _03371_ VGND VGND VPWR VPWR _03591_ sky130_fd_sc_hd__and2b_1
XFILLER_0_123_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14250_ _06630_ VGND VGND VPWR VPWR _00100_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11393_ _03504_ _03507_ _03505_ VGND VGND VPWR VPWR _03515_ sky130_fd_sc_hd__a21o_1
X_10413_ _02432_ _02447_ _02448_ VGND VGND VPWR VPWR _02449_ sky130_fd_sc_hd__nand3_1
X_14181_ _06517_ _06522_ VGND VGND VPWR VPWR _06555_ sky130_fd_sc_hd__nand2_1
X_13201_ _05476_ _05477_ _05471_ VGND VGND VPWR VPWR _05486_ sky130_fd_sc_hd__a21o_1
X_10344_ _02370_ _02371_ _02373_ VGND VGND VPWR VPWR _02374_ sky130_fd_sc_hd__nand3_1
X_13132_ net564 net572 net450 net441 VGND VGND VPWR VPWR _05410_ sky130_fd_sc_hd__and4_1
XFILLER_0_33_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_36_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10275_ _02297_ _02298_ VGND VGND VPWR VPWR _02300_ sky130_fd_sc_hd__and2_1
X_13063_ net571 net468 _05287_ _05285_ VGND VGND VPWR VPWR _05334_ sky130_fd_sc_hd__a31o_1
X_12014_ net653 net670 net151 net299 VGND VGND VPWR VPWR _04194_ sky130_fd_sc_hd__nand4_1
Xfanout490 net491 VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_45_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13965_ _06317_ _06318_ _06303_ VGND VGND VPWR VPWR _06321_ sky130_fd_sc_hd__a21o_1
X_12916_ _05164_ _05173_ VGND VGND VPWR VPWR _05174_ sky130_fd_sc_hd__xnor2_1
X_13896_ _06240_ _06241_ _06243_ VGND VGND VPWR VPWR _06246_ sky130_fd_sc_hd__a21o_1
X_12847_ _04998_ _05051_ _04990_ VGND VGND VPWR VPWR _05099_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_96_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12778_ _04958_ _05024_ VGND VGND VPWR VPWR _05025_ sky130_fd_sc_hd__and2_1
XFILLER_0_68_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11729_ net713 net280 net262 net722 VGND VGND VPWR VPWR _03884_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_56_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14517_ _06901_ _06902_ VGND VGND VPWR VPWR _06920_ sky130_fd_sc_hd__or2b_1
XFILLER_0_126_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14448_ _06843_ _06844_ _06767_ _06785_ VGND VGND VPWR VPWR _06846_ sky130_fd_sc_hd__a211o_1
XFILLER_0_36_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_54_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14379_ _06746_ _06747_ _06769_ VGND VGND VPWR VPWR _06771_ sky130_fd_sc_hd__or3_1
XFILLER_0_86_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08940_ _00968_ _00966_ VGND VGND VPWR VPWR _00982_ sky130_fd_sc_hd__or2b_1
XFILLER_0_86_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08871_ _00854_ _00857_ _00914_ VGND VGND VPWR VPWR _00915_ sky130_fd_sc_hd__a21o_1
X_07822_ _04967_ _04956_ _04674_ VGND VGND VPWR VPWR _07118_ sky130_fd_sc_hd__a21o_1
X_07753_ net218 net565 VGND VGND VPWR VPWR _06396_ sky130_fd_sc_hd__nand2_1
X_07684_ _05567_ _05512_ _05523_ VGND VGND VPWR VPWR _05644_ sky130_fd_sc_hd__nand3_1
X_09423_ net460 net552 net488 net410 VGND VGND VPWR VPWR _01424_ sky130_fd_sc_hd__nand4_1
XFILLER_0_137_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09354_ _01354_ _01355_ _01358_ VGND VGND VPWR VPWR _01359_ sky130_fd_sc_hd__nor3_1
XFILLER_0_47_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08305_ net181 net609 net614 net171 VGND VGND VPWR VPWR _00356_ sky130_fd_sc_hd__a22o_1
XFILLER_0_75_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09285_ a_sin\[6\] b_cos\[6\] VGND VGND VPWR VPWR _01299_ sky130_fd_sc_hd__or2b_1
XFILLER_0_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08236_ net214 net204 net597 net588 VGND VGND VPWR VPWR _00288_ sky130_fd_sc_hd__nand4_1
XFILLER_0_105_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08167_ _00162_ _00163_ _00218_ _00219_ VGND VGND VPWR VPWR _00220_ sky130_fd_sc_hd__o211a_1
XFILLER_0_31_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08098_ net575 net236 VGND VGND VPWR VPWR _00151_ sky130_fd_sc_hd__or2b_1
XFILLER_0_30_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10060_ net686 net476 VGND VGND VPWR VPWR _02065_ sky130_fd_sc_hd__nand2_1
XFILLER_0_100_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10962_ _02915_ _03044_ _03045_ _02982_ VGND VGND VPWR VPWR _03046_ sky130_fd_sc_hd__o211a_1
X_13750_ _05897_ _05987_ VGND VGND VPWR VPWR _06087_ sky130_fd_sc_hd__nor2_1
X_12701_ _04939_ _04940_ VGND VGND VPWR VPWR _04941_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10893_ _02953_ _02970_ VGND VGND VPWR VPWR _02971_ sky130_fd_sc_hd__xnor2_1
X_13681_ _06009_ _06010_ VGND VGND VPWR VPWR _06011_ sky130_fd_sc_hd__or2_2
X_12632_ net378 net259 VGND VGND VPWR VPWR _04866_ sky130_fd_sc_hd__nand2_1
XFILLER_0_65_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12563_ _04789_ _04790_ VGND VGND VPWR VPWR _04791_ sky130_fd_sc_hd__nor2_1
XFILLER_0_93_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11514_ _03640_ _03641_ _03646_ VGND VGND VPWR VPWR _03648_ sky130_fd_sc_hd__a21o_1
X_12494_ net558 net260 VGND VGND VPWR VPWR _04716_ sky130_fd_sc_hd__nand2_1
XFILLER_0_108_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14302_ _06685_ _06686_ VGND VGND VPWR VPWR _06687_ sky130_fd_sc_hd__nor2_1
X_11445_ _03348_ _03350_ _03349_ VGND VGND VPWR VPWR _03573_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_135_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14233_ _06609_ _06611_ VGND VGND VPWR VPWR _06612_ sky130_fd_sc_hd__xor2_1
XFILLER_0_22_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11376_ net219 net736 _03494_ _03496_ VGND VGND VPWR VPWR _03497_ sky130_fd_sc_hd__a31o_1
XFILLER_0_104_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14164_ _06534_ _06535_ _06464_ _06465_ VGND VGND VPWR VPWR _06537_ sky130_fd_sc_hd__a211oi_2
X_14095_ _06461_ VGND VGND VPWR VPWR _00098_ sky130_fd_sc_hd__clkbuf_1
X_10327_ net459 net344 _02352_ _02354_ VGND VGND VPWR VPWR _02356_ sky130_fd_sc_hd__nand4_2
X_13115_ _05379_ _05381_ _05390_ VGND VGND VPWR VPWR _05392_ sky130_fd_sc_hd__and3_1
X_13046_ _05261_ _05263_ _05262_ VGND VGND VPWR VPWR _05316_ sky130_fd_sc_hd__o21ba_1
X_10258_ _02275_ _02276_ _02280_ VGND VGND VPWR VPWR _02281_ sky130_fd_sc_hd__and3_1
X_10189_ _02084_ _02102_ _02204_ _02205_ VGND VGND VPWR VPWR _02206_ sky130_fd_sc_hd__o211a_1
X_13948_ _06206_ _06215_ _06214_ VGND VGND VPWR VPWR _06302_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_76_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13879_ net621 net343 _06224_ _06225_ VGND VGND VPWR VPWR _06227_ sky130_fd_sc_hd__nand4_2
XFILLER_0_56_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_62_Left_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09070_ _01108_ _01109_ VGND VGND VPWR VPWR _01110_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08021_ _07312_ _07313_ net263 net540 VGND VGND VPWR VPWR _07315_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_4_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_123_Right_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09972_ _01969_ _01970_ _01971_ VGND VGND VPWR VPWR _01972_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_110_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08923_ _00963_ _00965_ VGND VGND VPWR VPWR _00966_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_71_Left_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08854_ _00831_ _00832_ _00897_ VGND VGND VPWR VPWR _00898_ sky130_fd_sc_hd__a21oi_1
X_07805_ _06646_ _06809_ VGND VGND VPWR VPWR _06961_ sky130_fd_sc_hd__nor2_1
X_08785_ net251 net634 net645 net243 VGND VGND VPWR VPWR _00830_ sky130_fd_sc_hd__a22o_1
X_07736_ _06026_ _06200_ VGND VGND VPWR VPWR _06211_ sky130_fd_sc_hd__nor2_1
X_07667_ _04902_ _04913_ _04934_ VGND VGND VPWR VPWR _05457_ sky130_fd_sc_hd__and3_1
XFILLER_0_48_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_07598_ _04228_ _04206_ _04217_ VGND VGND VPWR VPWR _04706_ sky130_fd_sc_hd__or3_4
XPHY_EDGE_ROW_80_Left_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09406_ net708 net357 net347 net716 VGND VGND VPWR VPWR _01407_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_75_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09337_ _01335_ _01342_ _01343_ VGND VGND VPWR VPWR _01344_ sky130_fd_sc_hd__nor3_1
X_09268_ _01280_ _01283_ _01995_ VGND VGND VPWR VPWR _01285_ sky130_fd_sc_hd__a21o_1
XFILLER_0_132_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08219_ _00262_ _00269_ _00270_ VGND VGND VPWR VPWR _00271_ sky130_fd_sc_hd__nand3_1
XFILLER_0_16_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09199_ a_cos\[11\] b_sin\[11\] VGND VGND VPWR VPWR _01226_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11230_ _03329_ _03335_ VGND VGND VPWR VPWR _03336_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_105_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11161_ net175 net165 net729 net737 VGND VGND VPWR VPWR _03260_ sky130_fd_sc_hd__and4_1
X_10112_ _02120_ VGND VGND VPWR VPWR _02121_ sky130_fd_sc_hd__inv_2
X_11092_ net187 net141 net432 net424 VGND VGND VPWR VPWR _03186_ sky130_fd_sc_hd__and4_1
XFILLER_0_117_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold40 b_cos\[1\] VGND VGND VPWR VPWR net785 sky130_fd_sc_hd__dlygate4sd3_1
X_10043_ _02043_ _02044_ _01985_ _02039_ VGND VGND VPWR VPWR _02046_ sky130_fd_sc_hd__a211o_1
X_13802_ _06140_ _06141_ _06137_ VGND VGND VPWR VPWR _06143_ sky130_fd_sc_hd__a21oi_1
X_11994_ _04166_ _04171_ VGND VGND VPWR VPWR _04172_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_97_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14782_ clknet_3_6_0_clk _00083_ net320 VGND VGND VPWR VPWR a_sin\[10\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_119_Left_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10945_ _03025_ _03026_ VGND VGND VPWR VPWR _03028_ sky130_fd_sc_hd__nand2_1
X_13733_ _06065_ _06066_ _06049_ VGND VGND VPWR VPWR _06068_ sky130_fd_sc_hd__a21oi_1
X_13664_ _05992_ VGND VGND VPWR VPWR _00093_ sky130_fd_sc_hd__clkbuf_1
X_10876_ _02859_ _02925_ _02952_ _02876_ VGND VGND VPWR VPWR _02953_ sky130_fd_sc_hd__a31o_1
X_12615_ _04846_ _04847_ VGND VGND VPWR VPWR _04849_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_66_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13595_ net584 net412 VGND VGND VPWR VPWR _05918_ sky130_fd_sc_hd__nand2_1
X_12546_ _04770_ _04771_ _04667_ _04708_ VGND VGND VPWR VPWR _04774_ sky130_fd_sc_hd__a211oi_2
X_12477_ _04444_ _04618_ _04620_ VGND VGND VPWR VPWR _04699_ sky130_fd_sc_hd__a21o_1
XFILLER_0_41_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_128_Left_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11428_ _03480_ _03519_ _03518_ _03516_ VGND VGND VPWR VPWR _03554_ sky130_fd_sc_hd__a211oi_1
XANTENNA_4 net35 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14216_ _06525_ _06528_ VGND VGND VPWR VPWR _06594_ sky130_fd_sc_hd__or2_1
X_11359_ _03475_ _03476_ _03477_ VGND VGND VPWR VPWR _03478_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_1_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14147_ net577 net361 net351 net585 VGND VGND VPWR VPWR _06519_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14078_ _06421_ _06443_ VGND VGND VPWR VPWR _06444_ sky130_fd_sc_hd__xnor2_1
X_13029_ _05241_ _05243_ _05242_ VGND VGND VPWR VPWR _05297_ sky130_fd_sc_hd__a21bo_1
X_08570_ _00616_ _00617_ VGND VGND VPWR VPWR _00618_ sky130_fd_sc_hd__nor2_1
Xrebuffer27 _06113_ VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__clkbuf_1
Xrebuffer16 _06494_ VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_137_Left_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer38 net804 VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__dlygate4sd1_1
X_07521_ _02886_ _03243_ _03847_ _03858_ VGND VGND VPWR VPWR _03868_ sky130_fd_sc_hd__a211o_4
XFILLER_0_83_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_07452_ net149 net540 net550 net797 VGND VGND VPWR VPWR _03113_ sky130_fd_sc_hd__a22o_1
X_07383_ _02320_ _02353_ VGND VGND VPWR VPWR _02364_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_57_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09122_ _01084_ _01124_ _01126_ VGND VGND VPWR VPWR _01161_ sky130_fd_sc_hd__a21o_1
XFILLER_0_72_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09053_ _00862_ _01048_ _01092_ VGND VGND VPWR VPWR _01093_ sky130_fd_sc_hd__nor3_1
XFILLER_0_44_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08004_ net255 net247 net549 net567 VGND VGND VPWR VPWR _07298_ sky130_fd_sc_hd__and4_1
XFILLER_0_142_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09955_ _01952_ _01953_ _01954_ VGND VGND VPWR VPWR _01955_ sky130_fd_sc_hd__or3_1
X_08906_ _00870_ _00873_ _00947_ VGND VGND VPWR VPWR _00949_ sky130_fd_sc_hd__o21ai_1
X_09886_ _01839_ _01885_ _01886_ VGND VGND VPWR VPWR _01887_ sky130_fd_sc_hd__a21o_1
XFILLER_0_99_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08837_ _00875_ _00880_ VGND VGND VPWR VPWR _00881_ sky130_fd_sc_hd__xnor2_1
X_08768_ _00805_ _00812_ VGND VGND VPWR VPWR _00813_ sky130_fd_sc_hd__xnor2_2
X_08699_ _00737_ _00744_ VGND VGND VPWR VPWR _00745_ sky130_fd_sc_hd__xnor2_1
X_07719_ _05983_ _06015_ VGND VGND VPWR VPWR _06026_ sky130_fd_sc_hd__and2b_1
XFILLER_0_138_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10730_ _02791_ _02792_ _02772_ _02773_ VGND VGND VPWR VPWR _02794_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_95_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10661_ _02644_ _02654_ _02718_ VGND VGND VPWR VPWR _02719_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_118_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12400_ _04613_ _04614_ VGND VGND VPWR VPWR _04615_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_82_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13380_ _05663_ _05662_ VGND VGND VPWR VPWR _05683_ sky130_fd_sc_hd__and2b_1
X_10592_ _02643_ VGND VGND VPWR VPWR _02644_ sky130_fd_sc_hd__clkbuf_2
X_12331_ _04476_ _04477_ VGND VGND VPWR VPWR _04539_ sky130_fd_sc_hd__nor2_1
XFILLER_0_51_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12262_ _04462_ _04463_ VGND VGND VPWR VPWR _04464_ sky130_fd_sc_hd__or2_1
X_11213_ net194 net704 VGND VGND VPWR VPWR _03317_ sky130_fd_sc_hd__nand2_1
XFILLER_0_120_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14001_ _06198_ _06358_ _06359_ VGND VGND VPWR VPWR _06360_ sky130_fd_sc_hd__a21o_1
X_12193_ _04379_ _04387_ _04388_ VGND VGND VPWR VPWR _04389_ sky130_fd_sc_hd__nand3_1
XFILLER_0_120_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput85 net85 VGND VGND VPWR VPWR D[2] sky130_fd_sc_hd__clkbuf_4
X_11144_ _03220_ _03241_ VGND VGND VPWR VPWR _03242_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_101_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput96 net96 VGND VGND VPWR VPWR Q[12] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11075_ _03114_ _03166_ VGND VGND VPWR VPWR _03168_ sky130_fd_sc_hd__or2_1
X_10026_ net648 net352 _02025_ _02026_ VGND VGND VPWR VPWR _02029_ sky130_fd_sc_hd__nand4_1
XFILLER_0_59_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11977_ _04061_ _04049_ _04153_ VGND VGND VPWR VPWR _04155_ sky130_fd_sc_hd__or3_1
XFILLER_0_98_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14765_ clknet_3_4_0_clk _00066_ net320 VGND VGND VPWR VPWR a_cos\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_86_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10928_ _03007_ _03008_ VGND VGND VPWR VPWR _03009_ sky130_fd_sc_hd__and2_1
X_13716_ net611 net368 VGND VGND VPWR VPWR _06050_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14696_ _07024_ _07076_ _07113_ _07110_ VGND VGND VPWR VPWR _07114_ sky130_fd_sc_hd__a211oi_1
X_10859_ _02930_ _02931_ _02932_ VGND VGND VPWR VPWR _02934_ sky130_fd_sc_hd__nor3_1
X_13647_ _05802_ _05803_ _05805_ VGND VGND VPWR VPWR _05975_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_109_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13578_ _05867_ _05868_ _05869_ VGND VGND VPWR VPWR _05899_ sky130_fd_sc_hd__and3_1
X_12529_ net680 net237 VGND VGND VPWR VPWR _04755_ sky130_fd_sc_hd__and2b_1
XFILLER_0_42_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout308 net313 VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__buf_4
XFILLER_0_94_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout319 net321 VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__clkbuf_4
X_09740_ net682 net485 net407 net690 VGND VGND VPWR VPWR _01741_ sky130_fd_sc_hd__a22o_1
.ends
