* NGSPICE file created from park.ext - technology: sky130A

.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
X0 VPWR B a_59_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 X a_59_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.475 pd=2.95 as=0.167 ps=1.39 w=1 l=0.15
X2 VGND B a_145_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_59_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X4 X a_59_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.112 ps=1.04 w=0.65 l=0.15
X5 a_145_75# A a_59_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=0.59
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=0.59
.ends

.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
X0 VPWR A a_304_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X1 a_304_297# B a_220_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND C a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X3 a_220_297# C a_114_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X4 a_32_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_32_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X11 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X13 a_114_297# D a_32_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.26 ps=2.52 w=1 l=0.15
X14 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A a_113_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_113_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.05
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.05
.ends

.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=2.89
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=2.89
.ends

.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 a_81_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.257 ps=1.44 w=0.65 l=0.15
X1 a_299_297# B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_299_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 a_384_47# A1 a_81_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_197_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0798 pd=0.8 as=0.0609 ps=0.71 w=0.42 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.312 ps=1.68 w=1 l=0.15
X3 a_303_47# C a_197_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0798 ps=0.8 w=0.42 l=0.15
X4 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.68 as=0.0588 ps=0.7 w=0.42 l=0.15
X6 VGND D a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.196 pd=1.33 as=0.0693 ps=0.75 w=0.42 l=0.15
X7 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X8 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.196 ps=1.33 w=0.65 l=0.15
X9 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
X0 VGND A a_68_297# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_68_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_68_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR A a_150_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 X a_68_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.34 pd=2.68 as=0.146 ps=1.34 w=1 l=0.15
X5 a_150_297# B a_68_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
X0 VPWR a_505_21# a_535_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_505_21# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.0693 ps=0.75 w=0.42 l=0.15
X2 a_218_374# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0767 pd=0.785 as=0.158 ps=1.39 w=0.42 l=0.15
X3 VGND a_505_21# a_439_47# VNB sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.11 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 a_76_199# A0 a_218_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.193 pd=1.34 as=0.0767 ps=0.785 w=0.42 l=0.15
X5 a_505_21# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.145 ps=1.11 w=0.42 l=0.15
X6 a_439_47# A0 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0997 ps=0.895 w=0.42 l=0.15
X7 a_535_374# A1 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.193 ps=1.34 w=0.42 l=0.15
X8 a_76_199# A1 a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0997 pd=0.895 as=0.0693 ps=0.75 w=0.42 l=0.15
X9 a_218_47# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.113 ps=1.04 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.158 pd=1.39 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.04 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 Y B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X1 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.135 ps=1.27 w=1 l=0.15
X3 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_381_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_109_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VGND A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0683 ps=0.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
X0 X a_29_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.148 ps=1.34 w=1 l=0.15
X1 a_111_297# C a_29_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_29_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.102 ps=0.99 w=0.65 l=0.15
X3 a_183_297# B a_111_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 VPWR A a_183_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X5 a_29_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VGND C a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
X0 a_377_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.365 ps=1.73 w=1 l=0.15
X1 a_47_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.3 ps=2.6 w=1 l=0.15
X2 a_129_47# B a_47_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_285_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 Y a_47_47# a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_129_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0683 ps=0.86 w=0.65 l=0.15
X6 VPWR A a_47_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.365 pd=1.73 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_47_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.165 ps=1.33 w=1 l=0.15
X8 Y B a_377_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
X0 a_297_47# a_27_47# a_193_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_369_47# B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0441 ps=0.63 w=0.42 l=0.15
X2 VPWR D a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.0662 ps=0.735 w=0.42 l=0.15
X3 X a_193_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.103 ps=1 w=0.65 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND D a_469_47# VNB sky130_fd_pr__nfet_01v8 ad=0.103 pd=1 as=0.0609 ps=0.71 w=0.42 l=0.15
X6 X a_193_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR B a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.128 pd=1.03 as=0.0987 ps=0.89 w=0.42 l=0.15
X8 a_193_413# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.128 ps=1.03 w=0.42 l=0.15
X9 a_193_413# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0987 pd=0.89 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 a_469_47# C a_369_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.0735 ps=0.77 w=0.42 l=0.15
X11 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.16 ps=1.32 w=1 l=0.15
X1 a_27_297# B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X2 VGND A2 a_373_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.114 ps=1 w=0.65 l=0.15
X3 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X4 a_27_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.253 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.253 ps=2.52 w=1 l=0.15
X6 a_373_47# A1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.96 w=0.65 l=0.15
X8 a_109_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_298_297# a_27_413# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.265 ps=2.53 w=1 l=0.15
X1 a_215_297# a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.136 ps=1.1 w=0.65 l=0.15
X2 a_298_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.258 ps=1.45 w=0.65 l=0.15
X4 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X6 a_382_47# A1 a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.136 pd=1.1 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VPWR A1 a_298_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND A2 a_382_47# VNB sky130_fd_pr__nfet_01v8 ad=0.258 pd=1.45 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X4 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X5 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X6 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X8 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.301 ps=2.66 w=1 l=0.15
X9 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X10 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X11 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X12 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X13 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X14 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X15 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X16 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X17 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X18 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X19 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X20 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X21 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X22 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X23 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X24 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.209 ps=2.02 w=0.65 l=0.15
X25 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X26 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X27 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X28 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X29 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
X0 a_27_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_560_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X2 VGND B a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0991 ps=0.955 w=0.65 l=0.15
X3 Y B a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_297# a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_474_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X7 VGND A a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# B a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X12 a_474_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_560_47# a_27_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X14 VPWR A a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X15 Y a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X16 VPWR a_27_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X17 a_560_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.97
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.97
.ends

.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_470_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_470_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_470_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.106 ps=0.975 w=0.65 l=0.15
X6 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X8 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X10 a_470_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.162 ps=1.33 w=1 l=0.15
X11 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 VPWR B a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X13 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X16 X a_112_47# a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 a_470_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X18 X B a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_388_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.127 pd=1.25 as=0.153 ps=1.3 w=1 l=0.15
X1 a_105_352# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_297_47# a_105_352# Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A1 a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.127 ps=1.25 w=1 l=0.15
X5 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X6 VPWR B1_N a_105_352# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.178 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 Y a_105_352# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.178 ps=1.4 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
X0 VPWR a_75_212# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 a_75_212# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 a_75_212# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND a_75_212# X VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_286_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X2 a_286_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X3 Y A2 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 VGND A1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X6 VGND A2 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X7 a_487_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# B1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR A1 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_27_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X13 a_487_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X14 a_286_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_109_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 X a_79_204# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A1 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_473_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.195 ps=1.39 w=1 l=0.15
X3 X a_79_204# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X4 VGND C1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.104 ps=0.97 w=0.65 l=0.15
X5 a_79_204# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0926 ps=0.935 w=0.65 l=0.15
X6 VPWR a_79_204# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X7 a_473_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X8 a_473_297# B1 a_727_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.16 ps=1.32 w=1 l=0.15
X9 X a_79_204# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X10 VGND B1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.127 ps=1.04 w=0.65 l=0.15
X11 a_79_204# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.109 ps=0.985 w=0.65 l=0.15
X12 VGND a_79_204# X VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.0959 ps=0.945 w=0.65 l=0.15
X13 a_1123_47# A1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_555_297# B1 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X15 VPWR A2 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X16 VGND A2 a_1123_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.091 ps=0.93 w=0.65 l=0.15
X17 a_951_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.14 ps=1.08 w=0.65 l=0.15
X18 VPWR a_79_204# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_79_204# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X20 a_79_204# A1 a_951_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 a_79_204# C1 a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 a_727_297# C1 a_79_204# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X23 X a_79_204# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_222_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X1 VPWR A1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.105 ps=1.21 w=1 l=0.15
X2 VGND a_79_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_222_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.186 ps=1.41 w=0.42 l=0.15
X4 VGND A2 a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_448_47# a_222_93# a_79_199# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_79_199# a_222_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.3 ps=2.6 w=1 l=0.15
X7 a_544_297# A2 a_79_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X8 a_448_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.186 pd=1.41 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VPWR C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 a_181_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VGND C a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.132 pd=1.14 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 a_27_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X6 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.132 ps=1.14 w=0.65 l=0.15
X7 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.42 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0703 pd=0.755 as=0.111 ps=1.37 w=0.42 l=0.15
X6 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.14 ps=1.28 w=1 l=0.15
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0703 ps=0.755 w=0.42 l=0.15
X8 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.165 ps=1.33 w=1 l=0.15
X9 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
X0 X a_35_297# a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.26 ps=2.52 w=1 l=0.15
X1 X B a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.25 pd=1.42 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_117_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 VPWR B a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.25 ps=1.42 w=0.65 l=0.15
X7 a_285_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A a_117_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VGND A1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
X1 a_510_47# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.143 ps=1.09 w=0.65 l=0.15
X2 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.175 ps=1.35 w=1 l=0.15
X3 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.22 ps=1.44 w=1 l=0.15
X4 a_79_21# A2 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.22 pd=1.44 as=0.162 ps=1.33 w=1 l=0.15
X5 a_297_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X6 a_79_21# C1 a_510_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.114 ps=1 w=0.65 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X8 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
X9 a_215_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.106 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 Y A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.174 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.182 pd=1.92 as=0.174 ps=1.39 w=0.7 l=0.15
X2 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X3 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VGND A2 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR A1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_37_297# B1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_485_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_292_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VPWR A2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X8 a_485_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X11 a_37_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 Y A1 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X13 Y C1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_292_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X15 a_292_297# B1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X2 a_193_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y A a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X4 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 a_109_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
X0 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.157 ps=1.17 w=0.42 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.157 pd=1.17 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X6 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.149 ps=1.33 w=1 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.149 pd=1.33 as=0.166 ps=1.8 w=0.64 l=0.15
X3 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X4 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.745 as=0.111 ps=1.37 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.162 ps=1.33 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
X0 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X1 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND B a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
X0 a_27_47# C a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# C a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_445_47# B a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_445_47# B a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y A a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X14 Y A a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_803_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X17 a_803_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_445_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 a_803_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X23 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X24 a_445_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_803_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X30 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X31 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.35 as=0.265 ps=2.53 w=1 l=0.15
X1 a_209_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.172 ps=1.35 w=1 l=0.15
X2 a_303_47# A2 a_209_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.104 ps=0.97 w=0.65 l=0.15
X3 a_209_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.112 ps=0.995 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.172 ps=1.83 w=0.65 l=0.15
X5 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.107 ps=0.98 w=0.65 l=0.15
X6 a_80_21# A1 a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X7 VPWR A2 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.16 ps=1.32 w=1 l=0.15
X8 a_80_21# B1 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X9 a_209_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
X0 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_161_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X2 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_161_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A a_161_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_161_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_382_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X1 a_297_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X2 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.327 pd=1.65 as=0.28 ps=2.56 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.327 ps=1.65 w=1 l=0.15
X6 a_382_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.195 ps=1.39 w=1 l=0.15
X7 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X7 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.38 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X11 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X18 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_199_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_113_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.147 ps=1.29 w=1 l=0.15
X2 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X3 VPWR A1 a_113_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.29 as=0.14 ps=1.28 w=1 l=0.15
X4 a_113_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A2 a_199_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0959 ps=0.945 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_56_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A2 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_139_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.266 ps=2.12 w=0.65 l=0.15
X4 a_311_297# B1 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X5 Y C1 a_311_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X7 Y A1 a_139_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
X0 VGND C a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 a_277_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_47# B a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.135 ps=1.27 w=1 l=0.15
X8 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_277_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
X0 a_408_47# B a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_408_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y a_27_47# a_408_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.176 pd=1.39 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND C a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X6 a_218_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.12 ps=1.04 w=0.65 l=0.15
X7 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_218_47# B a_408_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X11 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.176 ps=1.39 w=1 l=0.15
X12 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.04 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0683 ps=0.86 w=0.65 l=0.15
X1 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=2.1 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A1 a_114_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
X3 a_114_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.185 ps=1.87 w=0.65 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.28 ps=2.56 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X10 a_285_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.091 ps=0.93 w=0.65 l=0.15
X11 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_467_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_467_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_109_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A2 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_109_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X1 a_80_21# C1 a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X2 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_300_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.26 ps=1.45 w=0.65 l=0.15
X6 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_80_21# A1 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 a_472_297# B1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X9 a_80_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.091 ps=0.93 w=0.65 l=0.15
X1 Y B1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.175 ps=1.35 w=1 l=0.15
X4 a_29_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y A2 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND A1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 a_112_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X8 a_112_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.14 ps=1.28 w=1 l=0.15
X9 a_29_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X11 a_29_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
X0 VPWR B a_207_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.228 pd=1.74 as=0.0609 ps=0.71 w=0.42 l=0.15
X1 X a_207_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.228 ps=1.74 w=1 l=0.15
X2 a_297_47# a_27_413# a_207_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0504 pd=0.66 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_207_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.99 w=0.65 l=0.15
X4 a_207_413# a_27_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0609 pd=0.71 as=0.0714 ps=0.76 w=0.42 l=0.15
X5 VPWR A_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0714 pd=0.76 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VGND B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.99 as=0.0504 ps=0.66 w=0.42 l=0.15
X7 a_27_413# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 Y A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.109 ps=0.985 w=0.65 l=0.15
X4 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_949_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 Y C1 a_949_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.15 ps=1.3 w=1 l=0.15
X10 a_781_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_27_297# B1 a_781_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_781_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_1301_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.15 ps=1.3 w=1 l=0.15
X16 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 Y C1 a_781_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.14 ps=1.28 w=1 l=0.15
X18 a_109_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_109_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_109_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.091 ps=0.93 w=0.65 l=0.15
X27 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X28 a_27_297# B1 a_1301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X29 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0894 ps=0.925 w=0.65 l=0.15
X30 a_109_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X31 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
X0 VPWR A a_49_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VGND a_285_47# a_391_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.5
X2 X a_391_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VGND A a_49_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR a_285_47# a_391_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.5
X5 a_285_47# a_49_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X6 a_285_47# a_49_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X7 X a_391_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
X0 a_27_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y A a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y A a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_445_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X12 a_445_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_445_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X17 a_445_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X23 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_206_369# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.146 ps=1.34 w=0.42 l=0.15
X1 a_206_369# A2_N a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 VGND B2 a_489_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_585_369# B2 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0672 ps=0.74 w=0.42 l=0.15
X4 a_489_47# a_206_369# a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_489_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VPWR A2_N a_206_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.209 pd=1.35 as=0.129 ps=1.18 w=0.42 l=0.15
X7 a_76_199# a_206_369# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.74 as=0.209 ps=1.35 w=0.42 l=0.15
X8 a_205_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0662 pd=0.735 as=0.0986 ps=0.98 w=0.42 l=0.15
X9 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.26 ps=2.52 w=1 l=0.15
X10 VPWR B1 a_585_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0986 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
X0 X a_61_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.167 ps=1.39 w=1 l=0.15
X1 VPWR a_61_75# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.195 ps=1.39 w=1 l=0.15
X2 VPWR B a_61_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 VGND B a_147_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 X a_61_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.112 ps=1.04 w=0.65 l=0.15
X5 VGND a_61_75# X VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.127 ps=1.04 w=0.65 l=0.15
X6 a_61_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X7 a_147_75# A a_61_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
D0 VNB DIODE sky130_fd_pr__diode_pw2nd_05v5 pj=2.64e+06 area=4.347e+11
.ends

.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
X0 X a_299_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X1 VPWR a_193_47# a_299_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 VGND a_193_47# a_299_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X6 X a_299_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
X0 VGND A a_311_413# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 VPWR A a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0598 ps=0.705 w=0.42 l=0.15
X2 a_393_413# a_205_93# a_311_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.122 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND C_N a_27_410# VNB sky130_fd_pr__nfet_01v8 ad=0.0619 pd=0.715 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR C_N a_27_410# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.123 pd=1.32 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_311_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X6 VGND a_27_410# a_311_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0598 ps=0.705 w=0.42 l=0.15
X7 a_561_297# B a_489_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0598 pd=0.705 as=0.0441 ps=0.63 w=0.42 l=0.15
X8 a_205_93# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0619 ps=0.715 w=0.42 l=0.15
X9 a_205_93# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.123 ps=1.32 w=0.42 l=0.15
X10 a_489_297# a_27_410# a_393_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.122 ps=1.33 w=0.42 l=0.15
X11 a_311_413# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X12 a_311_413# a_205_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0598 pd=0.705 as=0.109 ps=1.36 w=0.42 l=0.15
X13 X a_311_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.102 ps=0.99 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311ai_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
X0 a_39_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR A1 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X4 a_125_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0943 ps=0.94 w=0.65 l=0.15
X5 a_125_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_125_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_1163_47# B1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_39_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_1163_47# B1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A3 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND A3 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_39_297# A2 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_125_47# B1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X17 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 a_125_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X19 VGND A2 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_125_47# B1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VGND A2 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y C1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y C1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_461_297# A2 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 Y A3 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X26 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 Y A3 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 a_125_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 VPWR A1 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X31 a_461_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 a_461_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X33 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 a_125_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X35 a_1163_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X36 a_1163_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X37 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X38 a_39_297# A2 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X39 a_461_297# A2 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.172 ps=1.83 w=0.65 l=0.15
X2 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X3 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X5 a_326_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.127 ps=1.04 w=0.65 l=0.15
X6 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.635 pd=3.27 as=0.195 ps=1.39 w=1 l=0.15
X7 Y C1 a_326_47# VNB sky130_fd_pr__nfet_01v8 ad=0.393 pd=2.51 as=0.0683 ps=0.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X3 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X4 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X5 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.301 ps=2.66 w=1 l=0.15
X7 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X8 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X10 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X12 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X13 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X14 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X15 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X16 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X17 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X18 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X20 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X21 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X22 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.209 ps=2.02 w=0.65 l=0.15
X23 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X24 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X25 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X26 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X27 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.117 ps=1.01 w=0.65 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.41 pd=1.82 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.175 ps=1.35 w=1 l=0.15
X4 a_277_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.41 ps=1.82 w=1 l=0.15
X10 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.18 ps=1.36 w=1 l=0.15
X11 a_277_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.114 ps=1 w=0.65 l=0.15
X13 Y A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.0975 ps=0.95 w=0.65 l=0.15
X14 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
X0 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X1 a_471_47# B a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.42 pd=2.84 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_47# C a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=1.67 w=1 l=0.15
X8 a_277_47# B a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X9 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.335 pd=1.67 as=0.135 ps=1.27 w=1 l=0.15
X10 Y A a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_277_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X13 a_471_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_300_297# a_27_413# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X3 Y a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.102 ps=0.99 w=0.65 l=0.15
X4 VPWR A1 a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 a_384_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.143 ps=1.09 w=0.65 l=0.15
X6 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.111 ps=1.37 w=0.42 l=0.15
X7 a_300_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
X0 a_388_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.148 ps=1.34 w=0.42 l=0.15
X1 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X4 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X7 a_176_21# a_27_47# a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 a_472_297# B a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.102 ps=0.99 w=0.42 l=0.15
X10 a_176_21# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o41a_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 a_467_47# A4 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_467_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.153 ps=1.12 w=0.65 l=0.15
X3 a_467_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_467_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.153 pd=1.12 as=0.198 ps=1.26 w=0.65 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR A1 a_1083_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_1083_297# A2 a_889_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND A3 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_79_21# B1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X11 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_889_297# A2 a_1083_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X13 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_639_297# A3 a_889_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND A2 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0943 ps=0.94 w=0.65 l=0.15
X18 a_889_297# A3 a_639_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_639_297# A4 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.145 ps=1.29 w=1 l=0.15
X22 VGND A4 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0943 ps=0.94 w=0.65 l=0.15
X23 a_1083_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.49 pd=2.98 as=0.135 ps=1.27 w=1 l=0.15
X24 a_79_21# A4 a_639_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X25 a_467_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.319 pd=2.28 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X27 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_806_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_47# B1 a_1314_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=2.09 as=0.104 ps=0.97 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X17 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.0943 ps=0.94 w=0.65 l=0.15
X19 Y C1 a_978_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_27_47# B1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 a_806_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.675 pd=3.35 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.091 ps=0.93 w=0.65 l=0.15
X27 a_978_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.091 ps=0.93 w=0.65 l=0.15
X28 a_1314_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X31 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 a_103_199# B1 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.107 ps=0.98 w=0.65 l=0.15
X1 VPWR a_103_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.36 ps=2.72 w=1 l=0.15
X2 a_337_297# A2 a_253_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_103_199# A3 a_337_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.165 ps=1.33 w=1 l=0.15
X4 a_253_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.195 ps=1.39 w=1 l=0.15
X5 VPWR B1 a_103_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.345 pd=2.69 as=0.213 ps=1.42 w=1 l=0.15
X6 VGND a_103_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.234 ps=2.02 w=0.65 l=0.15
X7 a_253_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X8 a_253_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X9 VGND A2 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
X0 VPWR D a_343_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.46 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_223_47# B_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.5 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 a_515_93# a_223_47# a_429_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 a_223_47# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.134 pd=1.48 as=0.0588 ps=0.7 w=0.42 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.168 ps=1.64 w=0.42 l=0.15
X5 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.168 ps=1.64 w=0.42 l=0.15
X6 X a_343_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.172 ps=1.46 w=1 l=0.15
X7 a_429_93# a_27_47# a_343_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.118 ps=1.4 w=0.42 l=0.15
X8 VGND D a_615_93# VNB sky130_fd_pr__nfet_01v8 ad=0.126 pd=1.11 as=0.0777 ps=0.79 w=0.42 l=0.15
X9 a_343_93# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X10 a_343_93# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.122 ps=1.42 w=0.42 l=0.15
X11 a_615_93# C a_515_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X12 X a_343_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.82 as=0.126 ps=1.11 w=0.65 l=0.15
X13 VPWR a_223_47# a_343_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
X0 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.165 ps=1.33 w=1 l=0.15
X2 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_193_47# C a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_277_47# B a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.26 ps=1.45 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.4 ps=1.8 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.205 pd=1.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.135 ps=1.27 w=1 l=0.15
X5 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_109_297# C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.272 ps=2.56 w=1 l=0.15
X15 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X17 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X19 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X24 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.257 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X30 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X38 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
X0 VPWR a_29_311# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_29_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.151 ps=1.35 w=1 l=0.15
X2 VPWR A a_29_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND a_29_311# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_184_53# B a_112_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X5 VPWR C a_29_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.151 pd=1.35 as=0.0744 ps=0.815 w=0.42 l=0.15
X6 X a_29_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.13 ps=1.11 w=0.65 l=0.15
X7 a_112_53# A a_29_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_29_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 VGND C a_184_53# VNB sky130_fd_pr__nfet_01v8 ad=0.13 pd=1.11 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd2_1 A VGND VNB VPB VPWR X
X0 VPWR A a_49_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VPWR a_221_47# a_327_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.18
X2 X a_327_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X3 VGND A a_49_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_327_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X5 a_221_47# a_49_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.18
X6 a_221_47# a_49_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.18
X7 VGND a_221_47# a_327_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.18
.ends

.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_39_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=1 w=0.65 l=0.15
X2 VPWR a_39_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_39_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.156 ps=1.36 w=1 l=0.15
X4 VGND a_39_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.156 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VGND A a_39_297# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=1 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_39_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 a_79_21# A1 a_348_47# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.133 ps=1.06 w=0.65 l=0.15
X1 a_79_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X2 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.2 pd=1.26 as=0.091 ps=0.93 w=0.65 l=0.15
X3 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 a_79_21# C1 a_585_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X5 VPWR A2 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.26 ps=2.52 w=1 l=0.15
X6 a_299_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.195 ps=1.39 w=1 l=0.15
X7 a_585_297# B1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X8 a_348_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.2 ps=1.26 w=0.65 l=0.15
X9 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.115 ps=1 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
X0 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X5 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X7 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 Y a_61_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.183 ps=1.24 w=0.65 l=0.15
X1 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_217_297# a_61_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_479_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X4 a_217_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X5 Y a_61_47# a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 VPWR A1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_61_47# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VGND A2 a_637_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_61_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A1 a_479_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0683 ps=0.86 w=0.65 l=0.15
X11 VGND B1_N a_61_47# VNB sky130_fd_pr__nfet_01v8 ad=0.183 pd=1.24 as=0.126 ps=1.44 w=0.42 l=0.15
X12 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X13 a_637_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.221 pd=1.98 as=0.198 ps=1.26 w=0.65 l=0.15
X1 Y A3 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.393 pd=1.78 as=0.135 ps=1.27 w=1 l=0.15
X2 a_193_297# A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.393 ps=1.78 w=1 l=0.15
X5 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
X0 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X5 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X17 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X21 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X23 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X36 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X39 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.28 ps=2.56 w=1 l=0.15
X1 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X4 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.177 ps=1.36 w=1 l=0.15
X7 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.105 ps=1.21 w=1 l=0.15
X9 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y A1 a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.119 ps=1.01 w=0.65 l=0.15
X1 a_181_47# A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.0683 ps=0.86 w=0.65 l=0.15
X2 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.106 ps=0.975 w=0.65 l=0.15
X3 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.162 ps=1.33 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.153 ps=1.3 w=1 l=0.15
X6 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_475_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A1 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X9 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.27 pd=1.48 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X12 a_475_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 Y A2 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X14 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.27 ps=1.48 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
X0 VPWR a_30_53# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.315 pd=2.63 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND a_30_53# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_30_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X3 a_112_297# C a_30_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_30_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 VGND A a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 a_30_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 VGND C a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_184_297# B a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X9 VPWR A a_184_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X1 X a_80_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 VGND a_80_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=0.99 as=0.091 ps=0.93 w=0.65 l=0.15
X3 a_386_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.157 ps=1.32 w=1 l=0.15
X4 X a_80_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_80_199# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.162 pd=1.15 as=0.111 ps=0.99 w=0.65 l=0.15
X6 a_386_297# B1 a_80_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_458_47# A1 a_80_199# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.162 ps=1.15 w=0.65 l=0.15
X8 VPWR A1 a_386_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X9 VGND A2 a_458_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.123 ps=1.03 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 a_27_47# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.368 pd=1.74 as=0.14 ps=1.28 w=1 l=0.15
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.231 pd=2.01 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VPWR A1 a_373_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X4 a_182_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.165 ps=1.82 w=0.65 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.195 ps=1.39 w=1 l=0.15
X6 a_182_47# B1 a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X8 a_373_297# A2 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.368 ps=1.74 w=1 l=0.15
X9 a_110_47# C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X10 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X11 VGND A1 a_182_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
X0 a_109_93# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_209_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X2 a_109_93# A_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_296_53# a_109_93# a_209_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.108 ps=1.36 w=0.42 l=0.15
X4 VPWR C a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0744 ps=0.815 w=0.42 l=0.15
X5 a_368_53# B a_296_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_209_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.122 ps=1.08 w=0.65 l=0.15
X7 a_209_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VPWR a_109_93# a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.108 ps=1.36 w=0.42 l=0.15
X9 VGND C a_368_53# VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.08 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_397_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR B1_N a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X2 Y A2 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VGND A2 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND A1 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_28_297# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X6 Y a_28_297# a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VPWR a_28_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_397_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X9 a_229_47# a_28_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y a_28_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X11 a_229_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_229_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A1 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 a_465_47# A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND A4 a_561_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X2 VPWR A3 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X3 a_297_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X4 a_297_297# A4 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X5 VPWR A1 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_381_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.184 ps=1.22 w=0.65 l=0.15
X7 a_297_297# B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X8 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X9 a_79_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.184 pd=1.22 as=0.161 ps=1.14 w=0.65 l=0.15
X10 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.161 pd=1.14 as=0.169 ps=1.82 w=0.65 l=0.15
X11 a_561_47# A3 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2111oi_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
X0 a_316_297# C1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.172 ps=1.35 w=1 l=0.15
X1 Y D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.481 ps=2.78 w=0.65 l=0.15
X2 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.02 as=0.125 ps=1.03 w=0.65 l=0.15
X3 a_420_297# B1 a_316_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=1.58 as=0.185 ps=1.37 w=1 l=0.15
X4 VPWR A1 a_420_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.29 ps=1.58 w=1 l=0.15
X5 VGND A2 a_568_47# VNB sky130_fd_pr__nfet_01v8 ad=0.192 pd=1.89 as=0.0845 ps=0.91 w=0.65 l=0.15
X6 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.192 pd=1.24 as=0.12 ps=1.02 w=0.65 l=0.15
X7 a_420_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.138 ps=1.27 w=1 l=0.15
X8 a_217_297# D1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.35 as=0.755 ps=3.51 w=1 l=0.15
X9 a_568_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0845 pd=0.91 as=0.192 ps=1.24 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
X0 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND a_215_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR a_215_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_109_93# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X4 a_215_297# a_109_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.165 ps=1.82 w=0.65 l=0.15
X5 VGND C a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X6 VGND A a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X8 a_215_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_109_93# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X10 VPWR A a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND a_215_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_487_297# B a_403_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_403_297# C a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X14 VPWR a_215_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X15 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X16 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_297_297# a_109_93# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_93_21# A1 a_346_47# VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.146 ps=1.1 w=0.65 l=0.15
X1 a_93_21# B1 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.185 ps=1.37 w=1 l=0.15
X2 a_584_47# B1 a_93_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.143 ps=1.09 w=0.65 l=0.15
X3 VPWR a_93_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.243 pd=1.49 as=0.33 ps=2.66 w=1 l=0.15
X4 VGND B2 a_584_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 a_256_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.167 ps=1.16 w=0.65 l=0.15
X6 a_250_297# B2 a_93_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 VGND a_93_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.167 pd=1.16 as=0.214 ps=1.96 w=0.65 l=0.15
X8 a_250_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.243 ps=1.49 w=1 l=0.15
X9 VPWR A2 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.225 pd=1.45 as=0.165 ps=1.33 w=1 l=0.15
X10 a_250_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.225 ps=1.45 w=1 l=0.15
X11 a_346_47# A2 a_256_47# VNB sky130_fd_pr__nfet_01v8 ad=0.146 pd=1.1 as=0.0975 ps=0.95 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_223_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 Y A1 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X3 a_223_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X4 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 VGND A2 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_223_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X7 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.123 ps=1.03 w=0.65 l=0.15
X8 VPWR A2 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 a_658_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.201 ps=1.27 w=0.65 l=0.15
X10 VPWR A1 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_223_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 a_658_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 Y a_27_47# a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_223_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X15 VPWR A2 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.155 ps=1.31 w=1 l=0.15
X16 VPWR A1 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 a_658_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VGND B1_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.27 ps=2.13 w=0.65 l=0.15
X19 a_223_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X20 a_658_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 VGND A2 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.27 as=0.091 ps=0.93 w=0.65 l=0.15
X23 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X24 Y A1 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X25 Y a_27_47# a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22a_4 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 VPWR B1 a_566_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.135 ps=1.27 w=1 l=0.15
X1 a_484_47# B1 a_96_21# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_96_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR a_96_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_96_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_566_297# B2 a_96_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR a_96_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_96_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X8 VGND a_96_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_96_21# B2 a_566_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A1 a_918_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.135 ps=1.27 w=1 l=0.15
X11 a_484_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_566_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X13 a_484_47# B2 a_96_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_96_21# A2 a_918_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_918_297# A2 a_96_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 a_484_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_918_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.175 ps=1.35 w=1 l=0.15
X18 a_96_21# B1 a_484_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X19 VGND A2 a_484_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_96_21# B2 a_484_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VGND A1 a_484_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X22 X a_96_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X23 VGND a_96_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
X0 VGND a_91_199# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.221 ps=1.98 w=0.65 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A a_245_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.135 ps=1.27 w=1 l=0.15
X3 a_91_199# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_245_297# B a_161_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_91_199# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.146 ps=1.34 w=0.42 l=0.15
X7 a_161_297# a_91_199# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.32 ps=2.64 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_2 A1 A2 B1_N VGND VNB VPB VPWR X
X0 VGND B1_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VGND A2 a_478_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.106 ps=0.975 w=0.65 l=0.15
X2 a_478_47# a_27_93# a_174_21# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_478_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 X a_174_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X5 VPWR a_174_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_174_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X7 VPWR A1 a_574_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.105 ps=1.21 w=1 l=0.15
X8 VGND a_174_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR B1_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X10 a_574_297# A2 a_174_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X11 a_174_21# a_27_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.395 ps=1.79 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
X0 VPWR A a_94_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.198 pd=1.39 as=0.305 ps=2.61 w=1 l=0.15
X1 a_294_47# B a_185_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.128 ps=1.04 w=0.65 l=0.15
X2 a_185_47# A a_94_47# VNB sky130_fd_pr__nfet_01v8 ad=0.128 pd=1.04 as=0.198 ps=1.91 w=0.65 l=0.15
X3 VPWR a_94_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND C a_294_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 a_94_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.198 ps=1.39 w=1 l=0.15
X6 X a_94_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X7 X a_94_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 VPWR C a_94_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X9 X a_94_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X10 VGND a_94_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X11 VPWR a_94_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND a_94_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 X a_94_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
X0 a_109_93# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_215_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 VGND a_109_93# a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND A a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 VPWR A a_369_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_369_297# B a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_215_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X7 a_297_297# a_109_93# a_215_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_109_93# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 X a_215_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.1 ps=0.985 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.166 pd=1.63 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.345 pd=2.69 as=0.14 ps=1.28 w=1 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X6 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.305 ps=2.61 w=1 l=0.15
X7 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.139 ps=1.5 w=0.42 l=0.15
X8 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
X0 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_4 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 Y a_33_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_225_47# a_33_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR a_33_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_33_297# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.182 ps=1.86 w=0.65 l=0.15
X4 Y a_33_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A2 a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 Y a_33_297# a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 Y a_33_297# a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND A2 a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND A2 a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_561_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X11 a_225_47# a_33_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR A1 a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_225_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_225_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_225_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_225_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VPWR A1 a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 a_561_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR B1_N a_33_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X20 a_561_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VGND A1 a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y A2 a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VGND A1 a_225_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_561_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 VPWR a_33_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
X0 Y C a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 a_281_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X6 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X10 a_281_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_297# B a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X8 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X11 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=1.37 as=0.0588 ps=0.7 w=0.42 l=0.15
X18 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X20 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X21 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X22 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X23 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X25 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X26 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X27 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X28 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X29 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X30 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X31 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X32 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X33 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X34 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X35 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X36 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X37 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X38 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X39 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0578 ps=0.695 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X16 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X17 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X20 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_75_199# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.135 ps=1.07 w=0.65 l=0.15
X1 a_208_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.112 ps=0.995 w=0.65 l=0.15
X2 a_315_47# A2 a_208_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.17 as=0.125 ps=1.03 w=0.65 l=0.15
X3 VGND B1 a_75_199# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.07 as=0.106 ps=0.975 w=0.65 l=0.15
X4 a_75_199# A1 a_315_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.17 w=0.65 l=0.15
X5 a_75_199# C1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.207 ps=1.41 w=1 l=0.15
X6 a_544_297# B1 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.207 pd=1.41 as=0.162 ps=1.33 w=1 l=0.15
X7 VPWR a_75_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.285 ps=2.57 w=1 l=0.15
X8 a_201_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.142 ps=1.28 w=1 l=0.15
X9 VPWR A2 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.165 ps=1.33 w=1 l=0.15
X10 a_201_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.305 ps=1.61 w=1 l=0.15
X11 VGND a_75_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR A2 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 a_277_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X2 a_79_21# B1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X3 a_277_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_361_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_277_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.127 ps=1.04 w=0.65 l=0.15
X9 a_79_21# A1 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.135 ps=1.27 w=1 l=0.15
X3 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X17 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_803_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_803_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 VGND A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X30 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X31 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a41oi_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR Y
X0 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.29 ps=1.58 w=1 l=0.15
X1 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.338 ps=1.67 w=1 l=0.15
X2 Y A1 a_493_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 VPWR A4 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y A1 a_493_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.305 ps=1.61 w=1 l=0.15
X6 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.183 ps=1.37 w=1 l=0.15
X7 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_911_47# A2 a_493_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_911_47# A3 a_1269_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A4 a_1269_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A4 a_1269_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=1.58 as=0.135 ps=1.27 w=1 l=0.15
X14 a_493_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_493_47# A2 a_911_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_493_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_493_47# A2 a_911_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 a_911_47# A2 a_493_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 a_1269_47# A4 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.183 pd=1.37 as=0.135 ps=1.27 w=1 l=0.15
X26 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X27 a_911_47# A3 a_1269_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X28 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.338 pd=1.67 as=0.135 ps=1.27 w=1 l=0.15
X31 a_27_297# A4 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.135 ps=1.27 w=1 l=0.15
X32 VPWR A4 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 a_1269_47# A3 a_911_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X34 a_27_297# A4 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X35 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X36 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 a_1269_47# A3 a_911_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X38 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X39 a_1269_47# A4 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y A3 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_449_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 Y A3 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y B1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_449_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.263 ps=2.57 w=1 l=0.15
X8 Y B1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_31_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_297# A2 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.261 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 a_31_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 a_31_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_31_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_449_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X20 VGND A2 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 VGND A2 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VGND A3 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.223 pd=1.34 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_31_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.223 ps=1.34 w=0.65 l=0.15
X25 a_27_297# A2 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND A3 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 a_31_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X28 a_449_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 a_31_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 a_31_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_226_47# A2_N a_226_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_489_413# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_226_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.167 ps=1.43 w=0.42 l=0.15
X3 VPWR B2 a_489_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_489_413# a_226_47# a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_76_199# a_226_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.139 ps=1.08 w=0.42 l=0.15
X6 VGND B1 a_556_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_556_47# B2 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VGND A2_N a_226_47# VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.08 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_226_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.12 ps=1.09 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.43 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.09 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
X0 a_558_47# a_381_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X1 VGND X a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_841_47# a_664_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VPWR A a_62_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A a_62_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_558_47# a_381_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X6 X a_62_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR X a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_841_47# a_664_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X9 X a_62_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X10 VPWR a_558_47# a_664_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND a_558_47# a_664_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
X0 Y a_53_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.192 ps=1.38 w=1 l=0.15
X1 a_232_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.192 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A_N a_53_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A_N a_53_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_316_47# B a_232_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y a_53_93# a_316_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.125 ps=1.03 w=0.65 l=0.15
X7 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311a_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.305 ps=1.61 w=1 l=0.15
X1 a_467_47# C1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_467_47# B1 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND A1 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.135 ps=1.27 w=1 l=0.15
X6 a_79_21# C1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_717_47# B1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VGND A3 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.27 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_1147_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR A1 a_1147_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_1147_297# A2 a_875_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X18 a_79_21# A3 a_875_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X19 a_875_297# A3 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 a_875_297# A2 a_1147_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 a_717_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.201 ps=1.27 w=0.65 l=0.15
X23 a_717_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_717_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X26 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VGND A1 a_474_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.104 ps=0.97 w=0.65 l=0.15
X1 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 VPWR A1 a_1122_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.252 pd=1.5 as=0.14 ps=1.28 w=1 l=0.15
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.192 pd=1.89 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.252 ps=1.5 w=1 l=0.15
X8 a_950_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X9 a_557_47# B1 a_474_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X10 a_474_47# B1 a_748_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X11 VGND A2 a_474_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_79_21# C1 a_557_47# VNB sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.1 as=0.0683 ps=0.86 w=0.65 l=0.15
X15 a_474_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X16 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.14 ps=1.28 w=1 l=0.15
X17 a_748_47# C1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.145 ps=1.1 w=0.65 l=0.15
X18 a_474_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
X19 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.195 ps=1.39 w=1 l=0.15
X20 a_79_21# A2 a_950_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X21 a_1122_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X23 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.16 ps=1.32 w=1 l=0.15
X1 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.4 ps=1.8 w=1 l=0.15
X2 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0894 ps=0.925 w=0.65 l=0.15
X3 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_470_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.138 ps=1.27 w=1 l=0.15
X6 a_384_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 a_384_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.104 ps=0.97 w=0.65 l=0.15
X8 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
X0 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=1.67 w=1 l=0.15
X1 VGND A_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0.194 pd=1.95 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VGND B a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y a_27_93# a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 a_229_47# a_27_93# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.147 ps=1.34 w=1 l=0.15
X6 VPWR a_27_93# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.335 pd=1.67 as=0.165 ps=1.33 w=1 l=0.15
X7 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.135 ps=1.27 w=1 l=0.15
X8 a_229_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR A_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X7 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X11 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X12 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X14 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X15 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X16 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.155 ps=1.31 w=1 l=0.15
X20 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X21 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_585_47# B1 a_266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.119 ps=1.01 w=0.65 l=0.15
X1 VGND A2 a_266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.137 pd=1.07 as=0.117 ps=1.01 w=0.65 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.62 as=0.26 ps=2.52 w=1 l=0.15
X3 a_81_21# C1 a_585_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.203 pd=1.27 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_266_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.312 ps=1.62 w=1 l=0.15
X6 a_368_297# A2 a_266_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.21 pd=1.42 as=0.18 ps=1.36 w=1 l=0.15
X7 a_266_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.137 ps=1.07 w=0.65 l=0.15
X8 a_266_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.203 ps=1.27 w=0.65 l=0.15
X9 a_81_21# A3 a_368_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.21 ps=1.42 w=1 l=0.15
X10 a_81_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.15 ps=1.3 w=1 l=0.15
X11 VPWR B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.138 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_4 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_1021_47# A1 a_205_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 X a_205_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 VPWR a_205_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_205_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VGND A2 a_1021_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND a_42_47# a_205_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_861_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.101 ps=0.96 w=0.65 l=0.15
X7 a_205_21# A1 a_861_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0747 ps=0.88 w=0.65 l=0.15
X8 X a_205_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 a_603_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND B1_N a_42_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.25 ps=2.07 w=0.65 l=0.15
X11 VPWR A2 a_603_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_603_297# a_42_47# a_205_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 VPWR a_205_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.14 ps=1.28 w=1 l=0.15
X14 a_205_21# a_42_47# a_603_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND a_205_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.263 pd=1.46 as=0.091 ps=0.93 w=0.65 l=0.15
X16 VPWR B1_N a_42_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X17 VGND a_205_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VPWR A1 a_603_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 a_603_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 a_205_21# a_42_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.263 ps=1.46 w=0.65 l=0.15
X21 X a_205_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
X0 VGND A_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X1 Y a_27_93# a_206_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_206_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR a_27_93# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X5 VPWR A_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
X0 VPWR A1 a_485_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_485_297# a_297_93# a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X2 a_297_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.108 ps=1.01 w=0.42 l=0.15
X3 a_581_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X4 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.01 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_79_21# a_297_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X6 VGND A2 a_581_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.182 pd=1.51 as=0.14 ps=1.28 w=1 l=0.15
X8 a_297_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.182 ps=1.51 w=0.42 l=0.15
X9 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X10 a_485_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X11 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
X0 a_281_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND a_531_21# Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR C_N a_531_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X7 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X9 a_281_297# a_531_21# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X10 Y a_531_21# a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X11 VGND C_N a_531_21# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X12 a_27_297# B a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X13 Y a_531_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_33_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND A1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_33_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_797_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_797_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y B2 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR B1 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_33_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 a_33_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_33_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_33_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_797_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.16 ps=1.32 w=1 l=0.15
X17 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR B1 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND A2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_33_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 a_797_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.135 ps=1.27 w=1 l=0.15
X24 Y B2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 Y B2 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 Y B1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.104 ps=0.97 w=0.65 l=0.15
X27 Y B2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 Y B1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_33_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.29 ps=2.58 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 a_78_199# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 VPWR A1 a_493_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X2 a_493_297# A2 a_78_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.235 ps=1.47 w=1 l=0.15
X3 VPWR a_78_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.373 pd=1.75 as=0.28 ps=2.56 w=1 l=0.15
X4 VGND A2 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X5 a_78_199# B2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.235 pd=1.47 as=0.117 ps=1.24 w=1 l=0.15
X6 a_215_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_215_47# B2 a_78_199# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_292_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.117 pd=1.24 as=0.373 ps=1.75 w=1 l=0.15
X9 VGND a_78_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a41o_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 a_381_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A2 a_381_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X2 a_465_47# A4 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_549_47# A3 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_665_47# A2 a_549_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.14 ps=1.08 w=0.65 l=0.15
X7 a_381_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A4 a_381_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_381_297# B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 a_79_21# A1 a_665_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X1 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0926 ps=0.935 w=0.65 l=0.15
X2 VPWR A1 a_307_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.105 ps=1.21 w=1 l=0.15
X3 a_307_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.233 ps=1.47 w=1 l=0.15
X4 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.233 pd=1.47 as=0.112 ps=1.23 w=1 l=0.15
X6 a_109_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.112 pd=1.23 as=0.26 ps=2.52 w=1 l=0.15
X7 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2oi_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
X0 a_109_47# A2_N a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 a_397_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR B2 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A2_N a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.283 pd=1.52 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_397_297# a_109_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.34 ps=2.68 w=1 l=0.15
X5 a_481_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.283 ps=1.52 w=0.65 l=0.15
X7 VGND B1 a_481_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_109_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X9 a_109_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 a_676_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.213 ps=1.42 w=1 l=0.15
X1 a_512_47# B1 a_409_47# VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.119 ps=1.01 w=0.65 l=0.15
X2 a_306_47# D1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.198 ps=1.91 w=0.65 l=0.15
X3 VGND A2 a_512_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.198 ps=1.26 w=0.65 l=0.15
X4 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.218 ps=1.43 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.305 ps=1.61 w=1 l=0.15
X6 VPWR A1 a_676_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.105 ps=1.21 w=1 l=0.15
X7 a_512_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_409_47# C1 a_306_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.119 ps=1.01 w=0.65 l=0.15
X9 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.382 pd=1.76 as=0.26 ps=2.52 w=1 l=0.15
X10 a_79_21# D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.218 pd=1.43 as=0.382 ps=1.76 w=1 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2111oi_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
X0 Y D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_455_297# B1 a_821_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X2 a_28_297# D1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 a_821_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X4 a_28_297# C1 a_455_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 a_455_297# C1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND D1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 VPWR A2 a_821_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.2 ps=1.4 w=1 l=0.15
X9 Y D1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X10 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X11 VGND D1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X13 a_821_297# B1 a_455_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X14 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X15 Y D1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.117 ps=1.01 w=0.65 l=0.15
X17 a_1205_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X18 a_28_297# C1 a_455_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X19 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
X20 a_1205_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 a_821_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.14 ps=1.28 w=1 l=0.15
X22 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.091 ps=0.93 w=0.65 l=0.15
X23 Y A1 a_1205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X24 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X25 VPWR A1 a_821_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X26 Y A1 a_1205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.182 ps=1.86 w=0.65 l=0.15
X27 a_1205_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.02 as=0.091 ps=0.93 w=0.65 l=0.15
X28 a_28_297# D1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X29 VGND A2 a_1205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X30 a_455_297# B1 a_821_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X31 a_821_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.2 pd=1.4 as=0.15 ps=1.3 w=1 l=0.15
X32 a_1205_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X33 VGND A2 a_1205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.122 ps=1.02 w=0.65 l=0.15
X34 VPWR A1 a_821_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.14 ps=1.28 w=1 l=0.15
X35 a_821_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X36 VPWR A2 a_821_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.185 ps=1.37 w=1 l=0.15
X37 a_455_297# C1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X38 a_821_297# B1 a_455_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.14 ps=1.28 w=1 l=0.15
X39 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
X0 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0894 ps=0.925 w=0.65 l=0.15
X1 a_191_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.13 ps=1.26 w=1 l=0.15
X2 VPWR A a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.119 ps=1.01 w=0.65 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_297_297# B a_191_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X6 a_109_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.13 pd=1.26 as=0.26 ps=2.52 w=1 l=0.15
X7 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32ai_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 a_1224_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 VPWR A1 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.183 ps=1.37 w=1 l=0.15
X2 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_806_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.205 ps=1.28 w=0.65 l=0.15
X8 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.205 pd=1.28 as=0.14 ps=1.08 w=0.65 l=0.15
X10 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_806_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A3 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y A3 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X19 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.119 ps=1.01 w=0.65 l=0.15
X22 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0926 ps=0.935 w=0.65 l=0.15
X24 a_806_297# A2 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X25 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.142 ps=1.28 w=1 l=0.15
X28 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_1224_297# A2 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 a_1224_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.183 pd=1.37 as=0.135 ps=1.27 w=1 l=0.15
X32 a_806_297# A2 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 VPWR A1 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X35 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X36 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X37 a_1224_297# A2 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X38 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X39 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
X0 VPWR a_212_413# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_297_47# a_27_413# a_212_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_212_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.229 ps=1.75 w=1 l=0.15
X3 X a_212_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_212_413# a_27_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0609 pd=0.71 as=0.0767 ps=0.785 w=0.42 l=0.15
X5 VPWR A_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0767 pd=0.785 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VPWR B a_212_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.229 pd=1.75 as=0.0609 ps=0.71 w=0.42 l=0.15
X7 VGND B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VGND a_212_413# X VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_413# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
X0 VPWR a_219_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.295 pd=2.59 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.202 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.17 pd=1.34 as=0.105 ps=1.21 w=1 l=0.15
X3 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.111 ps=0.99 w=0.65 l=0.15
X5 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X6 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=0.99 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_219_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND a_219_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.17 ps=1.34 w=1 l=0.15
X11 VGND a_219_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.214 pd=1.96 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.202 ps=1.4 w=0.65 l=0.15
X13 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_77_199# B2 a_227_47# VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.127 ps=1.04 w=0.65 l=0.15
X1 a_323_297# A2 a_227_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.165 ps=1.33 w=1 l=0.15
X2 a_227_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_227_47# B1 a_77_199# VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.133 ps=1.06 w=0.65 l=0.15
X4 VGND a_77_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR B1 a_539_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.205 ps=1.41 w=1 l=0.15
X6 a_227_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X7 VPWR a_77_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=2.67 w=1 l=0.15
X8 a_77_199# A3 a_323_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X9 VGND A2 a_227_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 a_227_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_539_297# B2 a_77_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=1.41 as=0.195 ps=1.39 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_449_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 Y C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_449_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X10 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X15 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 VPWR a_27_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.107 ps=0.98 w=0.65 l=0.15
X2 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.965 w=0.65 l=0.15
X3 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.157 ps=1.32 w=1 l=0.15
X4 a_27_297# B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X5 a_27_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_27_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X8 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.165 ps=1.33 w=1 l=0.15
X9 a_381_47# A1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X10 a_109_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
X0 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.107 ps=0.98 w=0.65 l=0.15
X1 VGND D a_304_47# VNB sky130_fd_pr__nfet_01v8 ad=0.175 pd=1.26 as=0.0693 ps=0.75 w=0.42 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.28 ps=1.62 w=1 l=0.15
X3 a_198_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0798 pd=0.8 as=0.0619 ps=0.715 w=0.42 l=0.15
X4 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0777 ps=0.79 w=0.42 l=0.15
X5 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.165 ps=1.33 w=1 l=0.15
X6 a_304_47# C a_198_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0798 ps=0.8 w=0.42 l=0.15
X7 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0746 pd=0.775 as=0.109 ps=1.36 w=0.42 l=0.15
X8 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=1.62 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.175 ps=1.26 w=0.65 l=0.15
X10 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0746 ps=0.775 w=0.42 l=0.15
X11 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0619 pd=0.715 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4bb_2 A_N B_N C D VGND VNB VPB VPWR X
X0 a_174_21# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X1 a_174_21# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.74 as=0.331 ps=1.71 w=0.42 l=0.15
X2 a_476_47# a_27_47# a_174_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VPWR a_174_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.331 pd=1.71 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_174_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.141 ps=1.33 w=1 l=0.15
X5 a_548_47# a_505_280# a_476_47# VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X7 X a_174_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X8 VPWR D a_174_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0924 pd=0.86 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 VGND D a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0924 pd=0.86 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 VPWR a_505_280# a_174_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0672 ps=0.74 w=0.42 l=0.15
X11 a_505_280# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0924 ps=0.86 w=0.42 l=0.15
X12 VGND a_174_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_505_280# B_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0924 ps=0.86 w=0.42 l=0.15
X14 a_639_47# C a_548_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.064 ps=0.725 w=0.42 l=0.15
X15 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
X0 a_204_297# A1 a_396_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.16 ps=1.32 w=1 l=0.15
X1 VPWR a_396_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_396_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR S a_314_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_204_297# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.162 ps=1.33 w=1 l=0.15
X5 a_396_47# A0 a_314_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.26 ps=2.52 w=1 l=0.15
X6 a_206_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.109 ps=0.985 w=0.65 l=0.15
X7 X a_396_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_396_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_396_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_490_47# A1 a_396_47# VNB sky130_fd_pr__nfet_01v8 ad=0.275 pd=1.5 as=0.104 ps=0.97 w=0.65 l=0.15
X11 VGND S a_490_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.275 ps=1.5 w=0.65 l=0.15
X12 VGND a_396_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_396_47# A0 a_206_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.26 ps=1.45 w=0.65 l=0.15
X14 VGND a_396_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR S a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X16 X a_396_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND S a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32o_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 VPWR A3 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_299_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X2 a_352_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.21 ps=1.29 w=0.65 l=0.15
X3 a_549_47# A1 a_21_199# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.107 ps=0.98 w=0.65 l=0.15
X4 X a_21_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_21_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.21 pd=1.29 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_665_47# A2 a_549_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.14 ps=1.08 w=0.65 l=0.15
X7 VPWR A1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X8 a_299_297# B1 a_21_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_21_199# B2 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 VGND A3 a_665_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR a_21_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X12 X a_21_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_21_199# B1 a_352_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.115 ps=1 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111a_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 VGND A1 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.965 w=0.65 l=0.15
X1 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_297# A2 a_852_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.177 ps=1.36 w=1 l=0.15
X3 VPWR a_27_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND a_27_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.115 ps=1 w=0.65 l=0.15
X5 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_852_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X7 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_361_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.02 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR C1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND A2 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.1 as=0.12 ps=1.02 w=0.65 l=0.15
X11 a_27_297# D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.145 ps=1.1 w=0.65 l=0.15
X13 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X14 a_27_47# D1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_361_47# B1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_361_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.169 ps=1.82 w=0.65 l=0.15
X17 a_277_47# C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_445_47# B1 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.0926 ps=0.935 w=0.65 l=0.15
X20 a_27_297# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.135 ps=1.27 w=1 l=0.15
X21 a_681_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.305 ps=1.61 w=1 l=0.15
X22 a_27_47# C1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X23 VGND a_27_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0959 ps=0.945 w=0.65 l=0.15
X24 VPWR D1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X25 VPWR a_27_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X26 VPWR A1 a_681_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X27 a_27_297# D1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 VPWR a_82_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.186 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X1 a_646_47# B2 a_82_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_574_369# a_313_47# a_82_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0976 pd=0.945 as=0.166 ps=1.8 w=0.64 l=0.15
X3 a_574_369# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X4 VGND a_82_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.09 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR B2 a_574_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.0976 ps=0.945 w=0.64 l=0.15
X6 X a_82_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.172 ps=1.83 w=0.65 l=0.15
X7 X a_82_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.265 ps=2.53 w=1 l=0.15
X8 a_313_47# A2_N a_313_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.17 pd=1.81 as=0.0672 ps=0.85 w=0.64 l=0.15
X9 a_313_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.12 ps=1.09 w=0.42 l=0.15
X10 a_313_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.85 as=0.186 ps=1.43 w=0.64 l=0.15
X11 VGND A2_N a_313_47# VNB sky130_fd_pr__nfet_01v8 ad=0.142 pd=1.1 as=0.0567 ps=0.69 w=0.42 l=0.15
X12 a_82_21# a_313_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.142 ps=1.1 w=0.42 l=0.15
X13 VGND B1 a_646_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_4 A1 A2 B1_N VGND VNB VPB VPWR X
X0 VPWR B1_N a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.38 ps=2.76 w=1 l=0.15
X1 VPWR A1 a_743_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_743_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X3 a_575_47# a_27_297# a_187_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_743_297# A2 a_187_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR a_27_297# a_187_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X6 a_187_21# A2 a_743_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_187_21# a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_187_21# a_27_297# a_575_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VGND B1_N a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.198 ps=1.91 w=0.65 l=0.15
X10 VGND A2 a_575_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR a_187_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A1 a_575_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND a_187_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 X a_187_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VPWR a_187_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 a_575_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_575_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 X a_187_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 X a_187_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 X a_187_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VGND a_187_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 VGND A2 a_660_47# VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.0829 ps=0.905 w=0.65 l=0.15
X1 VGND C1 a_85_193# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.101 ps=0.96 w=0.65 l=0.15
X2 a_414_297# C1 a_334_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.125 ps=1.25 w=1 l=0.15
X3 VGND a_85_193# X VNB sky130_fd_pr__nfet_01v8 ad=0.275 pd=1.5 as=0.214 ps=1.96 w=0.65 l=0.15
X4 a_334_297# D1 a_85_193# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.125 pd=1.25 as=0.385 ps=2.77 w=1 l=0.15
X5 a_516_297# B1 a_414_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=1.56 as=0.18 ps=1.36 w=1 l=0.15
X6 a_516_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.135 ps=1.27 w=1 l=0.15
X7 a_660_47# A1 a_85_193# VNB sky130_fd_pr__nfet_01v8 ad=0.0829 pd=0.905 as=0.185 ps=1.22 w=0.65 l=0.15
X8 a_85_193# D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.275 ps=1.5 w=0.65 l=0.15
X9 VPWR A1 a_516_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=1.56 w=1 l=0.15
X10 a_85_193# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.22 as=0.117 ps=1.01 w=0.65 l=0.15
X11 VPWR a_85_193# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.29 ps=2.58 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3b_4 A B C_N VGND VNB VPB VPWR Y
X0 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VPWR A a_197_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_555_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_197_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_197_297# B a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X8 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X12 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y a_27_47# a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y a_27_47# a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X16 a_555_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_555_297# B a_197_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 a_197_297# B a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_555_297# B a_197_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 VPWR A a_197_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X23 a_197_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X25 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlymetal6s4s_1 A VGND VNB VPB VPWR X
X0 X a_345_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X1 VPWR a_239_47# a_345_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_841_47# a_664_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VGND a_239_47# a_345_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR A a_62_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND A a_62_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X6 X a_345_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 a_239_47# a_62_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X8 a_841_47# a_664_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X9 a_239_47# a_62_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X10 VPWR X a_664_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND X a_664_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2bb2ai_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
X0 VPWR A2_N a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.42 pd=1.84 as=0.135 ps=1.27 w=1 l=0.15
X1 Y a_112_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.42 ps=1.84 w=1 l=0.15
X2 VGND B2 a_394_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_112_297# A2_N a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.241 pd=2.04 as=0.0683 ps=0.86 w=0.65 l=0.15
X4 a_112_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.179 ps=1.85 w=0.65 l=0.15
X5 a_112_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X6 VPWR B1 a_478_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.135 ps=1.27 w=1 l=0.15
X7 a_394_47# a_112_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X8 a_394_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_478_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
X0 Y a_251_21# a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y a_251_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X5 VGND a_251_21# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X7 VPWR B_N a_251_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X8 VGND B_N a_251_21# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_27_297# a_251_21# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt park D[0] D[10] D[11] D[12] D[13] D[14] D[15] D[16] D[17] D[18] D[1] D[2]
+ D[3] D[4] D[5] D[6] D[7] D[8] D[9] Q[0] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15] Q[16]
+ Q[17] Q[18] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] VGND VPWR alpha[0] alpha[10]
+ alpha[11] alpha[12] alpha[13] alpha[14] alpha[15] alpha[16] alpha[17] alpha[18]
+ alpha[1] alpha[2] alpha[3] alpha[4] alpha[5] alpha[6] alpha[7] alpha[8] alpha[9]
+ beta[0] beta[10] beta[11] beta[12] beta[13] beta[14] beta[15] beta[16] beta[17]
+ beta[18] beta[1] beta[2] beta[3] beta[4] beta[5] beta[6] beta[7] beta[8] beta[9]
+ clk cos[0] cos[10] cos[11] cos[12] cos[13] cos[14] cos[15] cos[16] cos[17] cos[18]
+ cos[1] cos[2] cos[3] cos[4] cos[5] cos[6] cos[7] cos[8] cos[9] done rstb sin[0]
+ sin[10] sin[11] sin[12] sin[13] sin[14] sin[15] sin[16] sin[17] sin[18] sin[1] sin[2]
+ sin[3] sin[4] sin[5] sin[6] sin[7] sin[8] sin[9] start
X_09671_ _00904_ _00973_ VGND VGND VPWR VPWR _00981_ sky130_fd_sc_hd__and2_1
X_08622_ _03866_ _03932_ VGND VGND VPWR VPWR _07791_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_6_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08553_ _06190_ _06223_ _07020_ _07031_ VGND VGND VPWR VPWR _07042_ sky130_fd_sc_hd__or4_4
X_08484_ net199 net602 VGND VGND VPWR VPWR _06289_ sky130_fd_sc_hd__nand2_1
XFILLER_0_147_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09105_ _00419_ _00420_ _00421_ VGND VGND VPWR VPWR _00422_ sky130_fd_sc_hd__a21o_1
XFILLER_0_150_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09036_ net210 net201 net648 net639 VGND VGND VPWR VPWR _00354_ sky130_fd_sc_hd__and4_1
XFILLER_0_60_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09938_ net286 net277 VGND VGND VPWR VPWR _01244_ sky130_fd_sc_hd__or2_1
X_09869_ b_sin\[14\] _01176_ _00475_ VGND VGND VPWR VPWR _01177_ sky130_fd_sc_hd__mux2_1
X_11900_ net231 net482 net472 net315 VGND VGND VPWR VPWR _03252_ sky130_fd_sc_hd__a22oi_1
X_12880_ _04233_ _03933_ _04314_ VGND VGND VPWR VPWR _04322_ sky130_fd_sc_hd__or3_1
XFILLER_0_87_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11831_ _03175_ _03176_ VGND VGND VPWR VPWR _03177_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_95_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14550_ _06137_ _06139_ _05939_ _06049_ VGND VGND VPWR VPWR _06141_ sky130_fd_sc_hd__and4b_1
XFILLER_0_95_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11762_ net316 net492 _03100_ _03101_ VGND VGND VPWR VPWR _03102_ sky130_fd_sc_hd__a22o_1
X_13501_ _04996_ _04997_ _04993_ VGND VGND VPWR VPWR _04999_ sky130_fd_sc_hd__a21o_1
X_10713_ net384 net373 net742 net751 VGND VGND VPWR VPWR _01977_ sky130_fd_sc_hd__and4_1
XFILLER_0_67_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14481_ _06056_ _06063_ _06064_ VGND VGND VPWR VPWR _06065_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_126_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11693_ net232 net349 net500 net316 VGND VGND VPWR VPWR _03027_ sky130_fd_sc_hd__a22o_1
X_16220_ clknet_4_3_0_clk _00009_ net336 VGND VGND VPWR VPWR b_sin\[9\] sky130_fd_sc_hd__dfrtp_2
X_13432_ _04835_ _04923_ VGND VGND VPWR VPWR _04924_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_138_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10644_ _01850_ _01906_ _01851_ _01907_ VGND VGND VPWR VPWR _01908_ sky130_fd_sc_hd__a22o_1
XFILLER_0_24_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16151_ _07865_ _07884_ VGND VGND VPWR VPWR _07885_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_36_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13363_ _04842_ _04847_ VGND VGND VPWR VPWR _04848_ sky130_fd_sc_hd__xor2_2
X_10575_ _01836_ _01837_ _01838_ VGND VGND VPWR VPWR _01839_ sky130_fd_sc_hd__o21bai_1
Xrebuffer7 net817 VGND VGND VPWR VPWR net818 sky130_fd_sc_hd__clkbuf_1
X_15102_ _06742_ _06743_ _06637_ _06640_ VGND VGND VPWR VPWR _06745_ sky130_fd_sc_hd__o211ai_2
X_12314_ net730 net738 net214 net205 VGND VGND VPWR VPWR _03700_ sky130_fd_sc_hd__and4_1
X_16082_ net455 net643 VGND VGND VPWR VPWR _07810_ sky130_fd_sc_hd__nand2_1
XFILLER_0_106_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13294_ _04770_ _04771_ _04772_ VGND VGND VPWR VPWR _04773_ sky130_fd_sc_hd__a21o_1
X_15033_ _06457_ _06563_ VGND VGND VPWR VPWR _06669_ sky130_fd_sc_hd__nor2_1
X_12245_ _03600_ _03625_ VGND VGND VPWR VPWR _03627_ sky130_fd_sc_hd__xnor2_1
X_12176_ net231 net457 net152 net449 VGND VGND VPWR VPWR _03552_ sky130_fd_sc_hd__and4_1
X_11127_ _02194_ _02296_ _02297_ _02190_ VGND VGND VPWR VPWR _02411_ sky130_fd_sc_hd__and4b_1
X_11058_ net724 net362 _02334_ _02335_ VGND VGND VPWR VPWR _02336_ sky130_fd_sc_hd__a22o_1
X_15935_ _07337_ _07648_ _07649_ _07650_ VGND VGND VPWR VPWR _07652_ sky130_fd_sc_hd__a211o_4
X_10009_ _01262_ _01265_ _01263_ VGND VGND VPWR VPWR _01314_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_64_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15866_ _07504_ _07576_ VGND VGND VPWR VPWR _07577_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_149_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14817_ _06368_ _06433_ _06434_ VGND VGND VPWR VPWR _06435_ sky130_fd_sc_hd__and3_1
X_15797_ _07497_ _07501_ VGND VGND VPWR VPWR _07502_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_147_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14748_ _06147_ _06357_ _06358_ VGND VGND VPWR VPWR _06359_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14679_ _06206_ _06211_ _06205_ VGND VGND VPWR VPWR _06283_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout138 state VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__clkbuf_4
Xfanout149 net151 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_129_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09723_ _01017_ _01032_ VGND VGND VPWR VPWR _01033_ sky130_fd_sc_hd__xor2_1
X_09654_ _00905_ _00906_ _00963_ _00964_ VGND VGND VPWR VPWR _00965_ sky130_fd_sc_hd__o211a_1
X_08605_ _07325_ _07585_ _07596_ VGND VGND VPWR VPWR _07607_ sky130_fd_sc_hd__o21ai_1
X_09585_ _00896_ _00802_ VGND VGND VPWR VPWR _00897_ sky130_fd_sc_hd__nand2_2
XFILLER_0_77_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08536_ _06758_ _06835_ _06846_ VGND VGND VPWR VPWR _06857_ sky130_fd_sc_hd__a21o_1
XFILLER_0_148_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08467_ _05503_ _06036_ _06025_ _05926_ VGND VGND VPWR VPWR _06102_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_9_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08398_ _05275_ _05329_ _05286_ VGND VGND VPWR VPWR _05351_ sky130_fd_sc_hd__nand3_1
XFILLER_0_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10360_ _01622_ _01623_ VGND VGND VPWR VPWR _01624_ sky130_fd_sc_hd__or2b_1
XFILLER_0_103_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09019_ _00334_ _00335_ _00327_ VGND VGND VPWR VPWR _00337_ sky130_fd_sc_hd__a21o_1
X_10291_ net133 _01556_ _01563_ VGND VGND VPWR VPWR _00049_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_130_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12030_ _03389_ _03393_ VGND VGND VPWR VPWR _03394_ sky130_fd_sc_hd__xor2_1
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout650 net652 VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__clkbuf_4
Xfanout661 net662 VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__buf_2
Xfanout672 net675 VGND VGND VPWR VPWR net672 sky130_fd_sc_hd__clkbuf_2
X_13981_ _05520_ _05518_ VGND VGND VPWR VPWR _05521_ sky130_fd_sc_hd__and2_4
Xfanout683 net23 VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__clkbuf_4
Xfanout694 net695 VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__clkbuf_2
X_15720_ _07300_ _07317_ _07417_ VGND VGND VPWR VPWR _07418_ sky130_fd_sc_hd__a21o_1
X_12932_ net611 net194 VGND VGND VPWR VPWR _04379_ sky130_fd_sc_hd__nand2_1
XFILLER_0_88_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15651_ _07297_ _07298_ VGND VGND VPWR VPWR _07342_ sky130_fd_sc_hd__or2b_1
X_12863_ _04266_ _04267_ _04302_ _04303_ VGND VGND VPWR VPWR _04304_ sky130_fd_sc_hd__nand4_4
X_14602_ _06167_ _06170_ _06169_ VGND VGND VPWR VPWR _06198_ sky130_fd_sc_hd__o21bai_1
X_11814_ _03156_ net122 _03064_ _03066_ VGND VGND VPWR VPWR _03159_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_68_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15582_ _07257_ _07266_ VGND VGND VPWR VPWR _07267_ sky130_fd_sc_hd__xnor2_1
X_12794_ _04129_ _04131_ _04224_ _04227_ VGND VGND VPWR VPWR _04228_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_28_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14533_ _06116_ _06120_ VGND VGND VPWR VPWR _06122_ sky130_fd_sc_hd__or2_1
X_11745_ _02894_ _02895_ _02993_ _03083_ VGND VGND VPWR VPWR _03085_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_78_Left_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14464_ _06044_ _06045_ _05989_ _05987_ VGND VGND VPWR VPWR _06046_ sky130_fd_sc_hd__o211a_1
XFILLER_0_37_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11676_ _03002_ _03008_ VGND VGND VPWR VPWR _03009_ sky130_fd_sc_hd__xnor2_1
X_16203_ _07868_ _07940_ VGND VGND VPWR VPWR _07941_ sky130_fd_sc_hd__xnor2_1
X_13415_ _04891_ _04904_ VGND VGND VPWR VPWR _04906_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_64_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10627_ _01890_ VGND VGND VPWR VPWR _01891_ sky130_fd_sc_hd__buf_6
X_14395_ _05968_ _05969_ VGND VGND VPWR VPWR _05971_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_107_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16134_ net442 net652 VGND VGND VPWR VPWR _07866_ sky130_fd_sc_hd__nand2_1
X_13346_ _04823_ _04828_ VGND VGND VPWR VPWR _04831_ sky130_fd_sc_hd__or2_1
X_10558_ net381 net809 VGND VGND VPWR VPWR _01822_ sky130_fd_sc_hd__nand2_1
XFILLER_0_122_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16065_ net865 net866 net622 VGND VGND VPWR VPWR _07792_ sky130_fd_sc_hd__o21a_1
XFILLER_0_121_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13277_ _04639_ _04645_ VGND VGND VPWR VPWR _04755_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10489_ net811 _01751_ _01752_ VGND VGND VPWR VPWR _01753_ sky130_fd_sc_hd__and3_1
X_15016_ _06526_ _06528_ _06631_ _06632_ VGND VGND VPWR VPWR _06651_ sky130_fd_sc_hd__o211a_1
X_12228_ net152 net448 net143 net456 VGND VGND VPWR VPWR _03608_ sky130_fd_sc_hd__a22o_1
XFILLER_0_20_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_87_Left_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12159_ net465 net143 _03531_ VGND VGND VPWR VPWR _03533_ sky130_fd_sc_hd__and3_1
XFILLER_0_75_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15918_ _07631_ _07632_ VGND VGND VPWR VPWR _07633_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_79_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15849_ _02387_ net527 VGND VGND VPWR VPWR _07558_ sky130_fd_sc_hd__or2_1
XFILLER_0_149_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09370_ _00534_ _00618_ VGND VGND VPWR VPWR _00684_ sky130_fd_sc_hd__or2_1
XFILLER_0_115_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08321_ _04218_ _04262_ VGND VGND VPWR VPWR _04513_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_145_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_96_Left_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08252_ _03279_ _03290_ VGND VGND VPWR VPWR _03756_ sky130_fd_sc_hd__and2_1
XFILLER_0_7_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08183_ _02920_ _02996_ VGND VGND VPWR VPWR _03007_ sky130_fd_sc_hd__xnor2_2
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_132_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09706_ _00953_ _00956_ _01015_ VGND VGND VPWR VPWR _01016_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_4_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09637_ _00946_ _00947_ VGND VGND VPWR VPWR _00948_ sky130_fd_sc_hd__nor2_1
XFILLER_0_78_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09568_ _00878_ _00879_ VGND VGND VPWR VPWR _00880_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08519_ _06421_ _06475_ _06464_ VGND VGND VPWR VPWR _06671_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_148_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09499_ _00728_ _00730_ VGND VGND VPWR VPWR _00812_ sky130_fd_sc_hd__and2_1
XFILLER_0_77_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11530_ _02829_ _02848_ _02849_ VGND VGND VPWR VPWR _02850_ sky130_fd_sc_hd__nand3_1
XFILLER_0_92_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_137_Right_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11461_ _02771_ _02772_ _02774_ VGND VGND VPWR VPWR _02775_ sky130_fd_sc_hd__nand3_1
XFILLER_0_34_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13200_ _04667_ _04668_ _04669_ VGND VGND VPWR VPWR _04671_ sky130_fd_sc_hd__nand3_1
XFILLER_0_34_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10412_ _01643_ _01644_ _01638_ VGND VGND VPWR VPWR _01676_ sky130_fd_sc_hd__a21bo_1
X_14180_ net423 _00195_ _05696_ VGND VGND VPWR VPWR _05736_ sky130_fd_sc_hd__or3_1
XFILLER_0_61_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11392_ next_state _02697_ _02698_ _02699_ VGND VGND VPWR VPWR _00063_ sky130_fd_sc_hd__a31o_1
XFILLER_0_34_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13131_ _04586_ _04594_ _04595_ VGND VGND VPWR VPWR _04596_ sky130_fd_sc_hd__nand3_1
XFILLER_0_103_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10343_ net137 net117 VGND VGND VPWR VPWR _01608_ sky130_fd_sc_hd__or2_1
XFILLER_0_131_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13062_ net807 _00195_ VGND VGND VPWR VPWR _04520_ sky130_fd_sc_hd__nor2_1
X_10274_ net116 _01548_ net133 VGND VGND VPWR VPWR _01549_ sky130_fd_sc_hd__mux2_1
X_12013_ _03372_ _03373_ _03281_ _03374_ VGND VGND VPWR VPWR _03375_ sky130_fd_sc_hd__a211oi_1
Xfanout480 net43 VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__buf_4
XFILLER_0_136_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout491 net493 VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__buf_2
X_13964_ _05472_ _05473_ _05501_ VGND VGND VPWR VPWR _05502_ sky130_fd_sc_hd__a21o_1
XFILLER_0_45_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15703_ _07393_ _07398_ VGND VGND VPWR VPWR _07399_ sky130_fd_sc_hd__xor2_1
X_12915_ _04357_ _04358_ _04350_ VGND VGND VPWR VPWR _04361_ sky130_fd_sc_hd__a21o_1
X_13895_ _05425_ _05426_ VGND VGND VPWR VPWR _05428_ sky130_fd_sc_hd__xnor2_1
X_15634_ _07157_ _07241_ _07323_ VGND VGND VPWR VPWR _07324_ sky130_fd_sc_hd__o21a_1
XFILLER_0_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12846_ net425 net225 VGND VGND VPWR VPWR _04286_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15565_ _07248_ VGND VGND VPWR VPWR _00104_ sky130_fd_sc_hd__clkbuf_1
X_12777_ net806 net216 _04206_ VGND VGND VPWR VPWR _04210_ sky130_fd_sc_hd__a21o_1
XFILLER_0_84_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14516_ _06085_ _06086_ _06103_ VGND VGND VPWR VPWR _06104_ sky130_fd_sc_hd__nand3_2
X_11728_ _03017_ _03064_ _03065_ VGND VGND VPWR VPWR _03066_ sky130_fd_sc_hd__nand3b_2
XFILLER_0_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15496_ _07173_ _07071_ _07068_ VGND VGND VPWR VPWR _07174_ sky130_fd_sc_hd__a21o_1
XFILLER_0_138_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_878 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14447_ _05962_ _05967_ VGND VGND VPWR VPWR _06028_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_104_Right_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11659_ _02805_ _02889_ _02990_ VGND VGND VPWR VPWR _02991_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_142_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14378_ _05950_ _05951_ VGND VGND VPWR VPWR _05952_ sky130_fd_sc_hd__nor2_1
XFILLER_0_51_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16117_ _07682_ _07799_ VGND VGND VPWR VPWR _07848_ sky130_fd_sc_hd__nor2_1
X_13329_ _04694_ _04713_ _04712_ VGND VGND VPWR VPWR _04812_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16048_ _07709_ _07713_ _07710_ VGND VGND VPWR VPWR _07774_ sky130_fd_sc_hd__o21ba_1
X_08870_ b_sin\[2\] _00189_ _02181_ VGND VGND VPWR VPWR _00190_ sky130_fd_sc_hd__mux2_1
XFILLER_0_110_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09422_ _00656_ _00735_ VGND VGND VPWR VPWR _00736_ sky130_fd_sc_hd__xnor2_2
X_09353_ _00665_ _00666_ VGND VGND VPWR VPWR _00667_ sky130_fd_sc_hd__nor2_1
X_08304_ _04141_ _04317_ VGND VGND VPWR VPWR _04327_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09284_ net159 net670 net676 net305 VGND VGND VPWR VPWR _00599_ sky130_fd_sc_hd__a22o_1
XFILLER_0_145_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08235_ _03496_ _03507_ _03561_ VGND VGND VPWR VPWR _03572_ sky130_fd_sc_hd__nand3_2
XFILLER_0_144_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08166_ net196 net539 VGND VGND VPWR VPWR _02822_ sky130_fd_sc_hd__nand2_1
XFILLER_0_132_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08999_ _00315_ _00316_ VGND VGND VPWR VPWR _00317_ sky130_fd_sc_hd__xnor2_1
X_10961_ _02141_ _02143_ _02142_ VGND VGND VPWR VPWR _02230_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_15_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12700_ _04123_ _04081_ _04124_ VGND VGND VPWR VPWR _04125_ sky130_fd_sc_hd__and3_1
X_13680_ _05191_ _05193_ VGND VGND VPWR VPWR _05194_ sky130_fd_sc_hd__xor2_1
X_10892_ _02044_ _02049_ _02043_ VGND VGND VPWR VPWR _02156_ sky130_fd_sc_hd__a21bo_1
X_12631_ net748 net325 net243 net757 VGND VGND VPWR VPWR _04049_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_109_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15350_ _07013_ _07014_ VGND VGND VPWR VPWR _07015_ sky130_fd_sc_hd__nor2_1
X_12562_ _03880_ _03882_ VGND VGND VPWR VPWR _03973_ sky130_fd_sc_hd__nor2_1
XFILLER_0_109_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14301_ net419 net560 _05862_ _05864_ VGND VGND VPWR VPWR _05867_ sky130_fd_sc_hd__a22o_1
XFILLER_0_136_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11513_ net714 net484 net477 net723 VGND VGND VPWR VPWR _02831_ sky130_fd_sc_hd__a22oi_2
X_15281_ _06859_ _06939_ VGND VGND VPWR VPWR _06940_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_136_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12493_ _03787_ _03788_ VGND VGND VPWR VPWR _03897_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_81_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14232_ _05739_ _05757_ VGND VGND VPWR VPWR _05792_ sky130_fd_sc_hd__and2_1
X_11444_ net428 net359 _02754_ _02755_ VGND VGND VPWR VPWR _02756_ sky130_fd_sc_hd__a22o_1
XFILLER_0_135_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14163_ _05518_ _05520_ _05591_ _05716_ VGND VGND VPWR VPWR _05717_ sky130_fd_sc_hd__a211o_1
XFILLER_0_1_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11375_ _02652_ _02680_ VGND VGND VPWR VPWR _02682_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_150_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13114_ _04572_ _04575_ _04576_ VGND VGND VPWR VPWR _04577_ sky130_fd_sc_hd__and3_1
X_10326_ _01585_ _01591_ _01592_ VGND VGND VPWR VPWR _01594_ sky130_fd_sc_hd__or3_1
X_14094_ _05641_ _05642_ VGND VGND VPWR VPWR _05643_ sky130_fd_sc_hd__nor2_1
X_13045_ _04499_ _04500_ _04464_ VGND VGND VPWR VPWR _04503_ sky130_fd_sc_hd__o21ai_2
X_10257_ _01532_ _01533_ VGND VGND VPWR VPWR _01534_ sky130_fd_sc_hd__nand2_1
X_10188_ _01474_ _01475_ VGND VGND VPWR VPWR _01476_ sky130_fd_sc_hd__xnor2_1
X_14996_ _06626_ _06627_ _06522_ _06594_ VGND VGND VPWR VPWR _06630_ sky130_fd_sc_hd__o211a_1
X_13947_ net311 net271 VGND VGND VPWR VPWR _05484_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13878_ _05348_ _05349_ VGND VGND VPWR VPWR _05409_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15617_ _07304_ _07305_ VGND VGND VPWR VPWR _07306_ sky130_fd_sc_hd__nor2_1
X_12829_ _04264_ _04265_ _04244_ _04245_ VGND VGND VPWR VPWR _04267_ sky130_fd_sc_hd__a211o_1
XFILLER_0_8_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15548_ _07228_ _07229_ _07209_ VGND VGND VPWR VPWR _07231_ sky130_fd_sc_hd__a21o_1
X_15479_ _07078_ _07060_ VGND VGND VPWR VPWR _07155_ sky130_fd_sc_hd__and2b_1
XFILLER_0_126_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout7 net306 VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_4_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09971_ _01275_ _01276_ VGND VGND VPWR VPWR _01277_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_110_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08922_ _00146_ _00148_ VGND VGND VPWR VPWR _00241_ sky130_fd_sc_hd__nand2_1
X_08853_ _08068_ _00142_ _00171_ _00172_ VGND VGND VPWR VPWR _00173_ sky130_fd_sc_hd__a211oi_4
X_08784_ _08088_ _08091_ _08086_ VGND VGND VPWR VPWR _08094_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_98_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09405_ _00716_ _00717_ _00703_ VGND VGND VPWR VPWR _00719_ sky130_fd_sc_hd__a21o_1
X_09336_ _00647_ _00650_ VGND VGND VPWR VPWR _00651_ sky130_fd_sc_hd__xnor2_2
X_09267_ _00487_ _00490_ _00488_ VGND VGND VPWR VPWR _00582_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_7_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08218_ _03355_ _03366_ _03170_ _03203_ VGND VGND VPWR VPWR _03388_ sky130_fd_sc_hd__o211a_1
X_09198_ _00511_ _00512_ _00513_ VGND VGND VPWR VPWR _00514_ sky130_fd_sc_hd__a21o_1
XFILLER_0_62_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08149_ net171 net576 VGND VGND VPWR VPWR _02637_ sky130_fd_sc_hd__nand2_1
X_11160_ _02444_ _02445_ _02440_ VGND VGND VPWR VPWR _02447_ sky130_fd_sc_hd__a21o_1
XFILLER_0_31_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10111_ _01408_ _01409_ VGND VGND VPWR VPWR _01410_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11091_ _02369_ _02370_ _02305_ VGND VGND VPWR VPWR _02372_ sky130_fd_sc_hd__a21oi_1
X_10042_ _01345_ _01346_ VGND VGND VPWR VPWR _01347_ sky130_fd_sc_hd__nand2_1
Xhold41 a_cos\[12\] VGND VGND VPWR VPWR net852 sky130_fd_sc_hd__dlygate4sd3_1
X_14850_ net488 net574 net584 net478 VGND VGND VPWR VPWR _06470_ sky130_fd_sc_hd__a22oi_1
X_13801_ _05323_ _05324_ VGND VGND VPWR VPWR _05325_ sky130_fd_sc_hd__nor2_1
X_14781_ net360 net559 _06308_ _06307_ VGND VGND VPWR VPWR _06395_ sky130_fd_sc_hd__a31o_1
X_11993_ net316 net465 VGND VGND VPWR VPWR _03353_ sky130_fd_sc_hd__nand2_1
X_13732_ _05151_ _05152_ VGND VGND VPWR VPWR _05250_ sky130_fd_sc_hd__and2_1
XFILLER_0_85_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10944_ net742 net351 net502 net749 VGND VGND VPWR VPWR _02211_ sky130_fd_sc_hd__a22o_1
XFILLER_0_58_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13663_ _05038_ _05040_ _05174_ VGND VGND VPWR VPWR _05175_ sky130_fd_sc_hd__a21bo_1
X_10875_ _02137_ _02138_ VGND VGND VPWR VPWR _02139_ sky130_fd_sc_hd__and2b_1
X_15402_ net443 net573 _06963_ _07070_ VGND VGND VPWR VPWR _07071_ sky130_fd_sc_hd__a31o_1
XFILLER_0_94_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12614_ _04028_ _04021_ _04029_ VGND VGND VPWR VPWR _04030_ sky130_fd_sc_hd__nand3_4
X_13594_ _05097_ _05099_ VGND VGND VPWR VPWR _05100_ sky130_fd_sc_hd__xor2_2
XFILLER_0_81_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15333_ _06986_ _06994_ _06995_ VGND VGND VPWR VPWR _06996_ sky130_fd_sc_hd__nand3_2
X_12545_ _03951_ _03952_ _03953_ VGND VGND VPWR VPWR _03955_ sky130_fd_sc_hd__nand3_2
XFILLER_0_81_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15264_ net415 net635 net516 net431 VGND VGND VPWR VPWR _06921_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_124_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12476_ _03876_ _03878_ VGND VGND VPWR VPWR _03879_ sky130_fd_sc_hd__and2_2
XFILLER_0_22_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14215_ _05772_ _05717_ _05718_ _05720_ VGND VGND VPWR VPWR _05775_ sky130_fd_sc_hd__and4_1
XANTENNA_5 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11427_ net714 net493 VGND VGND VPWR VPWR _02738_ sky130_fd_sc_hd__and2_1
X_15195_ _06735_ _06738_ _06843_ _06845_ VGND VGND VPWR VPWR _06847_ sky130_fd_sc_hd__a211o_1
XFILLER_0_1_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14146_ _05680_ _05699_ VGND VGND VPWR VPWR _05700_ sky130_fd_sc_hd__xnor2_1
X_11358_ _02653_ _02662_ VGND VGND VPWR VPWR _02663_ sky130_fd_sc_hd__xor2_2
XFILLER_0_67_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10309_ b_cos\[14\] a_sin\[14\] VGND VGND VPWR VPWR _01579_ sky130_fd_sc_hd__and2b_1
X_14077_ net148 net271 VGND VGND VPWR VPWR _05625_ sky130_fd_sc_hd__nand2_1
X_11289_ _02585_ _02586_ _02552_ VGND VGND VPWR VPWR _02588_ sky130_fd_sc_hd__a21o_1
X_13028_ net141 net321 net237 net150 VGND VGND VPWR VPWR _04484_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_89_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer17 net827 VGND VGND VPWR VPWR net828 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_83_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer28 net218 VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__buf_2
XFILLER_0_88_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer39 _06867_ VGND VGND VPWR VPWR net877 sky130_fd_sc_hd__dlygate4sd1_1
X_14979_ _06609_ _06610_ VGND VGND VPWR VPWR _06611_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_77_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_882 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09121_ net167 net677 VGND VGND VPWR VPWR _00438_ sky130_fd_sc_hd__nand2_1
XFILLER_0_115_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09052_ _00367_ _00368_ _00352_ VGND VGND VPWR VPWR _00370_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09954_ _01213_ _01204_ VGND VGND VPWR VPWR _01260_ sky130_fd_sc_hd__and2b_1
X_08905_ _00220_ _00223_ VGND VGND VPWR VPWR _00224_ sky130_fd_sc_hd__xnor2_1
X_09885_ _01123_ _01126_ _01124_ VGND VGND VPWR VPWR _01192_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_148_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08836_ net195 net678 VGND VGND VPWR VPWR _00156_ sky130_fd_sc_hd__and2_1
X_08767_ _08017_ _08076_ _08077_ VGND VGND VPWR VPWR _08078_ sky130_fd_sc_hd__and3_1
XFILLER_0_68_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08698_ _07835_ _07878_ _08006_ _08008_ VGND VGND VPWR VPWR _08009_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_94_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10660_ _01625_ _01734_ VGND VGND VPWR VPWR _01924_ sky130_fd_sc_hd__and2_1
XFILLER_0_35_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09319_ _00531_ _00532_ _00543_ _00544_ VGND VGND VPWR VPWR _00634_ sky130_fd_sc_hd__or4bb_1
XFILLER_0_118_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10591_ _01843_ _01844_ _01828_ VGND VGND VPWR VPWR _01855_ sky130_fd_sc_hd__o21a_1
X_12330_ net721 net214 net205 net729 VGND VGND VPWR VPWR _03718_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_63_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12261_ _03393_ _03516_ _03640_ _03641_ _03643_ VGND VGND VPWR VPWR _03644_ sky130_fd_sc_hd__o311ai_4
XFILLER_0_31_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14000_ _05539_ _05540_ VGND VGND VPWR VPWR _05541_ sky130_fd_sc_hd__xor2_1
XFILLER_0_120_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11212_ _02409_ _02393_ VGND VGND VPWR VPWR _02503_ sky130_fd_sc_hd__and2b_1
XFILLER_0_31_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12192_ _03543_ _03567_ VGND VGND VPWR VPWR _03569_ sky130_fd_sc_hd__nor2_1
X_11143_ _02425_ _02426_ _02427_ VGND VGND VPWR VPWR _02428_ sky130_fd_sc_hd__nand3_2
XFILLER_0_37_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput86 net86 VGND VGND VPWR VPWR D[16] sky130_fd_sc_hd__clkbuf_4
Xoutput97 net97 VGND VGND VPWR VPWR D[9] sky130_fd_sc_hd__clkbuf_4
X_11074_ _02246_ _02248_ _02247_ VGND VGND VPWR VPWR _02353_ sky130_fd_sc_hd__o21bai_1
X_15951_ _07662_ _07667_ VGND VGND VPWR VPWR _07668_ sky130_fd_sc_hd__xnor2_1
X_10025_ _01181_ _01328_ VGND VGND VPWR VPWR _01330_ sky130_fd_sc_hd__or2_1
X_14902_ _06524_ _06525_ _06424_ _06492_ VGND VGND VPWR VPWR _06527_ sky130_fd_sc_hd__o211a_1
X_15882_ _07591_ _07592_ VGND VGND VPWR VPWR _07593_ sky130_fd_sc_hd__xor2_1
X_14833_ _06450_ _06437_ _06449_ _06360_ VGND VGND VPWR VPWR _06451_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_144_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14764_ net470 net604 VGND VGND VPWR VPWR _06376_ sky130_fd_sc_hd__and2_1
X_11976_ _03332_ _03334_ VGND VGND VPWR VPWR _03335_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13715_ _05211_ _05212_ _05229_ _05230_ VGND VGND VPWR VPWR _05232_ sky130_fd_sc_hd__o211ai_2
X_10927_ _02171_ _02192_ VGND VGND VPWR VPWR _02193_ sky130_fd_sc_hd__or2_1
X_14695_ _06283_ _06298_ _06299_ VGND VGND VPWR VPWR _06301_ sky130_fd_sc_hd__nand3_4
X_13646_ _05070_ _05071_ VGND VGND VPWR VPWR _05157_ sky130_fd_sc_hd__or2b_1
X_10858_ _02118_ _02121_ VGND VGND VPWR VPWR _02122_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_128_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13577_ net312 net158 net304 net423 VGND VGND VPWR VPWR _05082_ sky130_fd_sc_hd__a22o_1
XFILLER_0_82_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10789_ _02050_ _02051_ _02036_ VGND VGND VPWR VPWR _02053_ sky130_fd_sc_hd__a21o_1
XFILLER_0_82_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15316_ _06960_ _06977_ VGND VGND VPWR VPWR _06978_ sky130_fd_sc_hd__xnor2_2
X_12528_ _03934_ _03935_ VGND VGND VPWR VPWR _03936_ sky130_fd_sc_hd__nand2_1
X_16296_ clknet_4_9_0_clk _00085_ net341 VGND VGND VPWR VPWR a_sin\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_81_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15247_ _06901_ _06902_ VGND VGND VPWR VPWR _06903_ sky130_fd_sc_hd__nor2_1
X_12459_ net780 net789 net294 net284 VGND VGND VPWR VPWR _03860_ sky130_fd_sc_hd__and4_1
XFILLER_0_112_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15178_ net460 net454 net573 net585 VGND VGND VPWR VPWR _06828_ sky130_fd_sc_hd__and4_1
XFILLER_0_68_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14129_ net149 net271 _05624_ VGND VGND VPWR VPWR _05681_ sky130_fd_sc_hd__and3_1
Xfanout309 net310 VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_94_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09670_ _00980_ VGND VGND VPWR VPWR _00011_ sky130_fd_sc_hd__clkbuf_1
X_08621_ _03800_ _03855_ VGND VGND VPWR VPWR _07781_ sky130_fd_sc_hd__and2b_1
XFILLER_0_118_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08552_ _06168_ _06606_ _06595_ VGND VGND VPWR VPWR _07031_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_147_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08483_ _06256_ _06267_ VGND VGND VPWR VPWR _06278_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09104_ net297 net529 VGND VGND VPWR VPWR _00421_ sky130_fd_sc_hd__and2_1
XFILLER_0_72_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09035_ net201 net648 net639 net210 VGND VGND VPWR VPWR _00353_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_5_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_107_Left_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout810 net811 VGND VGND VPWR VPWR net810 sky130_fd_sc_hd__clkbuf_4
X_09937_ net286 net277 net624 VGND VGND VPWR VPWR _01243_ sky130_fd_sc_hd__and3_1
X_09868_ _01118_ _01175_ VGND VGND VPWR VPWR _01176_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_99_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08819_ _00120_ _00137_ _00138_ VGND VGND VPWR VPWR _00139_ sky130_fd_sc_hd__and3_1
X_09799_ _01036_ _01037_ _01039_ _01107_ VGND VGND VPWR VPWR _01108_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_99_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_116_Left_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11830_ net511 net466 VGND VGND VPWR VPWR _03176_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11761_ net232 net346 net498 net153 VGND VGND VPWR VPWR _03101_ sky130_fd_sc_hd__nand4_2
XFILLER_0_67_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13500_ _04993_ _04996_ _04997_ VGND VGND VPWR VPWR _04998_ sky130_fd_sc_hd__nand3_1
XFILLER_0_95_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10712_ net363 net761 VGND VGND VPWR VPWR _01976_ sky130_fd_sc_hd__nand2_1
X_14480_ _06057_ _06059_ _06062_ VGND VGND VPWR VPWR _06064_ sky130_fd_sc_hd__nand3_1
X_11692_ _03024_ _03025_ VGND VGND VPWR VPWR _03026_ sky130_fd_sc_hd__xnor2_1
X_13431_ _04920_ _04922_ VGND VGND VPWR VPWR _04923_ sky130_fd_sc_hd__xnor2_2
X_10643_ _01784_ VGND VGND VPWR VPWR _01907_ sky130_fd_sc_hd__inv_2
XFILLER_0_82_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16150_ _07882_ _07883_ VGND VGND VPWR VPWR _07884_ sky130_fd_sc_hd__and2_1
X_13362_ _04845_ _04846_ VGND VGND VPWR VPWR _04847_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_106_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10574_ net522 net437 net769 net778 VGND VGND VPWR VPWR _01838_ sky130_fd_sc_hd__and4_1
Xrebuffer8 net876 VGND VGND VPWR VPWR net819 sky130_fd_sc_hd__clkbuf_1
X_15101_ _06637_ _06640_ _06742_ _06743_ VGND VGND VPWR VPWR _06744_ sky130_fd_sc_hd__a211o_1
XFILLER_0_2_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12313_ net747 net197 VGND VGND VPWR VPWR _03699_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_125_Left_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16081_ _07751_ _07754_ VGND VGND VPWR VPWR _07809_ sky130_fd_sc_hd__nor2_1
X_13293_ net719 net300 VGND VGND VPWR VPWR _04772_ sky130_fd_sc_hd__and2_1
X_15032_ _06652_ _06667_ VGND VGND VPWR VPWR _06668_ sky130_fd_sc_hd__xnor2_1
X_12244_ _03602_ _03624_ VGND VGND VPWR VPWR _03625_ sky130_fd_sc_hd__xor2_1
XFILLER_0_31_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12175_ net231 net449 _03549_ VGND VGND VPWR VPWR _03551_ sky130_fd_sc_hd__a21boi_1
X_11126_ _02393_ _02409_ VGND VGND VPWR VPWR _02410_ sky130_fd_sc_hd__xnor2_1
X_11057_ net615 net715 net384 net373 VGND VGND VPWR VPWR _02335_ sky130_fd_sc_hd__nand4_2
X_15934_ _07505_ _07495_ _07574_ VGND VGND VPWR VPWR _07650_ sky130_fd_sc_hd__o21a_1
X_10008_ _01311_ _01312_ VGND VGND VPWR VPWR _01313_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_134_Left_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15865_ _07505_ _07574_ VGND VGND VPWR VPWR _07576_ sky130_fd_sc_hd__xor2_1
XFILLER_0_99_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14816_ _06430_ _06431_ _06315_ _06341_ VGND VGND VPWR VPWR _06434_ sky130_fd_sc_hd__a211o_1
X_15796_ _07337_ _07498_ _07500_ VGND VGND VPWR VPWR _07501_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_98_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14747_ _06279_ _06352_ _06351_ _06275_ VGND VGND VPWR VPWR _06358_ sky130_fd_sc_hd__and4b_1
X_11959_ _03245_ _03316_ VGND VGND VPWR VPWR _03317_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14678_ _06215_ _06216_ _06226_ VGND VGND VPWR VPWR _06282_ sky130_fd_sc_hd__nand3_2
XFILLER_0_55_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13629_ _05136_ _05137_ VGND VGND VPWR VPWR _05138_ sky130_fd_sc_hd__or2b_1
XFILLER_0_116_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_143_Left_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16279_ clknet_4_7_0_clk _00068_ net338 VGND VGND VPWR VPWR a_cos\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_2_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout139 net140 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__buf_2
X_09722_ _01030_ _01031_ VGND VGND VPWR VPWR _01032_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09653_ _00941_ _00942_ _00961_ _00962_ VGND VGND VPWR VPWR _00964_ sky130_fd_sc_hd__nand4_2
X_08604_ _06190_ _06223_ _06617_ VGND VGND VPWR VPWR _07596_ sky130_fd_sc_hd__o21ai_1
X_09584_ _00800_ _00786_ VGND VGND VPWR VPWR _00896_ sky130_fd_sc_hd__or2b_1
XFILLER_0_54_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_118_Right_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08535_ _06769_ _06780_ _06824_ VGND VGND VPWR VPWR _06846_ sky130_fd_sc_hd__and3_1
XFILLER_0_77_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08466_ _06058_ _06080_ VGND VGND VPWR VPWR _06091_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_92_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08397_ _05275_ _05286_ _05329_ VGND VGND VPWR VPWR _05340_ sky130_fd_sc_hd__a21o_1
XFILLER_0_9_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09018_ _00327_ _00334_ _00335_ VGND VGND VPWR VPWR _00336_ sky130_fd_sc_hd__nand3_1
XFILLER_0_103_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10290_ _01561_ _01562_ net135 VGND VGND VPWR VPWR _01563_ sky130_fd_sc_hd__or3b_2
XFILLER_0_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout640 net27 VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__clkbuf_4
Xfanout651 net652 VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__buf_2
Xfanout662 net665 VGND VGND VPWR VPWR net662 sky130_fd_sc_hd__buf_2
X_13980_ _05203_ _05204_ _05366_ _05517_ _05519_ VGND VGND VPWR VPWR _05520_ sky130_fd_sc_hd__o41a_4
Xfanout673 net675 VGND VGND VPWR VPWR net673 sky130_fd_sc_hd__clkbuf_4
Xfanout684 net685 VGND VGND VPWR VPWR net684 sky130_fd_sc_hd__buf_6
Xfanout695 net21 VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__buf_2
X_12931_ _04368_ _04377_ VGND VGND VPWR VPWR _04378_ sky130_fd_sc_hd__xor2_2
X_12862_ _04300_ _04301_ _03830_ _04268_ VGND VGND VPWR VPWR _04303_ sky130_fd_sc_hd__o211ai_4
X_15650_ _07322_ _07324_ VGND VGND VPWR VPWR _07341_ sky130_fd_sc_hd__nor2_1
X_14601_ _06174_ _06180_ _06173_ VGND VGND VPWR VPWR _06197_ sky130_fd_sc_hd__a21bo_1
X_11813_ _03064_ _03066_ _03156_ net122 VGND VGND VPWR VPWR _03158_ sky130_fd_sc_hd__a211oi_2
X_15581_ _07264_ _07265_ VGND VGND VPWR VPWR _07266_ sky130_fd_sc_hd__or2b_1
X_12793_ _03986_ _04226_ VGND VGND VPWR VPWR _04227_ sky130_fd_sc_hd__xor2_2
X_14532_ _06116_ _06120_ VGND VGND VPWR VPWR _06121_ sky130_fd_sc_hd__nand2_1
X_11744_ _02902_ _02892_ _02992_ VGND VGND VPWR VPWR _03083_ sky130_fd_sc_hd__o21a_1
XFILLER_0_139_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14463_ _06042_ _06043_ _05982_ VGND VGND VPWR VPWR _06045_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_83_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11675_ _03005_ _03006_ VGND VGND VPWR VPWR _03008_ sky130_fd_sc_hd__xnor2_1
X_13414_ _04902_ _04903_ VGND VGND VPWR VPWR _04904_ sky130_fd_sc_hd__nor2_1
X_16202_ _07938_ _07939_ VGND VGND VPWR VPWR _07940_ sky130_fd_sc_hd__xnor2_1
X_10626_ net517 net432 VGND VGND VPWR VPWR _01890_ sky130_fd_sc_hd__and2_1
X_14394_ _05919_ _05921_ _05920_ VGND VGND VPWR VPWR _05969_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_63_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16133_ _07724_ _07797_ _07864_ VGND VGND VPWR VPWR _07865_ sky130_fd_sc_hd__a21bo_1
X_13345_ _04823_ _04828_ VGND VGND VPWR VPWR _04830_ sky130_fd_sc_hd__nand2_1
XFILLER_0_106_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10557_ _01813_ _01820_ VGND VGND VPWR VPWR _01821_ sky130_fd_sc_hd__nor2_1
XFILLER_0_51_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16064_ net865 net866 net622 VGND VGND VPWR VPWR _07790_ sky130_fd_sc_hd__and3_1
X_13276_ _04751_ _04753_ VGND VGND VPWR VPWR _04754_ sky130_fd_sc_hd__xnor2_1
X_10488_ _01748_ _01750_ VGND VGND VPWR VPWR _01752_ sky130_fd_sc_hd__xor2_1
X_15015_ _06460_ _06566_ _06567_ VGND VGND VPWR VPWR _06650_ sky130_fd_sc_hd__o21a_1
XFILLER_0_121_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12227_ net448 net143 VGND VGND VPWR VPWR _03607_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12158_ net465 net143 _03531_ VGND VGND VPWR VPWR _03532_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_75_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11109_ _02196_ _02304_ VGND VGND VPWR VPWR _02391_ sky130_fd_sc_hd__nor2_1
X_12089_ _03396_ _03457_ VGND VGND VPWR VPWR _03458_ sky130_fd_sc_hd__xnor2_1
X_15917_ _07528_ _07532_ _07535_ VGND VGND VPWR VPWR _07632_ sky130_fd_sc_hd__a21o_1
XFILLER_0_91_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15848_ _07554_ _07556_ VGND VGND VPWR VPWR _07557_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15779_ _07463_ _07481_ VGND VGND VPWR VPWR _07482_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08320_ _04360_ _04480_ _04491_ VGND VGND VPWR VPWR _04502_ sky130_fd_sc_hd__nand3_2
XFILLER_0_87_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08251_ _03712_ _03723_ _02899_ _03409_ VGND VGND VPWR VPWR _03745_ sky130_fd_sc_hd__o211a_1
XFILLER_0_145_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08182_ _02931_ _02986_ VGND VGND VPWR VPWR _02996_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_15_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09705_ _00957_ _00958_ VGND VGND VPWR VPWR _01015_ sky130_fd_sc_hd__or2_1
XFILLER_0_97_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09636_ net265 net255 net689 net696 VGND VGND VPWR VPWR _00947_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09567_ net248 net535 VGND VGND VPWR VPWR _00879_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08518_ _05741_ _06212_ _06628_ _06649_ VGND VGND VPWR VPWR _06660_ sky130_fd_sc_hd__o31a_1
X_09498_ _00742_ _00810_ VGND VGND VPWR VPWR _00811_ sky130_fd_sc_hd__xor2_1
XFILLER_0_136_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08449_ _05806_ _05882_ _05893_ VGND VGND VPWR VPWR _05904_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_37_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11460_ _02667_ _02668_ _02672_ _02773_ VGND VGND VPWR VPWR _02774_ sky130_fd_sc_hd__a31o_1
XFILLER_0_92_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10411_ _01668_ _01673_ _01674_ VGND VGND VPWR VPWR _01675_ sky130_fd_sc_hd__nand3_2
XFILLER_0_104_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11391_ a_cos\[5\] net863 VGND VGND VPWR VPWR _02699_ sky130_fd_sc_hd__and2_1
XFILLER_0_150_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13130_ _04592_ _04593_ _04485_ _04587_ VGND VGND VPWR VPWR _04595_ sky130_fd_sc_hd__a211o_1
XFILLER_0_21_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10342_ _01607_ VGND VGND VPWR VPWR _00056_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_131_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13061_ _04512_ VGND VGND VPWR VPWR _04519_ sky130_fd_sc_hd__inv_2
X_10273_ _01546_ _01547_ VGND VGND VPWR VPWR _01548_ sky130_fd_sc_hd__xnor2_2
X_12012_ _03282_ _03306_ VGND VGND VPWR VPWR _03374_ sky130_fd_sc_hd__nor2_1
Xfanout470 net44 VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__buf_4
XFILLER_0_136_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout481 net483 VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__clkbuf_4
Xfanout492 net493 VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__buf_2
X_13963_ _05499_ _05500_ VGND VGND VPWR VPWR _05501_ sky130_fd_sc_hd__xor2_1
X_15702_ _07396_ _07397_ VGND VGND VPWR VPWR _07398_ sky130_fd_sc_hd__nor2_1
X_12914_ _04350_ _04357_ _04358_ VGND VGND VPWR VPWR _04359_ sky130_fd_sc_hd__nand3_2
X_13894_ net718 _00408_ VGND VGND VPWR VPWR _05426_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12845_ _04280_ _04283_ VGND VGND VPWR VPWR _04285_ sky130_fd_sc_hd__xnor2_2
X_15633_ _07237_ _07240_ VGND VGND VPWR VPWR _07323_ sky130_fd_sc_hd__or2_1
XFILLER_0_61_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12776_ _04201_ _04205_ _04208_ VGND VGND VPWR VPWR _04209_ sky130_fd_sc_hd__a21bo_1
X_15564_ b_cos\[8\] _07247_ _06949_ VGND VGND VPWR VPWR _07248_ sky130_fd_sc_hd__mux2_1
XFILLER_0_84_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14515_ _06088_ _06090_ _06095_ _06101_ VGND VGND VPWR VPWR _06103_ sky130_fd_sc_hd__a31o_1
X_11727_ _03061_ _03063_ _02955_ _02980_ VGND VGND VPWR VPWR _03065_ sky130_fd_sc_hd__o211ai_2
X_15495_ _07064_ _07065_ _07066_ VGND VGND VPWR VPWR _07173_ sky130_fd_sc_hd__a21o_1
XFILLER_0_138_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14446_ _06024_ _06023_ _05993_ _05960_ VGND VGND VPWR VPWR _06027_ sky130_fd_sc_hd__o211a_1
XFILLER_0_126_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11658_ _02887_ _02885_ VGND VGND VPWR VPWR _02990_ sky130_fd_sc_hd__and2b_1
XFILLER_0_142_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10609_ _01865_ _01871_ _01872_ VGND VGND VPWR VPWR _01873_ sky130_fd_sc_hd__and3_1
XFILLER_0_4_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14377_ net408 net398 net550 net560 VGND VGND VPWR VPWR _05951_ sky130_fd_sc_hd__and4_1
X_11589_ _02911_ _02912_ _02913_ VGND VGND VPWR VPWR _02914_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_10_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13328_ _04795_ _04810_ VGND VGND VPWR VPWR _04811_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_52_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16116_ _07831_ _07834_ _07832_ VGND VGND VPWR VPWR _07847_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_150_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_882 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13259_ _04733_ _04735_ VGND VGND VPWR VPWR _04736_ sky130_fd_sc_hd__xor2_1
X_16047_ _07769_ _07772_ VGND VGND VPWR VPWR _07773_ sky130_fd_sc_hd__xor2_2
XFILLER_0_110_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09421_ _00732_ _00734_ VGND VGND VPWR VPWR _00735_ sky130_fd_sc_hd__xor2_2
X_09352_ _00663_ _00664_ net249 net554 VGND VGND VPWR VPWR _00666_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_75_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08303_ _04295_ _04306_ VGND VGND VPWR VPWR _04317_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_19_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09283_ _00596_ _00597_ VGND VGND VPWR VPWR _00598_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_19_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08234_ _03518_ _03550_ VGND VGND VPWR VPWR _03561_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_145_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08165_ _02779_ _02790_ _02735_ VGND VGND VPWR VPWR _02811_ sky130_fd_sc_hd__a21o_1
XFILLER_0_133_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08998_ _00193_ net599 VGND VGND VPWR VPWR _00316_ sky130_fd_sc_hd__nor2_1
X_10960_ _02134_ _02136_ VGND VGND VPWR VPWR _02229_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09619_ net166 net619 VGND VGND VPWR VPWR _00930_ sky130_fd_sc_hd__nand2_2
X_10891_ _02152_ _02153_ _02145_ VGND VGND VPWR VPWR _02155_ sky130_fd_sc_hd__a21o_1
X_12630_ net766 net221 VGND VGND VPWR VPWR _04048_ sky130_fd_sc_hd__nand2_1
XFILLER_0_109_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12561_ _03963_ _03959_ VGND VGND VPWR VPWR _03972_ sky130_fd_sc_hd__or2b_1
XFILLER_0_38_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11512_ _02752_ _02760_ _02759_ VGND VGND VPWR VPWR _02830_ sky130_fd_sc_hd__a21bo_1
X_14300_ _05817_ _05818_ _05815_ VGND VGND VPWR VPWR _05866_ sky130_fd_sc_hd__o21bai_1
X_15280_ _06861_ _06938_ VGND VGND VPWR VPWR _06939_ sky130_fd_sc_hd__xnor2_2
X_12492_ _03890_ _03894_ _03895_ VGND VGND VPWR VPWR _03896_ sky130_fd_sc_hd__o21ba_1
X_14231_ _05789_ _05790_ VGND VGND VPWR VPWR _05791_ sky130_fd_sc_hd__xor2_1
XFILLER_0_150_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11443_ net233 net317 net378 net368 VGND VGND VPWR VPWR _02755_ sky130_fd_sc_hd__nand4_2
XFILLER_0_33_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14162_ _05650_ _05712_ VGND VGND VPWR VPWR _05716_ sky130_fd_sc_hd__or2_1
X_11374_ _02678_ _02679_ VGND VGND VPWR VPWR _02680_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_22_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13113_ net611 net175 _04573_ _04574_ VGND VGND VPWR VPWR _04576_ sky130_fd_sc_hd__nand4_1
X_10325_ _01585_ _01591_ _01592_ VGND VGND VPWR VPWR _01593_ sky130_fd_sc_hd__o21ai_1
X_14093_ _05573_ _05576_ _05639_ _05640_ VGND VGND VPWR VPWR _05642_ sky130_fd_sc_hd__o211a_1
X_13044_ _04464_ _04499_ _04500_ VGND VGND VPWR VPWR _04501_ sky130_fd_sc_hd__or3_4
X_10256_ a_sin\[7\] b_cos\[7\] VGND VGND VPWR VPWR _01533_ sky130_fd_sc_hd__or2b_1
X_10187_ _01467_ _01469_ _01466_ VGND VGND VPWR VPWR _01475_ sky130_fd_sc_hd__o21ba_1
X_14995_ _06522_ _06594_ _06626_ _06627_ VGND VGND VPWR VPWR _06629_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_89_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
X_13946_ net227 net148 net287 net278 VGND VGND VPWR VPWR _05483_ sky130_fd_sc_hd__and4_1
X_13877_ _05326_ _05330_ _05404_ _05406_ VGND VGND VPWR VPWR _05408_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_88_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15616_ net455 net447 net527 net536 VGND VGND VPWR VPWR _07305_ sky130_fd_sc_hd__and4_1
X_12828_ _04244_ _04245_ _04264_ _04265_ VGND VGND VPWR VPWR _04266_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_146_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15547_ _07209_ _07228_ _07229_ VGND VGND VPWR VPWR _07230_ sky130_fd_sc_hd__nand3_1
XFILLER_0_139_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12759_ _04164_ _04189_ VGND VGND VPWR VPWR _04190_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15478_ _07055_ _07142_ VGND VGND VPWR VPWR _07154_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14429_ _06000_ _06001_ _06007_ VGND VGND VPWR VPWR _06008_ sky130_fd_sc_hd__nand3_1
XFILLER_0_115_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout8 net156 VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__buf_4
X_09970_ _00194_ net666 VGND VGND VPWR VPWR _01276_ sky130_fd_sc_hd__nor2_1
XFILLER_0_122_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08921_ _00152_ _00169_ _00170_ VGND VGND VPWR VPWR _00240_ sky130_fd_sc_hd__nand3_2
XFILLER_0_0_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08852_ _00169_ _00170_ _00152_ VGND VGND VPWR VPWR _00172_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_137_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08783_ _08093_ VGND VGND VPWR VPWR _00001_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_137_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09404_ _00703_ _00716_ _00717_ VGND VGND VPWR VPWR _00718_ sky130_fd_sc_hd__nand3_1
XFILLER_0_94_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09335_ _00473_ _00648_ _00649_ VGND VGND VPWR VPWR _00650_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_47_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09266_ _00575_ _00580_ VGND VGND VPWR VPWR _00581_ sky130_fd_sc_hd__xor2_4
XFILLER_0_106_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08217_ _03170_ _03203_ _03355_ _03366_ VGND VGND VPWR VPWR _03377_ sky130_fd_sc_hd__a211oi_2
X_09197_ net297 net695 VGND VGND VPWR VPWR _00513_ sky130_fd_sc_hd__and2_1
XFILLER_0_50_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08148_ _02310_ _02332_ _02321_ VGND VGND VPWR VPWR _02626_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_30_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10110_ _01400_ _01403_ _01401_ VGND VGND VPWR VPWR _01409_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_30_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11090_ _02305_ _02369_ _02370_ VGND VGND VPWR VPWR _02371_ sky130_fd_sc_hd__and3_2
X_10041_ _01284_ _01301_ _01344_ VGND VGND VPWR VPWR _01346_ sky130_fd_sc_hd__or3_1
Xhold42 b_cos\[12\] VGND VGND VPWR VPWR net853 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13800_ _05137_ _05241_ _05136_ VGND VGND VPWR VPWR _05324_ sky130_fd_sc_hd__a21o_1
X_14780_ _06301_ _06302_ _06312_ VGND VGND VPWR VPWR _06394_ sky130_fd_sc_hd__nand3_2
X_11992_ _03350_ _03351_ VGND VGND VPWR VPWR _03352_ sky130_fd_sc_hd__nor2_1
XFILLER_0_97_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13731_ _05247_ _05232_ _05233_ VGND VGND VPWR VPWR _05249_ sky130_fd_sc_hd__nand3_2
X_10943_ _02208_ _02209_ VGND VGND VPWR VPWR _02210_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13662_ _05031_ _05037_ VGND VGND VPWR VPWR _05174_ sky130_fd_sc_hd__nand2_1
X_10874_ _02135_ _02136_ _02132_ VGND VGND VPWR VPWR _02138_ sky130_fd_sc_hd__a21o_1
X_15401_ net554 _06962_ VGND VGND VPWR VPWR _07070_ sky130_fd_sc_hd__and2_1
X_12613_ _04018_ _04019_ _04005_ _04017_ VGND VGND VPWR VPWR _04029_ sky130_fd_sc_hd__o211ai_4
X_13593_ _04979_ _05005_ _05098_ VGND VGND VPWR VPWR _05099_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_26_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12544_ _03913_ _03912_ _03904_ VGND VGND VPWR VPWR _03953_ sky130_fd_sc_hd__a21o_1
X_15332_ _06991_ _06992_ _06993_ VGND VGND VPWR VPWR _06995_ sky130_fd_sc_hd__a21o_1
XFILLER_0_53_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12475_ _03871_ _03872_ _03875_ VGND VGND VPWR VPWR _03878_ sky130_fd_sc_hd__a21o_1
XFILLER_0_81_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15263_ net415 net626 VGND VGND VPWR VPWR _06920_ sky130_fd_sc_hd__nand2_2
X_14214_ _05717_ _05718_ _05720_ _05772_ VGND VGND VPWR VPWR _05773_ sky130_fd_sc_hd__a31oi_2
X_11426_ net513 net614 net349 net500 VGND VGND VPWR VPWR _02737_ sky130_fd_sc_hd__nand4_1
XANTENNA_6 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_15194_ _06820_ _06844_ _06842_ VGND VGND VPWR VPWR _06845_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_34_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14145_ _05696_ _05697_ VGND VGND VPWR VPWR _05699_ sky130_fd_sc_hd__xnor2_1
X_11357_ _02660_ _02661_ VGND VGND VPWR VPWR _02662_ sky130_fd_sc_hd__and2b_1
XFILLER_0_104_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10308_ a_sin\[14\] b_cos\[14\] VGND VGND VPWR VPWR _01578_ sky130_fd_sc_hd__and2b_1
X_14076_ _05620_ _05623_ VGND VGND VPWR VPWR _05624_ sky130_fd_sc_hd__nor2_1
XFILLER_0_120_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11288_ _02552_ _02585_ _02586_ VGND VGND VPWR VPWR _02587_ sky130_fd_sc_hd__nand3_1
X_13027_ net230 net219 VGND VGND VPWR VPWR _04483_ sky130_fd_sc_hd__nand2_1
X_10239_ net111 _01518_ net136 VGND VGND VPWR VPWR _01519_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer18 _00160_ VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_83_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer29 net839 VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__dlygate4sd2_1
X_14978_ net388 net682 VGND VGND VPWR VPWR _06610_ sky130_fd_sc_hd__and2_1
XFILLER_0_89_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13929_ _05462_ _05463_ VGND VGND VPWR VPWR _05464_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09120_ net658 _00435_ _00436_ VGND VGND VPWR VPWR _00437_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_57_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09051_ _00352_ _00367_ _00368_ VGND VGND VPWR VPWR _00369_ sky130_fd_sc_hd__nand3_1
XFILLER_0_5_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09953_ _01193_ _01195_ _01258_ VGND VGND VPWR VPWR _01259_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_110_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08904_ net553 _00221_ _00222_ VGND VGND VPWR VPWR _00223_ sky130_fd_sc_hd__a21bo_1
X_09884_ _01184_ _01190_ VGND VGND VPWR VPWR _01191_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_29_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08835_ net658 _00153_ _00154_ VGND VGND VPWR VPWR _00155_ sky130_fd_sc_hd__a21bo_1
X_08766_ _08074_ _08075_ _07987_ _07989_ VGND VGND VPWR VPWR _08077_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_79_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08697_ net702 _08007_ VGND VGND VPWR VPWR _08008_ sky130_fd_sc_hd__nand2_2
XFILLER_0_94_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09318_ _00622_ _00632_ VGND VGND VPWR VPWR _00633_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10590_ _01826_ _01853_ VGND VGND VPWR VPWR _01854_ sky130_fd_sc_hd__xor2_1
XFILLER_0_106_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09249_ b_sin\[6\] _00564_ _00475_ VGND VGND VPWR VPWR _00565_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12260_ _03642_ _03524_ _03580_ VGND VGND VPWR VPWR _03643_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_120_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11211_ _02392_ _02371_ _02479_ _02480_ VGND VGND VPWR VPWR _02502_ sky130_fd_sc_hd__o211a_1
X_12191_ _03543_ _03567_ VGND VGND VPWR VPWR _03568_ sky130_fd_sc_hd__and2_1
X_11142_ _02314_ _02316_ _02315_ VGND VGND VPWR VPWR _02427_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_102_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput87 net87 VGND VGND VPWR VPWR D[17] sky130_fd_sc_hd__clkbuf_4
X_15950_ _07665_ _07666_ VGND VGND VPWR VPWR _07667_ sky130_fd_sc_hd__xnor2_1
X_11073_ _02349_ _02350_ _02348_ VGND VGND VPWR VPWR _02352_ sky130_fd_sc_hd__o21ai_1
Xoutput98 net98 VGND VGND VPWR VPWR Q[0] sky130_fd_sc_hd__buf_2
X_10024_ _01181_ _01328_ VGND VGND VPWR VPWR _01329_ sky130_fd_sc_hd__nand2_1
X_14901_ _06424_ _06492_ _06524_ _06525_ VGND VGND VPWR VPWR _06526_ sky130_fd_sc_hd__a211oi_4
X_15881_ _07546_ _07549_ _07547_ VGND VGND VPWR VPWR _07592_ sky130_fd_sc_hd__o21ba_1
X_14832_ _06343_ VGND VGND VPWR VPWR _06450_ sky130_fd_sc_hd__inv_2
XFILLER_0_53_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14763_ _06373_ _06374_ VGND VGND VPWR VPWR _06375_ sky130_fd_sc_hd__nor2_1
XFILLER_0_58_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11975_ _03295_ _03294_ VGND VGND VPWR VPWR _03334_ sky130_fd_sc_hd__and2b_1
X_13714_ _05213_ _05214_ _05228_ VGND VGND VPWR VPWR _05230_ sky130_fd_sc_hd__nand3_1
XFILLER_0_85_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10926_ net792 net453 VGND VGND VPWR VPWR _02192_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14694_ _06291_ _06292_ _06297_ VGND VGND VPWR VPWR _06299_ sky130_fd_sc_hd__a21o_1
XFILLER_0_129_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13645_ _05153_ _05134_ _05135_ VGND VGND VPWR VPWR _05156_ sky130_fd_sc_hd__and3_1
X_10857_ _02119_ _02120_ VGND VGND VPWR VPWR _02121_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13576_ _05078_ _05080_ VGND VGND VPWR VPWR _05081_ sky130_fd_sc_hd__xnor2_1
X_10788_ _02036_ _02050_ _02051_ VGND VGND VPWR VPWR _02052_ sky130_fd_sc_hd__nand3_4
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15315_ _06974_ _06975_ VGND VGND VPWR VPWR _06977_ sky130_fd_sc_hd__xnor2_2
X_12527_ _03930_ _03929_ _03901_ VGND VGND VPWR VPWR _03935_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_124_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16295_ clknet_4_9_0_clk _00084_ net341 VGND VGND VPWR VPWR a_sin\[7\] sky130_fd_sc_hd__dfrtp_1
X_15246_ _06898_ _06899_ _06884_ VGND VGND VPWR VPWR _06902_ sky130_fd_sc_hd__a21oi_1
X_12458_ net780 net294 net284 net788 VGND VGND VPWR VPWR _03859_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_78_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11409_ _02717_ VGND VGND VPWR VPWR _02718_ sky130_fd_sc_hd__inv_2
XFILLER_0_2_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12389_ net774 net162 net308 net782 VGND VGND VPWR VPWR _03783_ sky130_fd_sc_hd__a22oi_1
X_15177_ net460 net573 net585 net454 VGND VGND VPWR VPWR _06827_ sky130_fd_sc_hd__a22oi_1
X_14128_ _05480_ _05629_ _05679_ VGND VGND VPWR VPWR _05680_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_120_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14059_ _05603_ _05604_ VGND VGND VPWR VPWR _05605_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08620_ _07748_ _07759_ VGND VGND VPWR VPWR _07770_ sky130_fd_sc_hd__nor2_1
X_08551_ _06987_ _07009_ VGND VGND VPWR VPWR _07020_ sky130_fd_sc_hd__or2_1
XFILLER_0_89_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08482_ net217 net583 net591 net208 VGND VGND VPWR VPWR _06267_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_65_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09103_ net158 net304 net686 net695 VGND VGND VPWR VPWR _00420_ sky130_fd_sc_hd__nand4_1
XFILLER_0_150_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09034_ _00343_ _00351_ VGND VGND VPWR VPWR _00352_ sky130_fd_sc_hd__xor2_2
XFILLER_0_72_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout800 net804 VGND VGND VPWR VPWR net800 sky130_fd_sc_hd__buf_6
Xfanout811 net1 VGND VGND VPWR VPWR net811 sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09936_ _01209_ _01211_ _01203_ VGND VGND VPWR VPWR _01242_ sky130_fd_sc_hd__o21ai_1
X_09867_ _01119_ _01174_ VGND VGND VPWR VPWR _01175_ sky130_fd_sc_hd__xor2_1
X_08818_ _00135_ _00136_ _00121_ VGND VGND VPWR VPWR _00138_ sky130_fd_sc_hd__a21o_1
XFILLER_0_99_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09798_ _01042_ _01040_ VGND VGND VPWR VPWR _01107_ sky130_fd_sc_hd__and2b_1
X_08749_ _08057_ _08058_ _08059_ VGND VGND VPWR VPWR _08060_ sky130_fd_sc_hd__or3_1
X_11760_ net232 net498 net153 net346 VGND VGND VPWR VPWR _03100_ sky130_fd_sc_hd__a22o_1
XFILLER_0_68_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10711_ _01936_ _01938_ _01937_ VGND VGND VPWR VPWR _01975_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_138_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11691_ net713 net466 VGND VGND VPWR VPWR _03025_ sky130_fd_sc_hd__nand2_1
XFILLER_0_83_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13430_ _04740_ _04820_ _04921_ VGND VGND VPWR VPWR _04922_ sky130_fd_sc_hd__a21oi_2
X_10642_ _01784_ _01818_ VGND VGND VPWR VPWR _01906_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13361_ net763 net249 VGND VGND VPWR VPWR _04846_ sky130_fd_sc_hd__nand2_1
XFILLER_0_134_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10573_ net522 net769 net778 net437 VGND VGND VPWR VPWR _01837_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_23_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15100_ _06740_ _06741_ _06650_ VGND VGND VPWR VPWR _06743_ sky130_fd_sc_hd__o21a_1
X_12312_ _03692_ _03693_ _03697_ VGND VGND VPWR VPWR _03698_ sky130_fd_sc_hd__a21o_1
Xrebuffer9 _04717_ VGND VGND VPWR VPWR net820 sky130_fd_sc_hd__clkbuf_1
X_13292_ net610 net710 net159 net305 VGND VGND VPWR VPWR _04771_ sky130_fd_sc_hd__nand4_1
X_16080_ _07724_ _07757_ _07807_ VGND VGND VPWR VPWR _07808_ sky130_fd_sc_hd__a21bo_1
X_15031_ _06665_ _06666_ VGND VGND VPWR VPWR _06667_ sky130_fd_sc_hd__xor2_1
X_12243_ _03605_ _03623_ VGND VGND VPWR VPWR _03624_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_121_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12174_ net457 net152 VGND VGND VPWR VPWR _03549_ sky130_fd_sc_hd__nand2_1
X_11125_ _02406_ _02407_ VGND VGND VPWR VPWR _02409_ sky130_fd_sc_hd__xor2_1
X_11056_ net615 net384 net373 net715 VGND VGND VPWR VPWR _02334_ sky130_fd_sc_hd__a22o_1
XFILLER_0_3_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15933_ _07497_ _07500_ _07576_ VGND VGND VPWR VPWR _07649_ sky130_fd_sc_hd__and3_1
X_10007_ _01243_ _01247_ _01310_ VGND VGND VPWR VPWR _01312_ sky130_fd_sc_hd__o21ai_1
X_15864_ _07572_ _07573_ VGND VGND VPWR VPWR _07574_ sky130_fd_sc_hd__xor2_1
X_14815_ _06315_ _06341_ _06430_ _06431_ VGND VGND VPWR VPWR _06433_ sky130_fd_sc_hd__o211ai_4
X_15795_ _07341_ _07327_ _07422_ VGND VGND VPWR VPWR _07500_ sky130_fd_sc_hd__o21a_1
XFILLER_0_59_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14746_ _06275_ _06279_ _06280_ _06356_ VGND VGND VPWR VPWR _06357_ sky130_fd_sc_hd__and4_1
XFILLER_0_58_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11958_ _03247_ _03315_ VGND VGND VPWR VPWR _03316_ sky130_fd_sc_hd__xor2_1
XFILLER_0_74_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10909_ _02085_ _02087_ _02173_ VGND VGND VPWR VPWR _02175_ sky130_fd_sc_hd__and3_1
X_14677_ _06183_ _06196_ _06227_ _06228_ VGND VGND VPWR VPWR _06281_ sky130_fd_sc_hd__a211o_1
XFILLER_0_86_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11889_ _03086_ _03239_ _03240_ VGND VGND VPWR VPWR _03241_ sky130_fd_sc_hd__o21ai_1
X_13628_ _04892_ _05052_ VGND VGND VPWR VPWR _05137_ sky130_fd_sc_hd__or2_2
XFILLER_0_104_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13559_ net149 net141 net183 net173 VGND VGND VPWR VPWR _05062_ sky130_fd_sc_hd__nand4_1
XFILLER_0_42_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16278_ clknet_4_13_0_clk _00067_ net339 VGND VGND VPWR VPWR a_cos\[9\] sky130_fd_sc_hd__dfrtp_1
X_15229_ _06775_ _06777_ VGND VGND VPWR VPWR _06883_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09721_ _00408_ net526 VGND VGND VPWR VPWR _01031_ sky130_fd_sc_hd__or2_1
X_09652_ _00941_ _00942_ _00961_ _00962_ VGND VGND VPWR VPWR _00963_ sky130_fd_sc_hd__a22o_1
X_08603_ _07314_ _07336_ _07346_ _07575_ VGND VGND VPWR VPWR _07585_ sky130_fd_sc_hd__o211a_1
X_09583_ _00893_ _00894_ VGND VGND VPWR VPWR _00895_ sky130_fd_sc_hd__xor2_2
XFILLER_0_145_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08534_ _06769_ _06780_ _06824_ VGND VGND VPWR VPWR _06835_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08465_ _05959_ _05981_ _06069_ VGND VGND VPWR VPWR _06080_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_64_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08396_ _05296_ _05307_ _05318_ VGND VGND VPWR VPWR _05329_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_9_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09017_ _00331_ _00332_ _00333_ VGND VGND VPWR VPWR _00335_ sky130_fd_sc_hd__a21o_1
XFILLER_0_143_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout630 net636 VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__clkbuf_2
Xfanout641 net643 VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__clkbuf_4
X_09919_ _01140_ _01122_ VGND VGND VPWR VPWR _01226_ sky130_fd_sc_hd__or2b_1
Xfanout652 net655 VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__clkbuf_4
Xfanout663 net665 VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__clkbuf_4
Xfanout674 net675 VGND VGND VPWR VPWR net674 sky130_fd_sc_hd__buf_2
Xfanout685 net692 VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__clkbuf_4
X_12930_ _04375_ _04376_ VGND VGND VPWR VPWR _04377_ sky130_fd_sc_hd__and2b_1
Xfanout696 net701 VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__clkbuf_4
X_12861_ _03830_ _04268_ _04300_ _04301_ VGND VGND VPWR VPWR _04302_ sky130_fd_sc_hd__a211o_2
X_14600_ _06183_ _06184_ _06195_ VGND VGND VPWR VPWR _06196_ sky130_fd_sc_hd__nand3_1
X_11812_ _03132_ _03133_ _03155_ VGND VGND VPWR VPWR _03157_ sky130_fd_sc_hd__nor3_1
XFILLER_0_96_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15580_ _07262_ _07263_ _07258_ VGND VGND VPWR VPWR _07265_ sky130_fd_sc_hd__a21o_1
X_12792_ _04083_ _04127_ _04225_ VGND VGND VPWR VPWR _04226_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_139_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14531_ _06117_ _06118_ _06119_ VGND VGND VPWR VPWR _06120_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_95_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11743_ _02492_ _02693_ _02694_ _03080_ VGND VGND VPWR VPWR _03082_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_95_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14462_ _05982_ _06042_ _06043_ VGND VGND VPWR VPWR _06044_ sky130_fd_sc_hd__and3_1
XFILLER_0_37_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11674_ net740 net444 VGND VGND VPWR VPWR _03006_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16201_ net455 net624 VGND VGND VPWR VPWR _07939_ sky130_fd_sc_hd__nand2_1
X_13413_ _04901_ _04900_ _04892_ _04805_ VGND VGND VPWR VPWR _04903_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_52_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10625_ net418 net809 _01881_ _01882_ VGND VGND VPWR VPWR _01889_ sky130_fd_sc_hd__a22o_1
X_14393_ _05962_ _05967_ VGND VGND VPWR VPWR _05968_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_106_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16132_ _07789_ _07798_ VGND VGND VPWR VPWR _07864_ sky130_fd_sc_hd__nand2_1
X_13344_ _04628_ _04824_ _04827_ VGND VGND VPWR VPWR _04828_ sky130_fd_sc_hd__o21a_1
XFILLER_0_107_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10556_ _01810_ _01811_ _01812_ VGND VGND VPWR VPWR _01820_ sky130_fd_sc_hd__o21ba_1
X_16063_ _07755_ _07756_ _07747_ VGND VGND VPWR VPWR _07789_ sky130_fd_sc_hd__o21bai_1
X_13275_ _04642_ _04644_ _04641_ VGND VGND VPWR VPWR _04753_ sky130_fd_sc_hd__o21ba_1
X_10487_ net385 net374 net793 VGND VGND VPWR VPWR _01751_ sky130_fd_sc_hd__and3_1
X_15014_ _02389_ net708 VGND VGND VPWR VPWR _06648_ sky130_fd_sc_hd__nor2_1
X_12226_ net231 net441 VGND VGND VPWR VPWR _03606_ sky130_fd_sc_hd__nand2_1
XFILLER_0_122_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12157_ _03529_ _03530_ VGND VGND VPWR VPWR _03531_ sky130_fd_sc_hd__nor2_2
X_11108_ _02199_ _02373_ _02374_ VGND VGND VPWR VPWR _02390_ sky130_fd_sc_hd__nand3_2
X_12088_ _03397_ _03456_ VGND VGND VPWR VPWR _03457_ sky130_fd_sc_hd__xnor2_1
X_15916_ _07608_ _07630_ VGND VGND VPWR VPWR _07631_ sky130_fd_sc_hd__xnor2_1
X_11039_ net864 net740 net352 net503 VGND VGND VPWR VPWR _02315_ sky130_fd_sc_hd__nand4_1
X_15847_ _07472_ _07473_ _07555_ VGND VGND VPWR VPWR _07556_ sky130_fd_sc_hd__a21oi_1
X_15778_ _07464_ _07480_ VGND VGND VPWR VPWR _07481_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_87_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14729_ _06319_ _06320_ _06336_ VGND VGND VPWR VPWR _06338_ sky130_fd_sc_hd__nand3_1
XFILLER_0_59_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08250_ _02899_ _03409_ _03712_ _03723_ VGND VGND VPWR VPWR _03734_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_145_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08181_ _02942_ _02975_ VGND VGND VPWR VPWR _02986_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_7_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09704_ _00936_ _00939_ _01011_ _01012_ VGND VGND VPWR VPWR _01014_ sky130_fd_sc_hd__o211ai_4
X_09635_ net265 net689 net696 net255 VGND VGND VPWR VPWR _00946_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_69_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09566_ _00876_ _00877_ VGND VGND VPWR VPWR _00878_ sky130_fd_sc_hd__nor2_1
X_08517_ _05199_ _05741_ _06639_ VGND VGND VPWR VPWR _06649_ sky130_fd_sc_hd__or3_1
XFILLER_0_93_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09497_ _00806_ _00809_ VGND VGND VPWR VPWR _00810_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_81_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08448_ _05816_ _05871_ _05827_ VGND VGND VPWR VPWR _05893_ sky130_fd_sc_hd__nand3_1
XFILLER_0_37_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08379_ _05024_ _05112_ _05122_ _05133_ VGND VGND VPWR VPWR _05144_ sky130_fd_sc_hd__o211a_1
XFILLER_0_136_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10410_ _01665_ _01667_ _01666_ VGND VGND VPWR VPWR _01674_ sky130_fd_sc_hd__a21o_1
X_11390_ _02690_ _02696_ VGND VGND VPWR VPWR _02698_ sky130_fd_sc_hd__or2_1
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10341_ net107 _01606_ net133 VGND VGND VPWR VPWR _01607_ sky130_fd_sc_hd__mux2_1
X_13060_ _04518_ VGND VGND VPWR VPWR _00079_ sky130_fd_sc_hd__clkbuf_1
X_10272_ _01538_ _01541_ _01539_ VGND VGND VPWR VPWR _01547_ sky130_fd_sc_hd__a21bo_1
X_12011_ _03371_ _03340_ _03341_ VGND VGND VPWR VPWR _03373_ sky130_fd_sc_hd__or3_1
Xfanout460 net461 VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__buf_2
Xfanout471 net473 VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__clkbuf_4
Xfanout482 net865 VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__buf_2
X_13962_ _05399_ _05402_ _05406_ VGND VGND VPWR VPWR _05500_ sky130_fd_sc_hd__a21boi_1
Xfanout493 net497 VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__clkbuf_4
X_15701_ _07394_ _07395_ net442 net536 VGND VGND VPWR VPWR _07397_ sky130_fd_sc_hd__and4bb_1
X_12913_ _04354_ _04355_ _04356_ VGND VGND VPWR VPWR _04358_ sky130_fd_sc_hd__a21o_1
XFILLER_0_88_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13893_ _05421_ _05424_ VGND VGND VPWR VPWR _05425_ sky130_fd_sc_hd__xnor2_1
X_15632_ _07252_ _07321_ VGND VGND VPWR VPWR _07322_ sky130_fd_sc_hd__xnor2_1
X_12844_ _04281_ _04282_ VGND VGND VPWR VPWR _04283_ sky130_fd_sc_hd__nor2_1
XFILLER_0_69_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15563_ _07153_ _07246_ VGND VGND VPWR VPWR _07247_ sky130_fd_sc_hd__xnor2_1
X_12775_ net806 net840 _04206_ VGND VGND VPWR VPWR _04208_ sky130_fd_sc_hd__nand3_1
XFILLER_0_83_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14514_ _06096_ _06099_ _06100_ VGND VGND VPWR VPWR _06101_ sky130_fd_sc_hd__and3_1
X_11726_ _02955_ _02980_ _03061_ _03063_ VGND VGND VPWR VPWR _03064_ sky130_fd_sc_hd__a211o_2
X_15494_ _07167_ _07168_ _07169_ VGND VGND VPWR VPWR _07171_ sky130_fd_sc_hd__nand3_1
XFILLER_0_126_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14445_ _05960_ _05993_ _06023_ _06024_ VGND VGND VPWR VPWR _06026_ sky130_fd_sc_hd__a211oi_4
X_11657_ _02904_ _02988_ VGND VGND VPWR VPWR _02989_ sky130_fd_sc_hd__xor2_2
XFILLER_0_4_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10608_ _01870_ _01863_ _01868_ VGND VGND VPWR VPWR _01872_ sky130_fd_sc_hd__nand3_1
X_14376_ net408 net550 net560 net398 VGND VGND VPWR VPWR _05950_ sky130_fd_sc_hd__a22oi_1
X_11588_ _02831_ _02835_ _02832_ VGND VGND VPWR VPWR _02913_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_107_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16115_ _07838_ _07840_ VGND VGND VPWR VPWR _07846_ sky130_fd_sc_hd__and2b_1
XFILLER_0_3_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13327_ _04808_ _04809_ VGND VGND VPWR VPWR _04810_ sky130_fd_sc_hd__xor2_1
X_10539_ net392 net794 _01790_ _01789_ VGND VGND VPWR VPWR _01803_ sky130_fd_sc_hd__a31o_1
XFILLER_0_51_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16046_ _07771_ _07679_ VGND VGND VPWR VPWR _07772_ sky130_fd_sc_hd__nor2_1
X_13258_ _04623_ _04628_ _04734_ VGND VGND VPWR VPWR _04735_ sky130_fd_sc_hd__o21a_1
XFILLER_0_86_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12209_ _03423_ _03537_ VGND VGND VPWR VPWR _03587_ sky130_fd_sc_hd__nor2_1
X_13189_ _04560_ _04562_ VGND VGND VPWR VPWR _04659_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09420_ _00570_ _00644_ _00733_ VGND VGND VPWR VPWR _00734_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_35_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09351_ net249 net554 _00663_ _00664_ VGND VGND VPWR VPWR _00665_ sky130_fd_sc_hd__o2bb2a_1
X_08302_ _03181_ _03192_ VGND VGND VPWR VPWR _04306_ sky130_fd_sc_hd__xnor2_1
X_09282_ net273 net538 VGND VGND VPWR VPWR _00597_ sky130_fd_sc_hd__nand2_1
XFILLER_0_51_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08233_ _03528_ _03539_ VGND VGND VPWR VPWR _03550_ sky130_fd_sc_hd__nor2_1
XFILLER_0_142_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08164_ _02735_ _02779_ _02790_ VGND VGND VPWR VPWR _02800_ sky130_fd_sc_hd__nand3_1
XFILLER_0_144_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_10_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08997_ _00312_ _00314_ VGND VGND VPWR VPWR _00315_ sky130_fd_sc_hd__xor2_1
X_09618_ net166 net628 _00836_ _00833_ VGND VGND VPWR VPWR _00929_ sky130_fd_sc_hd__a31o_1
XFILLER_0_97_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10890_ _02145_ _02152_ _02153_ VGND VGND VPWR VPWR _02154_ sky130_fd_sc_hd__nand3_2
XFILLER_0_66_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09549_ _00853_ _00860_ VGND VGND VPWR VPWR _00861_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12560_ _03956_ _03958_ VGND VGND VPWR VPWR _03971_ sky130_fd_sc_hd__or2b_1
XFILLER_0_26_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11511_ _02742_ _02744_ VGND VGND VPWR VPWR _02829_ sky130_fd_sc_hd__nand2_1
X_12491_ _03889_ _03729_ _03884_ VGND VGND VPWR VPWR _03895_ sky130_fd_sc_hd__and3_1
XFILLER_0_80_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14230_ net797 net270 _01244_ _05621_ VGND VGND VPWR VPWR _05790_ sky130_fd_sc_hd__a31o_1
XFILLER_0_123_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11442_ net233 net379 net368 net317 VGND VGND VPWR VPWR _02754_ sky130_fd_sc_hd__a22o_1
XFILLER_0_18_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14161_ _00739_ _05713_ _05714_ _05715_ VGND VGND VPWR VPWR _00093_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_104_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11373_ _02564_ _02581_ _02580_ VGND VGND VPWR VPWR _02679_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_150_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13112_ net611 net175 _04573_ _04574_ VGND VGND VPWR VPWR _04575_ sky130_fd_sc_hd__a22o_1
X_10324_ b_cos\[16\] a_sin\[16\] VGND VGND VPWR VPWR _01592_ sky130_fd_sc_hd__xnor2_1
X_14092_ _05639_ _05640_ _05573_ _05576_ VGND VGND VPWR VPWR _05641_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_131_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13043_ _04497_ _04498_ _04397_ _04465_ VGND VGND VPWR VPWR _04500_ sky130_fd_sc_hd__o211a_1
X_10255_ b_cos\[7\] a_sin\[7\] VGND VGND VPWR VPWR _01532_ sky130_fd_sc_hd__or2b_1
XFILLER_0_147_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10186_ _01472_ _01473_ VGND VGND VPWR VPWR _01474_ sky130_fd_sc_hd__nor2_1
X_14994_ _06624_ _06625_ _06605_ VGND VGND VPWR VPWR _06627_ sky130_fd_sc_hd__a21oi_2
Xfanout290 net62 VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__buf_2
X_13945_ net148 net287 net278 net226 VGND VGND VPWR VPWR _05482_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_88_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13876_ _05404_ _05406_ _05326_ _05330_ VGND VGND VPWR VPWR _05407_ sky130_fd_sc_hd__a211o_1
XFILLER_0_76_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15615_ net455 net527 net536 net447 VGND VGND VPWR VPWR _07304_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_9_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12827_ _04246_ _04247_ _04263_ VGND VGND VPWR VPWR _04265_ sky130_fd_sc_hd__nand3_2
XFILLER_0_127_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15546_ _07225_ _07226_ _07210_ VGND VGND VPWR VPWR _07229_ sky130_fd_sc_hd__a21o_1
X_12758_ net814 _04162_ _04161_ VGND VGND VPWR VPWR _04189_ sky130_fd_sc_hd__a21o_1
XFILLER_0_57_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11709_ _03043_ _03044_ VGND VGND VPWR VPWR _03045_ sky130_fd_sc_hd__or2_1
X_15477_ _07151_ _07147_ _07152_ VGND VGND VPWR VPWR _07153_ sky130_fd_sc_hd__o21a_1
X_12689_ _04065_ _04058_ _04066_ VGND VGND VPWR VPWR _04113_ sky130_fd_sc_hd__or3_4
XFILLER_0_115_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14428_ _06002_ _06006_ VGND VGND VPWR VPWR _06007_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_141_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14359_ _05929_ _05928_ _05897_ _05879_ VGND VGND VPWR VPWR _05931_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_12_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout9 net145 VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__buf_6
XFILLER_0_123_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08920_ _00237_ _00238_ VGND VGND VPWR VPWR _00239_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16029_ net464 net641 _07750_ _07752_ VGND VGND VPWR VPWR _07753_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_110_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08851_ _00152_ _00169_ _00170_ VGND VGND VPWR VPWR _00171_ sky130_fd_sc_hd__and3_1
XFILLER_0_110_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08782_ b_sin\[1\] _08092_ _02181_ VGND VGND VPWR VPWR _08093_ sky130_fd_sc_hd__mux2_1
X_09403_ _00714_ _00715_ _00708_ VGND VGND VPWR VPWR _00717_ sky130_fd_sc_hd__a21o_1
XFILLER_0_48_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09334_ _00480_ _00478_ _00562_ VGND VGND VPWR VPWR _00649_ sky130_fd_sc_hd__a21o_1
XFILLER_0_47_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09265_ _00578_ _00579_ VGND VGND VPWR VPWR _00580_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_63_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08216_ _03214_ _03225_ _03344_ VGND VGND VPWR VPWR _03366_ sky130_fd_sc_hd__and3_1
X_09196_ net158 net304 net677 net686 VGND VGND VPWR VPWR _00512_ sky130_fd_sc_hd__nand4_1
XFILLER_0_133_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08147_ _02572_ _02605_ VGND VGND VPWR VPWR _02615_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10040_ _01284_ _01301_ _01344_ VGND VGND VPWR VPWR _01345_ sky130_fd_sc_hd__o21ai_2
Xhold43 b_cos\[17\] VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11991_ net232 net481 net472 net152 VGND VGND VPWR VPWR _03351_ sky130_fd_sc_hd__and4_1
XFILLER_0_98_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13730_ _05232_ _05233_ _05247_ VGND VGND VPWR VPWR _05248_ sky130_fd_sc_hd__a21o_1
X_10942_ net784 net469 VGND VGND VPWR VPWR _02209_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13661_ _05171_ _05172_ VGND VGND VPWR VPWR _05173_ sky130_fd_sc_hd__xnor2_1
X_10873_ _02132_ _02135_ _02136_ VGND VGND VPWR VPWR _02137_ sky130_fd_sc_hd__and3_1
X_15400_ _07067_ _07068_ VGND VGND VPWR VPWR _07069_ sky130_fd_sc_hd__nor2_1
X_12612_ _04026_ _04027_ VGND VGND VPWR VPWR _04028_ sky130_fd_sc_hd__nor2_1
X_13592_ _05002_ _05004_ VGND VGND VPWR VPWR _05098_ sky130_fd_sc_hd__or2b_1
XFILLER_0_109_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15331_ _06991_ _06992_ _06993_ VGND VGND VPWR VPWR _06994_ sky130_fd_sc_hd__nand3_2
X_12543_ _03904_ _03913_ _03912_ VGND VGND VPWR VPWR _03952_ sky130_fd_sc_hd__nand3_1
XFILLER_0_136_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15262_ net387 net653 _06916_ _06917_ VGND VGND VPWR VPWR _06919_ sky130_fd_sc_hd__nand4_1
XFILLER_0_123_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12474_ _03871_ _03872_ _03875_ VGND VGND VPWR VPWR _03876_ sky130_fd_sc_hd__nand3_1
X_14213_ _05771_ VGND VGND VPWR VPWR _05772_ sky130_fd_sc_hd__inv_2
XFILLER_0_34_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11425_ net511 net349 net500 net613 VGND VGND VPWR VPWR _02736_ sky130_fd_sc_hd__a22o_1
X_15193_ _06818_ _06819_ _06731_ _06760_ VGND VGND VPWR VPWR _06844_ sky130_fd_sc_hd__a211oi_1
XANTENNA_7 net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14144_ net422 _00194_ VGND VGND VPWR VPWR _05697_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11356_ _02657_ _02658_ _02654_ VGND VGND VPWR VPWR _02661_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10307_ _01564_ _01570_ _01573_ VGND VGND VPWR VPWR _01577_ sky130_fd_sc_hd__o21a_1
X_14075_ net140 _05621_ VGND VGND VPWR VPWR _05623_ sky130_fd_sc_hd__and2_1
X_11287_ _02582_ _02584_ _02553_ _02470_ VGND VGND VPWR VPWR _02586_ sky130_fd_sc_hd__a211o_1
X_13026_ _04479_ _04481_ VGND VGND VPWR VPWR _04482_ sky130_fd_sc_hd__xnor2_1
X_10238_ _01516_ _01517_ VGND VGND VPWR VPWR _01518_ sky130_fd_sc_hd__xnor2_1
X_10169_ _01459_ VGND VGND VPWR VPWR _00031_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14977_ net664 _06607_ _06608_ VGND VGND VPWR VPWR _06609_ sky130_fd_sc_hd__a21bo_1
Xrebuffer19 _04821_ VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__buf_1
X_13928_ _05420_ _05419_ VGND VGND VPWR VPWR _05463_ sky130_fd_sc_hd__and2b_1
XFILLER_0_16_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13859_ net139 _05387_ VGND VGND VPWR VPWR _05388_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15529_ _07116_ _07124_ _07123_ VGND VGND VPWR VPWR _07210_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_5_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09050_ _00364_ _00365_ _00366_ VGND VGND VPWR VPWR _00368_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09952_ _01196_ _01197_ VGND VGND VPWR VPWR _01258_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08903_ net300 net544 net553 net292 VGND VGND VPWR VPWR _00222_ sky130_fd_sc_hd__a22o_1
X_09883_ _01188_ _01189_ VGND VGND VPWR VPWR _01190_ sky130_fd_sc_hd__nor2_1
X_08834_ net211 net658 net668 net202 VGND VGND VPWR VPWR _00154_ sky130_fd_sc_hd__a22o_1
X_08765_ _07987_ _07989_ _08074_ _08075_ VGND VGND VPWR VPWR _08076_ sky130_fd_sc_hd__a211o_1
X_08696_ net268 net259 net599 VGND VGND VPWR VPWR _08007_ sky130_fd_sc_hd__and3_1
XFILLER_0_68_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09317_ _00623_ _00631_ VGND VGND VPWR VPWR _00632_ sky130_fd_sc_hd__xor2_1
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09248_ _00479_ _00563_ VGND VGND VPWR VPWR _00564_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_23_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09179_ _00492_ _00494_ VGND VGND VPWR VPWR _00495_ sky130_fd_sc_hd__xnor2_2
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_121_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11210_ _02489_ net48 _02487_ _02486_ VGND VGND VPWR VPWR _02501_ sky130_fd_sc_hd__a31o_1
X_12190_ _03545_ _03566_ VGND VGND VPWR VPWR _03567_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_120_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11141_ _02424_ _02422_ _02423_ VGND VGND VPWR VPWR _02426_ sky130_fd_sc_hd__nand3_1
XFILLER_0_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11072_ _02348_ _02349_ _02350_ VGND VGND VPWR VPWR _02351_ sky130_fd_sc_hd__or3_1
Xoutput88 net88 VGND VGND VPWR VPWR D[18] sky130_fd_sc_hd__clkbuf_4
Xoutput99 net99 VGND VGND VPWR VPWR Q[10] sky130_fd_sc_hd__clkbuf_4
X_10023_ _01211_ _01327_ VGND VGND VPWR VPWR _01328_ sky130_fd_sc_hd__xor2_1
X_14900_ _06522_ _06523_ _06503_ VGND VGND VPWR VPWR _06525_ sky130_fd_sc_hd__a21oi_2
X_15880_ _07584_ _07590_ VGND VGND VPWR VPWR _07591_ sky130_fd_sc_hd__xnor2_1
X_14831_ _06343_ _06438_ _06435_ _06436_ VGND VGND VPWR VPWR _06449_ sky130_fd_sc_hd__a211o_1
X_14762_ net488 net478 net584 net594 VGND VGND VPWR VPWR _06374_ sky130_fd_sc_hd__and4_1
XFILLER_0_59_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11974_ _03287_ _03293_ VGND VGND VPWR VPWR _03332_ sky130_fd_sc_hd__and2b_1
X_13713_ _05213_ _05214_ _05228_ VGND VGND VPWR VPWR _05229_ sky130_fd_sc_hd__a21o_1
XFILLER_0_98_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10925_ net792 net463 net453 net808 VGND VGND VPWR VPWR _02191_ sky130_fd_sc_hd__a22o_1
X_14693_ _06291_ _06292_ _06297_ VGND VGND VPWR VPWR _06298_ sky130_fd_sc_hd__nand3_2
XFILLER_0_128_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13644_ _05134_ _05135_ _05153_ VGND VGND VPWR VPWR _05154_ sky130_fd_sc_hd__a21oi_1
X_10856_ net751 net759 net351 net505 VGND VGND VPWR VPWR _02120_ sky130_fd_sc_hd__and4_1
XFILLER_0_67_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13575_ net718 net272 VGND VGND VPWR VPWR _05080_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10787_ _02043_ _02044_ _02049_ VGND VGND VPWR VPWR _02051_ sky130_fd_sc_hd__a21o_1
XFILLER_0_137_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15314_ _02385_ net584 VGND VGND VPWR VPWR _06975_ sky130_fd_sc_hd__nor2_1
XFILLER_0_93_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12526_ _03901_ _03930_ _03929_ VGND VGND VPWR VPWR _03934_ sky130_fd_sc_hd__or3_1
X_16294_ clknet_4_9_0_clk _00083_ net341 VGND VGND VPWR VPWR a_sin\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_109_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15245_ _06884_ _06898_ _06899_ VGND VGND VPWR VPWR _06901_ sky130_fd_sc_hd__and3_1
X_12457_ net807 net274 VGND VGND VPWR VPWR _03858_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11408_ _02613_ _02617_ _02614_ VGND VGND VPWR VPWR _02717_ sky130_fd_sc_hd__o21ba_1
X_15176_ _06675_ _06677_ _06676_ net556 VGND VGND VPWR VPWR _06826_ sky130_fd_sc_hd__a22o_1
X_12388_ net774 net782 net162 net308 VGND VGND VPWR VPWR _03782_ sky130_fd_sc_hd__and4_1
X_14127_ _05630_ _05619_ VGND VGND VPWR VPWR _05679_ sky130_fd_sc_hd__or2b_1
XFILLER_0_1_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11339_ _02638_ _02639_ _02640_ VGND VGND VPWR VPWR _02642_ sky130_fd_sc_hd__nand3_1
X_14058_ net422 net247 _05602_ VGND VGND VPWR VPWR _05604_ sky130_fd_sc_hd__and3_1
X_13009_ _04460_ _04461_ _04441_ VGND VGND VPWR VPWR _04463_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_89_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08550_ _06595_ _06998_ VGND VGND VPWR VPWR _07009_ sky130_fd_sc_hd__or2_4
X_08481_ net217 net208 net583 net591 VGND VGND VPWR VPWR _06256_ sky130_fd_sc_hd__and4_1
XFILLER_0_43_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09102_ net158 net686 net695 net304 VGND VGND VPWR VPWR _00419_ sky130_fd_sc_hd__a22o_1
XFILLER_0_72_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09033_ _00349_ _00350_ VGND VGND VPWR VPWR _00351_ sky130_fd_sc_hd__and2b_1
XFILLER_0_87_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout801 net804 VGND VGND VPWR VPWR net801 sky130_fd_sc_hd__buf_2
X_09935_ _01240_ VGND VGND VPWR VPWR _01241_ sky130_fd_sc_hd__inv_2
X_09866_ _01172_ _01173_ VGND VGND VPWR VPWR _01174_ sky130_fd_sc_hd__xnor2_1
X_08817_ _00121_ _00135_ _00136_ VGND VGND VPWR VPWR _00137_ sky130_fd_sc_hd__nand3_1
X_09797_ _01104_ _01105_ VGND VGND VPWR VPWR _01106_ sky130_fd_sc_hd__xnor2_2
X_08748_ net236 net648 net639 net320 VGND VGND VPWR VPWR _08059_ sky130_fd_sc_hd__a22oi_2
X_08679_ net878 net881 _07989_ _07990_ VGND VGND VPWR VPWR _07991_ sky130_fd_sc_hd__o211ai_4
X_10710_ _01948_ _01950_ _01949_ VGND VGND VPWR VPWR _01974_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11690_ _03022_ _03023_ VGND VGND VPWR VPWR _03024_ sky130_fd_sc_hd__nor2_1
XFILLER_0_36_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10641_ _01784_ _01818_ _01852_ _01904_ VGND VGND VPWR VPWR _01905_ sky130_fd_sc_hd__a31oi_1
XFILLER_0_119_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13360_ _04843_ _04844_ VGND VGND VPWR VPWR _04845_ sky130_fd_sc_hd__nor2_1
XFILLER_0_119_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10572_ net420 net786 VGND VGND VPWR VPWR _01836_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12311_ _03694_ _03695_ _03696_ VGND VGND VPWR VPWR _03697_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_90_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13291_ net610 net159 net305 net710 VGND VGND VPWR VPWR _04770_ sky130_fd_sc_hd__a22o_1
XFILLER_0_106_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15030_ net443 net604 VGND VGND VPWR VPWR _06666_ sky130_fd_sc_hd__nand2_1
X_12242_ _03621_ _03622_ VGND VGND VPWR VPWR _03623_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_2_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12173_ _03490_ _03493_ VGND VGND VPWR VPWR _03548_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11124_ net792 net444 VGND VGND VPWR VPWR _02407_ sky130_fd_sc_hd__nand2_1
X_11055_ _02240_ _02242_ _02241_ VGND VGND VPWR VPWR _02333_ sky130_fd_sc_hd__o21bai_1
X_15932_ _07497_ _07498_ _07576_ VGND VGND VPWR VPWR _07648_ sky130_fd_sc_hd__and3_1
X_10006_ _01243_ _01247_ _01310_ VGND VGND VPWR VPWR _01311_ sky130_fd_sc_hd__or3_1
X_15863_ _07487_ _07491_ _07486_ VGND VGND VPWR VPWR _07573_ sky130_fd_sc_hd__a21o_1
X_14814_ _06392_ _06393_ _06428_ _06429_ VGND VGND VPWR VPWR _06431_ sky130_fd_sc_hd__a22o_1
X_15794_ _07329_ _07424_ VGND VGND VPWR VPWR _07498_ sky130_fd_sc_hd__nor2_1
X_14745_ _06353_ _06354_ VGND VGND VPWR VPWR _06356_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_48_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11957_ _03313_ _03314_ VGND VGND VPWR VPWR _03315_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10908_ _02085_ _02087_ _02173_ VGND VGND VPWR VPWR _02174_ sky130_fd_sc_hd__a21oi_2
X_14676_ _06273_ _06277_ _06042_ _06276_ VGND VGND VPWR VPWR _06280_ sky130_fd_sc_hd__o211ai_1
X_11888_ _03090_ _03077_ _03166_ VGND VGND VPWR VPWR _03240_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_67_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13627_ _04892_ _05052_ _05053_ VGND VGND VPWR VPWR _05136_ sky130_fd_sc_hd__and3_2
XFILLER_0_13_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10839_ _02026_ _02031_ _02032_ _02102_ VGND VGND VPWR VPWR _02103_ sky130_fd_sc_hd__and4b_1
XFILLER_0_13_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13558_ net141 net183 net173 net149 VGND VGND VPWR VPWR _05061_ sky130_fd_sc_hd__a22o_1
XFILLER_0_70_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_132_Right_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12509_ _03705_ _03698_ _03704_ VGND VGND VPWR VPWR _03915_ sky130_fd_sc_hd__nand3_2
X_16277_ clknet_4_13_0_clk _00066_ net339 VGND VGND VPWR VPWR a_cos\[8\] sky130_fd_sc_hd__dfrtp_1
X_13489_ _04893_ _04983_ _04984_ VGND VGND VPWR VPWR _04986_ sky130_fd_sc_hd__nand3_1
X_15228_ _06863_ _06881_ VGND VGND VPWR VPWR _06882_ sky130_fd_sc_hd__xor2_2
XFILLER_0_2_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15159_ _06805_ _06803_ _06804_ VGND VGND VPWR VPWR _06807_ sky130_fd_sc_hd__nand3_2
XFILLER_0_1_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09720_ _01026_ _01029_ VGND VGND VPWR VPWR _01030_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_129_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09651_ _00943_ _00960_ VGND VGND VPWR VPWR _00962_ sky130_fd_sc_hd__or2_1
XFILLER_0_145_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08602_ _07292_ _07357_ _07564_ VGND VGND VPWR VPWR _07575_ sky130_fd_sc_hd__and3_1
X_09582_ _00783_ _00804_ VGND VGND VPWR VPWR _00894_ sky130_fd_sc_hd__and2_1
XFILLER_0_54_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08533_ _06791_ _06802_ _06813_ VGND VGND VPWR VPWR _06824_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_148_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08464_ net704 _05937_ _05992_ VGND VGND VPWR VPWR _06069_ sky130_fd_sc_hd__and3_1
XFILLER_0_18_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08395_ net330 net246 net548 net558 VGND VGND VPWR VPWR _05318_ sky130_fd_sc_hd__and4_1
XFILLER_0_70_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09016_ _00331_ _00332_ _00333_ VGND VGND VPWR VPWR _00334_ sky130_fd_sc_hd__nand3_1
XFILLER_0_131_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout620 net621 VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__clkbuf_4
Xfanout631 net632 VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__buf_2
X_09918_ _01162_ _01223_ _01221_ _01222_ VGND VGND VPWR VPWR _01225_ sky130_fd_sc_hd__a211oi_2
Xfanout642 net643 VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__buf_2
Xfanout653 net655 VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__clkbuf_4
Xfanout664 net665 VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__buf_2
Xfanout675 net24 VGND VGND VPWR VPWR net675 sky130_fd_sc_hd__buf_4
Xfanout686 net838 VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__buf_4
X_09849_ _01074_ _01156_ VGND VGND VPWR VPWR _01157_ sky130_fd_sc_hd__nand2_1
Xfanout697 net701 VGND VGND VPWR VPWR net697 sky130_fd_sc_hd__clkbuf_4
X_12860_ _04298_ _04299_ _04279_ VGND VGND VPWR VPWR _04301_ sky130_fd_sc_hd__a21oi_2
X_11811_ _03132_ _03133_ _03155_ VGND VGND VPWR VPWR _03156_ sky130_fd_sc_hd__o21a_1
X_12791_ _04034_ _04036_ _03984_ _04037_ VGND VGND VPWR VPWR _04225_ sky130_fd_sc_hd__o211a_1
XFILLER_0_139_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14530_ net519 net434 net596 net606 VGND VGND VPWR VPWR _06119_ sky130_fd_sc_hd__nand4_1
XFILLER_0_96_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11742_ _03080_ _02493_ _02492_ _02601_ VGND VGND VPWR VPWR _03081_ sky130_fd_sc_hd__and4b_1
XFILLER_0_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14461_ _06041_ _06040_ _05986_ _05974_ VGND VGND VPWR VPWR _06043_ sky130_fd_sc_hd__o211ai_2
X_11673_ _03003_ _03004_ VGND VGND VPWR VPWR _03005_ sky130_fd_sc_hd__nor2_1
XFILLER_0_126_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16200_ net442 net652 _07869_ _07937_ VGND VGND VPWR VPWR _07938_ sky130_fd_sc_hd__a31o_1
X_13412_ _04805_ _04892_ _04900_ _04901_ VGND VGND VPWR VPWR _04902_ sky130_fd_sc_hd__o211a_1
XFILLER_0_37_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10624_ net410 net809 _01885_ VGND VGND VPWR VPWR _01888_ sky130_fd_sc_hd__a21o_1
XFILLER_0_107_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14392_ _05963_ _05966_ VGND VGND VPWR VPWR _05967_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_107_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16131_ _07819_ _07822_ _07862_ VGND VGND VPWR VPWR _07863_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_141_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13343_ _04734_ _04825_ _04826_ VGND VGND VPWR VPWR _04827_ sky130_fd_sc_hd__a21o_1
X_10555_ _01814_ _01816_ VGND VGND VPWR VPWR _01819_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_122_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16062_ _07682_ _07760_ VGND VGND VPWR VPWR _07788_ sky130_fd_sc_hd__nor2_1
X_13274_ _04745_ _04750_ VGND VGND VPWR VPWR _04751_ sky130_fd_sc_hd__xnor2_1
X_10486_ _01619_ _01749_ VGND VGND VPWR VPWR _01750_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_121_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15013_ _06647_ VGND VGND VPWR VPWR _00098_ sky130_fd_sc_hd__clkbuf_1
X_12225_ _03464_ _03535_ _03603_ VGND VGND VPWR VPWR _03605_ sky130_fd_sc_hd__a21bo_1
X_12156_ net481 net471 net801 VGND VGND VPWR VPWR _03530_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_20_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11107_ _02388_ VGND VGND VPWR VPWR _02389_ sky130_fd_sc_hd__buf_4
X_12087_ _03454_ _03455_ VGND VGND VPWR VPWR _03456_ sky130_fd_sc_hd__xnor2_1
X_15915_ _07610_ _07628_ VGND VGND VPWR VPWR _07630_ sky130_fd_sc_hd__xnor2_1
X_11038_ net864 net352 net502 net740 VGND VGND VPWR VPWR _02314_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_56_Left_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15846_ _07465_ _07471_ VGND VGND VPWR VPWR _07555_ sky130_fd_sc_hd__and2b_1
X_12989_ _04357_ _04359_ VGND VGND VPWR VPWR _04441_ sky130_fd_sc_hd__nand2_1
X_15777_ _07478_ _07479_ VGND VGND VPWR VPWR _07480_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_115_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14728_ _06319_ _06320_ _06336_ VGND VGND VPWR VPWR _06337_ sky130_fd_sc_hd__a21o_1
XFILLER_0_86_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14659_ _06229_ _06230_ _06250_ _06251_ VGND VGND VPWR VPWR _06261_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_28_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08180_ _02953_ _02964_ VGND VGND VPWR VPWR _02975_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_65_Left_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09703_ _01011_ _01012_ _00936_ _00939_ VGND VGND VPWR VPWR _01013_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_74_Left_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09634_ _00849_ _00852_ _00850_ VGND VGND VPWR VPWR _00945_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_65_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09565_ net265 net255 net696 net526 VGND VGND VPWR VPWR _00877_ sky130_fd_sc_hd__and4_1
XFILLER_0_78_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08516_ _06190_ VGND VGND VPWR VPWR _06639_ sky130_fd_sc_hd__inv_2
X_09496_ _00678_ _00807_ _00808_ VGND VGND VPWR VPWR _00809_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_93_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08447_ _05816_ _05827_ _05871_ VGND VGND VPWR VPWR _05882_ sky130_fd_sc_hd__a21o_1
XFILLER_0_136_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_83_Left_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08378_ _04556_ _04327_ _04545_ VGND VGND VPWR VPWR _05133_ sky130_fd_sc_hd__or3_1
XFILLER_0_80_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10340_ _01604_ _01605_ VGND VGND VPWR VPWR _01606_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_103_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10271_ _01544_ _01545_ VGND VGND VPWR VPWR _01546_ sky130_fd_sc_hd__nand2_1
XFILLER_0_103_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12010_ _03340_ _03341_ _03371_ VGND VGND VPWR VPWR _03372_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_92_Left_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout450 net46 VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__clkbuf_4
Xfanout461 net45 VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__clkbuf_4
Xfanout472 net866 VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__buf_2
X_13961_ _05476_ _05498_ VGND VGND VPWR VPWR _05499_ sky130_fd_sc_hd__xnor2_1
Xfanout483 net490 VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__buf_1
Xfanout494 net497 VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__clkbuf_4
X_12912_ _04354_ _04355_ _04356_ VGND VGND VPWR VPWR _04357_ sky130_fd_sc_hd__nand3_1
X_15700_ net442 net536 _07394_ _07395_ VGND VGND VPWR VPWR _07396_ sky130_fd_sc_hd__o2bb2a_1
X_13892_ _05422_ _05423_ VGND VGND VPWR VPWR _05424_ sky130_fd_sc_hd__nor2_1
X_12843_ net510 net211 net202 net611 VGND VGND VPWR VPWR _04282_ sky130_fd_sc_hd__a22oi_2
X_15631_ _07319_ _07320_ VGND VGND VPWR VPWR _07321_ sky130_fd_sc_hd__xnor2_1
X_15562_ _07154_ _07245_ VGND VGND VPWR VPWR _07246_ sky130_fd_sc_hd__xnor2_2
X_12774_ _04201_ _04205_ VGND VGND VPWR VPWR _04206_ sky130_fd_sc_hd__xor2_1
XFILLER_0_139_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14513_ _06088_ _06090_ _06095_ VGND VGND VPWR VPWR _06100_ sky130_fd_sc_hd__a21o_1
XFILLER_0_68_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11725_ _03060_ _03041_ _03042_ VGND VGND VPWR VPWR _03063_ sky130_fd_sc_hd__and3_1
XFILLER_0_84_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15493_ _07167_ _07168_ _07169_ VGND VGND VPWR VPWR _07170_ sky130_fd_sc_hd__a21o_1
XFILLER_0_139_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14444_ _06011_ _06022_ _06012_ VGND VGND VPWR VPWR _06024_ sky130_fd_sc_hd__and3_1
XFILLER_0_9_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11656_ _02984_ _02987_ VGND VGND VPWR VPWR _02988_ sky130_fd_sc_hd__xnor2_2
X_10607_ _01863_ _01868_ _01870_ VGND VGND VPWR VPWR _01871_ sky130_fd_sc_hd__a21o_1
XFILLER_0_142_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14375_ _05945_ _05946_ _05947_ VGND VGND VPWR VPWR _05949_ sky130_fd_sc_hd__nand3_1
X_11587_ _02908_ _02910_ net749 net444 VGND VGND VPWR VPWR _02912_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_135_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16114_ _07844_ VGND VGND VPWR VPWR _00112_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13326_ _04700_ net813 _04706_ VGND VGND VPWR VPWR _04809_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_40_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10538_ _01786_ _01787_ _01801_ VGND VGND VPWR VPWR _01802_ sky130_fd_sc_hd__nand3_2
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16045_ _07677_ _07660_ VGND VGND VPWR VPWR _07771_ sky130_fd_sc_hd__and2b_1
X_13257_ _04519_ _04619_ _04620_ VGND VGND VPWR VPWR _04734_ sky130_fd_sc_hd__nand3_1
X_10469_ net495 net810 _01730_ _01731_ VGND VGND VPWR VPWR _01733_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_110_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12208_ _03570_ _03574_ _03571_ VGND VGND VPWR VPWR _03586_ sky130_fd_sc_hd__a21boi_1
X_13188_ _04569_ _04604_ _04605_ VGND VGND VPWR VPWR _04658_ sky130_fd_sc_hd__nor3_1
X_12139_ _03509_ _03511_ VGND VGND VPWR VPWR _03512_ sky130_fd_sc_hd__xor2_2
XFILLER_0_36_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15829_ _07453_ _07454_ VGND VGND VPWR VPWR _07536_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09350_ net267 net258 net535 net545 VGND VGND VPWR VPWR _00664_ sky130_fd_sc_hd__and4_1
XFILLER_0_59_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08301_ _04218_ _04273_ _04284_ VGND VGND VPWR VPWR _04295_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_47_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09281_ _00594_ _00595_ VGND VGND VPWR VPWR _00596_ sky130_fd_sc_hd__nor2_1
XFILLER_0_142_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08232_ net213 net685 net694 net204 VGND VGND VPWR VPWR _03539_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_145_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08163_ _02757_ _02768_ _02746_ VGND VGND VPWR VPWR _02790_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_141_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08996_ _00206_ _00208_ _00313_ VGND VGND VPWR VPWR _00314_ sky130_fd_sc_hd__a21boi_1
X_09617_ _00830_ _00840_ VGND VGND VPWR VPWR _00928_ sky130_fd_sc_hd__nor2_1
XFILLER_0_92_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09548_ _00858_ _00859_ VGND VGND VPWR VPWR _00860_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09479_ _00790_ _00791_ VGND VGND VPWR VPWR _00792_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_19_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11510_ _02807_ _02827_ VGND VGND VPWR VPWR _02828_ sky130_fd_sc_hd__xor2_2
XFILLER_0_136_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12490_ _03891_ _03892_ _03893_ VGND VGND VPWR VPWR _03894_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_108_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11441_ _02664_ _02666_ _02665_ VGND VGND VPWR VPWR _02753_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_135_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14160_ net860 net863 VGND VGND VPWR VPWR _05715_ sky130_fd_sc_hd__nand2_1
XFILLER_0_132_840 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11372_ _02663_ _02677_ VGND VGND VPWR VPWR _02678_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_150_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13111_ net424 net509 net195 net185 VGND VGND VPWR VPWR _04574_ sky130_fd_sc_hd__nand4_2
XFILLER_0_21_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10323_ _01578_ _01581_ _01587_ VGND VGND VPWR VPWR _01591_ sky130_fd_sc_hd__o21a_1
X_14091_ _05638_ _05616_ _05617_ VGND VGND VPWR VPWR _05640_ sky130_fd_sc_hd__nand3_2
X_13042_ _04397_ _04465_ _04497_ _04498_ VGND VGND VPWR VPWR _04499_ sky130_fd_sc_hd__a211oi_4
X_10254_ _01531_ VGND VGND VPWR VPWR _00044_ sky130_fd_sc_hd__clkbuf_1
X_10185_ a_cos\[15\] b_sin\[15\] VGND VGND VPWR VPWR _01473_ sky130_fd_sc_hd__nor2_1
Xfanout280 net281 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__buf_2
X_14993_ _06605_ _06624_ _06625_ VGND VGND VPWR VPWR _06626_ sky130_fd_sc_hd__and3_1
Xfanout291 net292 VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__clkbuf_4
X_13944_ _05479_ VGND VGND VPWR VPWR _05480_ sky130_fd_sc_hd__inv_2
XFILLER_0_72_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13875_ _05403_ _05397_ _05398_ VGND VGND VPWR VPWR _05406_ sky130_fd_sc_hd__or3_2
X_12826_ _04246_ _04247_ _04263_ VGND VGND VPWR VPWR _04264_ sky130_fd_sc_hd__a21o_2
X_15614_ net464 net527 _07213_ _07212_ VGND VGND VPWR VPWR _07302_ sky130_fd_sc_hd__a31o_1
XFILLER_0_97_871 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12757_ _04170_ _04187_ VGND VGND VPWR VPWR _04188_ sky130_fd_sc_hd__or2_1
X_15545_ _07210_ _07225_ _07226_ VGND VGND VPWR VPWR _07228_ sky130_fd_sc_hd__nand3_1
XFILLER_0_56_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11708_ _02773_ _02932_ VGND VGND VPWR VPWR _03044_ sky130_fd_sc_hd__nor2_1
X_15476_ _07053_ _07143_ VGND VGND VPWR VPWR _07152_ sky130_fd_sc_hd__nand2_1
X_12688_ _04104_ _04110_ _04111_ VGND VGND VPWR VPWR _04112_ sky130_fd_sc_hd__and3_1
XFILLER_0_112_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14427_ _06004_ _06005_ VGND VGND VPWR VPWR _06006_ sky130_fd_sc_hd__nor2_1
X_11639_ _02837_ _02839_ _02838_ VGND VGND VPWR VPWR _02969_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_13_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14358_ _05879_ _05897_ _05928_ _05929_ VGND VGND VPWR VPWR _05930_ sky130_fd_sc_hd__o211a_2
XFILLER_0_108_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13309_ net509 net167 _04788_ _04789_ VGND VGND VPWR VPWR _04790_ sky130_fd_sc_hd__a22o_1
XFILLER_0_122_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14289_ net380 net369 net605 VGND VGND VPWR VPWR _05854_ sky130_fd_sc_hd__and3_1
XFILLER_0_150_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16028_ _07751_ VGND VGND VPWR VPWR _07752_ sky130_fd_sc_hd__inv_2
XFILLER_0_0_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08850_ _00166_ _00167_ _00168_ VGND VGND VPWR VPWR _00170_ sky130_fd_sc_hd__a21o_1
X_08781_ _08088_ _08091_ VGND VGND VPWR VPWR _08092_ sky130_fd_sc_hd__xor2_1
XFILLER_0_137_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09402_ _00708_ _00714_ _00715_ VGND VGND VPWR VPWR _00716_ sky130_fd_sc_hd__nand3_2
XFILLER_0_149_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09333_ _00468_ _00563_ VGND VGND VPWR VPWR _00648_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09264_ net249 net566 VGND VGND VPWR VPWR _00579_ sky130_fd_sc_hd__nand2_2
XFILLER_0_118_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08215_ _03214_ _03225_ _03344_ VGND VGND VPWR VPWR _03355_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_106_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09195_ net158 net677 net686 net304 VGND VGND VPWR VPWR _00511_ sky130_fd_sc_hd__a22o_1
XFILLER_0_90_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08146_ net171 net582 _02583_ _02594_ VGND VGND VPWR VPWR _02605_ sky130_fd_sc_hd__and4_1
XFILLER_0_15_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08979_ _00279_ VGND VGND VPWR VPWR _00297_ sky130_fd_sc_hd__inv_2
Xhold44 a_sin\[0\] VGND VGND VPWR VPWR net855 sky130_fd_sc_hd__dlygate4sd3_1
X_11990_ net231 net472 net152 net482 VGND VGND VPWR VPWR _03350_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_97_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10941_ _02206_ _02207_ VGND VGND VPWR VPWR _02208_ sky130_fd_sc_hd__nor2_1
X_13660_ _05033_ _05036_ VGND VGND VPWR VPWR _05172_ sky130_fd_sc_hd__or2_1
X_10872_ net362 net742 _02133_ _02134_ VGND VGND VPWR VPWR _02136_ sky130_fd_sc_hd__nand4_1
XFILLER_0_39_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12611_ _04022_ _04023_ _04025_ VGND VGND VPWR VPWR _04027_ sky130_fd_sc_hd__and3_1
XFILLER_0_109_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13591_ _05072_ _05096_ VGND VGND VPWR VPWR _05097_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_93_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15330_ _06890_ _06892_ _06891_ VGND VGND VPWR VPWR _06993_ sky130_fd_sc_hd__a21bo_1
X_12542_ _03941_ _03949_ _03950_ VGND VGND VPWR VPWR _03951_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_81_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15261_ net387 net653 _06916_ _06917_ VGND VGND VPWR VPWR _06918_ sky130_fd_sc_hd__a22o_1
X_12473_ _03873_ _03874_ VGND VGND VPWR VPWR _03875_ sky130_fd_sc_hd__and2_1
X_14212_ _05769_ _05770_ VGND VGND VPWR VPWR _05771_ sky130_fd_sc_hd__nor2_1
X_11424_ _02732_ _02733_ VGND VGND VPWR VPWR _02734_ sky130_fd_sc_hd__xnor2_1
X_15192_ _06820_ _06821_ _06842_ VGND VGND VPWR VPWR _06843_ sky130_fd_sc_hd__and3b_1
XFILLER_0_123_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_8 net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_123_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14143_ _05693_ _05695_ VGND VGND VPWR VPWR _05696_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11355_ _02654_ _02657_ _02658_ VGND VGND VPWR VPWR _02660_ sky130_fd_sc_hd__and3_1
X_10306_ net134 _01574_ _01575_ _01576_ VGND VGND VPWR VPWR _00051_ sky130_fd_sc_hd__a31o_1
X_14074_ net797 net286 net277 VGND VGND VPWR VPWR _05621_ sky130_fd_sc_hd__and3_1
X_11286_ _02553_ _02470_ _02582_ _02584_ VGND VGND VPWR VPWR _02585_ sky130_fd_sc_hd__o211ai_2
X_13025_ net509 net195 VGND VGND VPWR VPWR _04481_ sky130_fd_sc_hd__and2_1
X_10237_ _01506_ _01511_ _01507_ VGND VGND VPWR VPWR _01517_ sky130_fd_sc_hd__a21bo_1
X_10168_ net82 _01458_ net135 VGND VGND VPWR VPWR _01459_ sky130_fd_sc_hd__mux2_1
X_14976_ net405 net664 net673 net395 VGND VGND VPWR VPWR _06608_ sky130_fd_sc_hd__a22o_1
X_10099_ _01399_ VGND VGND VPWR VPWR _00021_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13927_ _05412_ _05418_ VGND VGND VPWR VPWR _05462_ sky130_fd_sc_hd__and2b_1
X_13858_ net797 net868 net302 VGND VGND VPWR VPWR _05387_ sky130_fd_sc_hd__and3_1
XFILLER_0_147_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12809_ _03857_ _03862_ VGND VGND VPWR VPWR _04245_ sky130_fd_sc_hd__and2_1
X_13789_ _05303_ _05311_ VGND VGND VPWR VPWR _05312_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15528_ _07095_ _07098_ VGND VGND VPWR VPWR _07209_ sky130_fd_sc_hd__nand2_1
XFILLER_0_127_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15459_ _07030_ _07034_ VGND VGND VPWR VPWR _07134_ sky130_fd_sc_hd__nor2_1
XFILLER_0_115_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09951_ _01255_ _01256_ VGND VGND VPWR VPWR _01257_ sky130_fd_sc_hd__nor2_1
XFILLER_0_111_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08902_ net300 net292 net544 VGND VGND VPWR VPWR _00221_ sky130_fd_sc_hd__and3_1
X_09882_ net251 net666 _01187_ VGND VGND VPWR VPWR _01189_ sky130_fd_sc_hd__and3_1
XFILLER_0_148_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08833_ net211 net202 net668 VGND VGND VPWR VPWR _00153_ sky130_fd_sc_hd__and3_1
XFILLER_0_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08764_ _08072_ _08073_ _08040_ VGND VGND VPWR VPWR _08075_ sky130_fd_sc_hd__o21a_1
XFILLER_0_79_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08695_ net268 net599 net702 net259 VGND VGND VPWR VPWR _08006_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_146_Right_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09316_ _00629_ _00630_ VGND VGND VPWR VPWR _00631_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09247_ _00480_ _00562_ VGND VGND VPWR VPWR _00563_ sky130_fd_sc_hd__xor2_2
XFILLER_0_63_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09178_ _00493_ VGND VGND VPWR VPWR _00494_ sky130_fd_sc_hd__inv_2
XFILLER_0_16_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08129_ net324 net678 net685 net240 VGND VGND VPWR VPWR _02419_ sky130_fd_sc_hd__a22oi_2
X_11140_ _02422_ _02423_ _02424_ VGND VGND VPWR VPWR _02425_ sky130_fd_sc_hd__a21o_1
X_11071_ net517 net432 net154 net869 VGND VGND VPWR VPWR _02350_ sky130_fd_sc_hd__and4_1
XFILLER_0_101_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput89 net89 VGND VGND VPWR VPWR D[1] sky130_fd_sc_hd__clkbuf_4
X_10022_ _01245_ _01326_ VGND VGND VPWR VPWR _01327_ sky130_fd_sc_hd__xor2_1
X_14830_ _06448_ VGND VGND VPWR VPWR _00096_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_98_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14761_ net488 net584 net594 net478 VGND VGND VPWR VPWR _06373_ sky130_fd_sc_hd__a22oi_1
X_11973_ _03329_ _03330_ VGND VGND VPWR VPWR _03331_ sky130_fd_sc_hd__xor2_1
X_13712_ _05219_ _05227_ VGND VGND VPWR VPWR _05228_ sky130_fd_sc_hd__xnor2_1
X_10924_ _02113_ _02116_ VGND VGND VPWR VPWR _02190_ sky130_fd_sc_hd__or2_1
X_14692_ _06293_ _06296_ VGND VGND VPWR VPWR _06297_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_39_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_113_Right_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13643_ _05151_ _05152_ VGND VGND VPWR VPWR _05153_ sky130_fd_sc_hd__xor2_1
XFILLER_0_39_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10855_ net751 net351 net505 net758 VGND VGND VPWR VPWR _02119_ sky130_fd_sc_hd__a22oi_2
X_13574_ _05076_ _05077_ VGND VGND VPWR VPWR _05078_ sky130_fd_sc_hd__nor2_1
XFILLER_0_66_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10786_ _02043_ _02044_ _02049_ VGND VGND VPWR VPWR _02050_ sky130_fd_sc_hd__nand3_2
X_12525_ _03879_ _03931_ VGND VGND VPWR VPWR _03933_ sky130_fd_sc_hd__xor2_4
X_15313_ _06971_ _06973_ VGND VGND VPWR VPWR _06974_ sky130_fd_sc_hd__xor2_2
XFILLER_0_82_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16293_ clknet_4_9_0_clk _00082_ net341 VGND VGND VPWR VPWR a_sin\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_136_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12456_ _03850_ _03856_ VGND VGND VPWR VPWR _03857_ sky130_fd_sc_hd__xnor2_1
X_15244_ _06896_ _06897_ _06888_ VGND VGND VPWR VPWR _06899_ sky130_fd_sc_hd__a21o_1
XFILLER_0_35_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11407_ _02709_ _02715_ VGND VGND VPWR VPWR _02716_ sky130_fd_sc_hd__xor2_2
X_15175_ _06674_ _06689_ _06690_ _06694_ VGND VGND VPWR VPWR _06825_ sky130_fd_sc_hd__a31o_1
X_12387_ net788 net298 VGND VGND VPWR VPWR _03781_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14126_ _05608_ _05610_ _05677_ VGND VGND VPWR VPWR _05678_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_104_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11338_ _02638_ _02639_ _02640_ VGND VGND VPWR VPWR _02641_ sky130_fd_sc_hd__a21o_1
XFILLER_0_22_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14057_ net422 net247 _05602_ VGND VGND VPWR VPWR _05603_ sky130_fd_sc_hd__a21oi_1
X_11269_ net233 net396 net155 net406 VGND VGND VPWR VPWR _02566_ sky130_fd_sc_hd__a22o_1
XFILLER_0_120_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13008_ _04441_ _04460_ _04461_ VGND VGND VPWR VPWR _04462_ sky130_fd_sc_hd__and3_1
XFILLER_0_118_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14959_ _06571_ _06587_ _06588_ VGND VGND VPWR VPWR _06589_ sky130_fd_sc_hd__nand3_1
X_08480_ _05893_ net874 _05806_ VGND VGND VPWR VPWR _06245_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09101_ _00416_ _00417_ VGND VGND VPWR VPWR _00418_ sky130_fd_sc_hd__xor2_1
XFILLER_0_45_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09032_ _00347_ _00348_ _00344_ VGND VGND VPWR VPWR _00350_ sky130_fd_sc_hd__a21o_1
XFILLER_0_115_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout802 net804 VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__buf_2
X_09934_ _01172_ _01173_ _01231_ VGND VGND VPWR VPWR _01240_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09865_ _01102_ _01105_ _01103_ VGND VGND VPWR VPWR _01173_ sky130_fd_sc_hd__o21bai_2
X_08816_ _00133_ _00134_ _00126_ VGND VGND VPWR VPWR _00136_ sky130_fd_sc_hd__a21o_1
X_09796_ _01017_ _01032_ _01034_ VGND VGND VPWR VPWR _01105_ sky130_fd_sc_hd__o21a_1
X_08747_ net320 net236 net648 net639 VGND VGND VPWR VPWR _08058_ sky130_fd_sc_hd__and4_1
XFILLER_0_68_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08678_ _07954_ _07955_ _07987_ _07988_ VGND VGND VPWR VPWR _07990_ sky130_fd_sc_hd__a22o_1
XFILLER_0_68_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10640_ _01850_ _01898_ _01899_ _01902_ _01903_ VGND VGND VPWR VPWR _01904_ sky130_fd_sc_hd__a41o_1
XFILLER_0_119_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10571_ _01797_ _01796_ _01795_ VGND VGND VPWR VPWR _01835_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_64_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12310_ net712 net721 net329 net245 VGND VGND VPWR VPWR _03696_ sky130_fd_sc_hd__and4_1
XFILLER_0_106_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13290_ _04767_ _04768_ VGND VGND VPWR VPWR _04769_ sky130_fd_sc_hd__xor2_1
XFILLER_0_17_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12241_ net315 _02389_ _03620_ VGND VGND VPWR VPWR _03622_ sky130_fd_sc_hd__or3_1
XFILLER_0_133_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12172_ _03464_ _03497_ _03546_ VGND VGND VPWR VPWR _03547_ sky130_fd_sc_hd__a21o_1
XFILLER_0_48_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11123_ _02404_ _02405_ VGND VGND VPWR VPWR _02406_ sky130_fd_sc_hd__xor2_1
X_15931_ _07646_ VGND VGND VPWR VPWR _07647_ sky130_fd_sc_hd__inv_2
X_11054_ _02232_ _02235_ VGND VGND VPWR VPWR _02331_ sky130_fd_sc_hd__nand2_1
X_10005_ _01306_ _01309_ VGND VGND VPWR VPWR _01310_ sky130_fd_sc_hd__xor2_1
X_15862_ _07569_ _07571_ VGND VGND VPWR VPWR _07572_ sky130_fd_sc_hd__xnor2_1
X_14813_ _06392_ _06393_ _06428_ _06429_ VGND VGND VPWR VPWR _06430_ sky130_fd_sc_hd__nand4_4
X_15793_ _07495_ _07496_ VGND VGND VPWR VPWR _07497_ sky130_fd_sc_hd__nor2_1
XFILLER_0_99_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14744_ _06274_ _06266_ VGND VGND VPWR VPWR _06354_ sky130_fd_sc_hd__or2b_1
X_11956_ _03230_ _03233_ _03229_ VGND VGND VPWR VPWR _03314_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_103_Left_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10907_ _02169_ _02172_ VGND VGND VPWR VPWR _02173_ sky130_fd_sc_hd__or2_1
X_14675_ _06042_ _06276_ _06273_ _06277_ VGND VGND VPWR VPWR _06279_ sky130_fd_sc_hd__a211o_1
X_11887_ _03079_ _03167_ VGND VGND VPWR VPWR _03239_ sky130_fd_sc_hd__or2_1
XFILLER_0_13_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13626_ _05087_ _05089_ _05132_ VGND VGND VPWR VPWR _05135_ sky130_fd_sc_hd__nand3_1
X_10838_ _02100_ _02101_ VGND VGND VPWR VPWR _02102_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13557_ net141 net193 _04982_ _05059_ VGND VGND VPWR VPWR _05060_ sky130_fd_sc_hd__a31o_1
X_10769_ _01923_ _01926_ _02015_ _02016_ VGND VGND VPWR VPWR _02033_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12508_ _03904_ _03912_ _03913_ VGND VGND VPWR VPWR _03914_ sky130_fd_sc_hd__a21bo_1
X_13488_ _04983_ _04984_ _04893_ VGND VGND VPWR VPWR _04985_ sky130_fd_sc_hd__a21o_1
X_16276_ clknet_4_13_0_clk _00065_ net339 VGND VGND VPWR VPWR a_cos\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_124_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12439_ _03836_ _03837_ VGND VGND VPWR VPWR _03838_ sky130_fd_sc_hd__nor2_1
X_15227_ _06864_ _06880_ VGND VGND VPWR VPWR _06881_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_112_Left_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15158_ _06803_ _06804_ _06805_ VGND VGND VPWR VPWR _06806_ sky130_fd_sc_hd__a21o_1
XFILLER_0_22_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14109_ _05626_ _05628_ _05658_ VGND VGND VPWR VPWR _05659_ sky130_fd_sc_hd__o21ai_1
X_15089_ _06624_ _06697_ _06729_ _06730_ VGND VGND VPWR VPWR _06731_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09650_ _00943_ _00960_ VGND VGND VPWR VPWR _00961_ sky130_fd_sc_hd__nand2_1
X_08601_ _07531_ _07542_ _07249_ _07270_ _07553_ VGND VGND VPWR VPWR _07564_ sky130_fd_sc_hd__a2111oi_1
X_09581_ _00870_ _00892_ VGND VGND VPWR VPWR _00893_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_89_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08532_ net328 net244 net576 net583 VGND VGND VPWR VPWR _06813_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_121_Left_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08463_ net163 net704 VGND VGND VPWR VPWR _06058_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08394_ net824 net548 net558 net823 VGND VGND VPWR VPWR _05307_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_70_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09015_ _00227_ _00225_ _00226_ VGND VGND VPWR VPWR _00333_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_5_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_130_Left_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout610 net617 VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__buf_2
Xfanout621 net29 VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__buf_6
X_09917_ _01221_ _01222_ _01162_ _01223_ VGND VGND VPWR VPWR _01224_ sky130_fd_sc_hd__o211a_1
Xfanout632 net633 VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__buf_2
Xfanout643 net645 VGND VGND VPWR VPWR net643 sky130_fd_sc_hd__clkbuf_4
Xfanout654 net655 VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__buf_2
XFILLER_0_95_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout665 net25 VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__buf_4
Xfanout676 net677 VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__clkbuf_4
X_09848_ _01145_ _01155_ VGND VGND VPWR VPWR _01156_ sky130_fd_sc_hd__xnor2_1
Xfanout687 net689 VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__buf_4
Xfanout698 net701 VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__buf_2
X_09779_ _01086_ _01087_ net618 VGND VGND VPWR VPWR _01088_ sky130_fd_sc_hd__and3b_1
XFILLER_0_68_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11810_ _03135_ _03154_ VGND VGND VPWR VPWR _03155_ sky130_fd_sc_hd__xnor2_1
X_12790_ _04168_ _04221_ _04222_ _04223_ VGND VGND VPWR VPWR _04224_ sky130_fd_sc_hd__a31o_1
XFILLER_0_68_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11741_ _02690_ _02797_ _02900_ _02993_ VGND VGND VPWR VPWR _03080_ sky130_fd_sc_hd__or4b_4
XFILLER_0_96_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14460_ _05974_ _05986_ _06040_ _06041_ VGND VGND VPWR VPWR _06042_ sky130_fd_sc_hd__a211o_1
X_11672_ net722 net731 net458 net452 VGND VGND VPWR VPWR _03004_ sky130_fd_sc_hd__and4_1
XFILLER_0_37_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13411_ _04898_ _04899_ _04893_ VGND VGND VPWR VPWR _04901_ sky130_fd_sc_hd__a21o_1
X_10623_ _01880_ _01884_ _01886_ VGND VGND VPWR VPWR _01887_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_126_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14391_ _05964_ _05965_ VGND VGND VPWR VPWR _05966_ sky130_fd_sc_hd__nor2_1
XFILLER_0_64_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13342_ _04631_ _04732_ VGND VGND VPWR VPWR _04826_ sky130_fd_sc_hd__nor2_1
X_16130_ _02389_ net671 _07823_ VGND VGND VPWR VPWR _07862_ sky130_fd_sc_hd__or3_1
X_10554_ _01783_ _01785_ _01817_ VGND VGND VPWR VPWR _01818_ sky130_fd_sc_hd__a21o_1
XFILLER_0_106_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13273_ _04748_ _04749_ VGND VGND VPWR VPWR _04750_ sky130_fd_sc_hd__xnor2_1
X_16061_ _07774_ _07773_ VGND VGND VPWR VPWR _07787_ sky130_fd_sc_hd__and2b_1
X_10485_ _01621_ _01620_ VGND VGND VPWR VPWR _01749_ sky130_fd_sc_hd__nor2_1
XFILLER_0_51_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15012_ b_cos\[2\] _06646_ _05291_ VGND VGND VPWR VPWR _06647_ sky130_fd_sc_hd__mux2_1
X_12224_ _03527_ _03536_ VGND VGND VPWR VPWR _03603_ sky130_fd_sc_hd__nand2_1
X_12155_ net481 net471 net801 VGND VGND VPWR VPWR _03529_ sky130_fd_sc_hd__and3_1
XFILLER_0_75_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11106_ _02387_ VGND VGND VPWR VPWR _02388_ sky130_fd_sc_hd__clkbuf_8
X_12086_ _03375_ _03380_ _03376_ VGND VGND VPWR VPWR _03455_ sky130_fd_sc_hd__o21ba_1
X_15914_ _07626_ _07627_ VGND VGND VPWR VPWR _07628_ sky130_fd_sc_hd__nor2_1
X_11037_ _02311_ _02312_ VGND VGND VPWR VPWR _02313_ sky130_fd_sc_hd__xnor2_1
X_15845_ _07551_ _07552_ VGND VGND VPWR VPWR _07554_ sky130_fd_sc_hd__xor2_1
XFILLER_0_91_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15776_ _02387_ net536 VGND VGND VPWR VPWR _07479_ sky130_fd_sc_hd__or2_1
X_12988_ _04335_ _04439_ VGND VGND VPWR VPWR _04440_ sky130_fd_sc_hd__xor2_1
XFILLER_0_148_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14727_ _06328_ _06335_ VGND VGND VPWR VPWR _06336_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11939_ _03210_ _03213_ _03211_ VGND VGND VPWR VPWR _03295_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_115_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14658_ _06253_ _06258_ _06259_ VGND VGND VPWR VPWR _06260_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_131_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13609_ _05029_ _05048_ _05115_ VGND VGND VPWR VPWR _05116_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_15_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14589_ _06181_ _06182_ _06165_ VGND VGND VPWR VPWR _06184_ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16259_ clknet_4_0_0_clk _00048_ net331 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_51_880 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09702_ _01010_ _01004_ _01005_ VGND VGND VPWR VPWR _01012_ sky130_fd_sc_hd__nand3_2
X_09633_ _00862_ _00864_ VGND VGND VPWR VPWR _00944_ sky130_fd_sc_hd__nand2_1
X_09564_ net265 net696 net526 net254 VGND VGND VPWR VPWR _00876_ sky130_fd_sc_hd__a22oi_2
X_08515_ _06190_ _06223_ _06617_ VGND VGND VPWR VPWR _06628_ sky130_fd_sc_hd__or3_1
X_09495_ _00723_ _00726_ VGND VGND VPWR VPWR _00808_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08446_ _05838_ _05849_ _05860_ VGND VGND VPWR VPWR _05871_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_65_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08377_ _04556_ _04545_ _04327_ VGND VGND VPWR VPWR _05122_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_135_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10270_ a_sin\[9\] b_cos\[9\] VGND VGND VPWR VPWR _01545_ sky130_fd_sc_hd__or2b_1
XFILLER_0_103_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout440 net49 VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__clkbuf_2
Xfanout451 net454 VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__clkbuf_4
Xfanout462 net45 VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__clkbuf_4
X_13960_ _05478_ _05497_ VGND VGND VPWR VPWR _05498_ sky130_fd_sc_hd__xnor2_1
Xfanout473 net480 VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__buf_1
Xfanout484 net490 VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__clkbuf_4
Xfanout495 net497 VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__clkbuf_4
X_12911_ _04255_ _04256_ _04257_ VGND VGND VPWR VPWR _04356_ sky130_fd_sc_hd__o21bai_1
X_13891_ _05343_ _05342_ VGND VGND VPWR VPWR _05423_ sky130_fd_sc_hd__and2b_1
X_15630_ _07232_ _07233_ _07235_ _07236_ _07181_ VGND VGND VPWR VPWR _07320_ sky130_fd_sc_hd__a32o_1
X_12842_ net510 net611 net211 net202 VGND VGND VPWR VPWR _04281_ sky130_fd_sc_hd__and4_1
XFILLER_0_96_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15561_ _07242_ _07244_ VGND VGND VPWR VPWR _07245_ sky130_fd_sc_hd__xor2_2
X_12773_ net783 net791 net326 net242 _04204_ VGND VGND VPWR VPWR _04205_ sky130_fd_sc_hd__a41o_1
XFILLER_0_96_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14512_ _06097_ _06098_ VGND VGND VPWR VPWR _06099_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11724_ _03041_ _03042_ _03060_ VGND VGND VPWR VPWR _03061_ sky130_fd_sc_hd__a21oi_2
X_15492_ _07062_ _07065_ VGND VGND VPWR VPWR _07169_ sky130_fd_sc_hd__nand2_1
XFILLER_0_138_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14443_ _06011_ _06012_ _06022_ VGND VGND VPWR VPWR _06023_ sky130_fd_sc_hd__a21oi_2
X_11655_ _02828_ _02884_ _02985_ VGND VGND VPWR VPWR _02987_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_37_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10606_ _01833_ _01869_ VGND VGND VPWR VPWR _01870_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_52_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14374_ _05942_ _05944_ _05943_ VGND VGND VPWR VPWR _05947_ sky130_fd_sc_hd__o21ai_1
X_11586_ net749 net444 _02908_ _02910_ VGND VGND VPWR VPWR _02911_ sky130_fd_sc_hd__o2bb2a_1
X_16113_ b_cos\[16\] _07843_ _06949_ VGND VGND VPWR VPWR _07844_ sky130_fd_sc_hd__mux2_1
X_13325_ _04805_ _04806_ VGND VGND VPWR VPWR _04808_ sky130_fd_sc_hd__or2_1
X_10537_ _01792_ _01799_ _01800_ VGND VGND VPWR VPWR _01801_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_10_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16044_ _07767_ _07768_ VGND VGND VPWR VPWR _07769_ sky130_fd_sc_hd__xnor2_2
X_13256_ _04631_ _04732_ VGND VGND VPWR VPWR _04733_ sky130_fd_sc_hd__xnor2_1
X_10468_ _01730_ _01731_ net495 net810 VGND VGND VPWR VPWR _01732_ sky130_fd_sc_hd__and4bb_1
X_12207_ _03577_ _03579_ VGND VGND VPWR VPWR _03585_ sky130_fd_sc_hd__and2b_1
X_13187_ _04637_ _04656_ VGND VGND VPWR VPWR _04657_ sky130_fd_sc_hd__xor2_1
X_10399_ net421 net734 VGND VGND VPWR VPWR _01663_ sky130_fd_sc_hd__nand2_1
X_12138_ _03510_ _03419_ VGND VGND VPWR VPWR _03511_ sky130_fd_sc_hd__nor2_1
X_12069_ _03349_ _03435_ VGND VGND VPWR VPWR _03436_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_126_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15828_ _07533_ _07526_ _07527_ VGND VGND VPWR VPWR _07535_ sky130_fd_sc_hd__nor3_1
XFILLER_0_35_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15759_ _07457_ _07458_ _07459_ _07384_ VGND VGND VPWR VPWR _07460_ sky130_fd_sc_hd__o211ai_2
X_08300_ _04185_ _04207_ VGND VGND VPWR VPWR _04284_ sky130_fd_sc_hd__and2_1
X_09280_ net289 net280 net696 net526 VGND VGND VPWR VPWR _00595_ sky130_fd_sc_hd__and4_1
XFILLER_0_19_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08231_ net213 net204 net685 net694 VGND VGND VPWR VPWR _03528_ sky130_fd_sc_hd__and4_1
XFILLER_0_74_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08162_ _02746_ _02757_ _02768_ VGND VGND VPWR VPWR _02779_ sky130_fd_sc_hd__or3_1
XFILLER_0_16_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08995_ _00200_ _00205_ VGND VGND VPWR VPWR _00313_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09616_ _00924_ _00925_ _00907_ _00908_ VGND VGND VPWR VPWR _00927_ sky130_fd_sc_hd__a211o_1
X_09547_ _00749_ _00752_ _00750_ VGND VGND VPWR VPWR _00859_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_93_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09478_ net249 net545 VGND VGND VPWR VPWR _00791_ sky130_fd_sc_hd__nand2_1
XFILLER_0_93_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08429_ _05590_ _05665_ _05676_ VGND VGND VPWR VPWR _05687_ sky130_fd_sc_hd__and3_2
XFILLER_0_18_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11440_ _02656_ _02658_ VGND VGND VPWR VPWR _02752_ sky130_fd_sc_hd__nand2_1
XFILLER_0_124_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11371_ _02675_ _02676_ VGND VGND VPWR VPWR _02677_ sky130_fd_sc_hd__xor2_1
XFILLER_0_150_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13110_ net424 net195 net185 net509 VGND VGND VPWR VPWR _04573_ sky130_fd_sc_hd__a22o_1
X_10322_ net133 _01588_ _01589_ _01590_ VGND VGND VPWR VPWR _00053_ sky130_fd_sc_hd__a31o_1
X_14090_ _05616_ _05617_ _05638_ VGND VGND VPWR VPWR _05639_ sky130_fd_sc_hd__a21o_1
XFILLER_0_132_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13041_ _04495_ _04496_ _04476_ VGND VGND VPWR VPWR _04498_ sky130_fd_sc_hd__a21oi_2
X_10253_ net113 _01530_ net136 VGND VGND VPWR VPWR _01531_ sky130_fd_sc_hd__mux2_1
X_10184_ a_cos\[15\] b_sin\[15\] VGND VGND VPWR VPWR _01472_ sky130_fd_sc_hd__and2_1
X_14992_ _06621_ _06622_ _06623_ VGND VGND VPWR VPWR _06625_ sky130_fd_sc_hd__a21o_1
Xfanout270 net271 VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__clkbuf_4
Xfanout281 net63 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__buf_2
Xfanout292 net62 VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__clkbuf_4
X_13943_ _05321_ _05400_ _05378_ VGND VGND VPWR VPWR _05479_ sky130_fd_sc_hd__a21boi_4
XFILLER_0_89_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13874_ _05397_ _05398_ _05403_ VGND VGND VPWR VPWR _05404_ sky130_fd_sc_hd__o21ai_2
X_15613_ _07228_ _07230_ VGND VGND VPWR VPWR _07301_ sky130_fd_sc_hd__nand2_1
X_12825_ _04254_ _04261_ VGND VGND VPWR VPWR _04263_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15544_ _07223_ _07224_ _07215_ VGND VGND VPWR VPWR _07226_ sky130_fd_sc_hd__a21o_1
X_12756_ _04171_ _04184_ _04186_ VGND VGND VPWR VPWR _04187_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_84_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11707_ _02773_ _02932_ _02933_ VGND VGND VPWR VPWR _03043_ sky130_fd_sc_hd__and3_2
XFILLER_0_56_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15475_ _07053_ _07143_ VGND VGND VPWR VPWR _07151_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12687_ _04087_ _04088_ _04103_ VGND VGND VPWR VPWR _04111_ sky130_fd_sc_hd__a21o_1
XFILLER_0_71_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14426_ net411 net542 net550 net400 VGND VGND VPWR VPWR _06005_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_112_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11638_ _02963_ _02965_ _02966_ VGND VGND VPWR VPWR _02968_ sky130_fd_sc_hd__nand3_1
XFILLER_0_21_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14357_ _05916_ _05927_ _05917_ VGND VGND VPWR VPWR _05929_ sky130_fd_sc_hd__nand3_2
XFILLER_0_21_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11569_ _02801_ _02891_ VGND VGND VPWR VPWR _02893_ sky130_fd_sc_hd__nor2_1
XFILLER_0_141_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13308_ net313 net424 net186 net176 VGND VGND VPWR VPWR _04789_ sky130_fd_sc_hd__nand4_2
XFILLER_0_40_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14288_ net391 net605 _05837_ _05836_ VGND VGND VPWR VPWR _05853_ sky130_fd_sc_hd__a31o_1
XFILLER_0_122_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16027_ net865 net866 net631 net622 VGND VGND VPWR VPWR _07751_ sky130_fd_sc_hd__and4_1
X_13239_ _04694_ _04712_ _04713_ VGND VGND VPWR VPWR _04714_ sky130_fd_sc_hd__nand3_1
X_08780_ _08001_ _08089_ _08090_ net118 VGND VGND VPWR VPWR _08091_ sky130_fd_sc_hd__o22a_4
XPHY_EDGE_ROW_127_Right_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09401_ _00711_ _00712_ _00713_ VGND VGND VPWR VPWR _00715_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09332_ _00566_ _00646_ VGND VGND VPWR VPWR _00647_ sky130_fd_sc_hd__xor2_2
XFILLER_0_87_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09263_ _00576_ _00577_ VGND VGND VPWR VPWR _00578_ sky130_fd_sc_hd__nor2_2
XFILLER_0_75_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08214_ _03301_ _03333_ VGND VGND VPWR VPWR _03344_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09194_ _00508_ _00509_ VGND VGND VPWR VPWR _00510_ sky130_fd_sc_hd__xor2_4
XFILLER_0_132_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08145_ net189 net564 net576 net179 VGND VGND VPWR VPWR _02594_ sky130_fd_sc_hd__a22o_1
XFILLER_0_16_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08978_ _00196_ _00284_ _00283_ VGND VGND VPWR VPWR _00296_ sky130_fd_sc_hd__a21bo_1
Xhold45 a_sin\[17\] VGND VGND VPWR VPWR net856 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10940_ net768 net779 net489 net479 VGND VGND VPWR VPWR _02207_ sky130_fd_sc_hd__and4_1
XFILLER_0_98_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10871_ net362 net742 _02133_ _02134_ VGND VGND VPWR VPWR _02135_ sky130_fd_sc_hd__a22o_1
XFILLER_0_78_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12610_ _04022_ _04023_ _04025_ VGND VGND VPWR VPWR _04026_ sky130_fd_sc_hd__a21oi_1
X_13590_ _05094_ _05095_ VGND VGND VPWR VPWR _05096_ sky130_fd_sc_hd__nand2_1
XFILLER_0_149_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12541_ _03948_ _03942_ _03944_ VGND VGND VPWR VPWR _03950_ sky130_fd_sc_hd__nand3_1
XFILLER_0_54_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15260_ net404 net394 net644 net635 VGND VGND VPWR VPWR _06917_ sky130_fd_sc_hd__nand4_1
X_12472_ _03801_ _03806_ _03808_ VGND VGND VPWR VPWR _03874_ sky130_fd_sc_hd__or3_1
XFILLER_0_124_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14211_ _05767_ _05768_ _05721_ VGND VGND VPWR VPWR _05770_ sky130_fd_sc_hd__a21oi_1
X_11423_ net740 net469 VGND VGND VPWR VPWR _02733_ sky130_fd_sc_hd__nand2_1
X_15191_ _06823_ _06841_ VGND VGND VPWR VPWR _06842_ sky130_fd_sc_hd__xor2_1
XFILLER_0_105_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_9 net93 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11354_ net513 net359 _02655_ _02656_ VGND VGND VPWR VPWR _02658_ sky130_fd_sc_hd__nand4_1
X_14142_ _05598_ _05603_ _05604_ _05694_ VGND VGND VPWR VPWR _05695_ sky130_fd_sc_hd__o31a_1
XFILLER_0_104_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10305_ net134 net102 VGND VGND VPWR VPWR _01576_ sky130_fd_sc_hd__and2b_1
X_14073_ net797 net287 net278 net139 VGND VGND VPWR VPWR _05620_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_120_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11285_ _02580_ _02581_ _02564_ VGND VGND VPWR VPWR _02584_ sky130_fd_sc_hd__a21o_1
XFILLER_0_120_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13024_ net212 _04477_ _04478_ VGND VGND VPWR VPWR _04479_ sky130_fd_sc_hd__a21bo_1
X_10236_ _01514_ _01515_ VGND VGND VPWR VPWR _01516_ sky130_fd_sc_hd__nand2_1
X_10167_ _01456_ _01457_ VGND VGND VPWR VPWR _01458_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_83_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14975_ net405 net395 net673 VGND VGND VPWR VPWR _06607_ sky130_fd_sc_hd__and3_1
X_10098_ net90 _01398_ net137 VGND VGND VPWR VPWR _01399_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13926_ _05458_ _05460_ VGND VGND VPWR VPWR _05461_ sky130_fd_sc_hd__xor2_1
XFILLER_0_107_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13857_ net797 net868 net302 net139 VGND VGND VPWR VPWR _05386_ sky130_fd_sc_hd__a22o_1
XFILLER_0_16_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12808_ _03850_ _03856_ VGND VGND VPWR VPWR _04244_ sky130_fd_sc_hd__and2b_1
XFILLER_0_69_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13788_ _05309_ _05310_ VGND VGND VPWR VPWR _05311_ sky130_fd_sc_hd__xnor2_1
X_15527_ _07202_ _07203_ _07206_ VGND VGND VPWR VPWR _07208_ sky130_fd_sc_hd__nand3_2
X_12739_ _04084_ _04085_ _04132_ _04167_ VGND VGND VPWR VPWR _04168_ sky130_fd_sc_hd__a31o_1
XFILLER_0_139_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15458_ _07104_ _07132_ VGND VGND VPWR VPWR _07133_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_5_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14409_ _05974_ _05984_ _05975_ VGND VGND VPWR VPWR _05986_ sky130_fd_sc_hd__nand3_2
XFILLER_0_115_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15389_ _06959_ _06978_ _07056_ VGND VGND VPWR VPWR _07057_ sky130_fd_sc_hd__a21o_1
XFILLER_0_142_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09950_ _01072_ _01216_ _01254_ VGND VGND VPWR VPWR _01256_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08901_ net282 net562 VGND VGND VPWR VPWR _00220_ sky130_fd_sc_hd__and2_1
XFILLER_0_110_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09881_ net248 net666 _01187_ VGND VGND VPWR VPWR _01188_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_110_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08832_ _00143_ _00151_ VGND VGND VPWR VPWR _00152_ sky130_fd_sc_hd__xor2_2
XFILLER_0_57_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08763_ _08040_ _08072_ _08073_ VGND VGND VPWR VPWR _08074_ sky130_fd_sc_hd__nor3_1
XFILLER_0_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08694_ _04042_ _07995_ _07996_ VGND VGND VPWR VPWR _08005_ sky130_fd_sc_hd__nor3b_1
XFILLER_0_88_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09315_ _00627_ _00628_ _00624_ VGND VGND VPWR VPWR _00630_ sky130_fd_sc_hd__a21o_1
XFILLER_0_36_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09246_ _00559_ _00561_ VGND VGND VPWR VPWR _00562_ sky130_fd_sc_hd__xnor2_2
X_09177_ net562 _00397_ _00399_ _00400_ VGND VGND VPWR VPWR _00493_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_105_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08128_ net324 net240 net678 net684 VGND VGND VPWR VPWR _02408_ sky130_fd_sc_hd__and4_1
XFILLER_0_98_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11070_ net432 net154 net869 net517 VGND VGND VPWR VPWR _02349_ sky130_fd_sc_hd__a22oi_2
Xoutput79 net79 VGND VGND VPWR VPWR D[0] sky130_fd_sc_hd__clkbuf_4
X_10021_ net270 net624 VGND VGND VPWR VPWR _01326_ sky130_fd_sc_hd__nand2_1
X_14760_ _06303_ _06310_ VGND VGND VPWR VPWR _06372_ sky130_fd_sc_hd__or2b_1
X_11972_ _03288_ _03292_ _03289_ VGND VGND VPWR VPWR _03330_ sky130_fd_sc_hd__o21ba_1
X_13711_ _05225_ _05226_ VGND VGND VPWR VPWR _05227_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10923_ _02098_ _02184_ VGND VGND VPWR VPWR _02189_ sky130_fd_sc_hd__nor2_1
X_14691_ _06294_ _06295_ VGND VGND VPWR VPWR _06296_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13642_ _05052_ _05053_ _05055_ _05056_ _05069_ VGND VGND VPWR VPWR _05152_ sky130_fd_sc_hd__a32o_1
X_10854_ net496 net768 VGND VGND VPWR VPWR _02118_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13573_ net609 net709 net288 net279 VGND VGND VPWR VPWR _05077_ sky130_fd_sc_hd__and4_1
X_10785_ _02045_ _02048_ VGND VGND VPWR VPWR _02049_ sky130_fd_sc_hd__xnor2_2
X_15312_ _06872_ _06873_ _06972_ VGND VGND VPWR VPWR _06973_ sky130_fd_sc_hd__o21a_1
X_12524_ _03901_ _03929_ _03930_ VGND VGND VPWR VPWR _03931_ sky130_fd_sc_hd__o21ba_2
X_16292_ clknet_4_8_0_clk _00081_ net343 VGND VGND VPWR VPWR a_sin\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_35_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15243_ _06888_ _06896_ _06897_ VGND VGND VPWR VPWR _06898_ sky130_fd_sc_hd__nand3_1
X_12455_ _03851_ _03854_ VGND VGND VPWR VPWR _03856_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11406_ _02712_ _02714_ VGND VGND VPWR VPWR _02715_ sky130_fd_sc_hd__xor2_2
XFILLER_0_34_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15174_ net443 net604 _06665_ _06822_ VGND VGND VPWR VPWR _06823_ sky130_fd_sc_hd__a31o_1
X_12386_ _03776_ _03777_ _03779_ VGND VGND VPWR VPWR _03780_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14125_ net507 _00194_ _05612_ VGND VGND VPWR VPWR _05677_ sky130_fd_sc_hd__or3_1
X_11337_ net723 net497 VGND VGND VPWR VPWR _02640_ sky130_fd_sc_hd__and2_1
X_14056_ _05599_ _05601_ VGND VGND VPWR VPWR _05602_ sky130_fd_sc_hd__nor2_1
X_11268_ net233 net406 net155 VGND VGND VPWR VPWR _02565_ sky130_fd_sc_hd__and3_1
X_13007_ _04457_ _04459_ _04442_ VGND VGND VPWR VPWR _04461_ sky130_fd_sc_hd__a21o_1
X_10219_ _01501_ VGND VGND VPWR VPWR _00039_ sky130_fd_sc_hd__clkbuf_1
X_11199_ _02373_ _02390_ _02483_ net833 VGND VGND VPWR VPWR _02490_ sky130_fd_sc_hd__a211o_1
XFILLER_0_27_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14958_ _06585_ _06586_ _06577_ VGND VGND VPWR VPWR _06588_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13909_ _05375_ _05442_ VGND VGND VPWR VPWR _05443_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14889_ _06510_ _06511_ _06512_ VGND VGND VPWR VPWR _06513_ sky130_fd_sc_hd__or3_1
XFILLER_0_73_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09100_ net273 net552 VGND VGND VPWR VPWR _00417_ sky130_fd_sc_hd__nand2_1
XFILLER_0_143_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09031_ _00344_ _00347_ _00348_ VGND VGND VPWR VPWR _00349_ sky130_fd_sc_hd__and3_1
XFILLER_0_142_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09933_ b_sin\[15\] _00739_ _01239_ VGND VGND VPWR VPWR _00015_ sky130_fd_sc_hd__a21bo_1
Xfanout803 net804 VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__buf_4
XFILLER_0_0_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09864_ _01170_ _01171_ VGND VGND VPWR VPWR _01172_ sky130_fd_sc_hd__xnor2_1
X_08815_ _00126_ _00133_ _00134_ VGND VGND VPWR VPWR _00135_ sky130_fd_sc_hd__nand3_1
X_09795_ _01102_ _01103_ VGND VGND VPWR VPWR _01104_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08746_ net220 net659 VGND VGND VPWR VPWR _08057_ sky130_fd_sc_hd__nand2_1
X_08677_ _07954_ _07955_ _07987_ _07988_ VGND VGND VPWR VPWR _07989_ sky130_fd_sc_hd__nand4_4
XFILLER_0_67_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10570_ _01797_ _01795_ _01796_ VGND VGND VPWR VPWR _01834_ sky130_fd_sc_hd__or3_1
XFILLER_0_134_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09229_ _00543_ _00544_ VGND VGND VPWR VPWR _00545_ sky130_fd_sc_hd__and2_1
XFILLER_0_106_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12240_ net315 _02389_ _03620_ VGND VGND VPWR VPWR _03621_ sky130_fd_sc_hd__o21ai_1
X_12171_ _03488_ _03498_ VGND VGND VPWR VPWR _03546_ sky130_fd_sc_hd__and2b_1
X_11122_ _02193_ _02297_ _02296_ VGND VGND VPWR VPWR _02405_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_102_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15930_ _07579_ _07645_ VGND VGND VPWR VPWR _07646_ sky130_fd_sc_hd__xor2_1
X_11053_ _02239_ _02258_ _02259_ VGND VGND VPWR VPWR _02330_ sky130_fd_sc_hd__nand3_1
X_10004_ net262 net637 _01307_ _01308_ VGND VGND VPWR VPWR _01309_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15861_ _07570_ _07482_ VGND VGND VPWR VPWR _07571_ sky130_fd_sc_hd__nand2_1
X_14812_ _06426_ _06427_ _06301_ _06394_ VGND VGND VPWR VPWR _06429_ sky130_fd_sc_hd__o211ai_4
X_15792_ _07427_ _07494_ VGND VGND VPWR VPWR _07496_ sky130_fd_sc_hd__nor2_1
X_14743_ _06351_ _06352_ VGND VGND VPWR VPWR _06353_ sky130_fd_sc_hd__nand2_1
X_11955_ _03309_ _03311_ VGND VGND VPWR VPWR _03313_ sky130_fd_sc_hd__xnor2_1
X_10906_ _02168_ _02171_ VGND VGND VPWR VPWR _02172_ sky130_fd_sc_hd__and2b_1
XFILLER_0_58_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14674_ _06271_ _06272_ _06037_ VGND VGND VPWR VPWR _06277_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_74_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11886_ _03171_ _03237_ VGND VGND VPWR VPWR _03238_ sky130_fd_sc_hd__xor2_2
XFILLER_0_55_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13625_ _05087_ _05089_ _05132_ VGND VGND VPWR VPWR _05134_ sky130_fd_sc_hd__a21o_1
X_10837_ _02098_ _02099_ _02024_ VGND VGND VPWR VPWR _02101_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13556_ net799 net210 net201 VGND VGND VPWR VPWR _05059_ sky130_fd_sc_hd__and3_1
XFILLER_0_13_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10768_ _02030_ _01741_ _02027_ VGND VGND VPWR VPWR _02032_ sky130_fd_sc_hd__nand3_1
X_12507_ _03911_ _03905_ _03906_ VGND VGND VPWR VPWR _03913_ sky130_fd_sc_hd__nand3_1
XFILLER_0_70_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16275_ clknet_4_12_0_clk _00064_ net340 VGND VGND VPWR VPWR a_cos\[6\] sky130_fd_sc_hd__dfrtp_1
X_13487_ net141 net193 _04980_ _04982_ VGND VGND VPWR VPWR _04984_ sky130_fd_sc_hd__nand4_1
XFILLER_0_125_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10699_ _01957_ _01961_ _01962_ VGND VGND VPWR VPWR _01963_ sky130_fd_sc_hd__nand3_1
XFILLER_0_35_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15226_ _06877_ _06879_ VGND VGND VPWR VPWR _06880_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_23_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12438_ net729 net738 net192 net178 VGND VGND VPWR VPWR _03837_ sky130_fd_sc_hd__and4_1
XFILLER_0_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15157_ _06716_ _06717_ _06718_ VGND VGND VPWR VPWR _06805_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_140_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12369_ _03732_ _03735_ _03733_ VGND VGND VPWR VPWR _03761_ sky130_fd_sc_hd__o21ba_1
X_14108_ net295 _05387_ VGND VGND VPWR VPWR _05658_ sky130_fd_sc_hd__nand2_1
X_15088_ _06727_ _06728_ _06708_ VGND VGND VPWR VPWR _06730_ sky130_fd_sc_hd__a21oi_2
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14039_ _05581_ _05583_ VGND VGND VPWR VPWR _05584_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08600_ _07205_ _07238_ _07227_ VGND VGND VPWR VPWR _07553_ sky130_fd_sc_hd__a21oi_1
X_09580_ _00872_ _00891_ VGND VGND VPWR VPWR _00892_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_145_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08531_ net328 net575 net583 net244 VGND VGND VPWR VPWR _06802_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08462_ _05926_ _06025_ _06036_ _05503_ VGND VGND VPWR VPWR _06047_ sky130_fd_sc_hd__o211a_2
XFILLER_0_148_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08393_ net224 net565 VGND VGND VPWR VPWR _05296_ sky130_fd_sc_hd__nand2_1
XFILLER_0_64_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09014_ _00328_ _00329_ _00330_ VGND VGND VPWR VPWR _00332_ sky130_fd_sc_hd__nand3_1
XFILLER_0_116_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout600 net608 VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__clkbuf_2
Xfanout611 net617 VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__clkbuf_4
X_09916_ _01163_ _01142_ _01143_ VGND VGND VPWR VPWR _01223_ sky130_fd_sc_hd__nand3_1
Xfanout622 net623 VGND VGND VPWR VPWR net622 sky130_fd_sc_hd__clkbuf_4
Xfanout633 net636 VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__clkbuf_2
Xfanout644 net645 VGND VGND VPWR VPWR net644 sky130_fd_sc_hd__clkbuf_4
Xfanout655 net26 VGND VGND VPWR VPWR net655 sky130_fd_sc_hd__clkbuf_8
Xfanout666 net670 VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__clkbuf_4
Xfanout677 net23 VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__clkbuf_4
X_09847_ _01077_ _01154_ VGND VGND VPWR VPWR _01155_ sky130_fd_sc_hd__xnor2_1
Xfanout688 net689 VGND VGND VPWR VPWR net688 sky130_fd_sc_hd__buf_2
Xfanout699 net701 VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__clkbuf_4
X_09778_ net157 net303 VGND VGND VPWR VPWR _01087_ sky130_fd_sc_hd__or2_2
XFILLER_0_96_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08729_ _08038_ _08039_ VGND VGND VPWR VPWR _08040_ sky130_fd_sc_hd__nand2_1
X_11740_ _03077_ _03078_ VGND VGND VPWR VPWR _03079_ sky130_fd_sc_hd__or2_1
XFILLER_0_139_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11671_ net722 net458 net452 net731 VGND VGND VPWR VPWR _03003_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_48_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13410_ _04893_ _04898_ _04899_ VGND VGND VPWR VPWR _04900_ sky130_fd_sc_hd__nand3_1
XFILLER_0_36_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10622_ net410 net809 _01885_ VGND VGND VPWR VPWR _01886_ sky130_fd_sc_hd__nand3_1
X_14390_ net380 net578 net587 net370 VGND VGND VPWR VPWR _05965_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_91_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13341_ _04631_ _04732_ VGND VGND VPWR VPWR _04825_ sky130_fd_sc_hd__nand2_1
XFILLER_0_106_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10553_ _01814_ _01816_ VGND VGND VPWR VPWR _01817_ sky130_fd_sc_hd__and2_1
XFILLER_0_91_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16060_ _07776_ _07779_ _07785_ VGND VGND VPWR VPWR _07786_ sky130_fd_sc_hd__a21oi_1
X_13272_ net772 net251 VGND VGND VPWR VPWR _04749_ sky130_fd_sc_hd__nand2_1
X_10484_ net393 net786 _01746_ _01747_ VGND VGND VPWR VPWR _01748_ sky130_fd_sc_hd__a31o_1
XFILLER_0_106_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15011_ _06552_ _06645_ VGND VGND VPWR VPWR _06646_ sky130_fd_sc_hd__xor2_1
X_12223_ _03558_ _03562_ _03601_ VGND VGND VPWR VPWR _03602_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_32_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12154_ _03494_ _03495_ _03487_ VGND VGND VPWR VPWR _03527_ sky130_fd_sc_hd__o21bai_1
X_11105_ _02385_ VGND VGND VPWR VPWR _02387_ sky130_fd_sc_hd__buf_4
X_12085_ _03450_ _03452_ VGND VGND VPWR VPWR _03454_ sky130_fd_sc_hd__xnor2_1
X_15913_ _07611_ _07625_ VGND VGND VPWR VPWR _07627_ sky130_fd_sc_hd__and2_1
X_11036_ net776 net470 VGND VGND VPWR VPWR _02312_ sky130_fd_sc_hd__and2_1
X_15844_ _07467_ _07470_ _07468_ VGND VGND VPWR VPWR _07552_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_99_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15775_ _07474_ _07476_ VGND VGND VPWR VPWR _07478_ sky130_fd_sc_hd__xor2_2
X_12987_ _04437_ _04438_ VGND VGND VPWR VPWR _04439_ sky130_fd_sc_hd__or2_1
XFILLER_0_99_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14726_ _06329_ _06334_ VGND VGND VPWR VPWR _06335_ sky130_fd_sc_hd__xor2_1
XFILLER_0_87_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11938_ _03287_ _03293_ VGND VGND VPWR VPWR _03294_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_74_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14657_ _06011_ _06257_ _06255_ _06254_ VGND VGND VPWR VPWR _06259_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_39_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11869_ _03137_ _03143_ VGND VGND VPWR VPWR _03219_ sky130_fd_sc_hd__and2_1
XFILLER_0_145_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13608_ _05047_ _05030_ VGND VGND VPWR VPWR _05115_ sky130_fd_sc_hd__and2b_1
XFILLER_0_6_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14588_ _06165_ _06181_ _06182_ VGND VGND VPWR VPWR _06183_ sky130_fd_sc_hd__nand3_2
XFILLER_0_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13539_ _05039_ VGND VGND VPWR VPWR _05040_ sky130_fd_sc_hd__inv_2
XFILLER_0_42_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16258_ clknet_4_0_0_clk _00047_ net331 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_23_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15209_ _06823_ _06841_ _06860_ VGND VGND VPWR VPWR _06861_ sky130_fd_sc_hd__a21o_1
XFILLER_0_23_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16189_ _07872_ _07875_ _07873_ VGND VGND VPWR VPWR _07926_ sky130_fd_sc_hd__o21a_1
XFILLER_0_11_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09701_ _01004_ _01005_ _01010_ VGND VGND VPWR VPWR _01011_ sky130_fd_sc_hd__a21o_1
XFILLER_0_65_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09632_ _00883_ _00885_ _00889_ VGND VGND VPWR VPWR _00943_ sky130_fd_sc_hd__o21ai_1
X_09563_ _00744_ _00747_ _00745_ VGND VGND VPWR VPWR _00875_ sky130_fd_sc_hd__o21ba_1
X_08514_ _06168_ _06595_ _06606_ VGND VGND VPWR VPWR _06617_ sky130_fd_sc_hd__nand3_1
X_09494_ _00723_ _00726_ VGND VGND VPWR VPWR _00807_ sky130_fd_sc_hd__nor2_1
XFILLER_0_81_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08445_ net824 net823 net558 net565 VGND VGND VPWR VPWR _05860_ sky130_fd_sc_hd__nand4_1
XFILLER_0_77_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08376_ _05014_ _05090_ _05101_ VGND VGND VPWR VPWR _05112_ sky130_fd_sc_hd__and3_4
XFILLER_0_34_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout430 net5 VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__buf_6
Xfanout441 net446 VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__clkbuf_4
Xfanout452 net454 VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__clkbuf_4
Xfanout463 net45 VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__clkbuf_2
Xfanout474 net480 VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__clkbuf_4
Xfanout485 net490 VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__clkbuf_2
X_12910_ _04351_ _04352_ _04353_ VGND VGND VPWR VPWR _04355_ sky130_fd_sc_hd__nand3_1
Xfanout496 net497 VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__clkbuf_2
X_13890_ _05335_ _05341_ VGND VGND VPWR VPWR _05422_ sky130_fd_sc_hd__and2b_1
XFILLER_0_69_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12841_ net711 net197 VGND VGND VPWR VPWR _04280_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15560_ _07057_ _07141_ _07243_ VGND VGND VPWR VPWR _07244_ sky130_fd_sc_hd__a21oi_2
X_12772_ net806 net221 _04202_ _04203_ VGND VGND VPWR VPWR _04204_ sky130_fd_sc_hd__and4_1
XFILLER_0_68_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14511_ net409 net399 net606 net706 VGND VGND VPWR VPWR _06098_ sky130_fd_sc_hd__and4_1
XFILLER_0_56_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11723_ _03058_ _03059_ VGND VGND VPWR VPWR _03060_ sky130_fd_sc_hd__xor2_1
X_15491_ _07166_ _07164_ _07165_ VGND VGND VPWR VPWR _07168_ sky130_fd_sc_hd__or3_1
XFILLER_0_37_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14442_ _06020_ _06021_ VGND VGND VPWR VPWR _06022_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_126_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11654_ _02881_ _02883_ VGND VGND VPWR VPWR _02985_ sky130_fd_sc_hd__nor2_1
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10605_ _01841_ _01840_ VGND VGND VPWR VPWR _01869_ sky130_fd_sc_hd__and2b_1
XFILLER_0_4_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14373_ _05899_ _05900_ _05898_ VGND VGND VPWR VPWR _05946_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_107_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11585_ net731 net740 net462 net452 VGND VGND VPWR VPWR _02910_ sky130_fd_sc_hd__and4_1
XFILLER_0_141_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16112_ _07786_ _07842_ VGND VGND VPWR VPWR _07843_ sky130_fd_sc_hd__xnor2_1
X_13324_ _04800_ _04801_ _04804_ VGND VGND VPWR VPWR _04806_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_107_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10536_ _01793_ _01794_ _01798_ VGND VGND VPWR VPWR _01800_ sky130_fd_sc_hd__nand3_1
X_16043_ _07701_ _07702_ _07706_ VGND VGND VPWR VPWR _07768_ sky130_fd_sc_hd__a21boi_2
X_13255_ _04729_ _04730_ VGND VGND VPWR VPWR _04732_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_108_Right_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10467_ net353 net785 net793 net505 VGND VGND VPWR VPWR _01731_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_86_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12206_ _03584_ VGND VGND VPWR VPWR _00074_ sky130_fd_sc_hd__clkbuf_1
X_13186_ _04638_ _04655_ VGND VGND VPWR VPWR _04656_ sky130_fd_sc_hd__xnor2_1
X_10398_ net524 net439 net715 net725 VGND VGND VPWR VPWR _01662_ sky130_fd_sc_hd__and4_1
XFILLER_0_19_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12137_ _03417_ _03401_ VGND VGND VPWR VPWR _03510_ sky130_fd_sc_hd__and2b_1
XFILLER_0_20_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12068_ _03430_ _03434_ VGND VGND VPWR VPWR _03435_ sky130_fd_sc_hd__xor2_1
X_11019_ _02192_ _02291_ _02292_ VGND VGND VPWR VPWR _02293_ sky130_fd_sc_hd__a21oi_1
X_15827_ _07526_ _07527_ _07533_ VGND VGND VPWR VPWR _07534_ sky130_fd_sc_hd__o21a_1
XFILLER_0_35_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15758_ _07378_ _07381_ VGND VGND VPWR VPWR _07459_ sky130_fd_sc_hd__nand2_1
XFILLER_0_142_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14709_ _06313_ _06314_ _06215_ _06282_ VGND VGND VPWR VPWR _06316_ sky130_fd_sc_hd__o211a_1
X_15689_ _07382_ _07365_ _07366_ VGND VGND VPWR VPWR _07384_ sky130_fd_sc_hd__nand3_2
XFILLER_0_118_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08230_ net196 net530 VGND VGND VPWR VPWR _03518_ sky130_fd_sc_hd__nand2_1
XFILLER_0_145_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08161_ net320 net669 net679 net236 VGND VGND VPWR VPWR _02768_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_55_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08994_ _00310_ _00311_ VGND VGND VPWR VPWR _00312_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09615_ _00907_ _00908_ _00924_ _00925_ VGND VGND VPWR VPWR _00926_ sky130_fd_sc_hd__o211ai_2
X_09546_ _00856_ _00857_ VGND VGND VPWR VPWR _00858_ sky130_fd_sc_hd__xnor2_1
X_09477_ _00788_ _00789_ VGND VGND VPWR VPWR _00790_ sky130_fd_sc_hd__nor2_1
X_08428_ _05112_ _05644_ _05633_ _05535_ VGND VGND VPWR VPWR _05676_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_19_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08359_ net189 net582 net592 net179 VGND VGND VPWR VPWR _04927_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_46_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11370_ _02569_ _02576_ _02575_ VGND VGND VPWR VPWR _02676_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_116_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10321_ net133 net104 VGND VGND VPWR VPWR _01590_ sky130_fd_sc_hd__and2b_1
XFILLER_0_132_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13040_ _04476_ _04495_ _04496_ VGND VGND VPWR VPWR _04497_ sky130_fd_sc_hd__and3_1
X_10252_ _01528_ _01529_ VGND VGND VPWR VPWR _01530_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_131_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10183_ _01471_ VGND VGND VPWR VPWR _00033_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_100_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14991_ _06621_ _06622_ _06623_ VGND VGND VPWR VPWR _06624_ sky130_fd_sc_hd__nand3_4
Xfanout260 net66 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__clkbuf_2
Xfanout271 net272 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__clkbuf_4
Xfanout282 net285 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__clkbuf_4
X_13942_ _05385_ _05393_ _05477_ VGND VGND VPWR VPWR _05478_ sky130_fd_sc_hd__a21o_1
Xfanout293 net62 VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13873_ _05399_ _05402_ VGND VGND VPWR VPWR _05403_ sky130_fd_sc_hd__xnor2_1
X_15612_ _07175_ _07178_ _07176_ VGND VGND VPWR VPWR _07300_ sky130_fd_sc_hd__a21bo_1
X_12824_ _04259_ _04260_ VGND VGND VPWR VPWR _04261_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15543_ _07215_ _07223_ _07224_ VGND VGND VPWR VPWR _07225_ sky130_fd_sc_hd__nand3_1
X_12755_ _04180_ _04183_ _04173_ VGND VGND VPWR VPWR _04186_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_127_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11706_ _03038_ _03039_ _03019_ _03020_ VGND VGND VPWR VPWR _03042_ sky130_fd_sc_hd__a211o_1
X_15474_ _07149_ VGND VGND VPWR VPWR _00103_ sky130_fd_sc_hd__clkbuf_1
X_12686_ _04106_ _04109_ VGND VGND VPWR VPWR _04110_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14425_ net411 net400 net542 net549 VGND VGND VPWR VPWR _06004_ sky130_fd_sc_hd__and4_1
XFILLER_0_127_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11637_ _02963_ _02965_ _02966_ VGND VGND VPWR VPWR _02967_ sky130_fd_sc_hd__a21o_1
XFILLER_0_21_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14356_ _05916_ _05917_ _05927_ VGND VGND VPWR VPWR _05928_ sky130_fd_sc_hd__a21o_1
XFILLER_0_107_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11568_ _02801_ _02891_ VGND VGND VPWR VPWR _02892_ sky130_fd_sc_hd__and2_1
XFILLER_0_25_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13307_ net313 net186 net176 net424 VGND VGND VPWR VPWR _04788_ sky130_fd_sc_hd__a22o_1
X_10519_ _01755_ _01781_ _01782_ VGND VGND VPWR VPWR _01783_ sky130_fd_sc_hd__nand3_2
X_14287_ _05851_ VGND VGND VPWR VPWR _05852_ sky130_fd_sc_hd__inv_2
XFILLER_0_123_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11499_ _02814_ _02812_ _02813_ VGND VGND VPWR VPWR _02816_ sky130_fd_sc_hd__and3_1
X_16026_ net866 net631 net622 net865 VGND VGND VPWR VPWR _07750_ sky130_fd_sc_hd__a22o_1
X_13238_ _04708_ _04710_ _04711_ VGND VGND VPWR VPWR _04713_ sky130_fd_sc_hd__a21o_1
XFILLER_0_21_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13169_ _04536_ _04537_ _04636_ VGND VGND VPWR VPWR _04637_ sky130_fd_sc_hd__a21o_1
XFILLER_0_137_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09400_ _00711_ _00712_ _00713_ VGND VGND VPWR VPWR _00714_ sky130_fd_sc_hd__nand3_2
XFILLER_0_88_840 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09331_ _00568_ _00645_ VGND VGND VPWR VPWR _00646_ sky130_fd_sc_hd__xor2_2
XFILLER_0_47_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09262_ net266 net257 net544 net552 VGND VGND VPWR VPWR _00577_ sky130_fd_sc_hd__and4_1
XFILLER_0_8_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08213_ _03312_ _03322_ VGND VGND VPWR VPWR _03333_ sky130_fd_sc_hd__nor2_1
X_09193_ net273 net544 VGND VGND VPWR VPWR _00509_ sky130_fd_sc_hd__nand2_2
XFILLER_0_133_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08144_ net189 net179 net564 net576 VGND VGND VPWR VPWR _02583_ sky130_fd_sc_hd__nand4_1
XFILLER_0_70_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08977_ _00295_ VGND VGND VPWR VPWR _00003_ sky130_fd_sc_hd__clkbuf_1
Xhold46 b_sin\[16\] VGND VGND VPWR VPWR net857 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10870_ net724 net384 net373 net864 VGND VGND VPWR VPWR _02134_ sky130_fd_sc_hd__nand4_2
XFILLER_0_79_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09529_ _00763_ _00840_ VGND VGND VPWR VPWR _00841_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_149_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12540_ _03942_ _03944_ _03948_ VGND VGND VPWR VPWR _03949_ sky130_fd_sc_hd__a21o_1
XFILLER_0_109_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12471_ _03806_ _03808_ _03801_ VGND VGND VPWR VPWR _03873_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_136_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14210_ _05721_ _05767_ _05768_ VGND VGND VPWR VPWR _05769_ sky130_fd_sc_hd__and3_1
X_11422_ _02730_ _02731_ VGND VGND VPWR VPWR _02732_ sky130_fd_sc_hd__nor2_1
X_15190_ _06825_ _06840_ VGND VGND VPWR VPWR _06841_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_61_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14141_ _05607_ _05606_ VGND VGND VPWR VPWR _05694_ sky130_fd_sc_hd__or2b_1
XFILLER_0_62_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11353_ net513 net359 _02655_ _02656_ VGND VGND VPWR VPWR _02657_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_89_Left_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10304_ _01564_ _01570_ _01573_ VGND VGND VPWR VPWR _01575_ sky130_fd_sc_hd__o21ai_1
X_14072_ _05560_ _05563_ _05618_ VGND VGND VPWR VPWR _05619_ sky130_fd_sc_hd__a21o_1
XFILLER_0_120_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11284_ _02564_ _02580_ _02581_ VGND VGND VPWR VPWR _02582_ sky130_fd_sc_hd__nand3_1
X_13023_ net314 net212 net203 net424 VGND VGND VPWR VPWR _04478_ sky130_fd_sc_hd__a22o_1
X_10235_ a_sin\[4\] b_cos\[4\] VGND VGND VPWR VPWR _01515_ sky130_fd_sc_hd__or2b_1
X_10166_ _01449_ _01451_ _01448_ VGND VGND VPWR VPWR _01457_ sky130_fd_sc_hd__o21ba_1
X_14974_ _06596_ _06604_ VGND VGND VPWR VPWR _06605_ sky130_fd_sc_hd__xor2_2
X_10097_ _01394_ _01397_ VGND VGND VPWR VPWR _01398_ sky130_fd_sc_hd__xnor2_1
X_13925_ _05413_ _05417_ _05414_ VGND VGND VPWR VPWR _05460_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_16_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13856_ _05382_ _05384_ VGND VGND VPWR VPWR _05385_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_57_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12807_ _04241_ _04242_ VGND VGND VPWR VPWR _04243_ sky130_fd_sc_hd__nor2_1
XFILLER_0_97_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13787_ _05221_ _05224_ _05222_ VGND VGND VPWR VPWR _05310_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_57_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10999_ _02269_ _02270_ _02166_ _02177_ VGND VGND VPWR VPWR _02272_ sky130_fd_sc_hd__a211o_1
XFILLER_0_123_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12738_ _04123_ _04133_ _04166_ VGND VGND VPWR VPWR _04167_ sky130_fd_sc_hd__and3b_1
X_15526_ _07202_ _07203_ _07206_ VGND VGND VPWR VPWR _07207_ sky130_fd_sc_hd__a21o_1
XFILLER_0_123_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15457_ _07130_ _07131_ VGND VGND VPWR VPWR _07132_ sky130_fd_sc_hd__nand2_2
X_12669_ _04089_ _04090_ VGND VGND VPWR VPWR _04091_ sky130_fd_sc_hd__nor2_1
X_14408_ _05974_ _05975_ _05984_ VGND VGND VPWR VPWR _05985_ sky130_fd_sc_hd__a21o_1
XFILLER_0_113_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15388_ _06977_ _06960_ VGND VGND VPWR VPWR _07056_ sky130_fd_sc_hd__and2b_1
XFILLER_0_52_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14339_ net391 net577 VGND VGND VPWR VPWR _05909_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08900_ _00143_ _00150_ _00149_ VGND VGND VPWR VPWR _00219_ sky130_fd_sc_hd__a21o_1
X_16009_ _07729_ _07730_ VGND VGND VPWR VPWR _07731_ sky130_fd_sc_hd__nor2_1
X_09880_ _01185_ _01186_ VGND VGND VPWR VPWR _01187_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08831_ _00149_ _00150_ VGND VGND VPWR VPWR _00151_ sky130_fd_sc_hd__and2b_1
X_08762_ _08070_ _08071_ _07983_ _08041_ VGND VGND VPWR VPWR _08073_ sky130_fd_sc_hd__o211a_1
X_08693_ next_state _08002_ _08003_ _08004_ VGND VGND VPWR VPWR _00000_ sky130_fd_sc_hd__a31o_1
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09314_ _00624_ _00627_ _00628_ VGND VGND VPWR VPWR _00629_ sky130_fd_sc_hd__nand3_1
XFILLER_0_8_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09245_ _00392_ _00465_ _00560_ VGND VGND VPWR VPWR _00561_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_8_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09176_ _00486_ _00491_ VGND VGND VPWR VPWR _00492_ sky130_fd_sc_hd__xor2_2
XFILLER_0_16_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08127_ net224 net694 VGND VGND VPWR VPWR _02397_ sky130_fd_sc_hd__nand2_1
XFILLER_0_101_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10020_ _01211_ _01248_ _01203_ VGND VGND VPWR VPWR _01325_ sky130_fd_sc_hd__o21ai_1
X_11971_ _03323_ _03328_ VGND VGND VPWR VPWR _03329_ sky130_fd_sc_hd__xnor2_1
X_13710_ _05124_ _05127_ _05125_ VGND VGND VPWR VPWR _05226_ sky130_fd_sc_hd__o21ba_1
X_10922_ _02188_ VGND VGND VPWR VPWR _00058_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14690_ net411 net691 net700 net400 VGND VGND VPWR VPWR _06295_ sky130_fd_sc_hd__a22oi_1
X_13641_ _05139_ _05150_ VGND VGND VPWR VPWR _05151_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_79_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10853_ _02115_ _02116_ VGND VGND VPWR VPWR _02117_ sky130_fd_sc_hd__nor2_1
XFILLER_0_67_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13572_ net609 net288 net279 net709 VGND VGND VPWR VPWR _05076_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_82_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10784_ _02046_ _02047_ VGND VGND VPWR VPWR _02048_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15311_ _06865_ _06871_ VGND VGND VPWR VPWR _06972_ sky130_fd_sc_hd__nand2_1
X_12523_ _03925_ _03928_ _03810_ _03902_ VGND VGND VPWR VPWR _03930_ sky130_fd_sc_hd__o211a_1
XFILLER_0_137_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16291_ clknet_4_8_0_clk _00080_ net343 VGND VGND VPWR VPWR a_sin\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_109_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15242_ _06893_ _06894_ _06895_ VGND VGND VPWR VPWR _06897_ sky130_fd_sc_hd__a21o_1
X_12454_ _03852_ _03853_ VGND VGND VPWR VPWR _03854_ sky130_fd_sc_hd__nor2_1
XFILLER_0_136_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11405_ net767 net444 VGND VGND VPWR VPWR _02714_ sky130_fd_sc_hd__nand2_1
X_15173_ _06663_ _06664_ VGND VGND VPWR VPWR _06822_ sky130_fd_sc_hd__nor2_1
XFILLER_0_105_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12385_ net782 net791 net162 net308 VGND VGND VPWR VPWR _03779_ sky130_fd_sc_hd__and4_1
XFILLER_0_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14124_ _05673_ _05674_ VGND VGND VPWR VPWR _05675_ sky130_fd_sc_hd__nor2_1
X_11336_ net615 net714 net351 net503 VGND VGND VPWR VPWR _02639_ sky130_fd_sc_hd__nand4_2
X_14055_ net226 net311 net261 net252 VGND VGND VPWR VPWR _05601_ sky130_fd_sc_hd__and4_1
X_11267_ _02554_ _02563_ VGND VGND VPWR VPWR _02564_ sky130_fd_sc_hd__xor2_1
X_13006_ _04442_ _04457_ _04459_ VGND VGND VPWR VPWR _04460_ sky130_fd_sc_hd__nand3_1
X_10218_ net108 _01500_ net136 VGND VGND VPWR VPWR _01501_ sky130_fd_sc_hd__mux2_1
X_11198_ net808 VGND VGND VPWR VPWR _02489_ sky130_fd_sc_hd__inv_2
XFILLER_0_27_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10149_ a_cos\[10\] b_sin\[10\] VGND VGND VPWR VPWR _01442_ sky130_fd_sc_hd__and2_1
XFILLER_0_89_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14957_ _06577_ _06585_ _06586_ VGND VGND VPWR VPWR _06587_ sky130_fd_sc_hd__nand3_2
X_13908_ _05440_ _05441_ VGND VGND VPWR VPWR _05442_ sky130_fd_sc_hd__xnor2_2
X_14888_ net431 net654 net644 net516 VGND VGND VPWR VPWR _06512_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_58_843 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13839_ _05210_ _05195_ _05288_ VGND VGND VPWR VPWR _05367_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_147_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15509_ _07185_ _07186_ _07187_ VGND VGND VPWR VPWR _07188_ sky130_fd_sc_hd__and3_1
XFILLER_0_127_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09030_ net167 net686 _00345_ _00346_ VGND VGND VPWR VPWR _00348_ sky130_fd_sc_hd__nand4_2
XFILLER_0_143_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09932_ _01237_ net863 _01238_ VGND VGND VPWR VPWR _01239_ sky130_fd_sc_hd__or3b_1
XFILLER_0_110_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout804 net10 VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__buf_6
X_09863_ _01067_ _01070_ VGND VGND VPWR VPWR _01171_ sky130_fd_sc_hd__nand2_1
X_08814_ _00130_ _00131_ _00132_ VGND VGND VPWR VPWR _00134_ sky130_fd_sc_hd__a21o_1
X_09794_ _01014_ _01037_ _01100_ _01101_ VGND VGND VPWR VPWR _01103_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_84_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08745_ _08052_ _08055_ VGND VGND VPWR VPWR _08056_ sky130_fd_sc_hd__xnor2_2
X_08676_ _07985_ _07986_ _03593_ _07956_ VGND VGND VPWR VPWR _07988_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_49_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09228_ _00542_ _00541_ _00534_ _00452_ VGND VGND VPWR VPWR _00544_ sky130_fd_sc_hd__a211o_1
XFILLER_0_90_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09159_ b_sin\[5\] _00474_ _00475_ VGND VGND VPWR VPWR _00476_ sky130_fd_sc_hd__mux2_1
XFILLER_0_121_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12170_ _03476_ _03479_ _03544_ VGND VGND VPWR VPWR _03545_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_31_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11121_ _02402_ _02403_ VGND VGND VPWR VPWR _02404_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11052_ _02327_ _02328_ VGND VGND VPWR VPWR _02329_ sky130_fd_sc_hd__or2_1
X_10003_ net256 net637 net627 net262 VGND VGND VPWR VPWR _01308_ sky130_fd_sc_hd__a22oi_2
X_15860_ _07480_ _07464_ VGND VGND VPWR VPWR _07570_ sky130_fd_sc_hd__or2b_1
XFILLER_0_99_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14811_ _06301_ _06394_ _06426_ _06427_ VGND VGND VPWR VPWR _06428_ sky130_fd_sc_hd__a211o_2
X_15791_ _07427_ _07494_ VGND VGND VPWR VPWR _07495_ sky130_fd_sc_hd__and2_1
X_14742_ _06349_ _06350_ _06262_ _06264_ VGND VGND VPWR VPWR _06352_ sky130_fd_sc_hd__o211ai_2
X_11954_ _03207_ _03224_ _03310_ VGND VGND VPWR VPWR _03311_ sky130_fd_sc_hd__a21oi_1
X_10905_ net808 net463 VGND VGND VPWR VPWR _02171_ sky130_fd_sc_hd__nand2_1
X_14673_ _05982_ _06042_ _06043_ VGND VGND VPWR VPWR _06276_ sky130_fd_sc_hd__nand3_1
XFILLER_0_98_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11885_ _03234_ _03235_ VGND VGND VPWR VPWR _03237_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_39_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13624_ _05117_ _05131_ VGND VGND VPWR VPWR _05132_ sky130_fd_sc_hd__xor2_1
X_10836_ _02098_ _02099_ _02024_ VGND VGND VPWR VPWR _02100_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_67_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_17_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13555_ _04995_ _04997_ VGND VGND VPWR VPWR _05058_ sky130_fd_sc_hd__and2_1
XFILLER_0_55_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10767_ _01741_ _02027_ _02030_ VGND VGND VPWR VPWR _02031_ sky130_fd_sc_hd__a21o_1
XFILLER_0_82_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12506_ _03905_ _03906_ _03911_ VGND VGND VPWR VPWR _03912_ sky130_fd_sc_hd__a21o_1
XFILLER_0_42_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16274_ clknet_4_12_0_clk _00063_ net340 VGND VGND VPWR VPWR a_cos\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_125_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13486_ net141 net193 _04980_ _04982_ VGND VGND VPWR VPWR _04983_ sky130_fd_sc_hd__a22o_1
XFILLER_0_82_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10698_ _01959_ _01960_ _01958_ VGND VGND VPWR VPWR _01962_ sky130_fd_sc_hd__o21ai_1
X_15225_ _02385_ net593 VGND VGND VPWR VPWR _06879_ sky130_fd_sc_hd__nor2_1
X_12437_ net729 net187 net178 net738 VGND VGND VPWR VPWR _03836_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_2_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15156_ _01891_ _06801_ net415 net635 VGND VGND VPWR VPWR _06804_ sky130_fd_sc_hd__o211ai_2
X_12368_ _03757_ _03758_ _03741_ VGND VGND VPWR VPWR _03760_ sky130_fd_sc_hd__a21o_1
XFILLER_0_23_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14107_ _05647_ _05648_ VGND VGND VPWR VPWR _05657_ sky130_fd_sc_hd__and2b_1
XFILLER_0_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11319_ _02512_ _02513_ _02511_ VGND VGND VPWR VPWR _02620_ sky130_fd_sc_hd__o21ba_1
X_15087_ _06708_ _06727_ _06728_ VGND VGND VPWR VPWR _06729_ sky130_fd_sc_hd__and3_2
X_12299_ _03661_ _03684_ VGND VGND VPWR VPWR _03685_ sky130_fd_sc_hd__xnor2_1
X_14038_ _05582_ _05472_ VGND VGND VPWR VPWR _05583_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_26_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15989_ _07707_ _07708_ _07704_ _07706_ VGND VGND VPWR VPWR _07710_ sky130_fd_sc_hd__o211a_1
X_08530_ net222 net591 VGND VGND VPWR VPWR _06791_ sky130_fd_sc_hd__nand2_1
XFILLER_0_54_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08461_ _05383_ _05492_ _05481_ VGND VGND VPWR VPWR _06036_ sky130_fd_sc_hd__a21o_1
XFILLER_0_54_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_35_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08392_ net224 net558 _04796_ _04785_ VGND VGND VPWR VPWR _05286_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09013_ _00328_ _00329_ _00330_ VGND VGND VPWR VPWR _00331_ sky130_fd_sc_hd__a21o_1
XFILLER_0_61_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_44_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout601 net602 VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__buf_4
XFILLER_0_1_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout612 net617 VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__buf_2
X_09915_ _01220_ _01200_ _01201_ VGND VGND VPWR VPWR _01222_ sky130_fd_sc_hd__and3_1
Xfanout623 net624 VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__buf_2
Xfanout634 net636 VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__clkbuf_4
Xfanout645 net27 VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__clkbuf_4
Xfanout656 net665 VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__clkbuf_4
X_09846_ _01150_ _01153_ VGND VGND VPWR VPWR _01154_ sky130_fd_sc_hd__xnor2_1
Xfanout667 net670 VGND VGND VPWR VPWR net667 sky130_fd_sc_hd__buf_2
Xfanout678 net679 VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__buf_4
Xfanout689 net838 VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__buf_4
X_09777_ net157 net303 net618 VGND VGND VPWR VPWR _01086_ sky130_fd_sc_hd__and3_1
X_08728_ _08036_ _08037_ _08018_ _08019_ VGND VGND VPWR VPWR _08039_ sky130_fd_sc_hd__a211o_1
X_08659_ _07967_ _07970_ VGND VGND VPWR VPWR _07971_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_96_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11670_ net722 net466 _02960_ _02959_ VGND VGND VPWR VPWR _03002_ sky130_fd_sc_hd__a31o_1
XFILLER_0_49_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10621_ _01880_ _01884_ VGND VGND VPWR VPWR _01885_ sky130_fd_sc_hd__xor2_1
XFILLER_0_119_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13340_ _04621_ _04623_ _04733_ VGND VGND VPWR VPWR _04824_ sky130_fd_sc_hd__or3_4
XFILLER_0_134_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10552_ _01779_ _01815_ VGND VGND VPWR VPWR _01816_ sky130_fd_sc_hd__nor2_1
XFILLER_0_146_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13271_ _04746_ _04747_ VGND VGND VPWR VPWR _04748_ sky130_fd_sc_hd__nor2_1
XFILLER_0_122_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10483_ net413 net402 net769 net778 VGND VGND VPWR VPWR _01747_ sky130_fd_sc_hd__and4_1
X_15010_ _06539_ _06644_ VGND VGND VPWR VPWR _06645_ sky130_fd_sc_hd__xor2_1
XFILLER_0_32_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12222_ net426 _02389_ _03563_ VGND VGND VPWR VPWR _03601_ sky130_fd_sc_hd__or3_1
X_12153_ _03513_ _03512_ VGND VGND VPWR VPWR _03526_ sky130_fd_sc_hd__or2b_1
XFILLER_0_20_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11104_ net48 VGND VGND VPWR VPWR _02385_ sky130_fd_sc_hd__clkinv_4
X_12084_ _03451_ _03340_ VGND VGND VPWR VPWR _03452_ sky130_fd_sc_hd__nor2_1
X_15912_ _07611_ _07625_ VGND VGND VPWR VPWR _07626_ sky130_fd_sc_hd__nor2_1
X_11035_ net486 _02308_ _02309_ VGND VGND VPWR VPWR _02311_ sky130_fd_sc_hd__a21bo_1
X_15843_ _07545_ _07550_ VGND VGND VPWR VPWR _07551_ sky130_fd_sc_hd__xnor2_1
X_12986_ _04362_ _04364_ _04435_ VGND VGND VPWR VPWR _04438_ sky130_fd_sc_hd__a21oi_2
X_15774_ _07399_ _07402_ _07475_ VGND VGND VPWR VPWR _07476_ sky130_fd_sc_hd__a21o_1
XFILLER_0_115_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14725_ _06330_ _06332_ VGND VGND VPWR VPWR _06334_ sky130_fd_sc_hd__nand2_1
X_11937_ _03291_ _03292_ VGND VGND VPWR VPWR _03293_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_129_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14656_ _06254_ _06255_ _06257_ _06011_ VGND VGND VPWR VPWR _06258_ sky130_fd_sc_hd__o211a_1
X_11868_ _03216_ _03217_ VGND VGND VPWR VPWR _03218_ sky130_fd_sc_hd__xnor2_1
X_13607_ _05106_ _05108_ VGND VGND VPWR VPWR _05114_ sky130_fd_sc_hd__or2_1
X_10819_ _02078_ _02082_ VGND VGND VPWR VPWR _02083_ sky130_fd_sc_hd__xor2_1
XFILLER_0_28_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14587_ _06173_ _06174_ _06180_ VGND VGND VPWR VPWR _06182_ sky130_fd_sc_hd__a21o_1
X_11799_ _03141_ _03142_ VGND VGND VPWR VPWR _03143_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16326_ clknet_4_6_0_clk next_state net337 VGND VGND VPWR VPWR state sky130_fd_sc_hd__dfrtp_1
X_13538_ _04939_ _04942_ _04940_ VGND VGND VPWR VPWR _05039_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_131_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13469_ net423 net158 net304 net508 VGND VGND VPWR VPWR _04964_ sky130_fd_sc_hd__a22o_1
X_16257_ clknet_4_0_0_clk _00046_ net331 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_2_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15208_ _06840_ _06825_ VGND VGND VPWR VPWR _06860_ sky130_fd_sc_hd__and2b_1
XFILLER_0_11_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16188_ net442 net643 VGND VGND VPWR VPWR _07925_ sky130_fd_sc_hd__nand2_1
X_15139_ _06701_ _06703_ VGND VGND VPWR VPWR _06785_ sky130_fd_sc_hd__nand2_1
XFILLER_0_140_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09700_ _01006_ _01009_ VGND VGND VPWR VPWR _01010_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09631_ _00843_ _00940_ _00938_ _00939_ VGND VGND VPWR VPWR _00942_ sky130_fd_sc_hd__a211o_1
XFILLER_0_65_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09562_ _00873_ _00758_ VGND VGND VPWR VPWR _00874_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08513_ _06135_ _06157_ _06146_ VGND VGND VPWR VPWR _06606_ sky130_fd_sc_hd__a21o_1
X_09493_ _00804_ _00805_ VGND VGND VPWR VPWR _00806_ sky130_fd_sc_hd__nand2_1
XFILLER_0_148_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08444_ net824 net558 net565 net823 VGND VGND VPWR VPWR _05849_ sky130_fd_sc_hd__a22o_1
XFILLER_0_148_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08375_ _05003_ _04992_ _04981_ _04861_ VGND VGND VPWR VPWR _05101_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_147_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_52_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_882 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout420 net421 VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__buf_2
Xfanout431 net433 VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__buf_6
XFILLER_0_10_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout442 net446 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__clkbuf_4
Xfanout453 net454 VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__clkbuf_2
Xfanout464 net467 VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__clkbuf_4
Xfanout475 net480 VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__clkbuf_2
Xfanout486 net487 VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__clkbuf_4
X_09829_ _00408_ net689 VGND VGND VPWR VPWR _01137_ sky130_fd_sc_hd__or2_1
Xfanout497 net41 VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__buf_4
X_12840_ _04269_ _04278_ VGND VGND VPWR VPWR _04279_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_61_Left_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12771_ net782 net326 net846 net791 VGND VGND VPWR VPWR _04203_ sky130_fd_sc_hd__a22o_1
XFILLER_0_139_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14510_ net409 net605 net706 net399 VGND VGND VPWR VPWR _06097_ sky130_fd_sc_hd__a22oi_1
X_11722_ _02935_ _02950_ VGND VGND VPWR VPWR _03059_ sky130_fd_sc_hd__or2b_1
X_15490_ _07164_ _07165_ _07166_ VGND VGND VPWR VPWR _07167_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_56_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14441_ _05963_ _05965_ _05964_ VGND VGND VPWR VPWR _06021_ sky130_fd_sc_hd__o21ba_1
X_11653_ _02928_ _02983_ VGND VGND VPWR VPWR _02984_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_139_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10604_ _01866_ _01867_ VGND VGND VPWR VPWR _01868_ sky130_fd_sc_hd__or2b_1
XFILLER_0_119_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14372_ _05942_ _05943_ _05944_ VGND VGND VPWR VPWR _05945_ sky130_fd_sc_hd__or3_1
X_11584_ net731 net462 net452 net740 VGND VGND VPWR VPWR _02908_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_64_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13323_ _04800_ _04801_ _04804_ VGND VGND VPWR VPWR _04805_ sky130_fd_sc_hd__and3_1
XFILLER_0_3_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16111_ _07787_ _07841_ VGND VGND VPWR VPWR _07842_ sky130_fd_sc_hd__xor2_1
XFILLER_0_91_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_70_Left_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10535_ _01793_ _01794_ _01798_ VGND VGND VPWR VPWR _01799_ sky130_fd_sc_hd__a21o_1
XFILLER_0_122_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13254_ _04727_ _04728_ _04633_ _04615_ VGND VGND VPWR VPWR _04730_ sky130_fd_sc_hd__a211o_1
X_16042_ _07765_ _07766_ VGND VGND VPWR VPWR _07767_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10466_ net353 net505 net785 net793 VGND VGND VPWR VPWR _01730_ sky130_fd_sc_hd__and4_1
X_12205_ a_cos\[16\] _03582_ _03521_ VGND VGND VPWR VPWR _03584_ sky130_fd_sc_hd__mux2_1
X_13185_ _04652_ _04653_ VGND VGND VPWR VPWR _04655_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_86_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10397_ _01658_ _01659_ _01660_ VGND VGND VPWR VPWR _01661_ sky130_fd_sc_hd__nand3_4
X_12136_ _03506_ _03508_ VGND VGND VPWR VPWR _03509_ sky130_fd_sc_hd__xnor2_2
X_12067_ _03359_ _03432_ _03433_ VGND VGND VPWR VPWR _03434_ sky130_fd_sc_hd__mux2_1
X_11018_ net784 net792 net463 net453 VGND VGND VPWR VPWR _02292_ sky130_fd_sc_hd__and4_1
X_15826_ _07528_ _07532_ VGND VGND VPWR VPWR _07533_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15757_ _07456_ _07445_ _07446_ VGND VGND VPWR VPWR _07458_ sky130_fd_sc_hd__and3_1
X_12969_ _04320_ _04323_ _04418_ VGND VGND VPWR VPWR _04420_ sky130_fd_sc_hd__a21o_1
XFILLER_0_59_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14708_ _06215_ _06282_ _06313_ _06314_ VGND VGND VPWR VPWR _06315_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_47_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15688_ _07365_ _07366_ _07382_ VGND VGND VPWR VPWR _07383_ sky130_fd_sc_hd__a21o_1
XFILLER_0_142_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14639_ _06237_ _06238_ VGND VGND VPWR VPWR _06239_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_109_Left_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_144_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08160_ net320 net236 net668 net678 VGND VGND VPWR VPWR _02757_ sky130_fd_sc_hd__and4_1
XFILLER_0_126_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16309_ clknet_4_11_0_clk _00098_ net343 VGND VGND VPWR VPWR b_cos\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_42_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08993_ _00201_ _00204_ _00203_ VGND VGND VPWR VPWR _00311_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09614_ _00909_ _00910_ _00923_ VGND VGND VPWR VPWR _00925_ sky130_fd_sc_hd__nand3_1
X_09545_ net296 net657 VGND VGND VPWR VPWR _00857_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09476_ net264 net254 net526 net535 VGND VGND VPWR VPWR _00789_ sky130_fd_sc_hd__and4_1
XFILLER_0_148_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08427_ _05535_ _05633_ _05644_ _05112_ VGND VGND VPWR VPWR _05665_ sky130_fd_sc_hd__a211o_1
XFILLER_0_81_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08358_ net171 net603 VGND VGND VPWR VPWR _04916_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08289_ net213 net204 net548 net557 VGND VGND VPWR VPWR _04163_ sky130_fd_sc_hd__and4_1
XFILLER_0_104_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_871 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10320_ _01578_ _01581_ _01587_ VGND VGND VPWR VPWR _01589_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_21_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10251_ _01520_ _01523_ _01521_ VGND VGND VPWR VPWR _01529_ sky130_fd_sc_hd__a21bo_1
X_10182_ net84 _01470_ net135 VGND VGND VPWR VPWR _01471_ sky130_fd_sc_hd__mux2_1
Xfanout250 net251 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__buf_4
X_14990_ _06509_ _06517_ _06516_ VGND VGND VPWR VPWR _06623_ sky130_fd_sc_hd__a21bo_1
Xfanout261 net263 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__clkbuf_4
Xfanout272 net64 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__clkbuf_4
Xfanout283 net285 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__clkbuf_4
X_13941_ _05391_ _05392_ VGND VGND VPWR VPWR _05477_ sky130_fd_sc_hd__and2_1
Xfanout294 net62 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__buf_2
X_13872_ _05139_ _05401_ VGND VGND VPWR VPWR _05402_ sky130_fd_sc_hd__xnor2_1
X_15611_ _07297_ _07298_ VGND VGND VPWR VPWR _07299_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_97_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12823_ _03851_ _03853_ _03852_ VGND VGND VPWR VPWR _04260_ sky130_fd_sc_hd__o21ba_1
X_15542_ _07220_ _07221_ _07222_ VGND VGND VPWR VPWR _07224_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_141_Right_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12754_ _04173_ _04180_ _04183_ VGND VGND VPWR VPWR _04184_ sky130_fd_sc_hd__nand3_1
XFILLER_0_57_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11705_ _03019_ _03020_ _03038_ _03039_ VGND VGND VPWR VPWR _03041_ sky130_fd_sc_hd__o211ai_2
X_12685_ _04059_ _04107_ VGND VGND VPWR VPWR _04109_ sky130_fd_sc_hd__or2_1
X_15473_ b_cos\[7\] _07148_ _06949_ VGND VGND VPWR VPWR _07149_ sky130_fd_sc_hd__mux2_1
XFILLER_0_112_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14424_ net392 net559 VGND VGND VPWR VPWR _06002_ sky130_fd_sc_hd__nand2_1
X_11636_ net512 net493 VGND VGND VPWR VPWR _02966_ sky130_fd_sc_hd__and2_1
XFILLER_0_24_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14355_ _05924_ _05925_ VGND VGND VPWR VPWR _05927_ sky130_fd_sc_hd__xnor2_1
X_11567_ _02803_ _02890_ VGND VGND VPWR VPWR _02891_ sky130_fd_sc_hd__xor2_2
XFILLER_0_135_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13306_ net313 net194 _04696_ _04695_ net200 VGND VGND VPWR VPWR _04787_ sky130_fd_sc_hd__a32o_1
X_10518_ _01695_ _01780_ _01779_ _01776_ VGND VGND VPWR VPWR _01782_ sky130_fd_sc_hd__a211o_1
X_14286_ _05833_ _05834_ _05850_ VGND VGND VPWR VPWR _05851_ sky130_fd_sc_hd__nand3_2
XFILLER_0_134_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11498_ _02812_ _02813_ _02814_ VGND VGND VPWR VPWR _02815_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_150_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13237_ _04708_ _04710_ _04711_ VGND VGND VPWR VPWR _04712_ sky130_fd_sc_hd__nand3_1
X_16025_ _07690_ _07695_ _07747_ VGND VGND VPWR VPWR _07749_ sky130_fd_sc_hd__a21o_1
X_10449_ _01710_ _01711_ _01712_ VGND VGND VPWR VPWR _01713_ sky130_fd_sc_hd__nand3_2
XFILLER_0_122_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13168_ net789 net249 _04538_ VGND VGND VPWR VPWR _04636_ sky130_fd_sc_hd__and3_1
X_12119_ net481 net471 net143 net801 VGND VGND VPWR VPWR _03490_ sky130_fd_sc_hd__and4_1
X_13099_ _04557_ _04558_ _04559_ VGND VGND VPWR VPWR _04561_ sky130_fd_sc_hd__a21o_1
XFILLER_0_137_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15809_ net465 net671 VGND VGND VPWR VPWR _07514_ sky130_fd_sc_hd__nand2_1
XFILLER_0_149_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09330_ _00570_ _00644_ VGND VGND VPWR VPWR _00645_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_1_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09261_ net266 net544 net552 net257 VGND VGND VPWR VPWR _00576_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_145_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08212_ net293 net600 net705 net283 VGND VGND VPWR VPWR _03322_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_90_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09192_ _00506_ _00507_ VGND VGND VPWR VPWR _00508_ sky130_fd_sc_hd__or2_2
XFILLER_0_16_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08143_ net189 net179 net564 net576 VGND VGND VPWR VPWR _02572_ sky130_fd_sc_hd__and4_1
XFILLER_0_15_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08976_ b_sin\[3\] _00294_ _02181_ VGND VGND VPWR VPWR _00295_ sky130_fd_sc_hd__mux2_1
Xhold36 a_sin\[15\] VGND VGND VPWR VPWR net847 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 net100 VGND VGND VPWR VPWR net858 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_79_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09528_ _00832_ _00839_ VGND VGND VPWR VPWR _00840_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09459_ _00766_ _00771_ VGND VGND VPWR VPWR _00772_ sky130_fd_sc_hd__xor2_1
XFILLER_0_81_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12470_ _03869_ _03870_ _03773_ _03810_ VGND VGND VPWR VPWR _03872_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_19_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11421_ net723 net732 net486 net477 VGND VGND VPWR VPWR _02731_ sky130_fd_sc_hd__and4_1
XFILLER_0_62_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14140_ _05691_ _05692_ VGND VGND VPWR VPWR _05693_ sky130_fd_sc_hd__xnor2_1
X_11352_ net317 net428 net379 net368 VGND VGND VPWR VPWR _02656_ sky130_fd_sc_hd__nand4_1
XFILLER_0_104_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10303_ _01564_ _01570_ _01573_ VGND VGND VPWR VPWR _01574_ sky130_fd_sc_hd__or3_1
X_14071_ net295 _05387_ VGND VGND VPWR VPWR _05618_ sky130_fd_sc_hd__and2_1
X_11283_ _02577_ _02578_ _02579_ VGND VGND VPWR VPWR _02581_ sky130_fd_sc_hd__a21o_1
XFILLER_0_104_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13022_ net314 net424 net203 VGND VGND VPWR VPWR _04477_ sky130_fd_sc_hd__and3_1
X_10234_ b_cos\[4\] a_sin\[4\] VGND VGND VPWR VPWR _01514_ sky130_fd_sc_hd__or2b_1
X_10165_ _01454_ _01455_ VGND VGND VPWR VPWR _01456_ sky130_fd_sc_hd__nor2_1
X_14973_ _06602_ _06603_ VGND VGND VPWR VPWR _06604_ sky130_fd_sc_hd__and2b_1
X_10096_ _01395_ _01396_ VGND VGND VPWR VPWR _01397_ sky130_fd_sc_hd__and2b_1
X_13924_ _05452_ _05457_ VGND VGND VPWR VPWR _05458_ sky130_fd_sc_hd__xnor2_1
X_13855_ net422 net271 VGND VGND VPWR VPWR _05384_ sky130_fd_sc_hd__nand2_1
X_12806_ _03864_ _03867_ _04239_ VGND VGND VPWR VPWR _04242_ sky130_fd_sc_hd__and3_1
XFILLER_0_29_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13786_ _05306_ _05308_ VGND VGND VPWR VPWR _05309_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10998_ _02166_ _02177_ _02269_ _02270_ VGND VGND VPWR VPWR _02271_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_8_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15525_ _07114_ _07125_ _07126_ _07204_ VGND VGND VPWR VPWR _07206_ sky130_fd_sc_hd__a31o_1
X_12737_ net816 _04164_ _04120_ _04165_ VGND VGND VPWR VPWR _04166_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_32_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15456_ _07127_ _07128_ _07027_ _07105_ VGND VGND VPWR VPWR _07131_ sky130_fd_sc_hd__o211ai_1
X_12668_ net775 net216 net206 net781 VGND VGND VPWR VPWR _04090_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_72_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14407_ _05982_ _05983_ VGND VGND VPWR VPWR _05984_ sky130_fd_sc_hd__nor2_1
X_11619_ _02937_ _02945_ _02946_ VGND VGND VPWR VPWR _02947_ sky130_fd_sc_hd__nand3_1
XFILLER_0_5_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15387_ _06957_ _07044_ _07054_ VGND VGND VPWR VPWR _07055_ sky130_fd_sc_hd__a21boi_2
X_12599_ _04011_ _04012_ _04013_ VGND VGND VPWR VPWR _04014_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_53_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14338_ _05906_ _05907_ VGND VGND VPWR VPWR _05908_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14269_ _05819_ _05824_ _05823_ VGND VGND VPWR VPWR _05832_ sky130_fd_sc_hd__a21o_1
XFILLER_0_148_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16008_ net455 net447 net650 net660 VGND VGND VPWR VPWR _07730_ sky130_fd_sc_hd__and4_1
XFILLER_0_20_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08830_ _00147_ _00148_ _00144_ VGND VGND VPWR VPWR _00150_ sky130_fd_sc_hd__a21o_1
XFILLER_0_148_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08761_ _07983_ _08041_ _08070_ _08071_ VGND VGND VPWR VPWR _08072_ sky130_fd_sc_hd__a211oi_4
X_08692_ b_sin\[0\] net863 VGND VGND VPWR VPWR _08004_ sky130_fd_sc_hd__and2_1
X_09313_ net165 net657 _00625_ _00626_ VGND VGND VPWR VPWR _00628_ sky130_fd_sc_hd__nand4_2
XFILLER_0_87_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09244_ _00464_ _00463_ VGND VGND VPWR VPWR _00560_ sky130_fd_sc_hd__and2b_1
XFILLER_0_146_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09175_ _00489_ _00490_ VGND VGND VPWR VPWR _00491_ sky130_fd_sc_hd__xnor2_2
X_08126_ _02201_ _02223_ _02212_ VGND VGND VPWR VPWR _02386_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_102_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08959_ _00275_ _00276_ _00216_ VGND VGND VPWR VPWR _00278_ sky130_fd_sc_hd__a21oi_1
X_11970_ _03326_ _03327_ VGND VGND VPWR VPWR _03328_ sky130_fd_sc_hd__xnor2_1
X_10921_ a_cos\[0\] _02187_ _00475_ VGND VGND VPWR VPWR _02188_ sky130_fd_sc_hd__mux2_1
XFILLER_0_86_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13640_ _05140_ _05149_ VGND VGND VPWR VPWR _05150_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10852_ net469 net796 _02114_ VGND VGND VPWR VPWR _02116_ sky130_fd_sc_hd__and3_1
XFILLER_0_67_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13571_ _04991_ _04999_ _04998_ VGND VGND VPWR VPWR _05075_ sky130_fd_sc_hd__a21bo_1
X_10783_ net412 net616 net716 net401 VGND VGND VPWR VPWR _02047_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_94_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15310_ _06968_ _06970_ VGND VGND VPWR VPWR _06971_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_54_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12522_ _03810_ _03902_ _03925_ _03928_ VGND VGND VPWR VPWR _03929_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_137_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16290_ clknet_4_11_0_clk _00079_ net343 VGND VGND VPWR VPWR a_sin\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_82_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15241_ _06893_ _06894_ _06895_ VGND VGND VPWR VPWR _06896_ sky130_fd_sc_hd__nand3_1
X_12453_ net755 net162 net308 net763 VGND VGND VPWR VPWR _03853_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_35_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11404_ net462 _02710_ _02711_ VGND VGND VPWR VPWR _02712_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_124_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12384_ net782 net162 net308 net791 VGND VGND VPWR VPWR _03777_ sky130_fd_sc_hd__a22oi_2
X_15172_ _06818_ _06819_ _06731_ _06760_ VGND VGND VPWR VPWR _06821_ sky130_fd_sc_hd__a211o_1
X_14123_ _05474_ _05634_ _05672_ VGND VGND VPWR VPWR _05674_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11335_ net615 net351 net503 net714 VGND VGND VPWR VPWR _02638_ sky130_fd_sc_hd__a22o_1
XFILLER_0_104_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11266_ _02560_ _02562_ VGND VGND VPWR VPWR _02563_ sky130_fd_sc_hd__and2b_1
X_14054_ net226 net261 net252 net311 VGND VGND VPWR VPWR _05599_ sky130_fd_sc_hd__a22oi_1
X_13005_ _04455_ _04456_ _04448_ VGND VGND VPWR VPWR _04459_ sky130_fd_sc_hd__a21o_1
X_10217_ _01494_ _01499_ VGND VGND VPWR VPWR _01500_ sky130_fd_sc_hd__xnor2_1
X_11197_ net808 _02389_ _02486_ _02487_ VGND VGND VPWR VPWR _02488_ sky130_fd_sc_hd__or4b_4
X_10148_ _01441_ VGND VGND VPWR VPWR _00028_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_27_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10079_ _01352_ _01349_ _01382_ VGND VGND VPWR VPWR _01383_ sky130_fd_sc_hd__and3_1
X_14956_ _06581_ _06582_ _06583_ VGND VGND VPWR VPWR _06586_ sky130_fd_sc_hd__a21o_1
X_13907_ _05358_ _05360_ _05356_ VGND VGND VPWR VPWR _05441_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_77_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14887_ net516 net431 net654 net644 VGND VGND VPWR VPWR _06511_ sky130_fd_sc_hd__and4_1
XFILLER_0_89_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13838_ _05197_ _05289_ VGND VGND VPWR VPWR _05366_ sky130_fd_sc_hd__or2_1
XFILLER_0_9_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13769_ _02170_ VGND VGND VPWR VPWR _05291_ sky130_fd_sc_hd__buf_4
XFILLER_0_73_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15508_ _07022_ _07109_ _07110_ _07025_ VGND VGND VPWR VPWR _07187_ sky130_fd_sc_hd__a31o_1
XFILLER_0_150_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15439_ _07022_ _07109_ _07110_ VGND VGND VPWR VPWR _07112_ sky130_fd_sc_hd__nand3_1
XFILLER_0_115_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09931_ _01234_ _01236_ _01232_ VGND VGND VPWR VPWR _01238_ sky130_fd_sc_hd__a21o_1
XFILLER_0_68_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout805 net811 VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__buf_2
XFILLER_0_0_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09862_ _01168_ _01169_ VGND VGND VPWR VPWR _01170_ sky130_fd_sc_hd__or2b_1
X_08813_ _00130_ _00131_ _00132_ VGND VGND VPWR VPWR _00133_ sky130_fd_sc_hd__nand3_1
X_09793_ _01100_ _01101_ _01014_ _01037_ VGND VGND VPWR VPWR _01102_ sky130_fd_sc_hd__o211a_1
X_08744_ _08053_ _08054_ VGND VGND VPWR VPWR _08055_ sky130_fd_sc_hd__nor2_1
X_08675_ _03593_ _07956_ _07985_ _07986_ VGND VGND VPWR VPWR _07987_ sky130_fd_sc_hd__a211o_4
XFILLER_0_49_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09227_ _00452_ _00534_ _00541_ _00542_ VGND VGND VPWR VPWR _00543_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_44_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09158_ _02170_ VGND VGND VPWR VPWR _00475_ sky130_fd_sc_hd__clkbuf_8
X_08109_ net224 net530 VGND VGND VPWR VPWR _02201_ sky130_fd_sc_hd__nand2_1
XFILLER_0_133_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09089_ _00310_ _00311_ _00405_ VGND VGND VPWR VPWR _00406_ sky130_fd_sc_hd__a21o_1
X_11120_ net808 net444 _02293_ _02292_ VGND VGND VPWR VPWR _02403_ sky130_fd_sc_hd__a31oi_2
X_11051_ _02325_ _02326_ _02306_ VGND VGND VPWR VPWR _02328_ sky130_fd_sc_hd__a21oi_1
X_10002_ net256 net627 VGND VGND VPWR VPWR _01307_ sky130_fd_sc_hd__and2_1
X_14810_ _06424_ _06425_ _06405_ VGND VGND VPWR VPWR _06427_ sky130_fd_sc_hd__a21oi_2
X_15790_ _07492_ _07493_ VGND VGND VPWR VPWR _07494_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14741_ _06262_ _06264_ _06349_ _06350_ VGND VGND VPWR VPWR _06351_ sky130_fd_sc_hd__a211o_1
X_11953_ _03223_ _03208_ VGND VGND VPWR VPWR _03310_ sky130_fd_sc_hd__and2b_1
X_10904_ net808 net463 _02168_ VGND VGND VPWR VPWR _02169_ sky130_fd_sc_hd__and3_1
X_14672_ _06266_ _06274_ VGND VGND VPWR VPWR _06275_ sky130_fd_sc_hd__xnor2_1
X_11884_ _03159_ _03163_ _03158_ VGND VGND VPWR VPWR _03235_ sky130_fd_sc_hd__a21oi_2
X_13623_ _05123_ _05130_ VGND VGND VPWR VPWR _05131_ sky130_fd_sc_hd__xnor2_1
X_10835_ _02096_ _02097_ _02015_ _02033_ VGND VGND VPWR VPWR _02099_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_82_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13554_ _05054_ _05055_ VGND VGND VPWR VPWR _05056_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_54_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10766_ _02028_ _02029_ VGND VGND VPWR VPWR _02030_ sky130_fd_sc_hd__or2_1
X_12505_ _03907_ _03908_ _03909_ VGND VGND VPWR VPWR _03911_ sky130_fd_sc_hd__o21bai_1
X_16273_ clknet_4_14_0_clk _00062_ net340 VGND VGND VPWR VPWR a_cos\[4\] sky130_fd_sc_hd__dfrtp_1
X_13485_ net210 net201 net799 VGND VGND VPWR VPWR _04982_ sky130_fd_sc_hd__o21a_1
X_10697_ _01958_ _01959_ _01960_ VGND VGND VPWR VPWR _01961_ sky130_fd_sc_hd__or3_1
XFILLER_0_81_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15224_ _06874_ _06876_ VGND VGND VPWR VPWR _06877_ sky130_fd_sc_hd__xor2_4
X_12436_ net747 net170 VGND VGND VPWR VPWR _03835_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15155_ net415 net635 _01891_ _06801_ VGND VGND VPWR VPWR _06803_ sky130_fd_sc_hd__a211o_1
X_12367_ _03741_ _03757_ _03758_ VGND VGND VPWR VPWR _03759_ sky130_fd_sc_hd__nand3_4
XFILLER_0_10_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14106_ _05655_ VGND VGND VPWR VPWR _05656_ sky130_fd_sc_hd__inv_2
XFILLER_0_22_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11318_ _02612_ _02618_ VGND VGND VPWR VPWR _02619_ sky130_fd_sc_hd__xnor2_2
X_15086_ _06723_ _06724_ _06725_ VGND VGND VPWR VPWR _06728_ sky130_fd_sc_hd__a21o_1
X_12298_ _03672_ _03683_ VGND VGND VPWR VPWR _03684_ sky130_fd_sc_hd__xnor2_1
X_14037_ _05469_ _05451_ VGND VGND VPWR VPWR _05582_ sky130_fd_sc_hd__or2b_1
X_11249_ _02540_ _02541_ _02542_ VGND VGND VPWR VPWR _02544_ sky130_fd_sc_hd__a21o_1
XFILLER_0_38_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15988_ _07704_ _07706_ _07707_ _07708_ VGND VGND VPWR VPWR _07709_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_89_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14939_ _06487_ _06489_ _06565_ VGND VGND VPWR VPWR _06567_ sky130_fd_sc_hd__a21o_1
XFILLER_0_145_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08460_ _05926_ _06003_ _06014_ VGND VGND VPWR VPWR _06025_ sky130_fd_sc_hd__nor3_1
XFILLER_0_148_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08391_ _04796_ _04774_ _04785_ VGND VGND VPWR VPWR _05275_ sky130_fd_sc_hd__nand3_1
XFILLER_0_147_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09012_ net300 net538 VGND VGND VPWR VPWR _00330_ sky130_fd_sc_hd__and2_1
XFILLER_0_115_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout602 net603 VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__clkbuf_2
X_09914_ _01200_ _01201_ _01220_ VGND VGND VPWR VPWR _01221_ sky130_fd_sc_hd__a21oi_1
Xfanout613 net614 VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__clkbuf_4
Xfanout624 net626 VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__clkbuf_2
Xfanout635 net636 VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__clkbuf_2
Xfanout646 net655 VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__clkbuf_4
X_09845_ net296 _01151_ _01152_ VGND VGND VPWR VPWR _01153_ sky130_fd_sc_hd__a21o_1
Xfanout657 net665 VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__buf_2
XFILLER_0_95_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout668 net670 VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__clkbuf_4
Xfanout679 net23 VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__buf_2
X_09776_ net296 net627 VGND VGND VPWR VPWR _01085_ sky130_fd_sc_hd__nand2_1
X_08727_ _08018_ _08019_ _08036_ _08037_ VGND VGND VPWR VPWR _08038_ sky130_fd_sc_hd__o211ai_2
X_08658_ _07968_ _07969_ VGND VGND VPWR VPWR _07970_ sky130_fd_sc_hd__nor2_1
XFILLER_0_139_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08589_ _07379_ _07423_ VGND VGND VPWR VPWR _07433_ sky130_fd_sc_hd__xor2_1
XFILLER_0_37_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10620_ net520 net435 net787 net795 _01883_ VGND VGND VPWR VPWR _01884_ sky130_fd_sc_hd__a41o_1
XFILLER_0_76_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10551_ _01776_ _01778_ _01777_ VGND VGND VPWR VPWR _01815_ sky130_fd_sc_hd__o21a_1
XFILLER_0_106_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13270_ net754 net763 net267 net258 VGND VGND VPWR VPWR _04747_ sky130_fd_sc_hd__and4_1
X_10482_ net413 net769 net778 net402 VGND VGND VPWR VPWR _01746_ sky130_fd_sc_hd__a22o_1
XFILLER_0_60_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12221_ _03598_ _03599_ VGND VGND VPWR VPWR _03600_ sky130_fd_sc_hd__and2_1
X_12152_ _03515_ _03519_ _03524_ VGND VGND VPWR VPWR _03525_ sky130_fd_sc_hd__a21oi_1
X_11103_ _02384_ VGND VGND VPWR VPWR _00060_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_102_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12083_ _03338_ _03321_ VGND VGND VPWR VPWR _03451_ sky130_fd_sc_hd__and2b_1
X_15911_ _07616_ _07624_ VGND VGND VPWR VPWR _07625_ sky130_fd_sc_hd__xnor2_1
X_11034_ net759 net486 net479 net768 VGND VGND VPWR VPWR _02309_ sky130_fd_sc_hd__a22o_1
X_15842_ _07548_ _07549_ VGND VGND VPWR VPWR _07550_ sky130_fd_sc_hd__xnor2_1
X_15773_ _07393_ _07398_ VGND VGND VPWR VPWR _07475_ sky130_fd_sc_hd__and2_1
X_12985_ _04362_ _04364_ _04435_ VGND VGND VPWR VPWR _04437_ sky130_fd_sc_hd__and3_1
X_14724_ _06331_ VGND VGND VPWR VPWR _06332_ sky130_fd_sc_hd__inv_2
XFILLER_0_86_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11936_ net713 net446 VGND VGND VPWR VPWR _03292_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14655_ _06011_ _06022_ _06012_ VGND VGND VPWR VPWR _06257_ sky130_fd_sc_hd__nand3_1
XFILLER_0_129_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11867_ _03140_ _03142_ VGND VGND VPWR VPWR _03217_ sky130_fd_sc_hd__or2_1
XFILLER_0_129_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13606_ _05113_ VGND VGND VPWR VPWR _00085_ sky130_fd_sc_hd__clkbuf_1
X_10818_ _02079_ _02081_ VGND VGND VPWR VPWR _02082_ sky130_fd_sc_hd__nand2_1
X_14586_ _06173_ _06174_ _06180_ VGND VGND VPWR VPWR _06181_ sky130_fd_sc_hd__nand3_1
XFILLER_0_54_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11798_ _03139_ _03140_ net731 net446 VGND VGND VPWR VPWR _03142_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_6_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16325_ clknet_4_0_0_clk _00114_ net333 VGND VGND VPWR VPWR b_cos\[18\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_131_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13537_ _05031_ _05037_ VGND VGND VPWR VPWR _05038_ sky130_fd_sc_hd__xor2_2
X_10749_ _02007_ _02011_ _02012_ VGND VGND VPWR VPWR _02013_ sky130_fd_sc_hd__o21bai_2
X_16256_ clknet_4_10_0_clk _00045_ net344 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_125_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13468_ _04961_ _04962_ VGND VGND VPWR VPWR _04963_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_113_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15207_ _06759_ _06848_ _06847_ VGND VGND VPWR VPWR _06859_ sky130_fd_sc_hd__a21bo_1
X_12419_ net313 net425 net322 net238 VGND VGND VPWR VPWR _03816_ sky130_fd_sc_hd__and4_1
XFILLER_0_51_872 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16187_ _07920_ _07923_ VGND VGND VPWR VPWR _07924_ sky130_fd_sc_hd__xor2_1
X_13399_ _04882_ _04886_ _04887_ VGND VGND VPWR VPWR _04888_ sky130_fd_sc_hd__nand3_1
XFILLER_0_112_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15138_ _06723_ _06724_ _06725_ VGND VGND VPWR VPWR _06784_ sky130_fd_sc_hd__and3_1
XFILLER_0_11_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15069_ net395 net663 VGND VGND VPWR VPWR _06709_ sky130_fd_sc_hd__and2_1
XFILLER_0_120_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09630_ _00938_ _00939_ _00843_ _00940_ VGND VGND VPWR VPWR _00941_ sky130_fd_sc_hd__o211ai_2
X_09561_ _00756_ _00743_ VGND VGND VPWR VPWR _00873_ sky130_fd_sc_hd__or2b_1
X_08512_ _06519_ _06562_ _06573_ _06584_ VGND VGND VPWR VPWR _06595_ sky130_fd_sc_hd__o211a_1
X_09492_ _00782_ _00783_ _00802_ _00803_ VGND VGND VPWR VPWR _00805_ sky130_fd_sc_hd__a22o_1
X_08443_ net224 net575 VGND VGND VPWR VPWR _05838_ sky130_fd_sc_hd__and2_1
XFILLER_0_147_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08374_ _05068_ _05079_ VGND VGND VPWR VPWR _05090_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout410 net411 VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__buf_2
Xfanout421 net50 VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__clkbuf_4
Xfanout432 net433 VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__buf_4
Xfanout443 net445 VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__clkbuf_4
Xfanout454 net46 VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__clkbuf_4
Xfanout465 net466 VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__clkbuf_4
Xfanout476 net480 VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__clkbuf_4
X_09828_ _01132_ _01135_ VGND VGND VPWR VPWR _01136_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_122_Right_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout487 net490 VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__clkbuf_4
Xfanout498 net501 VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__clkbuf_4
X_09759_ _01001_ _01004_ _01066_ VGND VGND VPWR VPWR _01068_ sky130_fd_sc_hd__nand3_1
X_12770_ net781 net790 net882 net846 VGND VGND VPWR VPWR _04202_ sky130_fd_sc_hd__nand4_1
XFILLER_0_96_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11721_ _03046_ _03057_ VGND VGND VPWR VPWR _03058_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14440_ _06013_ _06019_ VGND VGND VPWR VPWR _06020_ sky130_fd_sc_hd__xor2_2
X_11652_ _02981_ _02982_ VGND VGND VPWR VPWR _02983_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_138_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10603_ _01862_ _01860_ VGND VGND VPWR VPWR _01867_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_52_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14371_ net523 net699 net533 net438 VGND VGND VPWR VPWR _05944_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_107_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11583_ _02848_ _02850_ VGND VGND VPWR VPWR _02907_ sky130_fd_sc_hd__and2_1
X_16110_ _07838_ _07840_ VGND VGND VPWR VPWR _07841_ sky130_fd_sc_hd__xnor2_1
X_13322_ net800 _00447_ _04802_ _04803_ _00450_ VGND VGND VPWR VPWR _04804_ sky130_fd_sc_hd__a32o_1
X_10534_ _01795_ _01796_ _01797_ VGND VGND VPWR VPWR _01798_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_10_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16041_ _07764_ _07745_ _07746_ VGND VGND VPWR VPWR _07766_ sky130_fd_sc_hd__or3_2
X_13253_ _04633_ _04615_ _04727_ _04728_ VGND VGND VPWR VPWR _04729_ sky130_fd_sc_hd__o211ai_4
X_10465_ _01687_ _01686_ VGND VGND VPWR VPWR _01729_ sky130_fd_sc_hd__or2b_1
XFILLER_0_20_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12204_ _03525_ _03581_ VGND VGND VPWR VPWR _03582_ sky130_fd_sc_hd__xnor2_1
X_13184_ net788 _00193_ VGND VGND VPWR VPWR _04653_ sky130_fd_sc_hd__nor2_1
X_10396_ _01645_ _01657_ _01656_ VGND VGND VPWR VPWR _01660_ sky130_fd_sc_hd__a21o_1
X_12135_ _03440_ _03441_ _03445_ VGND VGND VPWR VPWR _03508_ sky130_fd_sc_hd__a21boi_2
X_12066_ net492 net801 VGND VGND VPWR VPWR _03433_ sky130_fd_sc_hd__and2_1
X_11017_ net784 net463 VGND VGND VPWR VPWR _02291_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15825_ _07256_ _07530_ VGND VGND VPWR VPWR _07532_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_126_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15756_ _07445_ _07446_ _07456_ VGND VGND VPWR VPWR _07457_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_35_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12968_ _04320_ _04323_ _04418_ VGND VGND VPWR VPWR _04419_ sky130_fd_sc_hd__nand3_1
X_14707_ _06301_ _06302_ _06312_ VGND VGND VPWR VPWR _06314_ sky130_fd_sc_hd__a21oi_2
X_11919_ _03125_ _03272_ VGND VGND VPWR VPWR _03273_ sky130_fd_sc_hd__xnor2_1
X_15687_ _07378_ _07381_ VGND VGND VPWR VPWR _07382_ sky130_fd_sc_hd__xor2_1
X_12899_ _04254_ _04261_ VGND VGND VPWR VPWR _04343_ sky130_fd_sc_hd__and2_1
XFILLER_0_74_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14638_ net354 net578 net584 net504 VGND VGND VPWR VPWR _06238_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_136_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14569_ _05978_ _06034_ VGND VGND VPWR VPWR _06162_ sky130_fd_sc_hd__and2_1
XFILLER_0_82_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16308_ clknet_4_10_0_clk _00097_ net342 VGND VGND VPWR VPWR b_cos\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_126_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16239_ clknet_4_13_0_clk _00028_ net339 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_2_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08992_ _00304_ _00309_ VGND VGND VPWR VPWR _00310_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09613_ _00909_ _00910_ _00923_ VGND VGND VPWR VPWR _00924_ sky130_fd_sc_hd__a21o_1
X_09544_ _00854_ _00855_ VGND VGND VPWR VPWR _00856_ sky130_fd_sc_hd__nor2_1
X_09475_ net264 net526 net535 net258 VGND VGND VPWR VPWR _00788_ sky130_fd_sc_hd__a22oi_2
X_08426_ _05535_ _05633_ _05644_ _05112_ VGND VGND VPWR VPWR _05654_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_93_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08357_ _04872_ _04894_ VGND VGND VPWR VPWR _04905_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_73_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08288_ net213 net547 net557 net204 VGND VGND VPWR VPWR _04152_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_150_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10250_ _01526_ _01527_ VGND VGND VPWR VPWR _01528_ sky130_fd_sc_hd__nand2_1
XFILLER_0_100_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10181_ _01468_ _01469_ VGND VGND VPWR VPWR _01470_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout240 net246 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_100_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout251 net67 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__clkbuf_4
Xfanout262 net263 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__clkbuf_4
X_13940_ _05474_ _05475_ VGND VGND VPWR VPWR _05476_ sky130_fd_sc_hd__nand2_4
Xfanout273 net276 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__buf_4
Xfanout284 net285 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__buf_2
Xfanout295 net301 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__buf_2
X_13871_ _05321_ _05400_ VGND VGND VPWR VPWR _05401_ sky130_fd_sc_hd__xor2_2
X_15610_ _07208_ _07233_ VGND VGND VPWR VPWR _07298_ sky130_fd_sc_hd__nand2_1
X_12822_ _04255_ _04258_ VGND VGND VPWR VPWR _04259_ sky130_fd_sc_hd__xnor2_1
X_15541_ _07220_ _07221_ _07222_ VGND VGND VPWR VPWR _07223_ sky130_fd_sc_hd__nand3_2
X_12753_ _04181_ _04171_ _04182_ VGND VGND VPWR VPWR _04183_ sky130_fd_sc_hd__or3b_1
XFILLER_0_84_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11704_ _03036_ _03037_ _03021_ VGND VGND VPWR VPWR _03039_ sky130_fd_sc_hd__a21o_1
XFILLER_0_139_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15472_ _07144_ _07147_ VGND VGND VPWR VPWR _07148_ sky130_fd_sc_hd__xnor2_1
X_12684_ net790 net191 net181 net805 VGND VGND VPWR VPWR _04107_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_72_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14423_ _05998_ _05999_ _05994_ VGND VGND VPWR VPWR _06001_ sky130_fd_sc_hd__a21o_1
X_11635_ net316 net427 net349 net500 VGND VGND VPWR VPWR _02965_ sky130_fd_sc_hd__nand4_2
XFILLER_0_64_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14354_ _05881_ _05884_ _05883_ VGND VGND VPWR VPWR _05925_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_21_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11566_ _02805_ _02889_ VGND VGND VPWR VPWR _02890_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_141_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13305_ _04688_ _04690_ VGND VGND VPWR VPWR _04786_ sky130_fd_sc_hd__nand2_2
XFILLER_0_150_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10517_ _01776_ _01779_ _01780_ _01695_ VGND VGND VPWR VPWR _01781_ sky130_fd_sc_hd__o211ai_4
X_14285_ _05840_ _05847_ _05848_ VGND VGND VPWR VPWR _05850_ sky130_fd_sc_hd__a21bo_1
X_11497_ _02730_ _02733_ _02731_ VGND VGND VPWR VPWR _02814_ sky130_fd_sc_hd__o21bai_1
X_16024_ net491 _07619_ VGND VGND VPWR VPWR _07747_ sky130_fd_sc_hd__and2_1
X_13236_ _04586_ net836 _04594_ VGND VGND VPWR VPWR _04711_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_122_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10448_ _01703_ _01704_ _01709_ VGND VGND VPWR VPWR _01712_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13167_ _04541_ _04542_ _04634_ VGND VGND VPWR VPWR _04635_ sky130_fd_sc_hd__a21o_1
X_10379_ _01641_ _01642_ VGND VGND VPWR VPWR _01643_ sky130_fd_sc_hd__xnor2_2
X_12118_ net471 net143 net801 net481 VGND VGND VPWR VPWR _03489_ sky130_fd_sc_hd__a22o_1
X_13098_ _04557_ _04558_ _04559_ VGND VGND VPWR VPWR _04560_ sky130_fd_sc_hd__nand3_2
XFILLER_0_46_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12049_ _03412_ _03413_ VGND VGND VPWR VPWR _03414_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15808_ _07511_ _07512_ VGND VGND VPWR VPWR _07513_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15739_ net491 net651 VGND VGND VPWR VPWR _07438_ sky130_fd_sc_hd__nand2_1
X_09260_ _00506_ _00509_ _00507_ VGND VGND VPWR VPWR _00575_ sky130_fd_sc_hd__o21bai_4
XFILLER_0_62_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08211_ net293 net283 net600 net705 VGND VGND VPWR VPWR _03312_ sky130_fd_sc_hd__and4_1
XFILLER_0_90_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09191_ net288 net279 net529 net538 VGND VGND VPWR VPWR _00507_ sky130_fd_sc_hd__and4_1
XFILLER_0_8_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08142_ _02528_ _02539_ _02376_ VGND VGND VPWR VPWR _02561_ sky130_fd_sc_hd__a21o_1
XFILLER_0_16_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08975_ _00289_ _00293_ VGND VGND VPWR VPWR _00294_ sky130_fd_sc_hd__xor2_1
Xhold37 a_sin\[1\] VGND VGND VPWR VPWR net848 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 net98 VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09527_ _00766_ _00838_ VGND VGND VPWR VPWR _00839_ sky130_fd_sc_hd__xor2_1
XFILLER_0_78_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09458_ _00769_ _00770_ VGND VGND VPWR VPWR _00771_ sky130_fd_sc_hd__xor2_1
XFILLER_0_54_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08409_ _05438_ _05448_ _05459_ VGND VGND VPWR VPWR _05470_ sky130_fd_sc_hd__o21ba_1
X_09389_ _00623_ _00630_ _00629_ VGND VGND VPWR VPWR _00703_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_124_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11420_ net723 net486 net477 net732 VGND VGND VPWR VPWR _02730_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_46_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11351_ net317 net379 net368 net428 VGND VGND VPWR VPWR _02655_ sky130_fd_sc_hd__a22o_1
XFILLER_0_34_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10302_ _01571_ _01572_ VGND VGND VPWR VPWR _01573_ sky130_fd_sc_hd__nor2_1
X_14070_ _05595_ _05549_ _05615_ VGND VGND VPWR VPWR _05617_ sky130_fd_sc_hd__nand3_1
XFILLER_0_104_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_128_Left_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11282_ _02577_ _02578_ _02579_ VGND VGND VPWR VPWR _02580_ sky130_fd_sc_hd__nand3_1
XFILLER_0_120_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13021_ _04466_ _04475_ VGND VGND VPWR VPWR _04476_ sky130_fd_sc_hd__xor2_2
X_10233_ _01513_ VGND VGND VPWR VPWR _00041_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_120_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10164_ a_cos\[12\] b_sin\[12\] VGND VGND VPWR VPWR _01455_ sky130_fd_sc_hd__nor2_1
X_14972_ _06600_ _06601_ _06597_ VGND VGND VPWR VPWR _06603_ sky130_fd_sc_hd__a21o_1
X_10095_ a_cos\[2\] b_sin\[2\] VGND VGND VPWR VPWR _01396_ sky130_fd_sc_hd__nand2_1
X_13923_ _05455_ _05456_ VGND VGND VPWR VPWR _05457_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_137_Left_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13854_ _05380_ _05381_ VGND VGND VPWR VPWR _05382_ sky130_fd_sc_hd__nor2_1
X_12805_ _03864_ _03867_ _04239_ VGND VGND VPWR VPWR _04241_ sky130_fd_sc_hd__a21oi_2
X_13785_ net226 net295 VGND VGND VPWR VPWR _05308_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10997_ _02266_ _02268_ _02202_ VGND VGND VPWR VPWR _02270_ sky130_fd_sc_hd__a21o_1
X_15524_ _07111_ _07112_ _07113_ VGND VGND VPWR VPWR _07204_ sky130_fd_sc_hd__and3_1
X_12736_ _04117_ _04118_ _04116_ VGND VGND VPWR VPWR _04165_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_96_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_123_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15455_ _07027_ _07105_ _07127_ _07128_ VGND VGND VPWR VPWR _07130_ sky130_fd_sc_hd__a211o_1
X_12667_ net775 net781 net216 net206 VGND VGND VPWR VPWR _04089_ sky130_fd_sc_hd__and4_1
XFILLER_0_37_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14406_ _05976_ _05977_ _05980_ VGND VGND VPWR VPWR _05983_ sky130_fd_sc_hd__and3_1
XFILLER_0_127_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11618_ _02943_ _02944_ _02939_ VGND VGND VPWR VPWR _02946_ sky130_fd_sc_hd__a21o_1
X_15386_ _07043_ _07040_ VGND VGND VPWR VPWR _07054_ sky130_fd_sc_hd__or2b_1
XFILLER_0_108_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12598_ net782 net791 net190 net180 VGND VGND VPWR VPWR _04013_ sky130_fd_sc_hd__and4_1
XFILLER_0_53_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14337_ net408 net398 net560 net570 VGND VGND VPWR VPWR _05907_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_146_Left_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11549_ _02865_ _02869_ _02870_ VGND VGND VPWR VPWR _02871_ sky130_fd_sc_hd__nand3_1
XFILLER_0_80_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14268_ _05829_ _05830_ VGND VGND VPWR VPWR _05831_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16007_ net455 net650 net660 net447 VGND VGND VPWR VPWR _07729_ sky130_fd_sc_hd__a22oi_2
X_13219_ _04689_ _04690_ _04685_ VGND VGND VPWR VPWR _04692_ sky130_fd_sc_hd__a21o_1
X_14199_ _05755_ _05756_ VGND VGND VPWR VPWR _05757_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_148_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08760_ _08068_ _08069_ _08051_ VGND VGND VPWR VPWR _08071_ sky130_fd_sc_hd__a21oi_2
X_08691_ net119 net118 _08001_ VGND VGND VPWR VPWR _08003_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_76_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09312_ net165 net656 _00625_ _00626_ VGND VGND VPWR VPWR _00627_ sky130_fd_sc_hd__a22o_1
XFILLER_0_76_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09243_ _00482_ _00558_ VGND VGND VPWR VPWR _00559_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_90_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09174_ net250 net571 VGND VGND VPWR VPWR _00490_ sky130_fd_sc_hd__nand2_1
XFILLER_0_105_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08125_ _02299_ _02354_ _02365_ VGND VGND VPWR VPWR _02376_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_71_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08958_ _00216_ _00275_ _00276_ VGND VGND VPWR VPWR _00277_ sky130_fd_sc_hd__and3_1
X_08889_ _00207_ VGND VGND VPWR VPWR _00208_ sky130_fd_sc_hd__inv_2
XFILLER_0_98_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10920_ _02105_ _02186_ VGND VGND VPWR VPWR _02187_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_67_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10851_ net469 net796 _02114_ VGND VGND VPWR VPWR _02115_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_78_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13570_ _04963_ _04971_ _04972_ VGND VGND VPWR VPWR _05074_ sky130_fd_sc_hd__and3_1
XFILLER_0_66_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10782_ net412 net401 net616 net716 VGND VGND VPWR VPWR _02046_ sky130_fd_sc_hd__and4_1
XFILLER_0_27_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12521_ _03925_ _03926_ _03927_ VGND VGND VPWR VPWR _03928_ sky130_fd_sc_hd__nor3_2
XFILLER_0_93_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15240_ _06768_ _06771_ _06770_ VGND VGND VPWR VPWR _06895_ sky130_fd_sc_hd__a21bo_1
X_12452_ net754 net763 net161 net308 VGND VGND VPWR VPWR _03852_ sky130_fd_sc_hd__and4_1
XFILLER_0_35_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11403_ net749 net462 net452 net758 VGND VGND VPWR VPWR _02711_ sky130_fd_sc_hd__a22o_1
X_15171_ _06731_ _06760_ _06818_ _06819_ VGND VGND VPWR VPWR _06820_ sky130_fd_sc_hd__o211a_1
XFILLER_0_34_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12383_ net807 net298 VGND VGND VPWR VPWR _03776_ sky130_fd_sc_hd__nand2_1
X_14122_ _05474_ _05634_ _05672_ VGND VGND VPWR VPWR _05673_ sky130_fd_sc_hd__and3_1
X_11334_ _02634_ _02635_ VGND VGND VPWR VPWR _02636_ sky130_fd_sc_hd__xor2_1
XFILLER_0_132_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14053_ _05555_ _05559_ _05556_ VGND VGND VPWR VPWR _05598_ sky130_fd_sc_hd__o21ba_1
X_11265_ _02558_ _02559_ _02555_ VGND VGND VPWR VPWR _02562_ sky130_fd_sc_hd__a21o_1
XFILLER_0_30_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13004_ _04448_ _04455_ _04456_ VGND VGND VPWR VPWR _04457_ sky130_fd_sc_hd__nand3_2
X_10216_ _01497_ _01498_ VGND VGND VPWR VPWR _01499_ sky130_fd_sc_hd__or2b_1
X_11196_ _02483_ net833 _02373_ _02390_ VGND VGND VPWR VPWR _02487_ sky130_fd_sc_hd__o211ai_2
X_10147_ net97 _01440_ net138 VGND VGND VPWR VPWR _01441_ sky130_fd_sc_hd__mux2_1
X_14955_ _06581_ _06582_ _06583_ VGND VGND VPWR VPWR _06585_ sky130_fd_sc_hd__nand3_1
X_10078_ _01369_ _01381_ VGND VGND VPWR VPWR _01382_ sky130_fd_sc_hd__xnor2_1
X_13906_ _05436_ _05439_ VGND VGND VPWR VPWR _05440_ sky130_fd_sc_hd__xnor2_2
X_14886_ net417 net664 VGND VGND VPWR VPWR _06510_ sky130_fd_sc_hd__nand2_1
X_13837_ _05293_ _05364_ VGND VGND VPWR VPWR _05365_ sky130_fd_sc_hd__xnor2_2
X_13768_ _05208_ _05289_ VGND VGND VPWR VPWR _05290_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12719_ net766 net775 net325 net843 VGND VGND VPWR VPWR _04146_ sky130_fd_sc_hd__and4_1
X_15507_ _07022_ _07182_ _07184_ VGND VGND VPWR VPWR _07186_ sky130_fd_sc_hd__nand3_1
XFILLER_0_127_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
X_13699_ _05140_ _05149_ VGND VGND VPWR VPWR _05214_ sky130_fd_sc_hd__or2b_1
XFILLER_0_57_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15438_ _07109_ _07110_ _07022_ VGND VGND VPWR VPWR _07111_ sky130_fd_sc_hd__a21o_1
XFILLER_0_150_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15369_ _07003_ _07035_ VGND VGND VPWR VPWR _07036_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_13_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09930_ _01232_ _01234_ _01236_ VGND VGND VPWR VPWR _01237_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout806 net811 VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__clkbuf_2
X_09861_ _01166_ _01167_ _01164_ _01165_ VGND VGND VPWR VPWR _01169_ sky130_fd_sc_hd__a211o_1
X_08812_ _08026_ _08028_ _08027_ VGND VGND VPWR VPWR _00132_ sky130_fd_sc_hd__a21bo_1
X_09792_ _01099_ _01070_ _01071_ VGND VGND VPWR VPWR _01101_ sky130_fd_sc_hd__and3_1
X_08743_ net211 net669 net678 net202 VGND VGND VPWR VPWR _08054_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08674_ _07983_ _07984_ _07966_ VGND VGND VPWR VPWR _07986_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_67_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09226_ _00539_ _00540_ _00535_ VGND VGND VPWR VPWR _00542_ sky130_fd_sc_hd__a21o_1
XFILLER_0_32_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09157_ _00468_ _00473_ VGND VGND VPWR VPWR _00474_ sky130_fd_sc_hd__xnor2_2
X_08108_ _02181_ VGND VGND VPWR VPWR next_state sky130_fd_sc_hd__clkbuf_8
X_09088_ _00309_ _00304_ VGND VGND VPWR VPWR _00405_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11050_ _02306_ _02325_ _02326_ VGND VGND VPWR VPWR _02327_ sky130_fd_sc_hd__and3_1
XFILLER_0_101_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10001_ net251 net646 VGND VGND VPWR VPWR _01306_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14740_ _06343_ _06345_ _06348_ VGND VGND VPWR VPWR _06350_ sky130_fd_sc_hd__a21oi_1
X_11952_ _03307_ _03308_ VGND VGND VPWR VPWR _03309_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10903_ net469 net808 _02079_ _02080_ VGND VGND VPWR VPWR _02168_ sky130_fd_sc_hd__a31o_1
X_14671_ _06270_ _06273_ VGND VGND VPWR VPWR _06274_ sky130_fd_sc_hd__nor2_1
X_11883_ _03231_ _03233_ VGND VGND VPWR VPWR _03234_ sky130_fd_sc_hd__xor2_2
X_13622_ _05128_ _05129_ VGND VGND VPWR VPWR _05130_ sky130_fd_sc_hd__xor2_1
X_10834_ _02015_ _02033_ _02096_ _02097_ VGND VGND VPWR VPWR _02098_ sky130_fd_sc_hd__a211o_1
XFILLER_0_66_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13553_ _04893_ _04983_ _04984_ _04892_ VGND VGND VPWR VPWR _05055_ sky130_fd_sc_hd__a31o_1
XFILLER_0_94_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10765_ _02022_ _02021_ _01736_ VGND VGND VPWR VPWR _02029_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_27_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12504_ net721 net730 net834 net245 VGND VGND VPWR VPWR _03909_ sky130_fd_sc_hd__and4_1
XFILLER_0_81_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16272_ clknet_4_14_0_clk _00061_ net345 VGND VGND VPWR VPWR a_cos\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_125_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13484_ net799 net210 net201 VGND VGND VPWR VPWR _04980_ sky130_fd_sc_hd__nand3_2
XFILLER_0_81_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10696_ net524 net428 net514 net439 VGND VGND VPWR VPWR _01960_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_70_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15223_ _06832_ _06833_ _06875_ VGND VGND VPWR VPWR _06876_ sky130_fd_sc_hd__a21o_1
X_12435_ _03751_ _03753_ _03752_ VGND VGND VPWR VPWR _03834_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_63_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15154_ net516 net431 net625 VGND VGND VPWR VPWR _06801_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_23_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12366_ _03749_ _03750_ _03755_ VGND VGND VPWR VPWR _03758_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_136_Right_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14105_ _05594_ _05649_ VGND VGND VPWR VPWR _05655_ sky130_fd_sc_hd__and2b_1
XFILLER_0_50_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11317_ _02616_ _02617_ VGND VGND VPWR VPWR _02618_ sky130_fd_sc_hd__xnor2_2
X_15085_ _06723_ _06724_ _06725_ VGND VGND VPWR VPWR _06727_ sky130_fd_sc_hd__nand3_1
X_12297_ _03676_ _03682_ VGND VGND VPWR VPWR _03683_ sky130_fd_sc_hd__xnor2_1
X_14036_ _05578_ _05580_ VGND VGND VPWR VPWR _05581_ sky130_fd_sc_hd__and2b_1
X_11248_ _02540_ _02541_ _02542_ VGND VGND VPWR VPWR _02543_ sky130_fd_sc_hd__nand3_1
XFILLER_0_38_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11179_ _02465_ _02466_ _02467_ VGND VGND VPWR VPWR _02468_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15987_ _07633_ _07602_ _07603_ VGND VGND VPWR VPWR _07708_ sky130_fd_sc_hd__nor3_1
XFILLER_0_145_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14938_ _06487_ _06489_ _06565_ VGND VGND VPWR VPWR _06566_ sky130_fd_sc_hd__and3_1
XFILLER_0_145_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14869_ _06489_ _06490_ VGND VGND VPWR VPWR _06491_ sky130_fd_sc_hd__nand2_1
X_08390_ _05242_ _05253_ VGND VGND VPWR VPWR _05264_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_46_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09011_ net158 net867 net695 net529 VGND VGND VPWR VPWR _00329_ sky130_fd_sc_hd__nand4_1
XFILLER_0_5_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_103_Right_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09913_ _01218_ _01219_ VGND VGND VPWR VPWR _01220_ sky130_fd_sc_hd__and2b_1
Xfanout603 net608 VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__buf_6
XFILLER_0_95_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout614 net617 VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_0_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout625 net626 VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__buf_4
Xfanout636 net28 VGND VGND VPWR VPWR net636 sky130_fd_sc_hd__buf_4
X_09844_ net296 _01087_ net618 VGND VGND VPWR VPWR _01152_ sky130_fd_sc_hd__o21ai_1
Xfanout647 net655 VGND VGND VPWR VPWR net647 sky130_fd_sc_hd__buf_2
Xfanout658 net659 VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__clkbuf_4
Xfanout669 net670 VGND VGND VPWR VPWR net669 sky130_fd_sc_hd__buf_2
X_09775_ _00994_ _00996_ VGND VGND VPWR VPWR _01084_ sky130_fd_sc_hd__nor2_1
X_08726_ _08034_ _08035_ _08020_ VGND VGND VPWR VPWR _08037_ sky130_fd_sc_hd__a21o_1
X_08657_ net211 net679 net684 net202 VGND VGND VPWR VPWR _07969_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_95_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08588_ net326 net242 net592 net601 _07412_ VGND VGND VPWR VPWR _07423_ sky130_fd_sc_hd__a41o_1
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10550_ _01810_ _01813_ VGND VGND VPWR VPWR _01814_ sky130_fd_sc_hd__or2_1
XFILLER_0_17_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09209_ net183 net649 net659 net173 VGND VGND VPWR VPWR _00525_ sky130_fd_sc_hd__a22o_1
XFILLER_0_51_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10481_ net355 net810 VGND VGND VPWR VPWR _01745_ sky130_fd_sc_hd__nand2_1
X_12220_ _03343_ _03587_ _03597_ VGND VGND VPWR VPWR _03599_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_115_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12151_ _03523_ _03514_ VGND VGND VPWR VPWR _03524_ sky130_fd_sc_hd__nor2_1
X_11102_ a_cos\[2\] _02382_ _02383_ VGND VGND VPWR VPWR _02384_ sky130_fd_sc_hd__mux2_1
X_12082_ _03448_ _03449_ VGND VGND VPWR VPWR _03450_ sky130_fd_sc_hd__nor2_1
X_15910_ _07617_ _07623_ VGND VGND VPWR VPWR _07624_ sky130_fd_sc_hd__xnor2_1
X_11033_ net759 net768 net479 VGND VGND VPWR VPWR _02308_ sky130_fd_sc_hd__and3_1
X_15841_ net442 net697 VGND VGND VPWR VPWR _07549_ sky130_fd_sc_hd__nand2_1
X_12984_ _04433_ _04434_ VGND VGND VPWR VPWR _04435_ sky130_fd_sc_hd__xnor2_1
X_15772_ _07472_ _07473_ VGND VGND VPWR VPWR _07474_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_99_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14723_ net488 net478 net593 net608 VGND VGND VPWR VPWR _06331_ sky130_fd_sc_hd__and4_1
XFILLER_0_87_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11935_ _03288_ _03289_ VGND VGND VPWR VPWR _03291_ sky130_fd_sc_hd__nor2_1
X_14654_ _06183_ _06184_ _06195_ VGND VGND VPWR VPWR _06255_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_86_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11866_ _03209_ _03215_ VGND VGND VPWR VPWR _03216_ sky130_fd_sc_hd__xnor2_1
X_13605_ a_sin\[8\] _05111_ _03521_ VGND VGND VPWR VPWR _05113_ sky130_fd_sc_hd__mux2_1
XFILLER_0_95_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10817_ _02080_ VGND VGND VPWR VPWR _02081_ sky130_fd_sc_hd__inv_2
X_14585_ _06175_ _06178_ VGND VGND VPWR VPWR _06180_ sky130_fd_sc_hd__xnor2_1
X_11797_ net731 net441 _03139_ _03140_ VGND VGND VPWR VPWR _03141_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_138_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13536_ _05034_ _05036_ VGND VGND VPWR VPWR _05037_ sky130_fd_sc_hd__nor2_1
X_16324_ clknet_4_1_0_clk _00113_ net332 VGND VGND VPWR VPWR b_cos\[17\] sky130_fd_sc_hd__dfrtp_1
X_10748_ _01713_ _02010_ _02009_ _02008_ VGND VGND VPWR VPWR _02012_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_137_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16255_ clknet_4_10_0_clk _00044_ net342 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__dfrtp_1
X_13467_ net727 net273 VGND VGND VPWR VPWR _04962_ sky130_fd_sc_hd__nand2_1
X_10679_ _01927_ _01941_ _01942_ VGND VGND VPWR VPWR _01943_ sky130_fd_sc_hd__nand3_4
X_15206_ _06858_ VGND VGND VPWR VPWR _00100_ sky130_fd_sc_hd__clkbuf_1
X_12418_ net510 net219 VGND VGND VPWR VPWR _03815_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16186_ _07865_ _07884_ _07922_ VGND VGND VPWR VPWR _07923_ sky130_fd_sc_hd__a21bo_1
X_13398_ net424 net168 _04884_ _04885_ VGND VGND VPWR VPWR _04887_ sky130_fd_sc_hd__nand4_2
XFILLER_0_49_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15137_ _06761_ _06782_ VGND VGND VPWR VPWR _06783_ sky130_fd_sc_hd__xor2_1
XFILLER_0_11_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12349_ _03730_ _03738_ VGND VGND VPWR VPWR _03739_ sky130_fd_sc_hd__xnor2_1
X_15068_ _06698_ _06707_ VGND VGND VPWR VPWR _06708_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14019_ net295 _01087_ net797 VGND VGND VPWR VPWR _05562_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_65_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09560_ _00798_ _00799_ _00871_ VGND VGND VPWR VPWR _00872_ sky130_fd_sc_hd__o21ai_2
X_08511_ _06047_ _06091_ _06102_ VGND VGND VPWR VPWR _06584_ sky130_fd_sc_hd__or3_1
X_09491_ _00782_ _00783_ _00802_ _00803_ VGND VGND VPWR VPWR _00804_ sky130_fd_sc_hd__nand4_1
XFILLER_0_77_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08442_ _05318_ _05307_ _05296_ VGND VGND VPWR VPWR _05827_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_81_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08373_ _05035_ _05046_ _05057_ VGND VGND VPWR VPWR _05079_ sky130_fd_sc_hd__and3_1
XFILLER_0_18_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout400 net403 VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__clkbuf_4
Xfanout411 net414 VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__clkbuf_4
Xfanout422 net423 VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__clkbuf_4
Xfanout433 net49 VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__buf_6
Xfanout444 net445 VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__clkbuf_4
Xfanout455 net459 VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__buf_4
Xfanout466 net467 VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__clkbuf_4
X_09827_ _01133_ _01134_ VGND VGND VPWR VPWR _01135_ sky130_fd_sc_hd__nor2_1
Xfanout477 net480 VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__buf_2
Xfanout488 net490 VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__clkbuf_4
Xfanout499 net500 VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__clkbuf_4
X_09758_ _01001_ _01004_ _01066_ VGND VGND VPWR VPWR _01067_ sky130_fd_sc_hd__a21o_1
X_08709_ _07957_ _07964_ _07963_ VGND VGND VPWR VPWR _08020_ sky130_fd_sc_hd__a21o_1
XFILLER_0_69_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09689_ _00997_ _00998_ VGND VGND VPWR VPWR _00999_ sky130_fd_sc_hd__xor2_1
X_11720_ _03047_ _03056_ VGND VGND VPWR VPWR _03057_ sky130_fd_sc_hd__xnor2_1
X_11651_ _02852_ _02880_ _02878_ VGND VGND VPWR VPWR _02982_ sky130_fd_sc_hd__o21ai_2
X_10602_ _01864_ _01865_ VGND VGND VPWR VPWR _01866_ sky130_fd_sc_hd__or2_1
X_14370_ net420 net542 VGND VGND VPWR VPWR _05943_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11582_ _02824_ _02825_ _02905_ VGND VGND VPWR VPWR _02906_ sky130_fd_sc_hd__a21o_1
X_13321_ net321 net237 net799 VGND VGND VPWR VPWR _04803_ sky130_fd_sc_hd__o21a_1
X_10533_ net522 net437 net760 net769 VGND VGND VPWR VPWR _01797_ sky130_fd_sc_hd__and4_1
X_16040_ _07745_ _07746_ _07764_ VGND VGND VPWR VPWR _07765_ sky130_fd_sc_hd__o21ai_1
X_13252_ _04725_ _04726_ _04635_ VGND VGND VPWR VPWR _04728_ sky130_fd_sc_hd__a21o_1
XFILLER_0_51_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10464_ _01680_ _01685_ VGND VGND VPWR VPWR _01728_ sky130_fd_sc_hd__or2b_1
XFILLER_0_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12203_ _03526_ _03580_ VGND VGND VPWR VPWR _03581_ sky130_fd_sc_hd__xnor2_1
X_13183_ _04648_ _04651_ VGND VGND VPWR VPWR _04652_ sky130_fd_sc_hd__xor2_1
X_10395_ _01623_ _01622_ VGND VGND VPWR VPWR _01659_ sky130_fd_sc_hd__xnor2_2
X_12134_ _03504_ _03505_ VGND VGND VPWR VPWR _03506_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12065_ _03357_ _03359_ _03358_ VGND VGND VPWR VPWR _03432_ sky130_fd_sc_hd__a21oi_1
X_11016_ net12 net470 _02208_ _02207_ VGND VGND VPWR VPWR _02290_ sky130_fd_sc_hd__a31o_1
X_15824_ _07451_ _07529_ VGND VGND VPWR VPWR _07530_ sky130_fd_sc_hd__xor2_2
XFILLER_0_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12967_ _04324_ _04417_ VGND VGND VPWR VPWR _04418_ sky130_fd_sc_hd__xnor2_1
X_15755_ _07453_ _07454_ VGND VGND VPWR VPWR _07456_ sky130_fd_sc_hd__xor2_1
XFILLER_0_87_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14706_ _06301_ _06302_ _06312_ VGND VGND VPWR VPWR _06313_ sky130_fd_sc_hd__and3_1
X_11918_ _03195_ _03271_ VGND VGND VPWR VPWR _03272_ sky130_fd_sc_hd__xnor2_2
X_12898_ _04260_ _04259_ VGND VGND VPWR VPWR _04342_ sky130_fd_sc_hd__and2b_1
X_15686_ _07380_ _07267_ _07253_ VGND VGND VPWR VPWR _07381_ sky130_fd_sc_hd__a21o_1
XFILLER_0_142_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14637_ net354 net504 net578 net584 VGND VGND VPWR VPWR _06237_ sky130_fd_sc_hd__and4_1
X_11849_ _03046_ _03196_ VGND VGND VPWR VPWR _03197_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_145_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14568_ _06150_ _06160_ VGND VGND VPWR VPWR _06161_ sky130_fd_sc_hd__and2b_1
XFILLER_0_83_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16307_ clknet_4_10_0_clk _00096_ net342 VGND VGND VPWR VPWR b_cos\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13519_ _04823_ _04828_ _04924_ _05018_ VGND VGND VPWR VPWR _05019_ sky130_fd_sc_hd__o31a_1
X_14499_ _06064_ _06056_ _06063_ VGND VGND VPWR VPWR _06085_ sky130_fd_sc_hd__nand3_1
XFILLER_0_141_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16238_ clknet_4_13_0_clk _00027_ net339 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_30_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16169_ _07652_ _07777_ _07902_ _07903_ _07904_ VGND VGND VPWR VPWR _07905_ sky130_fd_sc_hd__a311o_1
XFILLER_0_11_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08991_ _00307_ _00308_ VGND VGND VPWR VPWR _00309_ sky130_fd_sc_hd__xnor2_1
X_09612_ _00915_ _00922_ VGND VGND VPWR VPWR _00923_ sky130_fd_sc_hd__xnor2_1
X_09543_ net157 net302 net647 net638 VGND VGND VPWR VPWR _00855_ sky130_fd_sc_hd__and4_1
XFILLER_0_92_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09474_ _00704_ _00707_ _00705_ VGND VGND VPWR VPWR _00787_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_116_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08425_ _05014_ _05101_ _05090_ VGND VGND VPWR VPWR _05644_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_109_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08356_ _04229_ _04883_ VGND VGND VPWR VPWR _04894_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_74_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08287_ _04108_ _04130_ VGND VGND VPWR VPWR _04141_ sky130_fd_sc_hd__and2_1
XFILLER_0_116_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_843 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10180_ _01461_ _01463_ _01460_ VGND VGND VPWR VPWR _01469_ sky130_fd_sc_hd__o21ba_1
Xfanout230 net235 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__clkbuf_2
Xfanout241 net242 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__buf_6
Xfanout252 net253 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__clkbuf_4
Xfanout263 net265 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__clkbuf_4
Xfanout274 net276 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__clkbuf_4
Xfanout285 net63 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__buf_2
Xfanout296 net301 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__buf_2
X_13870_ net798 net165 _00834_ _05235_ VGND VGND VPWR VPWR _05400_ sky130_fd_sc_hd__a31o_2
XFILLER_0_88_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12821_ _04256_ _04257_ VGND VGND VPWR VPWR _04258_ sky130_fd_sc_hd__nor2_1
X_12752_ _04176_ _04179_ VGND VGND VPWR VPWR _04182_ sky130_fd_sc_hd__xor2_1
XFILLER_0_57_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15540_ _07089_ _07091_ _07090_ VGND VGND VPWR VPWR _07222_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_96_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11703_ _03021_ _03036_ _03037_ VGND VGND VPWR VPWR _03038_ sky130_fd_sc_hd__nand3_1
X_15471_ _06947_ _07145_ _07146_ VGND VGND VPWR VPWR _07147_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_96_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12683_ net790 net198 _04091_ _04089_ VGND VGND VPWR VPWR _04106_ sky130_fd_sc_hd__a31o_1
XFILLER_0_127_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14422_ _05994_ _05998_ _05999_ VGND VGND VPWR VPWR _06000_ sky130_fd_sc_hd__nand3_1
XFILLER_0_126_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11634_ net316 net349 net500 net427 VGND VGND VPWR VPWR _02963_ sky130_fd_sc_hd__a22o_1
XFILLER_0_107_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14353_ _05918_ _05923_ VGND VGND VPWR VPWR _05924_ sky130_fd_sc_hd__xnor2_1
X_11565_ _02885_ _02887_ VGND VGND VPWR VPWR _02889_ sky130_fd_sc_hd__xnor2_2
X_13304_ _04762_ _04783_ VGND VGND VPWR VPWR _04784_ sky130_fd_sc_hd__xor2_2
XFILLER_0_52_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10516_ _01691_ _01694_ _01693_ VGND VGND VPWR VPWR _01780_ sky130_fd_sc_hd__a21o_1
XFILLER_0_123_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14284_ _05841_ _05842_ _05846_ VGND VGND VPWR VPWR _05848_ sky130_fd_sc_hd__nand3_1
XFILLER_0_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11496_ net758 net444 _02809_ _02810_ VGND VGND VPWR VPWR _02813_ sky130_fd_sc_hd__nand4_2
XFILLER_0_40_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13235_ _04706_ _04707_ _04700_ VGND VGND VPWR VPWR _04710_ sky130_fd_sc_hd__a21o_1
X_16023_ _07723_ _07744_ VGND VGND VPWR VPWR _07746_ sky130_fd_sc_hd__nor2_1
X_10447_ _01673_ _01674_ _01668_ VGND VGND VPWR VPWR _01711_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_21_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13166_ _04540_ _04525_ VGND VGND VPWR VPWR _04634_ sky130_fd_sc_hd__and2b_1
XFILLER_0_103_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10378_ net393 net769 VGND VGND VPWR VPWR _01642_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12117_ _03430_ _03434_ _03487_ VGND VGND VPWR VPWR _03488_ sky130_fd_sc_hd__a21oi_1
X_13097_ _04449_ _04451_ _04450_ VGND VGND VPWR VPWR _04559_ sky130_fd_sc_hd__a21bo_1
X_12048_ _03330_ _03329_ VGND VGND VPWR VPWR _03413_ sky130_fd_sc_hd__and2b_1
X_15807_ net482 net472 net650 net660 VGND VGND VPWR VPWR _07512_ sky130_fd_sc_hd__and4_1
XFILLER_0_88_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13999_ _05453_ _05456_ _05454_ VGND VGND VPWR VPWR _05540_ sky130_fd_sc_hd__o21ba_1
X_15738_ _07435_ _07436_ VGND VGND VPWR VPWR _07437_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15669_ _07359_ _07360_ _07352_ VGND VGND VPWR VPWR _07362_ sky130_fd_sc_hd__a21o_1
X_08210_ _03279_ _03290_ VGND VGND VPWR VPWR _03301_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09190_ net288 net529 net538 net279 VGND VGND VPWR VPWR _00506_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_56_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08141_ _02376_ _02528_ _02539_ VGND VGND VPWR VPWR _02550_ sky130_fd_sc_hd__nand3_2
XFILLER_0_126_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08974_ _08091_ _00290_ _00292_ VGND VGND VPWR VPWR _00293_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold38 a_cos\[17\] VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__dlygate4sd3_1
Xhold49 a_sin\[16\] VGND VGND VPWR VPWR net860 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_79_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09526_ _00836_ _00837_ VGND VGND VPWR VPWR _00838_ sky130_fd_sc_hd__xor2_1
XFILLER_0_79_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09457_ net166 net638 VGND VGND VPWR VPWR _00770_ sky130_fd_sc_hd__nand2_1
XFILLER_0_109_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08408_ net189 net181 net592 net603 VGND VGND VPWR VPWR _05459_ sky130_fd_sc_hd__and4_1
XFILLER_0_19_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_49_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09388_ _00598_ _00605_ _00606_ VGND VGND VPWR VPWR _00702_ sky130_fd_sc_hd__and3_1
XFILLER_0_46_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08339_ net217 net208 net558 net564 VGND VGND VPWR VPWR _04709_ sky130_fd_sc_hd__and4_1
XFILLER_0_105_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11350_ net317 net389 _02566_ _02565_ net396 VGND VGND VPWR VPWR _02654_ sky130_fd_sc_hd__a32o_1
XFILLER_0_61_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10301_ b_cos\[13\] a_sin\[13\] VGND VGND VPWR VPWR _01572_ sky130_fd_sc_hd__and2b_1
XFILLER_0_15_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11281_ _02455_ _02464_ _02462_ VGND VGND VPWR VPWR _02579_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_120_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13020_ _04473_ _04474_ VGND VGND VPWR VPWR _04475_ sky130_fd_sc_hd__and2b_1
X_10232_ net110 _01512_ net136 VGND VGND VPWR VPWR _01513_ sky130_fd_sc_hd__mux2_1
XFILLER_0_131_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10163_ a_cos\[12\] b_sin\[12\] VGND VGND VPWR VPWR _01454_ sky130_fd_sc_hd__and2_1
X_14971_ _06597_ _06600_ _06601_ VGND VGND VPWR VPWR _06602_ sky130_fd_sc_hd__and3_1
X_10094_ a_cos\[2\] b_sin\[2\] VGND VGND VPWR VPWR _01395_ sky130_fd_sc_hd__nor2_1
X_13922_ net609 net247 VGND VGND VPWR VPWR _05456_ sky130_fd_sc_hd__nand2_1
XFILLER_0_107_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13853_ net226 net311 net287 net278 VGND VGND VPWR VPWR _05381_ sky130_fd_sc_hd__and4_1
X_12804_ _04237_ _04238_ VGND VGND VPWR VPWR _04239_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_97_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13784_ _05304_ _05305_ VGND VGND VPWR VPWR _05306_ sky130_fd_sc_hd__nor2_1
XFILLER_0_97_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10996_ _02202_ _02266_ _02268_ VGND VGND VPWR VPWR _02269_ sky130_fd_sc_hd__nand3_2
XFILLER_0_57_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15523_ _07188_ _07189_ _07200_ _07201_ VGND VGND VPWR VPWR _07203_ sky130_fd_sc_hd__or4bb_1
X_12735_ _04161_ _04160_ _04162_ VGND VGND VPWR VPWR _04164_ sky130_fd_sc_hd__nand3_2
XFILLER_0_84_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12666_ _04054_ _04052_ _04045_ VGND VGND VPWR VPWR _04088_ sky130_fd_sc_hd__a21o_1
X_15454_ _07114_ _07115_ _07125_ _07126_ VGND VGND VPWR VPWR _07128_ sky130_fd_sc_hd__and4_1
XFILLER_0_53_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14405_ _05976_ _05977_ _05980_ VGND VGND VPWR VPWR _05982_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_127_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11617_ _02939_ _02943_ _02944_ VGND VGND VPWR VPWR _02945_ sky130_fd_sc_hd__nand3_1
X_12597_ net782 net190 net180 net791 VGND VGND VPWR VPWR _04012_ sky130_fd_sc_hd__a22oi_1
X_15385_ _07045_ _07047_ VGND VGND VPWR VPWR _07053_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11548_ net316 net358 _02867_ _02868_ VGND VGND VPWR VPWR _02870_ sky130_fd_sc_hd__nand4_2
XFILLER_0_25_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14336_ net408 net560 net570 net398 VGND VGND VPWR VPWR _05906_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_52_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14267_ net391 net595 VGND VGND VPWR VPWR _05830_ sky130_fd_sc_hd__nand2_1
XFILLER_0_122_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11479_ _02608_ _02687_ _02794_ VGND VGND VPWR VPWR _02795_ sky130_fd_sc_hd__a21oi_1
X_13218_ _04685_ _04689_ _04690_ VGND VGND VPWR VPWR _04691_ sky130_fd_sc_hd__and3_1
X_16006_ _07686_ _07689_ _07687_ VGND VGND VPWR VPWR _07728_ sky130_fd_sc_hd__o21ba_1
X_14198_ net312 _00195_ VGND VGND VPWR VPWR _05756_ sky130_fd_sc_hd__nor2_1
X_13149_ _04613_ _04614_ _04438_ _04522_ VGND VGND VPWR VPWR _04616_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_0_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08690_ net119 net862 _08001_ VGND VGND VPWR VPWR _08002_ sky130_fd_sc_hd__or3_1
XFILLER_0_73_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09311_ net184 net174 net649 net640 VGND VGND VPWR VPWR _00626_ sky130_fd_sc_hd__nand4_2
XFILLER_0_146_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09242_ _00555_ _00557_ VGND VGND VPWR VPWR _00558_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_8_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09173_ _00487_ _00488_ VGND VGND VPWR VPWR _00489_ sky130_fd_sc_hd__nor2_1
XFILLER_0_90_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08124_ _02288_ _02234_ _02245_ VGND VGND VPWR VPWR _02365_ sky130_fd_sc_hd__nand3_1
XFILLER_0_114_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08957_ _00273_ _00274_ _00173_ _00217_ VGND VGND VPWR VPWR _00276_ sky130_fd_sc_hd__a211o_1
X_08888_ net589 _08007_ _08098_ _08099_ VGND VGND VPWR VPWR _00207_ sky130_fd_sc_hd__o2bb2a_1
X_10850_ _02112_ _02113_ VGND VGND VPWR VPWR _02114_ sky130_fd_sc_hd__nor2_1
X_09509_ _08091_ _00290_ _00469_ _00818_ _00821_ VGND VGND VPWR VPWR _00822_ sky130_fd_sc_hd__a41oi_4
XFILLER_0_67_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10781_ net393 net724 VGND VGND VPWR VPWR _02045_ sky130_fd_sc_hd__nand2_1
X_12520_ _03923_ _03924_ _03917_ _03922_ VGND VGND VPWR VPWR _03927_ sky130_fd_sc_hd__o211a_1
XFILLER_0_94_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_117_Right_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12451_ net772 net299 VGND VGND VPWR VPWR _03851_ sky130_fd_sc_hd__nand2_1
XFILLER_0_81_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11402_ net749 net758 net452 VGND VGND VPWR VPWR _02710_ sky130_fd_sc_hd__and3_1
X_15170_ _06816_ _06817_ _06783_ VGND VGND VPWR VPWR _06819_ sky130_fd_sc_hd__a21o_1
XFILLER_0_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12382_ _03771_ _03772_ _03724_ _03740_ VGND VGND VPWR VPWR _03775_ sky130_fd_sc_hd__o211a_1
XFILLER_0_105_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14121_ _05670_ _05671_ VGND VGND VPWR VPWR _05672_ sky130_fd_sc_hd__or2_1
XFILLER_0_104_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11333_ net749 net469 VGND VGND VPWR VPWR _02635_ sky130_fd_sc_hd__nand2_1
XFILLER_0_105_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14052_ _05554_ _05565_ _05596_ VGND VGND VPWR VPWR _05597_ sky130_fd_sc_hd__a21o_1
X_11264_ _02555_ _02558_ _02559_ VGND VGND VPWR VPWR _02560_ sky130_fd_sc_hd__and3_1
XFILLER_0_120_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13003_ _04452_ _04453_ _04454_ VGND VGND VPWR VPWR _04456_ sky130_fd_sc_hd__a21o_1
X_10215_ b_cos\[1\] a_sin\[1\] VGND VGND VPWR VPWR _01498_ sky130_fd_sc_hd__or2b_1
X_11195_ _02373_ _02390_ _02483_ _02484_ VGND VGND VPWR VPWR _02486_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_101_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10146_ _01438_ _01439_ VGND VGND VPWR VPWR _01440_ sky130_fd_sc_hd__xnor2_1
X_10077_ _01378_ _01380_ VGND VGND VPWR VPWR _01381_ sky130_fd_sc_hd__xnor2_1
X_14954_ _06476_ _06478_ _06477_ VGND VGND VPWR VPWR _06583_ sky130_fd_sc_hd__a21bo_1
X_13905_ _05333_ _05352_ _05437_ VGND VGND VPWR VPWR _05439_ sky130_fd_sc_hd__a21oi_2
X_14885_ _06504_ _06507_ VGND VGND VPWR VPWR _06509_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_58_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13836_ _05361_ _05363_ VGND VGND VPWR VPWR _05364_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_134_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10979_ _02247_ _02248_ _02246_ VGND VGND VPWR VPWR _02250_ sky130_fd_sc_hd__o21ai_1
X_13767_ _05210_ _05288_ VGND VGND VPWR VPWR _05289_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_128_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15506_ _07182_ _07184_ _07022_ VGND VGND VPWR VPWR _07185_ sky130_fd_sc_hd__a21o_1
XFILLER_0_128_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12718_ net766 net325 net844 net775 VGND VGND VPWR VPWR _04145_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_72_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13698_ _05142_ _05148_ VGND VGND VPWR VPWR _05213_ sky130_fd_sc_hd__or2_1
XFILLER_0_73_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15437_ net387 net634 _07106_ _07108_ VGND VGND VPWR VPWR _07110_ sky130_fd_sc_hd__nand4_2
XFILLER_0_25_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12649_ _04058_ _04067_ _04017_ _04068_ VGND VGND VPWR VPWR _04069_ sky130_fd_sc_hd__o211a_2
XFILLER_0_127_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_143_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15368_ _07030_ _07034_ VGND VGND VPWR VPWR _07035_ sky130_fd_sc_hd__xor2_2
XFILLER_0_142_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14319_ _05880_ _05886_ VGND VGND VPWR VPWR _05887_ sky130_fd_sc_hd__xor2_1
XFILLER_0_7_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15299_ _02388_ net593 _06877_ _06958_ VGND VGND VPWR VPWR _06959_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout807 net811 VGND VGND VPWR VPWR net807 sky130_fd_sc_hd__clkbuf_4
X_09860_ _01164_ _01165_ _01166_ _01167_ VGND VGND VPWR VPWR _01168_ sky130_fd_sc_hd__o211a_1
XFILLER_0_110_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08811_ _00127_ _00128_ _00129_ VGND VGND VPWR VPWR _00131_ sky130_fd_sc_hd__nand3_1
X_09791_ _01070_ _01071_ _01099_ VGND VGND VPWR VPWR _01100_ sky130_fd_sc_hd__a21oi_1
X_08742_ net211 net202 net668 net678 VGND VGND VPWR VPWR _08053_ sky130_fd_sc_hd__and4_1
XFILLER_0_84_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08673_ _07966_ _07983_ _07984_ VGND VGND VPWR VPWR _07985_ sky130_fd_sc_hd__and3_4
XFILLER_0_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09225_ _00535_ _00539_ _00540_ VGND VGND VPWR VPWR _00541_ sky130_fd_sc_hd__nand3_2
XFILLER_0_106_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09156_ _00293_ _00469_ _00472_ VGND VGND VPWR VPWR _00473_ sky130_fd_sc_hd__a21boi_4
XFILLER_0_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08107_ _02170_ VGND VGND VPWR VPWR _02181_ sky130_fd_sc_hd__buf_4
X_09087_ _00402_ _00403_ VGND VGND VPWR VPWR _00404_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_142_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10000_ _01242_ _01250_ _01304_ VGND VGND VPWR VPWR _01305_ sky130_fd_sc_hd__a21o_1
X_09989_ _00739_ _01292_ _01293_ _01294_ VGND VGND VPWR VPWR _00016_ sky130_fd_sc_hd__o31ai_1
X_11951_ _03205_ _03228_ VGND VGND VPWR VPWR _03308_ sky130_fd_sc_hd__nand2_1
X_10902_ _02164_ _02165_ _02065_ _02089_ VGND VGND VPWR VPWR _02167_ sky130_fd_sc_hd__a211oi_2
X_14670_ _06037_ _06271_ _06272_ VGND VGND VPWR VPWR _06273_ sky130_fd_sc_hd__and3_1
X_11882_ _03135_ _03154_ _03232_ VGND VGND VPWR VPWR _03233_ sky130_fd_sc_hd__a21o_1
XFILLER_0_98_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13621_ _05083_ _05085_ VGND VGND VPWR VPWR _05129_ sky130_fd_sc_hd__nand2_1
X_10833_ _02091_ _02092_ _02095_ VGND VGND VPWR VPWR _02097_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_66_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13552_ _05052_ _05053_ VGND VGND VPWR VPWR _05054_ sky130_fd_sc_hd__nand2_1
X_10764_ _01736_ _02022_ _02021_ VGND VGND VPWR VPWR _02028_ sky130_fd_sc_hd__and3_1
XFILLER_0_55_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12503_ net721 net834 net837 net730 VGND VGND VPWR VPWR _03908_ sky130_fd_sc_hd__a22oi_2
X_13483_ _04977_ _04978_ VGND VGND VPWR VPWR _04979_ sky130_fd_sc_hd__nor2_2
X_16271_ clknet_4_14_0_clk _00060_ net345 VGND VGND VPWR VPWR a_cos\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_54_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10695_ net524 net439 net428 net514 VGND VGND VPWR VPWR _01959_ sky130_fd_sc_hd__and4_1
XFILLER_0_125_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12434_ _03763_ _03765_ _03764_ VGND VGND VPWR VPWR _03832_ sky130_fd_sc_hd__o21ba_1
X_15222_ _06831_ _06826_ VGND VGND VPWR VPWR _06875_ sky130_fd_sc_hd__and2b_1
XFILLER_0_2_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12365_ _03749_ _03750_ _03755_ VGND VGND VPWR VPWR _03757_ sky130_fd_sc_hd__nand3_2
X_15153_ _06798_ _06799_ VGND VGND VPWR VPWR _06800_ sky130_fd_sc_hd__xor2_2
X_14104_ net847 _00739_ _05653_ VGND VGND VPWR VPWR _00092_ sky130_fd_sc_hd__a21o_1
X_11316_ net776 net445 VGND VGND VPWR VPWR _02617_ sky130_fd_sc_hd__nand2_1
X_15084_ _06611_ _06620_ _06619_ VGND VGND VPWR VPWR _06725_ sky130_fd_sc_hd__a21bo_1
X_12296_ _03677_ _03681_ VGND VGND VPWR VPWR _03682_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14035_ _05577_ _05504_ _05575_ _05576_ VGND VGND VPWR VPWR _05580_ sky130_fd_sc_hd__a211o_1
X_11247_ _02424_ _02422_ _02423_ VGND VGND VPWR VPWR _02542_ sky130_fd_sc_hd__a21bo_1
X_11178_ _02347_ _02356_ _02355_ VGND VGND VPWR VPWR _02467_ sky130_fd_sc_hd__a21bo_1
X_10129_ a_cos\[7\] b_sin\[7\] VGND VGND VPWR VPWR _01425_ sky130_fd_sc_hd__nand2_1
X_15986_ _07631_ _07632_ VGND VGND VPWR VPWR _07707_ sky130_fd_sc_hd__and2_1
XFILLER_0_145_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14937_ _06563_ _06564_ VGND VGND VPWR VPWR _06565_ sky130_fd_sc_hd__xor2_1
X_14868_ _06487_ _06488_ _06467_ _06468_ VGND VGND VPWR VPWR _06490_ sky130_fd_sc_hd__a211o_1
XFILLER_0_148_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13819_ _05258_ _05263_ VGND VGND VPWR VPWR _05345_ sky130_fd_sc_hd__and2b_1
XFILLER_0_9_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14799_ _06412_ _06413_ _06414_ VGND VGND VPWR VPWR _06415_ sky130_fd_sc_hd__or3_1
XFILLER_0_18_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09010_ net158 net695 net529 net867 VGND VGND VPWR VPWR _00328_ sky130_fd_sc_hd__a22o_1
XFILLER_0_115_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09912_ _01072_ _01158_ _01217_ VGND VGND VPWR VPWR _01219_ sky130_fd_sc_hd__a21o_1
Xfanout604 net608 VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__clkbuf_4
Xfanout615 net617 VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__buf_4
Xfanout626 net29 VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__buf_4
X_09843_ net618 _01085_ _01087_ _01086_ VGND VGND VPWR VPWR _01151_ sky130_fd_sc_hd__a31o_1
Xfanout637 net640 VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__buf_2
Xfanout648 net655 VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__clkbuf_4
Xfanout659 net665 VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_13_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09774_ _01081_ _01082_ VGND VGND VPWR VPWR _01083_ sky130_fd_sc_hd__nor2_1
X_08725_ _08020_ _08034_ _08035_ VGND VGND VPWR VPWR _08036_ sky130_fd_sc_hd__nand3_2
X_08656_ net211 net202 net679 net684 VGND VGND VPWR VPWR _07968_ sky130_fd_sc_hd__and4_1
X_08587_ net221 net703 _07390_ _07401_ VGND VGND VPWR VPWR _07412_ sky130_fd_sc_hd__and4_1
XFILLER_0_138_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_22_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09208_ _00442_ _00444_ _00443_ VGND VGND VPWR VPWR _00524_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_51_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10480_ _01741_ _01742_ _01628_ VGND VGND VPWR VPWR _01744_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_134_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09139_ _00454_ _00455_ VGND VGND VPWR VPWR _00456_ sky130_fd_sc_hd__xor2_1
XFILLER_0_60_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12150_ _03460_ VGND VGND VPWR VPWR _03523_ sky130_fd_sc_hd__inv_2
X_11101_ _02170_ VGND VGND VPWR VPWR _02383_ sky130_fd_sc_hd__buf_4
XFILLER_0_130_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12081_ _03446_ _03447_ _03444_ _03445_ VGND VGND VPWR VPWR _03449_ sky130_fd_sc_hd__o211a_1
XFILLER_0_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11032_ _02229_ _02237_ _02236_ VGND VGND VPWR VPWR _02307_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_31_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15840_ _07546_ _07547_ VGND VGND VPWR VPWR _07548_ sky130_fd_sc_hd__nor2_1
X_15771_ _07395_ _07397_ VGND VGND VPWR VPWR _07473_ sky130_fd_sc_hd__or2_2
X_12983_ _04329_ _04330_ _04332_ VGND VGND VPWR VPWR _04434_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_87_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14722_ net488 net593 net608 net478 VGND VGND VPWR VPWR _06330_ sky130_fd_sc_hd__a22o_1
X_11934_ net511 net613 net456 net450 VGND VGND VPWR VPWR _03289_ sky130_fd_sc_hd__and4_1
XFILLER_0_129_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14653_ _06183_ _06184_ _06195_ VGND VGND VPWR VPWR _06254_ sky130_fd_sc_hd__and3_1
X_11865_ _03212_ _03213_ VGND VGND VPWR VPWR _03215_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_67_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_40_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13604_ _05023_ _05110_ VGND VGND VPWR VPWR _05111_ sky130_fd_sc_hd__xor2_1
X_10816_ net489 net479 net784 net792 VGND VGND VPWR VPWR _02080_ sky130_fd_sc_hd__and4_1
X_14584_ _06176_ _06177_ VGND VGND VPWR VPWR _06178_ sky130_fd_sc_hd__nor2_1
X_11796_ net713 net722 net458 net449 VGND VGND VPWR VPWR _03140_ sky130_fd_sc_hd__and4_1
XFILLER_0_28_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16323_ clknet_4_1_0_clk _00112_ net332 VGND VGND VPWR VPWR b_cos\[16\] sky130_fd_sc_hd__dfrtp_1
X_13535_ _05032_ _05033_ net745 net250 VGND VGND VPWR VPWR _05036_ sky130_fd_sc_hd__and4bb_1
X_10747_ _02008_ _02009_ _02010_ _01713_ VGND VGND VPWR VPWR _02011_ sky130_fd_sc_hd__o211a_1
XFILLER_0_131_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16254_ clknet_4_11_0_clk _00043_ net343 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dfrtp_1
X_13466_ _04958_ _04960_ VGND VGND VPWR VPWR _04961_ sky130_fd_sc_hd__nor2_1
XFILLER_0_125_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10678_ _01934_ _01935_ _01940_ VGND VGND VPWR VPWR _01942_ sky130_fd_sc_hd__a21o_1
XFILLER_0_51_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15205_ b_cos\[4\] _06856_ _05291_ VGND VGND VPWR VPWR _06858_ sky130_fd_sc_hd__mux2_1
XFILLER_0_113_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12417_ _03743_ _03746_ _03744_ VGND VGND VPWR VPWR _03814_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_112_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16185_ _07885_ _07863_ VGND VGND VPWR VPWR _07922_ sky130_fd_sc_hd__or2b_1
XFILLER_0_140_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13397_ net424 net168 _04884_ _04885_ VGND VGND VPWR VPWR _04886_ sky130_fd_sc_hd__a22o_1
XFILLER_0_106_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15136_ _06779_ _06781_ VGND VGND VPWR VPWR _06782_ sky130_fd_sc_hd__nor2_1
XFILLER_0_50_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12348_ _03731_ _03737_ VGND VGND VPWR VPWR _03738_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15067_ _06705_ _06706_ VGND VGND VPWR VPWR _06707_ sky130_fd_sc_hd__or2b_1
X_12279_ _03631_ _03629_ VGND VGND VPWR VPWR _03663_ sky130_fd_sc_hd__or2b_1
X_14018_ net797 _01087_ _05489_ _05387_ VGND VGND VPWR VPWR _05561_ sky130_fd_sc_hd__a31o_1
XFILLER_0_4_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15969_ _07686_ _07687_ VGND VGND VPWR VPWR _07688_ sky130_fd_sc_hd__nor2_1
X_08510_ _06047_ _06102_ _06091_ VGND VGND VPWR VPWR _06573_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_78_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09490_ _00785_ _00801_ VGND VGND VPWR VPWR _00803_ sky130_fd_sc_hd__or2_1
X_08441_ _05318_ _05296_ _05307_ VGND VGND VPWR VPWR _05816_ sky130_fd_sc_hd__or3_4
XFILLER_0_148_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08372_ _05035_ _05046_ _05057_ VGND VGND VPWR VPWR _05068_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_58_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_144_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout401 net403 VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__clkbuf_4
Xfanout412 net414 VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__clkbuf_4
Xfanout423 net430 VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__clkbuf_4
Xfanout434 net436 VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__buf_2
Xfanout445 net446 VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__clkbuf_4
Xfanout456 net458 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__clkbuf_4
X_09826_ _01059_ _01058_ VGND VGND VPWR VPWR _01134_ sky130_fd_sc_hd__and2b_1
Xfanout467 net44 VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__buf_2
Xfanout478 net480 VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__clkbuf_4
Xfanout489 net490 VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__buf_2
X_09757_ _01064_ _01065_ VGND VGND VPWR VPWR _01066_ sky130_fd_sc_hd__xnor2_1
X_08708_ _07889_ _07950_ VGND VGND VPWR VPWR _08019_ sky130_fd_sc_hd__and2_1
X_09688_ net296 net646 _00918_ _00917_ VGND VGND VPWR VPWR _00998_ sky130_fd_sc_hd__a31o_1
X_08639_ _07889_ _07950_ VGND VGND VPWR VPWR _07951_ sky130_fd_sc_hd__xnor2_1
X_11650_ _02979_ _02980_ VGND VGND VPWR VPWR _02981_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10601_ net410 net400 net794 net809 VGND VGND VPWR VPWR _01865_ sky130_fd_sc_hd__and4_1
XFILLER_0_36_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11581_ _02820_ _02823_ VGND VGND VPWR VPWR _02905_ sky130_fd_sc_hd__and2b_1
XFILLER_0_147_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13320_ net321 net237 net219 net142 VGND VGND VPWR VPWR _04802_ sky130_fd_sc_hd__a2bb2o_1
X_10532_ net522 net760 net769 net437 VGND VGND VPWR VPWR _01796_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_135_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13251_ _04635_ _04725_ _04726_ VGND VGND VPWR VPWR _04727_ sky130_fd_sc_hd__nand3_2
X_10463_ _01725_ _01724_ _01696_ _01678_ VGND VGND VPWR VPWR _01727_ sky130_fd_sc_hd__o211a_1
XFILLER_0_150_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12202_ _03577_ _03579_ VGND VGND VPWR VPWR _03580_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_122_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13182_ _04533_ _04649_ _04650_ VGND VGND VPWR VPWR _04651_ sky130_fd_sc_hd__a21oi_1
X_10394_ _01645_ _01656_ _01657_ VGND VGND VPWR VPWR _01658_ sky130_fd_sc_hd__nand3_4
XFILLER_0_32_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12133_ _03503_ _03484_ _03486_ VGND VGND VPWR VPWR _03505_ sky130_fd_sc_hd__or3_1
XFILLER_0_20_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12064_ _03428_ _03429_ VGND VGND VPWR VPWR _03430_ sky130_fd_sc_hd__xnor2_1
X_11015_ _02174_ _02271_ _02272_ VGND VGND VPWR VPWR _02289_ sky130_fd_sc_hd__nand3_1
X_15823_ net376 net365 net623 _07449_ VGND VGND VPWR VPWR _07529_ sky130_fd_sc_hd__a31o_2
XFILLER_0_99_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15754_ _07254_ _07375_ _07376_ _07253_ VGND VGND VPWR VPWR _07454_ sky130_fd_sc_hd__a31o_1
X_12966_ _04414_ _04416_ VGND VGND VPWR VPWR _04417_ sky130_fd_sc_hd__nor2_1
X_14705_ _06303_ _06310_ VGND VGND VPWR VPWR _06312_ sky130_fd_sc_hd__xnor2_2
X_11917_ net378 net367 net802 _03193_ VGND VGND VPWR VPWR _03271_ sky130_fd_sc_hd__a31o_2
X_15685_ _07253_ _07254_ VGND VGND VPWR VPWR _07380_ sky130_fd_sc_hd__and2b_1
X_12897_ _04339_ _04340_ VGND VGND VPWR VPWR _04341_ sky130_fd_sc_hd__nor2_1
XFILLER_0_129_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14636_ net495 net593 VGND VGND VPWR VPWR _06236_ sky130_fd_sc_hd__nand2_1
XFILLER_0_142_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11848_ _03190_ _03195_ VGND VGND VPWR VPWR _03196_ sky130_fd_sc_hd__xor2_1
XFILLER_0_117_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14567_ _06151_ _06159_ VGND VGND VPWR VPWR _06160_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_138_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_144_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11779_ _03118_ _03119_ _03048_ VGND VGND VPWR VPWR _03121_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_70_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16306_ clknet_4_0_0_clk _00095_ net333 VGND VGND VPWR VPWR a_sin\[18\] sky130_fd_sc_hd__dfrtp_1
X_13518_ _04835_ _04833_ _04923_ VGND VGND VPWR VPWR _05018_ sky130_fd_sc_hd__a21o_1
X_14498_ _06082_ _06083_ VGND VGND VPWR VPWR _06084_ sky130_fd_sc_hd__or2b_1
XFILLER_0_42_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16237_ clknet_4_13_0_clk _00026_ net339 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dfrtp_1
X_13449_ net754 net250 VGND VGND VPWR VPWR _04942_ sky130_fd_sc_hd__nand2_1
XFILLER_0_113_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16168_ _07787_ _07785_ _07841_ VGND VGND VPWR VPWR _07904_ sky130_fd_sc_hd__o21a_1
X_15119_ net487 net476 net546 VGND VGND VPWR VPWR _06763_ sky130_fd_sc_hd__and3_1
X_08990_ net250 net589 VGND VGND VPWR VPWR _00308_ sky130_fd_sc_hd__nand2_1
X_16099_ _07804_ _07828_ VGND VGND VPWR VPWR _07829_ sky130_fd_sc_hd__and2_1
X_09611_ _00920_ _00921_ VGND VGND VPWR VPWR _00922_ sky130_fd_sc_hd__xnor2_1
X_09542_ net302 net647 net638 net157 VGND VGND VPWR VPWR _00854_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_92_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09473_ _00718_ _00720_ VGND VGND VPWR VPWR _00786_ sky130_fd_sc_hd__nand2_1
XFILLER_0_65_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08424_ _05535_ _05611_ _05622_ VGND VGND VPWR VPWR _05633_ sky130_fd_sc_hd__nand3_4
XFILLER_0_59_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08355_ _04251_ _04240_ VGND VGND VPWR VPWR _04883_ sky130_fd_sc_hd__nor2_1
XFILLER_0_129_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08286_ _03094_ _04119_ VGND VGND VPWR VPWR _04130_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout220 net225 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__clkbuf_4
Xfanout231 net232 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__clkbuf_4
Xfanout242 net243 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__buf_6
Xfanout253 net256 VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__buf_4
Xfanout264 net265 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__clkbuf_4
Xfanout275 net276 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__clkbuf_2
Xfanout286 net287 VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__clkbuf_4
Xfanout297 net301 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__buf_4
X_09809_ _01117_ VGND VGND VPWR VPWR _00013_ sky130_fd_sc_hd__clkbuf_1
X_12820_ net746 net755 net161 net308 VGND VGND VPWR VPWR _04257_ sky130_fd_sc_hd__and4_1
XFILLER_0_97_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12751_ net790 net217 net207 net806 VGND VGND VPWR VPWR _04181_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_96_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11702_ _03034_ _03035_ _03026_ VGND VGND VPWR VPWR _03037_ sky130_fd_sc_hd__a21o_1
X_15470_ _06955_ _06952_ _07048_ VGND VGND VPWR VPWR _07146_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_84_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12682_ _04104_ VGND VGND VPWR VPWR _04105_ sky130_fd_sc_hd__inv_2
XFILLER_0_56_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14421_ _05996_ _05997_ _05995_ VGND VGND VPWR VPWR _05999_ sky130_fd_sc_hd__a21o_1
X_11633_ _02960_ _02961_ VGND VGND VPWR VPWR _02962_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_112_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14352_ _05919_ _05922_ VGND VGND VPWR VPWR _05923_ sky130_fd_sc_hd__xnor2_1
X_11564_ _02727_ _02787_ _02886_ VGND VGND VPWR VPWR _02887_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_135_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13303_ _04781_ _04782_ VGND VGND VPWR VPWR _04783_ sky130_fd_sc_hd__nor2_1
XFILLER_0_150_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10515_ _01776_ _01777_ _01778_ VGND VGND VPWR VPWR _01779_ sky130_fd_sc_hd__nor3_2
X_14283_ _05841_ _05842_ _05846_ VGND VGND VPWR VPWR _05847_ sky130_fd_sc_hd__a21o_1
X_11495_ net758 net444 _02809_ _02810_ VGND VGND VPWR VPWR _02812_ sky130_fd_sc_hd__a22o_1
XFILLER_0_122_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16022_ _07723_ _07744_ VGND VGND VPWR VPWR _07745_ sky130_fd_sc_hd__and2_1
XFILLER_0_21_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13234_ _04700_ _04706_ net812 VGND VGND VPWR VPWR _04708_ sky130_fd_sc_hd__nand3_1
X_10446_ _01703_ _01704_ _01709_ VGND VGND VPWR VPWR _01710_ sky130_fd_sc_hd__nand3_1
XFILLER_0_110_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13165_ _04524_ _04506_ _04610_ _04612_ VGND VGND VPWR VPWR _04633_ sky130_fd_sc_hd__o211a_1
X_10377_ _01639_ _01640_ VGND VGND VPWR VPWR _01641_ sky130_fd_sc_hd__nor2_1
XFILLER_0_20_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12116_ net492 _03358_ VGND VGND VPWR VPWR _03487_ sky130_fd_sc_hd__and2_1
X_13096_ _04555_ _04553_ _04554_ VGND VGND VPWR VPWR _04558_ sky130_fd_sc_hd__nand3_1
X_12047_ _03323_ _03328_ VGND VGND VPWR VPWR _03412_ sky130_fd_sc_hd__and2b_1
X_15806_ net482 net650 net660 net472 VGND VGND VPWR VPWR _07511_ sky130_fd_sc_hd__a22oi_2
X_13998_ _05537_ _05538_ VGND VGND VPWR VPWR _05539_ sky130_fd_sc_hd__nor2_1
XFILLER_0_149_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15737_ net346 net498 net642 net632 VGND VGND VPWR VPWR _07436_ sky130_fd_sc_hd__and4_1
X_12949_ _04394_ _04395_ _04396_ VGND VGND VPWR VPWR _04398_ sky130_fd_sc_hd__a21o_1
XFILLER_0_87_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15668_ _07352_ _07359_ _07360_ VGND VGND VPWR VPWR _07361_ sky130_fd_sc_hd__nand3_2
XFILLER_0_28_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14619_ _06188_ _06191_ _06189_ VGND VGND VPWR VPWR _06217_ sky130_fd_sc_hd__o21ba_1
X_15599_ _07217_ _07219_ _07218_ VGND VGND VPWR VPWR _07286_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_16_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08140_ _02452_ _02463_ _02517_ VGND VGND VPWR VPWR _02539_ sky130_fd_sc_hd__a21o_1
XFILLER_0_55_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08973_ _00291_ _08086_ _00187_ VGND VGND VPWR VPWR _00292_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_46_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold39 b_sin\[7\] VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__dlygate4sd3_1
X_09525_ net166 net628 VGND VGND VPWR VPWR _00837_ sky130_fd_sc_hd__nand2_1
XFILLER_0_149_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09456_ _00767_ _00768_ VGND VGND VPWR VPWR _00769_ sky130_fd_sc_hd__nor2_1
XFILLER_0_148_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08407_ net189 net591 net603 net179 VGND VGND VPWR VPWR _05448_ sky130_fd_sc_hd__a22oi_2
X_09387_ _00605_ VGND VGND VPWR VPWR _00701_ sky130_fd_sc_hd__inv_2
XFILLER_0_19_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08338_ net217 net557 net564 net208 VGND VGND VPWR VPWR _04698_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_117_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08269_ _03866_ _03932_ VGND VGND VPWR VPWR _03943_ sky130_fd_sc_hd__xnor2_1
X_10300_ a_sin\[13\] b_cos\[13\] VGND VGND VPWR VPWR _01571_ sky130_fd_sc_hd__and2b_1
XFILLER_0_131_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11280_ _02575_ _02576_ _02569_ VGND VGND VPWR VPWR _02578_ sky130_fd_sc_hd__a21o_1
X_10231_ _01508_ _01511_ VGND VGND VPWR VPWR _01512_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_104_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_5_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10162_ _01453_ VGND VGND VPWR VPWR _00030_ sky130_fd_sc_hd__clkbuf_1
X_14970_ net360 net532 _06598_ _06599_ VGND VGND VPWR VPWR _06601_ sky130_fd_sc_hd__nand4_2
X_10093_ a_cos\[1\] b_sin\[1\] _01390_ VGND VGND VPWR VPWR _01394_ sky130_fd_sc_hd__a21oi_1
X_13921_ _05453_ _05454_ VGND VGND VPWR VPWR _05455_ sky130_fd_sc_hd__nor2_1
X_13852_ net226 net287 net278 net311 VGND VGND VPWR VPWR _05380_ sky130_fd_sc_hd__a22oi_2
X_12803_ net807 net268 VGND VGND VPWR VPWR _04238_ sky130_fd_sc_hd__nand2_1
X_13783_ net148 net140 net868 net302 VGND VGND VPWR VPWR _05305_ sky130_fd_sc_hd__and4_1
X_10995_ _02264_ _02265_ _02162_ _02164_ VGND VGND VPWR VPWR _02268_ sky130_fd_sc_hd__o211ai_2
X_15522_ _07188_ _07189_ _07200_ _07201_ VGND VGND VPWR VPWR _07202_ sky130_fd_sc_hd__a2bb2o_1
X_12734_ _04112_ _04159_ _04151_ _04158_ VGND VGND VPWR VPWR _04162_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_85_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15453_ _07114_ _07115_ _07125_ _07126_ VGND VGND VPWR VPWR _07127_ sky130_fd_sc_hd__a22oi_2
X_12665_ _04054_ _04045_ _04052_ VGND VGND VPWR VPWR _04087_ sky130_fd_sc_hd__nand3_1
X_14404_ _05978_ _05979_ VGND VGND VPWR VPWR _05980_ sky130_fd_sc_hd__or2_1
X_11616_ net232 net358 _02940_ _02941_ VGND VGND VPWR VPWR _02944_ sky130_fd_sc_hd__nand4_1
X_15384_ _07051_ VGND VGND VPWR VPWR _00102_ sky130_fd_sc_hd__clkbuf_1
X_12596_ net805 net172 VGND VGND VPWR VPWR _04011_ sky130_fd_sc_hd__nand2_1
XFILLER_0_108_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14335_ _05901_ _05902_ _05903_ VGND VGND VPWR VPWR _05905_ sky130_fd_sc_hd__nand3_1
X_11547_ net316 net358 _02867_ _02868_ VGND VGND VPWR VPWR _02869_ sky130_fd_sc_hd__a22o_1
XFILLER_0_13_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14266_ _05826_ _05828_ VGND VGND VPWR VPWR _05829_ sky130_fd_sc_hd__and2b_1
X_11478_ _02685_ _02686_ VGND VGND VPWR VPWR _02794_ sky130_fd_sc_hd__nor2_1
XFILLER_0_150_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16005_ _07724_ _07696_ _07725_ VGND VGND VPWR VPWR _07727_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_0_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13217_ net611 net167 _04686_ _04688_ VGND VGND VPWR VPWR _04690_ sky130_fd_sc_hd__nand4_2
X_10429_ _01628_ _01692_ VGND VGND VPWR VPWR _01693_ sky130_fd_sc_hd__nor2_1
X_14197_ _05753_ _05754_ VGND VGND VPWR VPWR _05755_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_122_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13148_ _04438_ _04522_ _04613_ _04614_ VGND VGND VPWR VPWR _04615_ sky130_fd_sc_hd__o211a_2
XFILLER_0_20_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13079_ net789 net249 VGND VGND VPWR VPWR _04539_ sky130_fd_sc_hd__nand2_1
XFILLER_0_73_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09310_ net173 net649 net640 net184 VGND VGND VPWR VPWR _00625_ sky130_fd_sc_hd__a22o_1
XFILLER_0_87_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09241_ _00412_ _00462_ _00556_ VGND VGND VPWR VPWR _00557_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_118_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09172_ net266 net257 net552 net562 VGND VGND VPWR VPWR _00488_ sky130_fd_sc_hd__and4_1
XFILLER_0_44_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08123_ _02310_ _02343_ VGND VGND VPWR VPWR _02354_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_126_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08956_ _00173_ net129 _00273_ _00274_ VGND VGND VPWR VPWR _00275_ sky130_fd_sc_hd__o211ai_4
X_08887_ _00200_ _00205_ VGND VGND VPWR VPWR _00206_ sky130_fd_sc_hd__xor2_2
XFILLER_0_79_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09508_ _00649_ _00817_ _00820_ VGND VGND VPWR VPWR _00821_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_94_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10780_ _02041_ _02042_ _02037_ VGND VGND VPWR VPWR _02044_ sky130_fd_sc_hd__a21o_1
X_09439_ net297 net667 VGND VGND VPWR VPWR _00752_ sky130_fd_sc_hd__nand2_1
XFILLER_0_137_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12450_ _03793_ _03795_ _03794_ VGND VGND VPWR VPWR _03850_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_74_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11401_ _02632_ _02635_ _02633_ VGND VGND VPWR VPWR _02709_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_35_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12381_ _03724_ _03740_ _03771_ _03772_ VGND VGND VPWR VPWR _03774_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_62_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14120_ _05476_ _05669_ VGND VGND VPWR VPWR _05671_ sky130_fd_sc_hd__nor2_1
XFILLER_0_62_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11332_ _02632_ _02633_ VGND VGND VPWR VPWR _02634_ sky130_fd_sc_hd__or2_1
XFILLER_0_22_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14051_ _05479_ _05564_ VGND VGND VPWR VPWR _05596_ sky130_fd_sc_hd__nor2_1
XFILLER_0_120_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11263_ net615 net359 _02556_ _02557_ VGND VGND VPWR VPWR _02559_ sky130_fd_sc_hd__nand4_1
XFILLER_0_104_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13002_ _04452_ _04453_ _04454_ VGND VGND VPWR VPWR _04455_ sky130_fd_sc_hd__nand3_2
X_10214_ a_sin\[1\] b_cos\[1\] VGND VGND VPWR VPWR _01497_ sky130_fd_sc_hd__and2b_1
X_11194_ _02481_ _02482_ _02303_ _02391_ VGND VGND VPWR VPWR _02484_ sky130_fd_sc_hd__a211oi_2
X_10145_ _01430_ _01433_ _01431_ VGND VGND VPWR VPWR _01439_ sky130_fd_sc_hd__o21ai_1
X_10076_ _01345_ _01379_ VGND VGND VPWR VPWR _01380_ sky130_fd_sc_hd__xnor2_1
X_14953_ _06578_ _06579_ _06580_ VGND VGND VPWR VPWR _06582_ sky130_fd_sc_hd__nand3_1
X_13904_ _05350_ _05334_ VGND VGND VPWR VPWR _05437_ sky130_fd_sc_hd__and2b_1
X_14884_ _06505_ _06506_ VGND VGND VPWR VPWR _06507_ sky130_fd_sc_hd__nor2_1
X_13835_ _05280_ _05283_ VGND VGND VPWR VPWR _05363_ sky130_fd_sc_hd__and2b_1
X_13766_ _05285_ _05287_ VGND VGND VPWR VPWR _05288_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_85_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10978_ _02246_ _02247_ _02248_ VGND VGND VPWR VPWR _02249_ sky130_fd_sc_hd__or3_1
XFILLER_0_58_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15505_ net387 _07106_ _07108_ VGND VGND VPWR VPWR _07184_ sky130_fd_sc_hd__nand3_1
X_12717_ net781 net221 VGND VGND VPWR VPWR _04144_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13697_ _05123_ _05130_ VGND VGND VPWR VPWR _05212_ sky130_fd_sc_hd__and2_1
XFILLER_0_150_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15436_ net387 net634 _07106_ _07108_ VGND VGND VPWR VPWR _07109_ sky130_fd_sc_hd__a22o_1
X_12648_ _04005_ _04016_ _04015_ VGND VGND VPWR VPWR _04068_ sky130_fd_sc_hd__a21o_1
XFILLER_0_127_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15367_ _06915_ _07032_ _07033_ VGND VGND VPWR VPWR _07034_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_26_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12579_ _03990_ _03991_ VGND VGND VPWR VPWR _03992_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_142_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14318_ _05881_ _05885_ VGND VGND VPWR VPWR _05886_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_68_Left_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15298_ _06874_ _06876_ VGND VGND VPWR VPWR _06958_ sky130_fd_sc_hd__or2b_1
XFILLER_0_40_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14249_ _05767_ _05810_ VGND VGND VPWR VPWR _05811_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout808 net811 VGND VGND VPWR VPWR net808 sky130_fd_sc_hd__clkbuf_4
X_08810_ _00127_ _00128_ _00129_ VGND VGND VPWR VPWR _00130_ sky130_fd_sc_hd__a21o_1
X_09790_ _01096_ _01098_ VGND VGND VPWR VPWR _01099_ sky130_fd_sc_hd__xor2_1
X_08741_ net193 net684 VGND VGND VPWR VPWR _08052_ sky130_fd_sc_hd__nand2_1
X_08672_ _07980_ _07981_ _07982_ VGND VGND VPWR VPWR _07984_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_77_Left_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09224_ _00536_ _00537_ _00538_ VGND VGND VPWR VPWR _00540_ sky130_fd_sc_hd__nand3_1
XFILLER_0_90_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09155_ _00287_ _00470_ _00471_ VGND VGND VPWR VPWR _00472_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_72_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_86_Left_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08106_ net863 VGND VGND VPWR VPWR _02170_ sky130_fd_sc_hd__clkinv_4
X_09086_ _00305_ _00308_ _00306_ VGND VGND VPWR VPWR _00403_ sky130_fd_sc_hd__o21ba_2
XFILLER_0_32_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09988_ net857 _00739_ VGND VGND VPWR VPWR _01294_ sky130_fd_sc_hd__nand2_1
X_08939_ net320 net620 net68 VGND VGND VPWR VPWR _00258_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_95_Left_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_150_Right_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11950_ _03282_ _03306_ VGND VGND VPWR VPWR _03307_ sky130_fd_sc_hd__xnor2_1
X_10901_ _02065_ _02089_ _02164_ _02165_ VGND VGND VPWR VPWR _02166_ sky130_fd_sc_hd__o211a_2
X_11881_ _03153_ _03136_ VGND VGND VPWR VPWR _03232_ sky130_fd_sc_hd__and2b_1
X_13620_ _05126_ _05127_ VGND VGND VPWR VPWR _05128_ sky130_fd_sc_hd__xnor2_1
X_10832_ _02091_ _02092_ _02095_ VGND VGND VPWR VPWR _02096_ sky130_fd_sc_hd__and3_1
XFILLER_0_39_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13551_ _04893_ _05050_ _05051_ VGND VGND VPWR VPWR _05053_ sky130_fd_sc_hd__nand3_1
X_10763_ _01628_ _01741_ _01742_ VGND VGND VPWR VPWR _02027_ sky130_fd_sc_hd__nand3_1
XFILLER_0_66_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12502_ net739 net223 VGND VGND VPWR VPWR _03907_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16270_ clknet_4_15_0_clk _00059_ net345 VGND VGND VPWR VPWR a_cos\[1\] sky130_fd_sc_hd__dfrtp_1
X_13482_ _04975_ _04976_ _04956_ VGND VGND VPWR VPWR _04978_ sky130_fd_sc_hd__a21oi_1
X_10694_ net421 net616 VGND VGND VPWR VPWR _01958_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15221_ _06872_ _06873_ VGND VGND VPWR VPWR _06874_ sky130_fd_sc_hd__xnor2_4
X_12433_ _03828_ _03829_ _03813_ VGND VGND VPWR VPWR _03831_ sky130_fd_sc_hd__a21o_1
XFILLER_0_50_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15152_ net387 net663 VGND VGND VPWR VPWR _06799_ sky130_fd_sc_hd__nand2_1
X_12364_ _03751_ _03754_ VGND VGND VPWR VPWR _03755_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_133_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14103_ _02181_ _05651_ _05652_ VGND VGND VPWR VPWR _05653_ sky130_fd_sc_hd__and3_1
XFILLER_0_133_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11315_ _02613_ _02614_ VGND VGND VPWR VPWR _02616_ sky130_fd_sc_hd__nor2_1
X_15083_ _06721_ _06722_ _06713_ VGND VGND VPWR VPWR _06724_ sky130_fd_sc_hd__a21o_1
X_12295_ _03678_ _03679_ VGND VGND VPWR VPWR _03681_ sky130_fd_sc_hd__xnor2_1
X_14034_ _05575_ _05576_ _05577_ _05504_ VGND VGND VPWR VPWR _05578_ sky130_fd_sc_hd__o211a_1
X_11246_ _02536_ _02537_ _02538_ VGND VGND VPWR VPWR _02541_ sky130_fd_sc_hd__nand3_1
XFILLER_0_38_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11177_ _02462_ _02464_ _02455_ VGND VGND VPWR VPWR _02466_ sky130_fd_sc_hd__a21o_1
XFILLER_0_38_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10128_ a_cos\[7\] b_sin\[7\] VGND VGND VPWR VPWR _01424_ sky130_fd_sc_hd__or2_1
X_15985_ _07703_ _07679_ _07680_ VGND VGND VPWR VPWR _07706_ sky130_fd_sc_hd__or3_1
X_10059_ _01339_ _01340_ _01362_ VGND VGND VPWR VPWR _01363_ sky130_fd_sc_hd__a21oi_1
X_14936_ _06456_ _06457_ VGND VGND VPWR VPWR _06564_ sky130_fd_sc_hd__nand2_1
X_14867_ _06467_ _06468_ _06487_ _06488_ VGND VGND VPWR VPWR _06489_ sky130_fd_sc_hd__o211ai_2
X_13818_ _05342_ _05343_ VGND VGND VPWR VPWR _05344_ sky130_fd_sc_hd__xor2_1
XFILLER_0_98_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14798_ net518 net654 net664 net433 VGND VGND VPWR VPWR _06414_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_85_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13749_ _05171_ _05172_ _05268_ VGND VGND VPWR VPWR _05269_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_73_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15419_ net348 net499 net672 net680 VGND VGND VPWR VPWR _07090_ sky130_fd_sc_hd__nand4_1
XFILLER_0_5_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09911_ _01072_ _01158_ _01217_ VGND VGND VPWR VPWR _01218_ sky130_fd_sc_hd__and3_1
Xfanout605 net607 VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__buf_2
Xfanout616 net617 VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__buf_2
X_09842_ _01148_ _01149_ VGND VGND VPWR VPWR _01150_ sky130_fd_sc_hd__xnor2_2
Xfanout627 net636 VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__clkbuf_4
Xfanout638 net640 VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__buf_2
Xfanout649 net655 VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__clkbuf_2
X_09773_ _01078_ _01079_ _01080_ VGND VGND VPWR VPWR _01082_ sky130_fd_sc_hd__nor3_1
X_08724_ _08032_ _08033_ _08025_ VGND VGND VPWR VPWR _08035_ sky130_fd_sc_hd__a21o_1
X_08655_ net193 net693 VGND VGND VPWR VPWR _07967_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08586_ net326 net592 net601 net241 VGND VGND VPWR VPWR _07401_ sky130_fd_sc_hd__a22o_1
XFILLER_0_37_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09207_ net167 net677 _00436_ _00435_ net658 VGND VGND VPWR VPWR _00523_ sky130_fd_sc_hd__a32o_1
XFILLER_0_106_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09138_ _00357_ _00363_ _00362_ VGND VGND VPWR VPWR _00455_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_32_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09069_ _00289_ _00293_ _00287_ VGND VGND VPWR VPWR _00387_ sky130_fd_sc_hd__a21o_1
XFILLER_0_32_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11100_ _02287_ _02381_ VGND VGND VPWR VPWR _02382_ sky130_fd_sc_hd__xor2_1
X_12080_ _03444_ _03445_ _03446_ _03447_ VGND VGND VPWR VPWR _03448_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_102_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11031_ _02218_ _02220_ VGND VGND VPWR VPWR _02306_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15770_ _07465_ _07471_ VGND VGND VPWR VPWR _07472_ sky130_fd_sc_hd__xnor2_2
X_12982_ _04431_ _04432_ VGND VGND VPWR VPWR _04433_ sky130_fd_sc_hd__nand2_1
X_14721_ net468 net708 VGND VGND VPWR VPWR _06329_ sky130_fd_sc_hd__nand2_1
X_11933_ net511 net458 net449 net613 VGND VGND VPWR VPWR _03288_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_86_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14652_ _06162_ _06163_ VGND VGND VPWR VPWR _06253_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11864_ net722 net446 VGND VGND VPWR VPWR _03213_ sky130_fd_sc_hd__nand2_1
X_13603_ _05025_ _05109_ VGND VGND VPWR VPWR _05110_ sky130_fd_sc_hd__xnor2_1
X_10815_ net489 net784 net792 net479 VGND VGND VPWR VPWR _02079_ sky130_fd_sc_hd__a22o_1
XFILLER_0_67_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14583_ net411 net533 net542 net400 VGND VGND VPWR VPWR _06177_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_27_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11795_ net713 net458 net449 net722 VGND VGND VPWR VPWR _03139_ sky130_fd_sc_hd__a22oi_1
X_16322_ clknet_4_1_0_clk _00111_ net332 VGND VGND VPWR VPWR b_cos\[15\] sky130_fd_sc_hd__dfrtp_1
X_13534_ net745 net250 _05032_ _05033_ VGND VGND VPWR VPWR _05034_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_54_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10746_ _01713_ _01723_ _01714_ VGND VGND VPWR VPWR _02010_ sky130_fd_sc_hd__nand3_1
XFILLER_0_138_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16253_ clknet_4_11_0_clk _00042_ net342 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__dfrtp_1
X_13465_ net710 net718 net288 net279 VGND VGND VPWR VPWR _04960_ sky130_fd_sc_hd__and4_1
XFILLER_0_82_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10677_ _01934_ _01935_ _01940_ VGND VGND VPWR VPWR _01941_ sky130_fd_sc_hd__nand3_2
X_15204_ _06854_ _06855_ VGND VGND VPWR VPWR _06856_ sky130_fd_sc_hd__xor2_1
XFILLER_0_113_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12416_ _03750_ _03755_ _03749_ VGND VGND VPWR VPWR _03813_ sky130_fd_sc_hd__a21bo_1
X_16184_ net464 net622 _07792_ _07790_ VGND VGND VPWR VPWR _07920_ sky130_fd_sc_hd__a31o_1
X_13396_ net229 net313 net186 net176 VGND VGND VPWR VPWR _04885_ sky130_fd_sc_hd__nand4_2
XFILLER_0_51_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15135_ _06777_ _06778_ _06762_ VGND VGND VPWR VPWR _06781_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_140_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12347_ _03732_ _03736_ VGND VGND VPWR VPWR _03737_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_105_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15066_ _06702_ _06703_ _06699_ VGND VGND VPWR VPWR _06706_ sky130_fd_sc_hd__a21o_1
XFILLER_0_121_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12278_ _03628_ _03627_ VGND VGND VPWR VPWR _03662_ sky130_fd_sc_hd__or2b_1
XFILLER_0_120_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14017_ _05558_ _05559_ VGND VGND VPWR VPWR _05560_ sky130_fd_sc_hd__xnor2_1
X_11229_ _02518_ _02521_ VGND VGND VPWR VPWR _02522_ sky130_fd_sc_hd__xor2_1
XFILLER_0_4_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15968_ net865 net866 net641 net631 VGND VGND VPWR VPWR _07687_ sky130_fd_sc_hd__and4_1
X_14919_ _06444_ _06441_ VGND VGND VPWR VPWR _06546_ sky130_fd_sc_hd__and2_1
XFILLER_0_77_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15899_ net471 net650 net641 net481 VGND VGND VPWR VPWR _07612_ sky130_fd_sc_hd__a22oi_1
X_08440_ _05784_ _05795_ VGND VGND VPWR VPWR _05806_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08371_ _04108_ _04130_ VGND VGND VPWR VPWR _05057_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_81_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout402 net403 VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__buf_2
Xfanout413 net414 VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__buf_2
Xfanout424 net430 VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__clkbuf_4
Xfanout435 net436 VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__clkbuf_2
Xfanout446 net47 VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__clkbuf_4
X_09825_ _01052_ _01057_ VGND VGND VPWR VPWR _01133_ sky130_fd_sc_hd__and2b_1
Xfanout457 net458 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout468 net470 VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__clkbuf_4
Xfanout479 net480 VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__buf_2
X_09756_ _00408_ net696 VGND VGND VPWR VPWR _01065_ sky130_fd_sc_hd__or2_1
X_08707_ _07949_ _07943_ VGND VGND VPWR VPWR _08018_ sky130_fd_sc_hd__and2b_1
X_09687_ _00995_ _00996_ VGND VGND VPWR VPWR _00997_ sky130_fd_sc_hd__nor2_1
XFILLER_0_68_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08638_ _07943_ _07949_ VGND VGND VPWR VPWR _07950_ sky130_fd_sc_hd__xnor2_1
X_08569_ _07205_ VGND VGND VPWR VPWR _07216_ sky130_fd_sc_hd__inv_2
XFILLER_0_64_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10600_ net410 net794 net809 net399 VGND VGND VPWR VPWR _01864_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_37_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11580_ _02807_ _02827_ _02903_ VGND VGND VPWR VPWR _02904_ sky130_fd_sc_hd__a21o_1
XFILLER_0_107_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10531_ net420 net778 VGND VGND VPWR VPWR _01795_ sky130_fd_sc_hd__nand2_1
XFILLER_0_146_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13250_ _04723_ _04724_ _04608_ _04610_ VGND VGND VPWR VPWR _04726_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_134_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10462_ _01678_ _01696_ _01724_ _01725_ VGND VGND VPWR VPWR _01726_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_33_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12201_ _03509_ _03511_ _03578_ VGND VGND VPWR VPWR _03579_ sky130_fd_sc_hd__o21bai_1
X_13181_ _04526_ _04532_ VGND VGND VPWR VPWR _04650_ sky130_fd_sc_hd__and2_1
X_10393_ _01638_ _01644_ _01643_ VGND VGND VPWR VPWR _01657_ sky130_fd_sc_hd__a21o_1
X_12132_ _03484_ _03486_ _03503_ VGND VGND VPWR VPWR _03504_ sky130_fd_sc_hd__o21ai_1
X_12063_ net232 net465 VGND VGND VPWR VPWR _03429_ sky130_fd_sc_hd__nand2_1
X_11014_ _02279_ _02281_ _02283_ _02277_ _02189_ VGND VGND VPWR VPWR _02287_ sky130_fd_sc_hd__a32o_1
X_15822_ _07380_ _07452_ _07253_ VGND VGND VPWR VPWR _07528_ sky130_fd_sc_hd__a21o_1
X_15753_ _07256_ _07452_ VGND VGND VPWR VPWR _07453_ sky130_fd_sc_hd__xnor2_1
X_12965_ _04412_ _04413_ _04311_ _04325_ VGND VGND VPWR VPWR _04416_ sky130_fd_sc_hd__o211a_1
X_14704_ _06304_ _06309_ VGND VGND VPWR VPWR _06310_ sky130_fd_sc_hd__xnor2_2
X_11916_ _03125_ _03196_ _03043_ VGND VGND VPWR VPWR _03270_ sky130_fd_sc_hd__a21o_1
X_15684_ _07256_ _07377_ VGND VGND VPWR VPWR _07378_ sky130_fd_sc_hd__xnor2_1
X_12896_ _04264_ _04266_ _04337_ VGND VGND VPWR VPWR _04340_ sky130_fd_sc_hd__and3_1
X_14635_ _06186_ _06194_ VGND VGND VPWR VPWR _06235_ sky130_fd_sc_hd__or2b_1
X_11847_ _03048_ _03194_ VGND VGND VPWR VPWR _03195_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_7_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14566_ _06156_ _06158_ VGND VGND VPWR VPWR _06159_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_55_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11778_ _03048_ _03118_ _03119_ VGND VGND VPWR VPWR _03120_ sky130_fd_sc_hd__and3_1
XFILLER_0_16_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13517_ _04928_ _05016_ VGND VGND VPWR VPWR _05017_ sky130_fd_sc_hd__xnor2_2
X_16305_ clknet_4_0_0_clk _00094_ net331 VGND VGND VPWR VPWR a_sin\[17\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_82_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10729_ net353 net770 net777 net505 VGND VGND VPWR VPWR _01993_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_42_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14497_ _05939_ _05990_ _05989_ VGND VGND VPWR VPWR _06083_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_126_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16236_ clknet_4_12_0_clk _00025_ net340 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dfrtp_1
X_13448_ _04939_ _04940_ VGND VGND VPWR VPWR _04941_ sky130_fd_sc_hd__nor2_1
XFILLER_0_141_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16167_ _07776_ _07778_ _07842_ VGND VGND VPWR VPWR _07903_ sky130_fd_sc_hd__and3_1
XFILLER_0_3_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13379_ net736 net276 VGND VGND VPWR VPWR _04866_ sky130_fd_sc_hd__nand2_1
X_15118_ _06698_ _06706_ _06705_ VGND VGND VPWR VPWR _06762_ sky130_fd_sc_hd__a21o_1
X_16098_ _07806_ _07827_ VGND VGND VPWR VPWR _07828_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_121_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15049_ _06684_ _06685_ _06686_ VGND VGND VPWR VPWR _06687_ sky130_fd_sc_hd__nand3_1
X_09610_ _00854_ _00857_ _00855_ VGND VGND VPWR VPWR _00921_ sky130_fd_sc_hd__o21ba_1
X_09541_ _00851_ _00852_ VGND VGND VPWR VPWR _00853_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_92_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09472_ _00674_ _00675_ _00784_ VGND VGND VPWR VPWR _00785_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_25_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08423_ _05524_ _05514_ _05503_ _05383_ VGND VGND VPWR VPWR _05622_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_148_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08354_ _04698_ _04731_ _04709_ VGND VGND VPWR VPWR _04872_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_18_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08285_ net298 net705 _03073_ _03084_ VGND VGND VPWR VPWR _04119_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_61_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout210 net218 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout221 net222 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__clkbuf_4
Xfanout232 net235 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__clkbuf_4
Xfanout243 net244 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__buf_6
Xfanout254 net256 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__buf_4
Xfanout265 net65 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__buf_2
Xfanout276 net64 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__clkbuf_4
Xfanout287 net290 VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__clkbuf_4
X_09808_ b_sin\[13\] _01116_ _00475_ VGND VGND VPWR VPWR _01117_ sky130_fd_sc_hd__mux2_1
Xfanout298 net301 VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_97_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09739_ _01048_ VGND VGND VPWR VPWR _00012_ sky130_fd_sc_hd__clkbuf_1
X_12750_ _04176_ _04179_ VGND VGND VPWR VPWR _04180_ sky130_fd_sc_hd__nand2_1
X_11701_ _03026_ _03034_ _03035_ VGND VGND VPWR VPWR _03036_ sky130_fd_sc_hd__nand3_1
X_12681_ _04087_ _04088_ _04103_ VGND VGND VPWR VPWR _04104_ sky130_fd_sc_hd__nand3_1
XFILLER_0_139_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14420_ _05995_ _05996_ _05997_ VGND VGND VPWR VPWR _05998_ sky130_fd_sc_hd__nand3_1
X_11632_ net722 net466 VGND VGND VPWR VPWR _02961_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14351_ _05920_ _05921_ VGND VGND VPWR VPWR _05922_ sky130_fd_sc_hd__nor2_1
X_11563_ _02784_ _02786_ VGND VGND VPWR VPWR _02886_ sky130_fd_sc_hd__nor2_1
X_13302_ _04779_ _04780_ _04764_ VGND VGND VPWR VPWR _04782_ sky130_fd_sc_hd__a21oi_1
X_10514_ _01661_ _01775_ net132 _01770_ VGND VGND VPWR VPWR _01778_ sky130_fd_sc_hd__a211oi_2
X_14282_ _05843_ _05844_ _05845_ VGND VGND VPWR VPWR _05846_ sky130_fd_sc_hd__a21bo_1
X_11494_ net740 net749 net462 net452 VGND VGND VPWR VPWR _02810_ sky130_fd_sc_hd__nand4_2
X_16021_ _07727_ _07743_ VGND VGND VPWR VPWR _07744_ sky130_fd_sc_hd__xnor2_1
X_13233_ _04704_ _04705_ _04701_ VGND VGND VPWR VPWR _04707_ sky130_fd_sc_hd__a21o_1
X_10445_ _01705_ _01708_ VGND VGND VPWR VPWR _01709_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_20_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13164_ _04520_ _04618_ _04617_ VGND VGND VPWR VPWR _04631_ sky130_fd_sc_hd__a21bo_1
X_10376_ net413 net402 net752 net760 VGND VGND VPWR VPWR _01640_ sky130_fd_sc_hd__and4_1
X_12115_ _03462_ _03483_ VGND VGND VPWR VPWR _03486_ sky130_fd_sc_hd__nor2_1
X_13095_ _04553_ _04554_ _04555_ VGND VGND VPWR VPWR _04557_ sky130_fd_sc_hd__a21o_1
X_12046_ _03408_ _03410_ VGND VGND VPWR VPWR _03411_ sky130_fd_sc_hd__xor2_1
XFILLER_0_137_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15805_ _07447_ _07451_ _07508_ VGND VGND VPWR VPWR _07510_ sky130_fd_sc_hd__a21oi_2
X_13997_ _05483_ _05486_ _05536_ VGND VGND VPWR VPWR _05538_ sky130_fd_sc_hd__o21a_1
XFILLER_0_1_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12948_ _04394_ _04395_ _04396_ VGND VGND VPWR VPWR _04397_ sky130_fd_sc_hd__nand3_4
XFILLER_0_99_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15736_ net498 net642 net632 net346 VGND VGND VPWR VPWR _07435_ sky130_fd_sc_hd__a22oi_1
X_12879_ net855 _00739_ _04319_ _04321_ VGND VGND VPWR VPWR _00077_ sky130_fd_sc_hd__a22o_1
X_15667_ _07355_ _07356_ _07358_ VGND VGND VPWR VPWR _07360_ sky130_fd_sc_hd__a21o_1
XFILLER_0_118_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14618_ _06213_ _06214_ _06197_ VGND VGND VPWR VPWR _06216_ sky130_fd_sc_hd__a21o_1
XFILLER_0_55_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15598_ _07280_ _07282_ _07283_ VGND VGND VPWR VPWR _07285_ sky130_fd_sc_hd__nand3_1
XFILLER_0_145_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14549_ _06137_ _06139_ VGND VGND VPWR VPWR _06140_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_83_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16219_ clknet_4_13_0_clk _00008_ net339 VGND VGND VPWR VPWR b_sin\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_70_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08972_ _07995_ _08005_ _08082_ _08083_ VGND VGND VPWR VPWR _00291_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09524_ _00835_ VGND VGND VPWR VPWR _00836_ sky130_fd_sc_hd__buf_2
XFILLER_0_78_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09455_ net184 net174 net628 net619 VGND VGND VPWR VPWR _00768_ sky130_fd_sc_hd__and4_1
XFILLER_0_66_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08406_ net171 net704 VGND VGND VPWR VPWR _05438_ sky130_fd_sc_hd__nand2_1
XFILLER_0_143_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09386_ _00698_ _00699_ VGND VGND VPWR VPWR _00700_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_136_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08337_ _04469_ _04382_ _04458_ VGND VGND VPWR VPWR _04687_ sky130_fd_sc_hd__nand3_1
XFILLER_0_62_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08268_ _03877_ _03921_ VGND VGND VPWR VPWR _03932_ sky130_fd_sc_hd__xor2_1
XFILLER_0_105_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08199_ net293 net702 VGND VGND VPWR VPWR _03181_ sky130_fd_sc_hd__nand2_1
XFILLER_0_42_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10230_ _01509_ a_sin\[2\] _01510_ VGND VGND VPWR VPWR _01511_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_100_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10161_ net81 _01452_ net135 VGND VGND VPWR VPWR _01453_ sky130_fd_sc_hd__mux2_1
X_10092_ _01393_ VGND VGND VPWR VPWR _00020_ sky130_fd_sc_hd__clkbuf_1
X_13920_ net422 net507 net263 net253 VGND VGND VPWR VPWR _05454_ sky130_fd_sc_hd__and4_1
X_13851_ _05317_ _05321_ _05378_ VGND VGND VPWR VPWR _05379_ sky130_fd_sc_hd__a21boi_1
X_12802_ _03858_ _03859_ _03860_ VGND VGND VPWR VPWR _04237_ sky130_fd_sc_hd__o21ba_1
X_13782_ net140 net868 net302 net148 VGND VGND VPWR VPWR _05304_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_96_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10994_ _02162_ _02164_ _02264_ _02265_ VGND VGND VPWR VPWR _02266_ sky130_fd_sc_hd__a211o_1
X_12733_ _04154_ _04155_ VGND VGND VPWR VPWR _04161_ sky130_fd_sc_hd__nor2_1
XFILLER_0_69_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15521_ _07198_ _07199_ _07190_ VGND VGND VPWR VPWR _07201_ sky130_fd_sc_hd__a21o_1
XFILLER_0_139_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_106_Left_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15452_ _07123_ _07124_ _07116_ VGND VGND VPWR VPWR _07126_ sky130_fd_sc_hd__a21o_1
X_12664_ _04036_ _04082_ _04079_ _04081_ VGND VGND VPWR VPWR _04085_ sky130_fd_sc_hd__o211ai_2
X_14403_ net354 net607 net707 net504 VGND VGND VPWR VPWR _05979_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_127_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11615_ net232 net358 _02940_ _02941_ VGND VGND VPWR VPWR _02943_ sky130_fd_sc_hd__a22o_1
XFILLER_0_5_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15383_ b_cos\[6\] _07050_ _06949_ VGND VGND VPWR VPWR _07051_ sky130_fd_sc_hd__mux2_1
X_12595_ _04006_ _04008_ VGND VGND VPWR VPWR _04010_ sky130_fd_sc_hd__xnor2_1
X_14334_ _05898_ _05900_ _05899_ VGND VGND VPWR VPWR _05903_ sky130_fd_sc_hd__o21ai_1
X_11546_ net233 net378 net367 net154 VGND VGND VPWR VPWR _02868_ sky130_fd_sc_hd__nand4_2
XFILLER_0_122_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14265_ net408 net577 net586 net398 VGND VGND VPWR VPWR _05828_ sky130_fd_sc_hd__a22o_1
X_11477_ _02705_ _02792_ VGND VGND VPWR VPWR _02793_ sky130_fd_sc_hd__xnor2_1
X_16004_ _07685_ _07697_ VGND VGND VPWR VPWR _07725_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13216_ net611 net167 _04686_ _04688_ VGND VGND VPWR VPWR _04689_ sky130_fd_sc_hd__a22o_1
X_10428_ _01618_ _01624_ _01627_ VGND VGND VPWR VPWR _01692_ sky130_fd_sc_hd__and3_1
X_14196_ _05691_ _05692_ _05690_ VGND VGND VPWR VPWR _05754_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_115_Left_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13147_ _04610_ _04612_ _04524_ _04506_ VGND VGND VPWR VPWR _04614_ sky130_fd_sc_hd__a211o_1
XFILLER_0_148_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10359_ _01612_ _01617_ VGND VGND VPWR VPWR _01623_ sky130_fd_sc_hd__xnor2_2
X_13078_ _04536_ _04537_ VGND VGND VPWR VPWR _04538_ sky130_fd_sc_hd__xor2_1
X_12029_ _03086_ _03239_ _03390_ _03391_ _03392_ VGND VGND VPWR VPWR _03393_ sky130_fd_sc_hd__o311a_4
XFILLER_0_87_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_124_Left_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15719_ _07316_ _07301_ VGND VGND VPWR VPWR _07417_ sky130_fd_sc_hd__and2b_1
XFILLER_0_75_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09240_ _00460_ _00461_ VGND VGND VPWR VPWR _00556_ sky130_fd_sc_hd__and2b_1
XFILLER_0_146_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09171_ net266 net552 net562 net257 VGND VGND VPWR VPWR _00487_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_56_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08122_ _02321_ _02332_ VGND VGND VPWR VPWR _02343_ sky130_fd_sc_hd__nor2_1
XFILLER_0_126_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_133_Left_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_131_Right_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08955_ _00271_ _00272_ _00239_ VGND VGND VPWR VPWR _00274_ sky130_fd_sc_hd__o21ai_2
X_08886_ _00201_ _00204_ VGND VGND VPWR VPWR _00205_ sky130_fd_sc_hd__xor2_2
XFILLER_0_98_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_142_Left_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09507_ _00656_ _00654_ _00735_ VGND VGND VPWR VPWR _00820_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_66_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09438_ _00749_ _00750_ VGND VGND VPWR VPWR _00751_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09369_ _00681_ _00682_ VGND VGND VPWR VPWR _00683_ sky130_fd_sc_hd__nand2_1
XFILLER_0_93_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11400_ _02630_ _02651_ _02649_ VGND VGND VPWR VPWR _02708_ sky130_fd_sc_hd__a21o_1
X_12380_ _03724_ _03740_ _03771_ _03772_ VGND VGND VPWR VPWR _03773_ sky130_fd_sc_hd__a211o_1
XFILLER_0_34_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_884 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11331_ net732 net740 net486 net477 VGND VGND VPWR VPWR _02633_ sky130_fd_sc_hd__and4_1
XFILLER_0_50_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14050_ _05541_ _05544_ VGND VGND VPWR VPWR _05595_ sky130_fd_sc_hd__or2_1
XFILLER_0_104_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11262_ net615 net359 _02556_ _02557_ VGND VGND VPWR VPWR _02558_ sky130_fd_sc_hd__a22o_1
X_13001_ _04351_ _04353_ _04352_ VGND VGND VPWR VPWR _04454_ sky130_fd_sc_hd__a21bo_1
X_10213_ _01494_ _01496_ net136 net859 VGND VGND VPWR VPWR _00038_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_120_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11193_ _02303_ _02391_ _02481_ _02482_ VGND VGND VPWR VPWR _02483_ sky130_fd_sc_hd__o211a_4
X_10144_ _01436_ _01437_ VGND VGND VPWR VPWR _01438_ sky130_fd_sc_hd__nand2_1
XFILLER_0_118_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10075_ _00195_ net662 _01316_ _01317_ VGND VGND VPWR VPWR _01379_ sky130_fd_sc_hd__o31a_1
X_14952_ _06578_ _06579_ _06580_ VGND VGND VPWR VPWR _06581_ sky130_fd_sc_hd__a21o_1
X_13903_ _05434_ _05435_ VGND VGND VPWR VPWR _05436_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_89_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14883_ net405 net674 net682 net395 VGND VGND VPWR VPWR _06506_ sky130_fd_sc_hd__a22oi_2
X_13834_ _05358_ _05360_ VGND VGND VPWR VPWR _05361_ sky130_fd_sc_hd__xor2_2
X_13765_ _05116_ _05189_ _05187_ VGND VGND VPWR VPWR _05287_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_43_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10977_ net234 net433 net154 net518 VGND VGND VPWR VPWR _02248_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_58_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15504_ net387 net625 _07106_ _07108_ VGND VGND VPWR VPWR _07182_ sky130_fd_sc_hd__a22o_1
X_12716_ _04099_ _04098_ _04096_ VGND VGND VPWR VPWR _04143_ sky130_fd_sc_hd__o21ai_1
X_13696_ _05128_ _05129_ VGND VGND VPWR VPWR _05211_ sky130_fd_sc_hd__and2_1
XFILLER_0_127_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12647_ _04065_ _04058_ _04066_ VGND VGND VPWR VPWR _04067_ sky130_fd_sc_hd__nor3_1
X_15435_ net404 net394 net625 VGND VGND VPWR VPWR _07108_ sky130_fd_sc_hd__o21a_2
XFILLER_0_38_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15366_ _06926_ _06927_ VGND VGND VPWR VPWR _07033_ sky130_fd_sc_hd__nor2_1
X_12578_ net774 net197 VGND VGND VPWR VPWR _03991_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14317_ _05883_ _05884_ VGND VGND VPWR VPWR _05885_ sky130_fd_sc_hd__nor2_1
X_11529_ _02846_ _02847_ _02830_ VGND VGND VPWR VPWR _02849_ sky130_fd_sc_hd__a21o_1
X_15297_ _06863_ _06881_ _06956_ VGND VGND VPWR VPWR _06957_ sky130_fd_sc_hd__a21o_1
XFILLER_0_123_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14248_ _05779_ _05809_ VGND VGND VPWR VPWR _05810_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14179_ _05733_ _05734_ VGND VGND VPWR VPWR _05735_ sky130_fd_sc_hd__nor2_1
Xfanout809 net810 VGND VGND VPWR VPWR net809 sky130_fd_sc_hd__buf_2
X_08740_ _08042_ _08050_ VGND VGND VPWR VPWR _08051_ sky130_fd_sc_hd__xor2_2
XFILLER_0_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08671_ _07980_ _07981_ _07982_ VGND VGND VPWR VPWR _07983_ sky130_fd_sc_hd__nand3_4
XFILLER_0_48_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09223_ _00536_ _00537_ _00538_ VGND VGND VPWR VPWR _00539_ sky130_fd_sc_hd__a21o_1
XFILLER_0_57_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09154_ _00296_ _00385_ VGND VGND VPWR VPWR _00471_ sky130_fd_sc_hd__or2b_1
X_08105_ net136 net78 VGND VGND VPWR VPWR _02159_ sky130_fd_sc_hd__nand2b_2
XFILLER_0_31_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09085_ _00396_ _00401_ VGND VGND VPWR VPWR _00402_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_16_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09987_ _01241_ _01238_ _01291_ VGND VGND VPWR VPWR _01293_ sky130_fd_sc_hd__a21oi_1
X_08938_ net236 net629 VGND VGND VPWR VPWR _00257_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_150_Left_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08869_ _08094_ _00188_ VGND VGND VPWR VPWR _00189_ sky130_fd_sc_hd__xor2_1
XFILLER_0_99_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10900_ _02128_ _02129_ _02162_ _02163_ VGND VGND VPWR VPWR _02165_ sky130_fd_sc_hd__a22o_1
X_11880_ _03229_ _03230_ VGND VGND VPWR VPWR _03231_ sky130_fd_sc_hd__and2b_1
XFILLER_0_39_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10831_ _02093_ _02094_ VGND VGND VPWR VPWR _02095_ sky130_fd_sc_hd__and2_1
X_13550_ _05050_ _05051_ _04893_ VGND VGND VPWR VPWR _05052_ sky130_fd_sc_hd__a21o_1
XFILLER_0_149_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10762_ _02024_ _02025_ VGND VGND VPWR VPWR _02026_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12501_ _03696_ _03695_ _03694_ VGND VGND VPWR VPWR _03906_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_137_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13481_ _04956_ _04975_ _04976_ VGND VGND VPWR VPWR _04977_ sky130_fd_sc_hd__and3_1
XFILLER_0_125_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10693_ _01929_ _01931_ _01930_ VGND VGND VPWR VPWR _01957_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_125_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15220_ _06827_ _06830_ _06828_ VGND VGND VPWR VPWR _06873_ sky130_fd_sc_hd__o21ba_2
XFILLER_0_124_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12432_ _03813_ _03828_ _03829_ VGND VGND VPWR VPWR _03830_ sky130_fd_sc_hd__nand3_4
XFILLER_0_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15151_ net653 _06796_ _06797_ VGND VGND VPWR VPWR _06798_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_140_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12363_ _03752_ _03753_ VGND VGND VPWR VPWR _03754_ sky130_fd_sc_hd__nor2_1
X_14102_ _05650_ _05592_ _05593_ VGND VGND VPWR VPWR _05652_ sky130_fd_sc_hd__nand3_1
X_11314_ net758 net767 net462 net452 VGND VGND VPWR VPWR _02614_ sky130_fd_sc_hd__and4_1
X_15082_ _06713_ _06721_ _06722_ VGND VGND VPWR VPWR _06723_ sky130_fd_sc_hd__nand3_1
XFILLER_0_132_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12294_ net235 _02389_ VGND VGND VPWR VPWR _03679_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14033_ _05499_ _05500_ VGND VGND VPWR VPWR _05577_ sky130_fd_sc_hd__or2_1
X_11245_ _02536_ _02537_ _02538_ VGND VGND VPWR VPWR _02540_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11176_ _02455_ _02462_ _02464_ VGND VGND VPWR VPWR _02465_ sky130_fd_sc_hd__nand3_1
X_10127_ _01423_ VGND VGND VPWR VPWR _00025_ sky130_fd_sc_hd__clkbuf_1
X_15984_ _07679_ _07680_ _07703_ VGND VGND VPWR VPWR _07704_ sky130_fd_sc_hd__o21ai_1
X_10058_ _01343_ _01341_ VGND VGND VPWR VPWR _01362_ sky130_fd_sc_hd__and2b_1
X_14935_ _06560_ _06561_ VGND VGND VPWR VPWR _06563_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14866_ _06484_ _06485_ _06469_ VGND VGND VPWR VPWR _06488_ sky130_fd_sc_hd__a21o_1
X_13817_ _05259_ _05262_ _05260_ VGND VGND VPWR VPWR _05343_ sky130_fd_sc_hd__o21ba_1
X_14797_ net518 net433 net654 net664 VGND VGND VPWR VPWR _06413_ sky130_fd_sc_hd__and4_1
XFILLER_0_58_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13748_ _05164_ _05170_ VGND VGND VPWR VPWR _05268_ sky130_fd_sc_hd__and2b_1
XFILLER_0_57_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13679_ _05027_ _05105_ _05192_ VGND VGND VPWR VPWR _05193_ sky130_fd_sc_hd__o21a_1
XFILLER_0_72_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15418_ net348 net672 net680 net499 VGND VGND VPWR VPWR _07089_ sky130_fd_sc_hd__a22o_1
XFILLER_0_143_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15349_ _07011_ _07012_ _07004_ VGND VGND VPWR VPWR _07014_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_80_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09910_ _01215_ _01216_ VGND VGND VPWR VPWR _01217_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout606 net607 VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_95_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09841_ net270 net646 VGND VGND VPWR VPWR _01149_ sky130_fd_sc_hd__nand2_1
XFILLER_0_111_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout617 net3 VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__clkbuf_8
Xfanout628 net636 VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout639 net640 VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__clkbuf_4
X_09772_ _01078_ _01079_ _01080_ VGND VGND VPWR VPWR _01081_ sky130_fd_sc_hd__o21a_1
XFILLER_0_119_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08723_ _08025_ _08032_ _08033_ VGND VGND VPWR VPWR _08034_ sky130_fd_sc_hd__nand3_1
XFILLER_0_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08654_ _07957_ _07965_ VGND VGND VPWR VPWR _07966_ sky130_fd_sc_hd__xor2_2
XFILLER_0_96_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08585_ net325 net242 net592 net601 VGND VGND VPWR VPWR _07390_ sky130_fd_sc_hd__nand4_1
XFILLER_0_49_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09206_ _00503_ _00521_ VGND VGND VPWR VPWR _00522_ sky130_fd_sc_hd__xor2_2
XFILLER_0_8_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09137_ _00452_ _00453_ VGND VGND VPWR VPWR _00454_ sky130_fd_sc_hd__or2_2
XFILLER_0_60_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09068_ _00296_ _00385_ VGND VGND VPWR VPWR _00386_ sky130_fd_sc_hd__xor2_2
XFILLER_0_32_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11030_ _02196_ _02304_ VGND VGND VPWR VPWR _02305_ sky130_fd_sc_hd__xor2_1
X_12981_ _04424_ _04430_ VGND VGND VPWR VPWR _04432_ sky130_fd_sc_hd__nand2_1
X_14720_ _06321_ _06327_ VGND VGND VPWR VPWR _06328_ sky130_fd_sc_hd__xnor2_1
X_11932_ _03173_ _03176_ _03174_ VGND VGND VPWR VPWR _03287_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_87_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14651_ _06229_ _06230_ _06250_ _06251_ VGND VGND VPWR VPWR _06252_ sky130_fd_sc_hd__or4_4
X_11863_ _03210_ _03211_ VGND VGND VPWR VPWR _03212_ sky130_fd_sc_hd__nor2_1
X_13602_ _05106_ _05108_ VGND VGND VPWR VPWR _05109_ sky130_fd_sc_hd__xor2_1
X_10814_ net469 net811 VGND VGND VPWR VPWR _02078_ sky130_fd_sc_hd__nand2_1
X_14582_ net411 net400 net533 net542 VGND VGND VPWR VPWR _06176_ sky130_fd_sc_hd__and4_1
X_11794_ net713 net466 _03024_ _03023_ VGND VGND VPWR VPWR _03137_ sky130_fd_sc_hd__a31o_1
XFILLER_0_94_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16321_ clknet_4_1_0_clk _00110_ net333 VGND VGND VPWR VPWR b_cos\[14\] sky130_fd_sc_hd__dfrtp_1
X_13533_ net727 net736 net264 net257 VGND VGND VPWR VPWR _05033_ sky130_fd_sc_hd__and4_1
X_10745_ _01943_ _01944_ _01954_ VGND VGND VPWR VPWR _02009_ sky130_fd_sc_hd__a21oi_1
X_13464_ net710 net288 net279 net718 VGND VGND VPWR VPWR _04958_ sky130_fd_sc_hd__a22oi_1
X_16252_ clknet_4_10_0_clk _00041_ net342 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10676_ _01936_ _01939_ VGND VGND VPWR VPWR _01940_ sky130_fd_sc_hd__xnor2_2
X_12415_ _03759_ _03760_ _03770_ VGND VGND VPWR VPWR _03812_ sky130_fd_sc_hd__nand3_2
X_15203_ _06750_ _06753_ _06749_ VGND VGND VPWR VPWR _06855_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_35_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13395_ net229 net186 net176 net313 VGND VGND VPWR VPWR _04884_ sky130_fd_sc_hd__a22o_1
XFILLER_0_63_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16183_ _07912_ _07918_ VGND VGND VPWR VPWR _07919_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_62_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12346_ _03733_ _03735_ VGND VGND VPWR VPWR _03736_ sky130_fd_sc_hd__nor2_1
X_15134_ _06762_ _06777_ _06778_ VGND VGND VPWR VPWR _06779_ sky130_fd_sc_hd__and3_1
XFILLER_0_11_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15065_ _06699_ _06702_ _06703_ VGND VGND VPWR VPWR _06705_ sky130_fd_sc_hd__and3_1
XFILLER_0_121_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12277_ _03633_ _03660_ VGND VGND VPWR VPWR _03661_ sky130_fd_sc_hd__xnor2_1
X_14016_ net226 net271 VGND VGND VPWR VPWR _05559_ sky130_fd_sc_hd__nand2_1
X_11228_ _02519_ _02403_ _02520_ VGND VGND VPWR VPWR _02521_ sky130_fd_sc_hd__o21a_1
X_11159_ _02440_ _02444_ _02445_ VGND VGND VPWR VPWR _02446_ sky130_fd_sc_hd__and3_1
XFILLER_0_65_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15967_ net866 net641 net631 net865 VGND VGND VPWR VPWR _07686_ sky130_fd_sc_hd__a22oi_2
X_14918_ _06444_ _06441_ _06446_ VGND VGND VPWR VPWR _06545_ sky130_fd_sc_hd__a21bo_1
X_15898_ _07451_ _07529_ _07508_ VGND VGND VPWR VPWR _07611_ sky130_fd_sc_hd__a21oi_4
X_14849_ _06395_ _06403_ _06402_ VGND VGND VPWR VPWR _06469_ sky130_fd_sc_hd__a21o_1
XFILLER_0_147_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08370_ _04948_ _04905_ VGND VGND VPWR VPWR _05046_ sky130_fd_sc_hd__or2b_1
XFILLER_0_46_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout403 net52 VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__buf_4
Xfanout414 net51 VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__clkbuf_4
Xfanout425 net430 VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__buf_2
Xfanout436 net437 VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__buf_2
X_09824_ _01130_ _01131_ VGND VGND VPWR VPWR _01132_ sky130_fd_sc_hd__xor2_1
Xfanout447 net450 VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__buf_4
Xfanout458 net459 VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__clkbuf_4
Xfanout469 net470 VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__clkbuf_4
X_09755_ _01060_ _01063_ VGND VGND VPWR VPWR _01064_ sky130_fd_sc_hd__xnor2_1
X_08706_ _08015_ _08016_ VGND VGND VPWR VPWR _08017_ sky130_fd_sc_hd__nor2_1
X_09686_ _00993_ _00994_ net296 net637 VGND VGND VPWR VPWR _00996_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_69_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08637_ _03811_ _03833_ _03822_ VGND VGND VPWR VPWR _07949_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_139_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08568_ _07118_ _07172_ _07194_ VGND VGND VPWR VPWR _07205_ sky130_fd_sc_hd__a21o_1
Xfanout10 net551 VGND VGND VPWR VPWR net870 sky130_fd_sc_hd__buf_8
XFILLER_0_147_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08499_ _05948_ _06443_ VGND VGND VPWR VPWR _06453_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10530_ net421 net769 _01764_ _01763_ VGND VGND VPWR VPWR _01794_ sky130_fd_sc_hd__a22o_1
XFILLER_0_18_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10461_ _01713_ _01723_ _01714_ VGND VGND VPWR VPWR _01725_ sky130_fd_sc_hd__and3_1
XFILLER_0_122_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12200_ _03506_ _03508_ VGND VGND VPWR VPWR _03578_ sky130_fd_sc_hd__nor2_1
X_13180_ _04535_ VGND VGND VPWR VPWR _04649_ sky130_fd_sc_hd__inv_2
XFILLER_0_60_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10392_ _01647_ _01654_ _01655_ VGND VGND VPWR VPWR _01656_ sky130_fd_sc_hd__a21bo_1
X_12131_ _03501_ _03502_ VGND VGND VPWR VPWR _03503_ sky130_fd_sc_hd__nand2_1
XFILLER_0_102_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12062_ _03426_ _03427_ VGND VGND VPWR VPWR _03428_ sky130_fd_sc_hd__nor2_1
X_11013_ _02286_ VGND VGND VPWR VPWR _00059_ sky130_fd_sc_hd__clkbuf_1
X_15821_ _07506_ _07507_ _07525_ VGND VGND VPWR VPWR _07527_ sky130_fd_sc_hd__nor3_1
X_15752_ _07447_ _07451_ VGND VGND VPWR VPWR _07452_ sky130_fd_sc_hd__xor2_1
X_12964_ _04311_ _04325_ _04412_ _04413_ VGND VGND VPWR VPWR _04414_ sky130_fd_sc_hd__a211oi_4
X_14703_ _06305_ _06308_ VGND VGND VPWR VPWR _06309_ sky130_fd_sc_hd__xnor2_2
X_11915_ _03248_ _03249_ _03266_ VGND VGND VPWR VPWR _03269_ sky130_fd_sc_hd__nor3_1
X_15683_ _07375_ _07376_ VGND VGND VPWR VPWR _07377_ sky130_fd_sc_hd__and2_1
X_12895_ _04264_ _04266_ _04337_ VGND VGND VPWR VPWR _04339_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_68_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14634_ _06187_ _06193_ VGND VGND VPWR VPWR _06233_ sky130_fd_sc_hd__or2b_1
XFILLER_0_68_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11846_ _03191_ _03193_ VGND VGND VPWR VPWR _03194_ sky130_fd_sc_hd__or2_2
XFILLER_0_28_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14565_ _06030_ _06032_ VGND VGND VPWR VPWR _06158_ sky130_fd_sc_hd__nor2_1
X_11777_ net358 net144 _03115_ _03117_ VGND VGND VPWR VPWR _03119_ sky130_fd_sc_hd__nand4_1
XFILLER_0_67_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16304_ clknet_4_1_0_clk _00093_ net332 VGND VGND VPWR VPWR a_sin\[16\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_83_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13516_ _04930_ _05015_ VGND VGND VPWR VPWR _05016_ sky130_fd_sc_hd__xor2_2
X_10728_ net353 net505 net770 net777 VGND VGND VPWR VPWR _01992_ sky130_fd_sc_hd__and4_1
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14496_ _05939_ _06049_ _06081_ VGND VGND VPWR VPWR _06082_ sky130_fd_sc_hd__and3_1
XFILLER_0_125_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16235_ clknet_4_12_0_clk _00024_ net340 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_36_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13447_ net736 net745 net266 net257 VGND VGND VPWR VPWR _04940_ sky130_fd_sc_hd__and4_1
XFILLER_0_70_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10659_ _01913_ _01922_ VGND VGND VPWR VPWR _01923_ sky130_fd_sc_hd__and2b_1
XFILLER_0_35_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13378_ _04863_ _04864_ VGND VGND VPWR VPWR _04865_ sky130_fd_sc_hd__nor2_1
XFILLER_0_24_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16166_ _07901_ VGND VGND VPWR VPWR _07902_ sky130_fd_sc_hd__inv_2
XFILLER_0_23_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15117_ _06687_ _06689_ VGND VGND VPWR VPWR _06761_ sky130_fd_sc_hd__nand2_1
X_12329_ net721 net729 net214 net205 VGND VGND VPWR VPWR _03717_ sky130_fd_sc_hd__and4_1
X_16097_ _07808_ _07826_ VGND VGND VPWR VPWR _07827_ sky130_fd_sc_hd__xor2_1
X_15048_ _06578_ _06580_ _06579_ VGND VGND VPWR VPWR _06686_ sky130_fd_sc_hd__a21bo_1
X_09540_ net272 net689 VGND VGND VPWR VPWR _00852_ sky130_fd_sc_hd__nand2_1
X_09471_ _00671_ _00673_ VGND VGND VPWR VPWR _00784_ sky130_fd_sc_hd__or2b_1
XFILLER_0_92_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08422_ _05590_ _05600_ VGND VGND VPWR VPWR _05611_ sky130_fd_sc_hd__nor2_1
XFILLER_0_58_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08353_ _04687_ _04839_ _04850_ VGND VGND VPWR VPWR _04861_ sky130_fd_sc_hd__nand3_2
XFILLER_0_86_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08284_ net163 net309 net603 net704 VGND VGND VPWR VPWR _04108_ sky130_fd_sc_hd__and4_1
XFILLER_0_132_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout200 net201 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__clkbuf_4
Xfanout211 net218 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__clkbuf_4
Xfanout222 net223 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__buf_4
Xfanout233 net234 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__clkbuf_4
Xfanout244 net245 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__buf_6
Xfanout255 net256 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_5_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout266 net269 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__clkbuf_4
Xfanout277 net278 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__clkbuf_4
X_09807_ _01110_ _01115_ VGND VGND VPWR VPWR _01116_ sky130_fd_sc_hd__xor2_1
Xfanout288 net290 VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__clkbuf_4
Xfanout299 net300 VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__clkbuf_2
X_09738_ b_sin\[12\] _01047_ _00475_ VGND VGND VPWR VPWR _01048_ sky130_fd_sc_hd__mux2_1
XFILLER_0_97_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_19_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09669_ b_sin\[11\] _00979_ _00475_ VGND VGND VPWR VPWR _00980_ sky130_fd_sc_hd__mux2_1
XFILLER_0_97_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11700_ _03031_ _03032_ _03033_ VGND VGND VPWR VPWR _03035_ sky130_fd_sc_hd__a21o_1
X_12680_ _04093_ _04101_ _04102_ VGND VGND VPWR VPWR _04103_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_37_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11631_ _02958_ _02959_ VGND VGND VPWR VPWR _02960_ sky130_fd_sc_hd__nor2_1
XFILLER_0_108_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_145_Right_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14350_ net381 net586 net597 net370 VGND VGND VPWR VPWR _05921_ sky130_fd_sc_hd__a22oi_2
X_11562_ _02828_ _02884_ VGND VGND VPWR VPWR _02885_ sky130_fd_sc_hd__xor2_2
XFILLER_0_107_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13301_ _04764_ _04779_ _04780_ VGND VGND VPWR VPWR _04781_ sky130_fd_sc_hd__and3_1
X_10513_ _01745_ _01754_ VGND VGND VPWR VPWR _01777_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_135_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14281_ net520 net434 net570 net577 VGND VGND VPWR VPWR _05845_ sky130_fd_sc_hd__nand4_1
XFILLER_0_80_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11493_ net740 net462 net452 net749 VGND VGND VPWR VPWR _02809_ sky130_fd_sc_hd__a22o_1
X_13232_ _04701_ net832 _04705_ VGND VGND VPWR VPWR _04706_ sky130_fd_sc_hd__nand3_1
X_16020_ _07741_ _07742_ VGND VGND VPWR VPWR _07743_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_123_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10444_ _01706_ _01707_ VGND VGND VPWR VPWR _01708_ sky130_fd_sc_hd__nor2_1
XFILLER_0_150_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13163_ _04630_ VGND VGND VPWR VPWR _00080_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_103_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10375_ net413 net752 net760 net402 VGND VGND VPWR VPWR _01639_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_131_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12114_ _03462_ _03483_ VGND VGND VPWR VPWR _03484_ sky130_fd_sc_hd__and2_1
X_13094_ net728 net867 VGND VGND VPWR VPWR _04555_ sky130_fd_sc_hd__and2_1
X_12045_ _03324_ _03327_ _03325_ VGND VGND VPWR VPWR _03410_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_46_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15804_ _07450_ _07258_ VGND VGND VPWR VPWR _07508_ sky130_fd_sc_hd__and2b_1
X_13996_ _05483_ _05486_ _05536_ VGND VGND VPWR VPWR _05537_ sky130_fd_sc_hd__nor3_1
X_15735_ _07431_ _07432_ VGND VGND VPWR VPWR _07434_ sky130_fd_sc_hd__xnor2_1
X_12947_ _04285_ _04293_ _04292_ VGND VGND VPWR VPWR _04396_ sky130_fd_sc_hd__a21bo_1
X_15666_ _07355_ _07356_ _07358_ VGND VGND VPWR VPWR _07359_ sky130_fd_sc_hd__nand3_2
X_12878_ _03933_ _04039_ _04318_ _04320_ _02181_ VGND VGND VPWR VPWR _04321_ sky130_fd_sc_hd__o311a_1
XFILLER_0_68_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14617_ _06197_ _06213_ _06214_ VGND VGND VPWR VPWR _06215_ sky130_fd_sc_hd__nand3_4
XFILLER_0_8_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11829_ _03173_ _03174_ VGND VGND VPWR VPWR _03175_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15597_ _07280_ _07282_ _07283_ VGND VGND VPWR VPWR _07284_ sky130_fd_sc_hd__a21o_1
XFILLER_0_117_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14548_ _06081_ _06138_ VGND VGND VPWR VPWR _06139_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_112_Right_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14479_ _06057_ _06059_ _06062_ VGND VGND VPWR VPWR _06063_ sky130_fd_sc_hd__a21o_1
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16218_ clknet_4_13_0_clk _00007_ net339 VGND VGND VPWR VPWR b_sin\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_12_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16149_ _02389_ net660 _07881_ VGND VGND VPWR VPWR _07883_ sky130_fd_sc_hd__or3_1
XFILLER_0_87_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08971_ _08088_ _00188_ VGND VGND VPWR VPWR _00290_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09523_ _00833_ _00834_ net619 VGND VGND VPWR VPWR _00835_ sky130_fd_sc_hd__and3b_1
XFILLER_0_79_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09454_ net174 net627 net618 net184 VGND VGND VPWR VPWR _00767_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_149_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08405_ _05394_ _05416_ VGND VGND VPWR VPWR _05427_ sky130_fd_sc_hd__xnor2_1
X_09385_ _00622_ _00632_ _00621_ VGND VGND VPWR VPWR _00699_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_93_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08336_ _04632_ _04665_ VGND VGND VPWR VPWR _04676_ sky130_fd_sc_hd__and2_1
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08267_ _03888_ _03910_ VGND VGND VPWR VPWR _03921_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08198_ _03105_ _03160_ VGND VGND VPWR VPWR _03170_ sky130_fd_sc_hd__or2b_1
XFILLER_0_104_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10160_ _01450_ _01451_ VGND VGND VPWR VPWR _01452_ sky130_fd_sc_hd__xnor2_1
X_10091_ net89 _01392_ net137 VGND VGND VPWR VPWR _01393_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13850_ _05142_ _05320_ VGND VGND VPWR VPWR _05378_ sky130_fd_sc_hd__or2_1
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12801_ _04228_ _04232_ _04235_ VGND VGND VPWR VPWR _04236_ sky130_fd_sc_hd__a21o_1
X_13781_ _05301_ _05302_ VGND VGND VPWR VPWR _05303_ sky130_fd_sc_hd__xnor2_1
X_10993_ _02262_ _02263_ _02227_ VGND VGND VPWR VPWR _02265_ sky130_fd_sc_hd__o21a_1
XFILLER_0_97_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15520_ _07190_ _07198_ _07199_ VGND VGND VPWR VPWR _07200_ sky130_fd_sc_hd__nand3_1
X_12732_ _04151_ _04158_ _04112_ _04159_ VGND VGND VPWR VPWR _04160_ sky130_fd_sc_hd__a211o_4
XFILLER_0_97_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15451_ _07116_ _07123_ _07124_ VGND VGND VPWR VPWR _07125_ sky130_fd_sc_hd__nand3_1
XFILLER_0_127_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12663_ _04079_ _04081_ _04036_ _04082_ VGND VGND VPWR VPWR _04084_ sky130_fd_sc_hd__a211o_1
X_14402_ net354 net504 net607 net707 VGND VGND VPWR VPWR _05978_ sky130_fd_sc_hd__and4_1
XFILLER_0_37_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11614_ net378 net367 net153 net869 VGND VGND VPWR VPWR _02941_ sky130_fd_sc_hd__nand4_2
XFILLER_0_53_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15382_ _06953_ _07049_ VGND VGND VPWR VPWR _07050_ sky130_fd_sc_hd__xor2_1
X_12594_ _03960_ _04007_ VGND VGND VPWR VPWR _04008_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14333_ _05863_ _05864_ _05862_ VGND VGND VPWR VPWR _05902_ sky130_fd_sc_hd__a21bo_1
X_11545_ net233 net367 net154 net378 VGND VGND VPWR VPWR _02867_ sky130_fd_sc_hd__a22o_1
XFILLER_0_52_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14264_ net408 net398 net577 net586 VGND VGND VPWR VPWR _05826_ sky130_fd_sc_hd__and4_1
X_11476_ _02788_ _02791_ VGND VGND VPWR VPWR _02792_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_40_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16003_ _07611_ VGND VGND VPWR VPWR _07724_ sky130_fd_sc_hd__inv_2
X_13215_ net424 net509 net185 net176 VGND VGND VPWR VPWR _04688_ sky130_fd_sc_hd__nand4_2
X_10427_ _01658_ _01661_ _01689_ _01690_ VGND VGND VPWR VPWR _01691_ sky130_fd_sc_hd__a211o_2
X_14195_ _05750_ _05751_ VGND VGND VPWR VPWR _05753_ sky130_fd_sc_hd__xnor2_1
X_13146_ _04524_ _04506_ _04610_ _04612_ VGND VGND VPWR VPWR _04613_ sky130_fd_sc_hd__o211ai_2
X_10358_ _01619_ _01620_ _01621_ VGND VGND VPWR VPWR _01622_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_20_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13077_ _04332_ _04432_ _04431_ VGND VGND VPWR VPWR _04537_ sky130_fd_sc_hd__a21boi_1
X_10289_ _01550_ _01557_ _01560_ VGND VGND VPWR VPWR _01562_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12028_ _03247_ _03244_ _03315_ VGND VGND VPWR VPWR _03392_ sky130_fd_sc_hd__o21ai_1
X_13979_ _05375_ _05373_ _05442_ VGND VGND VPWR VPWR _05519_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_73_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15718_ _07414_ _07415_ VGND VGND VPWR VPWR _07416_ sky130_fd_sc_hd__or2b_1
X_15649_ _07328_ _07337_ _07327_ VGND VGND VPWR VPWR _07340_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09170_ net273 net552 _00415_ _00323_ net538 VGND VGND VPWR VPWR _00486_ sky130_fd_sc_hd__a32o_1
XFILLER_0_56_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08121_ net213 net540 net547 net204 VGND VGND VPWR VPWR _02332_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08954_ _00239_ _00271_ _00272_ VGND VGND VPWR VPWR _00273_ sky130_fd_sc_hd__or3_4
X_08885_ _00202_ _00203_ VGND VGND VPWR VPWR _00204_ sky130_fd_sc_hd__nand2_1
XFILLER_0_138_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09506_ _00472_ _00816_ _00818_ VGND VGND VPWR VPWR _00819_ sky130_fd_sc_hd__a21bo_4
XFILLER_0_2_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09437_ net868 net302 net647 net657 VGND VGND VPWR VPWR _00750_ sky130_fd_sc_hd__and4_1
XFILLER_0_136_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09368_ _00535_ _00679_ _00680_ VGND VGND VPWR VPWR _00682_ sky130_fd_sc_hd__nand3_1
XFILLER_0_34_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08319_ _02365_ _02299_ _02354_ VGND VGND VPWR VPWR _04491_ sky130_fd_sc_hd__a21o_1
X_09299_ net209 net200 net621 VGND VGND VPWR VPWR _00614_ sky130_fd_sc_hd__o21a_1
XANTENNA_60 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11330_ net732 net486 net477 net741 VGND VGND VPWR VPWR _02632_ sky130_fd_sc_hd__a22oi_2
X_11261_ net428 net513 net379 net368 VGND VGND VPWR VPWR _02557_ sky130_fd_sc_hd__nand4_1
X_13000_ _04449_ _04450_ _04451_ VGND VGND VPWR VPWR _04453_ sky130_fd_sc_hd__nand3_1
X_10212_ _01495_ a_sin\[0\] net136 VGND VGND VPWR VPWR _01496_ sky130_fd_sc_hd__o21a_1
X_11192_ _02479_ _02480_ _02392_ _02371_ VGND VGND VPWR VPWR _02482_ sky130_fd_sc_hd__a211o_1
XFILLER_0_101_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10143_ a_cos\[9\] b_sin\[9\] VGND VGND VPWR VPWR _01437_ sky130_fd_sc_hd__nand2_1
X_10074_ _01370_ _01377_ VGND VGND VPWR VPWR _01378_ sky130_fd_sc_hd__xnor2_1
X_14951_ net494 net556 VGND VGND VPWR VPWR _06580_ sky130_fd_sc_hd__and2_1
X_13902_ _05332_ _05355_ VGND VGND VPWR VPWR _05435_ sky130_fd_sc_hd__nand2_2
X_14882_ net405 net395 net674 net682 VGND VGND VPWR VPWR _06505_ sky130_fd_sc_hd__and4_1
X_13833_ _05255_ _05276_ _05359_ VGND VGND VPWR VPWR _05360_ sky130_fd_sc_hd__a21o_1
XFILLER_0_134_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13764_ _05283_ _05284_ VGND VGND VPWR VPWR _05285_ sky130_fd_sc_hd__and2_1
X_10976_ net518 net233 net433 net154 VGND VGND VPWR VPWR _02247_ sky130_fd_sc_hd__and4_1
X_15503_ _07159_ _07180_ VGND VGND VPWR VPWR _07181_ sky130_fd_sc_hd__xor2_2
X_12715_ _04099_ _04096_ _04098_ VGND VGND VPWR VPWR _04142_ sky130_fd_sc_hd__or3_1
XFILLER_0_128_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13695_ _05193_ _05191_ VGND VGND VPWR VPWR _05210_ sky130_fd_sc_hd__and2b_1
XFILLER_0_38_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15434_ net404 net394 net625 VGND VGND VPWR VPWR _07106_ sky130_fd_sc_hd__nand3_2
X_12646_ _04056_ _04057_ _04055_ VGND VGND VPWR VPWR _04066_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_72_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15365_ _06926_ _06927_ VGND VGND VPWR VPWR _07032_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12577_ _03988_ _03989_ VGND VGND VPWR VPWR _03990_ sky130_fd_sc_hd__nor2_1
XFILLER_0_53_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14316_ net380 net595 net605 net369 VGND VGND VPWR VPWR _05884_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_80_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11528_ _02830_ _02846_ _02847_ VGND VGND VPWR VPWR _02848_ sky130_fd_sc_hd__nand3_1
X_15296_ _06864_ _06880_ VGND VGND VPWR VPWR _06956_ sky130_fd_sc_hd__and2b_1
XFILLER_0_7_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14247_ _05788_ _05808_ VGND VGND VPWR VPWR _05809_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11459_ net416 net804 _01891_ VGND VGND VPWR VPWR _02773_ sky130_fd_sc_hd__and3_2
XFILLER_0_68_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14178_ _05723_ _05671_ _05732_ VGND VGND VPWR VPWR _05734_ sky130_fd_sc_hd__o21a_1
XFILLER_0_0_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13129_ _04485_ _04587_ _04592_ _04593_ VGND VGND VPWR VPWR _04594_ sky130_fd_sc_hd__o211ai_2
X_08670_ _03507_ _03561_ _03496_ VGND VGND VPWR VPWR _07982_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_124_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09222_ net194 net640 VGND VGND VPWR VPWR _00538_ sky130_fd_sc_hd__and2_1
XFILLER_0_17_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09153_ _00385_ _00296_ VGND VGND VPWR VPWR _00470_ sky130_fd_sc_hd__and2b_1
XFILLER_0_140_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09084_ _00399_ _00400_ VGND VGND VPWR VPWR _00401_ sky130_fd_sc_hd__xor2_4
XFILLER_0_114_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09986_ _01241_ _01238_ _01291_ VGND VGND VPWR VPWR _01292_ sky130_fd_sc_hd__and3_1
X_08937_ _00158_ _00159_ _00160_ VGND VGND VPWR VPWR _00256_ sky130_fd_sc_hd__nor3_1
X_08868_ _08084_ _00187_ VGND VGND VPWR VPWR _00188_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08799_ _08012_ _00118_ VGND VGND VPWR VPWR _00119_ sky130_fd_sc_hd__xor2_1
X_10830_ _01998_ _02002_ _02004_ VGND VGND VPWR VPWR _02094_ sky130_fd_sc_hd__or3_1
XFILLER_0_66_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10761_ _02017_ _02018_ _02023_ VGND VGND VPWR VPWR _02025_ sky130_fd_sc_hd__o21ai_1
X_12500_ _03694_ _03696_ _03695_ VGND VGND VPWR VPWR _03905_ sky130_fd_sc_hd__or3_1
XFILLER_0_82_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13480_ _04973_ _04974_ _04957_ VGND VGND VPWR VPWR _04976_ sky130_fd_sc_hd__a21o_1
X_10692_ _01935_ _01940_ _01934_ VGND VGND VPWR VPWR _01956_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_82_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12431_ _03820_ _03821_ _03827_ VGND VGND VPWR VPWR _03829_ sky130_fd_sc_hd__a21o_1
XFILLER_0_63_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15150_ net394 net653 net644 net404 VGND VGND VPWR VPWR _06797_ sky130_fd_sc_hd__a22o_1
X_12362_ net712 net214 net205 net720 VGND VGND VPWR VPWR _03753_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_62_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14101_ _05592_ _05593_ _05650_ VGND VGND VPWR VPWR _05651_ sky130_fd_sc_hd__a21o_1
XFILLER_0_105_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11313_ net758 net462 net452 net767 VGND VGND VPWR VPWR _02613_ sky130_fd_sc_hd__a22oi_2
X_15081_ _06719_ _06720_ _06614_ _06714_ VGND VGND VPWR VPWR _06722_ sky130_fd_sc_hd__a211o_1
X_12293_ _03611_ _03614_ _03612_ VGND VGND VPWR VPWR _03678_ sky130_fd_sc_hd__o21a_1
XFILLER_0_120_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14032_ _05574_ _05552_ _05553_ VGND VGND VPWR VPWR _05576_ sky130_fd_sc_hd__and3_1
X_11244_ net731 net494 VGND VGND VPWR VPWR _02538_ sky130_fd_sc_hd__and2_1
X_11175_ _02460_ _02461_ _02350_ _02456_ VGND VGND VPWR VPWR _02464_ sky130_fd_sc_hd__a211o_1
XFILLER_0_100_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10126_ net94 _01422_ net138 VGND VGND VPWR VPWR _01423_ sky130_fd_sc_hd__mux2_1
X_15983_ _07701_ _07702_ VGND VGND VPWR VPWR _07703_ sky130_fd_sc_hd__xnor2_1
X_10057_ _01355_ _01360_ VGND VGND VPWR VPWR _01361_ sky130_fd_sc_hd__xnor2_1
X_14934_ _06555_ _06559_ VGND VGND VPWR VPWR _06561_ sky130_fd_sc_hd__nand2_1
X_14865_ _06469_ _06484_ _06485_ VGND VGND VPWR VPWR _06487_ sky130_fd_sc_hd__nand3_2
X_13816_ _05335_ _05341_ VGND VGND VPWR VPWR _05342_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14796_ net417 net674 VGND VGND VPWR VPWR _06412_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13747_ _05265_ _05266_ VGND VGND VPWR VPWR _05267_ sky130_fd_sc_hd__xor2_2
XFILLER_0_70_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10959_ _02140_ _02157_ _02158_ VGND VGND VPWR VPWR _02228_ sky130_fd_sc_hd__nand3_2
XFILLER_0_85_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13678_ _05102_ _05104_ VGND VGND VPWR VPWR _05192_ sky130_fd_sc_hd__or2_1
X_15417_ _07086_ _07087_ VGND VGND VPWR VPWR _07088_ sky130_fd_sc_hd__xnor2_1
X_12629_ _03997_ _03996_ _03995_ VGND VGND VPWR VPWR _04047_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_143_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15348_ _07004_ _07011_ _07012_ VGND VGND VPWR VPWR _07013_ sky130_fd_sc_hd__and3_1
XFILLER_0_111_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15279_ _06936_ _06937_ VGND VGND VPWR VPWR _06938_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_1_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09840_ _01146_ _01147_ VGND VGND VPWR VPWR _01148_ sky130_fd_sc_hd__nor2_1
Xfanout607 net608 VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__buf_2
Xfanout618 net621 VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__clkbuf_4
Xfanout629 net636 VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__buf_4
XFILLER_0_119_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09771_ net270 net656 VGND VGND VPWR VPWR _01080_ sky130_fd_sc_hd__nand2_1
XFILLER_0_95_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08722_ _08029_ _08030_ _08031_ VGND VGND VPWR VPWR _08033_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08653_ _07963_ _07964_ VGND VGND VPWR VPWR _07965_ sky130_fd_sc_hd__and2b_1
XFILLER_0_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08584_ _07085_ _07368_ VGND VGND VPWR VPWR _07379_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09205_ _00505_ _00520_ VGND VGND VPWR VPWR _00521_ sky130_fd_sc_hd__xor2_2
XFILLER_0_107_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09136_ _00445_ _00446_ _00451_ VGND VGND VPWR VPWR _00453_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_44_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09067_ _00383_ _00384_ VGND VGND VPWR VPWR _00385_ sky130_fd_sc_hd__or2_1
XFILLER_0_114_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09969_ _01272_ _01274_ VGND VGND VPWR VPWR _01275_ sky130_fd_sc_hd__xnor2_1
X_12980_ _04424_ _04430_ VGND VGND VPWR VPWR _04431_ sky130_fd_sc_hd__or2_1
X_11931_ _03285_ _03188_ VGND VGND VPWR VPWR _03286_ sky130_fd_sc_hd__nand2_1
X_14650_ _06248_ _06249_ _06231_ _06232_ VGND VGND VPWR VPWR _06251_ sky130_fd_sc_hd__o211a_1
X_11862_ net613 net713 net458 net449 VGND VGND VPWR VPWR _03211_ sky130_fd_sc_hd__and4_1
XFILLER_0_79_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13601_ _04932_ _05013_ _05107_ VGND VGND VPWR VPWR _05108_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_67_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10813_ _02071_ _02076_ VGND VGND VPWR VPWR _02077_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14581_ net392 net549 VGND VGND VPWR VPWR _06175_ sky130_fd_sc_hd__nand2_1
XFILLER_0_138_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11793_ _03038_ _03041_ VGND VGND VPWR VPWR _03136_ sky130_fd_sc_hd__nand2_1
X_16320_ clknet_4_1_0_clk _00109_ net333 VGND VGND VPWR VPWR b_cos\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_95_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13532_ net727 net264 net257 net736 VGND VGND VPWR VPWR _05032_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_67_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10744_ _01943_ _01944_ _01954_ VGND VGND VPWR VPWR _02008_ sky130_fd_sc_hd__and3_1
XFILLER_0_131_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16251_ clknet_4_10_0_clk _00040_ net342 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__dfrtp_1
X_13463_ _04881_ _04889_ _04888_ VGND VGND VPWR VPWR _04957_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_36_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10675_ _01937_ _01938_ VGND VGND VPWR VPWR _01939_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15202_ _06756_ _06853_ VGND VGND VPWR VPWR _06854_ sky130_fd_sc_hd__xnor2_1
X_12414_ _03774_ _03775_ _03808_ _03809_ VGND VGND VPWR VPWR _03810_ sky130_fd_sc_hd__or4_4
X_16182_ _07914_ _07917_ VGND VGND VPWR VPWR _07918_ sky130_fd_sc_hd__xnor2_1
X_13394_ _04797_ _04799_ _04798_ VGND VGND VPWR VPWR _04882_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_90_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15133_ _06775_ _06776_ _06767_ VGND VGND VPWR VPWR _06778_ sky130_fd_sc_hd__a21o_1
X_12345_ net747 net190 net180 net756 VGND VGND VPWR VPWR _03735_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_50_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15064_ net366 net690 _06700_ _06701_ VGND VGND VPWR VPWR _06703_ sky130_fd_sc_hd__nand4_2
XFILLER_0_10_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12276_ _03650_ _03659_ VGND VGND VPWR VPWR _03660_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_120_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14015_ _05555_ _05556_ VGND VGND VPWR VPWR _05558_ sky130_fd_sc_hd__nor2_1
X_11227_ _02394_ _02401_ VGND VGND VPWR VPWR _02520_ sky130_fd_sc_hd__nand2_1
XFILLER_0_120_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11158_ net615 net368 _02442_ _02443_ VGND VGND VPWR VPWR _02445_ sky130_fd_sc_hd__nand4_2
X_10109_ _01406_ _01407_ VGND VGND VPWR VPWR _01408_ sky130_fd_sc_hd__and2b_1
X_15966_ _07616_ _07624_ _07684_ VGND VGND VPWR VPWR _07685_ sky130_fd_sc_hd__a21o_1
X_11089_ _02367_ _02368_ _02262_ _02264_ VGND VGND VPWR VPWR _02370_ sky130_fd_sc_hd__a211o_1
X_14917_ _06542_ _06543_ VGND VGND VPWR VPWR _06544_ sky130_fd_sc_hd__and2_1
X_15897_ _07515_ _07523_ _07609_ VGND VGND VPWR VPWR _07610_ sky130_fd_sc_hd__a21o_1
X_14848_ _06380_ _06387_ VGND VGND VPWR VPWR _06468_ sky130_fd_sc_hd__and2_1
XFILLER_0_148_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14779_ _06390_ _06391_ _06369_ _06370_ VGND VGND VPWR VPWR _06393_ sky130_fd_sc_hd__a211o_1
XFILLER_0_86_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout404 net414 VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_111_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout415 net417 VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__buf_4
Xfanout426 net430 VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_39_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09823_ _01053_ _01056_ _01054_ VGND VGND VPWR VPWR _01131_ sky130_fd_sc_hd__o21ba_1
Xfanout437 net438 VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__clkbuf_2
Xfanout448 net449 VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__clkbuf_4
Xfanout459 net45 VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__buf_2
X_09754_ _01061_ _01062_ VGND VGND VPWR VPWR _01063_ sky130_fd_sc_hd__nor2_1
X_08705_ _07952_ _07954_ _08014_ VGND VGND VPWR VPWR _08016_ sky130_fd_sc_hd__and3_1
X_09685_ net296 net637 _00993_ _00994_ VGND VGND VPWR VPWR _00995_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_146_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_126_Right_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08636_ _07900_ _07932_ VGND VGND VPWR VPWR _07943_ sky130_fd_sc_hd__xnor2_1
X_08567_ _06758_ _07183_ VGND VGND VPWR VPWR _07194_ sky130_fd_sc_hd__xnor2_1
Xfanout11 net164 VGND VGND VPWR VPWR net871 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_49_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08498_ net191 net602 net704 net181 VGND VGND VPWR VPWR _06443_ sky130_fd_sc_hd__a22o_1
XFILLER_0_147_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10460_ _01713_ _01714_ _01723_ VGND VGND VPWR VPWR _01724_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_150_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09119_ net183 net658 net668 net175 VGND VGND VPWR VPWR _00436_ sky130_fd_sc_hd__a22o_1
XFILLER_0_134_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10391_ _01648_ _01653_ _01649_ VGND VGND VPWR VPWR _01655_ sky130_fd_sc_hd__nand3_1
XFILLER_0_32_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12130_ _03343_ _03439_ _03500_ VGND VGND VPWR VPWR _03502_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_32_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12061_ net481 net471 net153 net144 VGND VGND VPWR VPWR _03427_ sky130_fd_sc_hd__and4_1
XFILLER_0_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11012_ a_cos\[1\] _02285_ _00475_ VGND VGND VPWR VPWR _02286_ sky130_fd_sc_hd__mux2_1
X_15820_ _07506_ _07507_ _07525_ VGND VGND VPWR VPWR _07526_ sky130_fd_sc_hd__o21a_1
XFILLER_0_99_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15751_ _07258_ _07450_ VGND VGND VPWR VPWR _07451_ sky130_fd_sc_hd__xnor2_4
X_12963_ _04410_ _04411_ _04241_ VGND VGND VPWR VPWR _04413_ sky130_fd_sc_hd__a21oi_2
X_14702_ _06306_ _06307_ VGND VGND VPWR VPWR _06308_ sky130_fd_sc_hd__nor2_1
XFILLER_0_87_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11914_ _03248_ _03249_ _03266_ VGND VGND VPWR VPWR _03267_ sky130_fd_sc_hd__o21a_1
X_15682_ _07373_ _07374_ _07367_ VGND VGND VPWR VPWR _07376_ sky130_fd_sc_hd__o21ai_1
X_12894_ _04335_ _04336_ VGND VGND VPWR VPWR _04337_ sky130_fd_sc_hd__nand2_1
X_14633_ _06151_ _06159_ VGND VGND VPWR VPWR _06232_ sky130_fd_sc_hd__or2b_1
X_11845_ net358 net802 _03115_ _03117_ VGND VGND VPWR VPWR _03193_ sky130_fd_sc_hd__and4_1
XFILLER_0_142_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14564_ _06152_ _06155_ VGND VGND VPWR VPWR _06156_ sky130_fd_sc_hd__xnor2_1
X_11776_ net358 net144 _03115_ _03117_ VGND VGND VPWR VPWR _03118_ sky130_fd_sc_hd__a22o_1
XFILLER_0_138_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16303_ clknet_4_1_0_clk _00092_ net332 VGND VGND VPWR VPWR a_sin\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_144_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13515_ _04932_ _05013_ VGND VGND VPWR VPWR _05015_ sky130_fd_sc_hd__xnor2_2
X_10727_ net496 net785 VGND VGND VPWR VPWR _01991_ sky130_fd_sc_hd__nand2_1
X_14495_ _06075_ _06078_ _06079_ _05896_ VGND VGND VPWR VPWR _06081_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_36_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16234_ clknet_4_14_0_clk _00023_ net344 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dfrtp_1
X_13446_ net736 net266 net257 net745 VGND VGND VPWR VPWR _04939_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_3_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10658_ _01914_ _01921_ VGND VGND VPWR VPWR _01922_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16165_ _07776_ _07842_ VGND VGND VPWR VPWR _07901_ sky130_fd_sc_hd__nand2_1
XFILLER_0_141_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13377_ net719 net727 net291 net285 VGND VGND VPWR VPWR _04864_ sky130_fd_sc_hd__and4_1
XFILLER_0_11_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10589_ _01847_ _01846_ VGND VGND VPWR VPWR _01853_ sky130_fd_sc_hd__nand2_1
XFILLER_0_140_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15116_ _06696_ _06731_ _06732_ VGND VGND VPWR VPWR _06760_ sky130_fd_sc_hd__nor3_1
XFILLER_0_140_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12328_ net738 net197 VGND VGND VPWR VPWR _03716_ sky130_fd_sc_hd__nand2_1
X_16096_ _07823_ _07825_ VGND VGND VPWR VPWR _07826_ sky130_fd_sc_hd__xnor2_1
X_15047_ _06683_ _06680_ _06681_ VGND VGND VPWR VPWR _06685_ sky130_fd_sc_hd__nand3_1
X_12259_ _03526_ VGND VGND VPWR VPWR _03642_ sky130_fd_sc_hd__inv_2
XFILLER_0_92_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15949_ net441 net680 VGND VGND VPWR VPWR _07666_ sky130_fd_sc_hd__nand2_1
XFILLER_0_92_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09470_ _00780_ _00781_ _00778_ _00779_ VGND VGND VPWR VPWR _00783_ sky130_fd_sc_hd__a211o_1
X_08421_ _05546_ _05557_ _05579_ VGND VGND VPWR VPWR _05600_ sky130_fd_sc_hd__and3_1
XFILLER_0_116_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08352_ _04469_ _04458_ _04382_ VGND VGND VPWR VPWR _04850_ sky130_fd_sc_hd__a21o_1
XFILLER_0_129_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08283_ _04075_ _04086_ VGND VGND VPWR VPWR _04097_ sky130_fd_sc_hd__nor2_1
XFILLER_0_116_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout201 net203 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__buf_4
Xfanout212 net839 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__clkbuf_2
Xfanout223 net224 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__buf_4
Xfanout234 net235 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__buf_4
Xfanout245 net246 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__buf_6
Xfanout256 net66 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__buf_2
Xfanout267 net269 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__buf_2
X_09806_ _01112_ _01114_ VGND VGND VPWR VPWR _01115_ sky130_fd_sc_hd__and2_1
Xfanout278 net281 VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__clkbuf_4
Xfanout289 net290 VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__buf_2
X_09737_ _00982_ _01046_ VGND VGND VPWR VPWR _01047_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09668_ _00974_ _00978_ VGND VGND VPWR VPWR _00979_ sky130_fd_sc_hd__xor2_1
X_08619_ _03954_ _03976_ _07737_ VGND VGND VPWR VPWR _07759_ sky130_fd_sc_hd__and3_1
X_09599_ _00832_ _00839_ VGND VGND VPWR VPWR _00910_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11630_ net614 net713 net485 net475 VGND VGND VPWR VPWR _02959_ sky130_fd_sc_hd__and4_1
XFILLER_0_64_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11561_ _02881_ _02883_ VGND VGND VPWR VPWR _02884_ sky130_fd_sc_hd__xor2_2
X_13300_ _04777_ _04778_ _04769_ VGND VGND VPWR VPWR _04780_ sky130_fd_sc_hd__a21o_1
XFILLER_0_64_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10512_ _01770_ net132 _01775_ _01661_ VGND VGND VPWR VPWR _01776_ sky130_fd_sc_hd__o211a_2
X_14280_ net519 net570 net577 net435 VGND VGND VPWR VPWR _05844_ sky130_fd_sc_hd__a22o_1
XFILLER_0_150_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11492_ _02729_ _02744_ _02745_ _02749_ VGND VGND VPWR VPWR _02808_ sky130_fd_sc_hd__a31o_1
XFILLER_0_134_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13231_ net876 _04703_ net142 net219 VGND VGND VPWR VPWR _04705_ sky130_fd_sc_hd__a2bb2o_1
X_10443_ net413 net734 net743 net402 VGND VGND VPWR VPWR _01707_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_21_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13162_ a_sin\[3\] _04629_ _03521_ VGND VGND VPWR VPWR _04630_ sky130_fd_sc_hd__mux2_1
X_10374_ _01632_ _01636_ _01637_ VGND VGND VPWR VPWR _01638_ sky130_fd_sc_hd__nand3_1
X_12113_ _03466_ _03482_ VGND VGND VPWR VPWR _03483_ sky130_fd_sc_hd__xnor2_1
X_13093_ net711 net719 net170 net161 VGND VGND VPWR VPWR _04554_ sky130_fd_sc_hd__nand4_2
X_12044_ _03402_ _03407_ VGND VGND VPWR VPWR _03408_ sky130_fd_sc_hd__xnor2_1
Xfanout790 net796 VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__clkbuf_4
X_15803_ _07434_ _07441_ VGND VGND VPWR VPWR _07507_ sky130_fd_sc_hd__and2_1
X_13995_ _05533_ _05534_ VGND VGND VPWR VPWR _05536_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_99_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15734_ net467 net680 VGND VGND VPWR VPWR _07432_ sky130_fd_sc_hd__nand2_1
X_12946_ _04391_ _04392_ _04384_ VGND VGND VPWR VPWR _04395_ sky130_fd_sc_hd__a21o_1
XFILLER_0_87_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15665_ _07280_ _07283_ _07282_ VGND VGND VPWR VPWR _07358_ sky130_fd_sc_hd__a21bo_1
X_12877_ _04228_ _04232_ _04235_ _04318_ VGND VGND VPWR VPWR _04320_ sky130_fd_sc_hd__a211o_1
XFILLER_0_141_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14616_ _06205_ _06206_ _06211_ VGND VGND VPWR VPWR _06214_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11828_ net315 net426 net482 net471 VGND VGND VPWR VPWR _03174_ sky130_fd_sc_hd__and4_1
X_15596_ net493 net672 VGND VGND VPWR VPWR _07283_ sky130_fd_sc_hd__and2_1
XFILLER_0_7_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14547_ _05896_ _06079_ _06078_ _06075_ VGND VGND VPWR VPWR _06138_ sky130_fd_sc_hd__o211a_1
XFILLER_0_55_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11759_ _03097_ _03098_ VGND VGND VPWR VPWR _03099_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_43_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14478_ net418 net595 _06060_ _06061_ VGND VGND VPWR VPWR _06062_ sky130_fd_sc_hd__a31o_1
X_16217_ clknet_4_12_0_clk _00006_ net339 VGND VGND VPWR VPWR b_sin\[6\] sky130_fd_sc_hd__dfrtp_1
X_13429_ _04817_ _04819_ VGND VGND VPWR VPWR _04921_ sky130_fd_sc_hd__nor2_1
XFILLER_0_140_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16148_ _02389_ net660 _07881_ VGND VGND VPWR VPWR _07882_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_12_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08970_ _00287_ _00288_ VGND VGND VPWR VPWR _00289_ sky130_fd_sc_hd__nor2_1
XFILLER_0_87_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16079_ _07749_ _07758_ VGND VGND VPWR VPWR _07807_ sky130_fd_sc_hd__nand2_1
Xinput1 alpha[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_1
X_09522_ net184 net174 VGND VGND VPWR VPWR _00834_ sky130_fd_sc_hd__or2_2
XFILLER_0_149_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09453_ _00765_ VGND VGND VPWR VPWR _00766_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_148_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08404_ _04916_ _05405_ VGND VGND VPWR VPWR _05416_ sky130_fd_sc_hd__xnor2_1
X_09384_ _00685_ _00697_ VGND VGND VPWR VPWR _00698_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_52_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08335_ _04589_ _04622_ _04600_ _04611_ VGND VGND VPWR VPWR _04665_ sky130_fd_sc_hd__a211o_1
XFILLER_0_7_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08266_ _03899_ VGND VGND VPWR VPWR _03910_ sky130_fd_sc_hd__inv_2
XFILLER_0_132_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08197_ _03116_ _03149_ VGND VGND VPWR VPWR _03160_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10090_ _01390_ _01391_ VGND VGND VPWR VPWR _01392_ sky130_fd_sc_hd__nor2_1
XFILLER_0_16_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12800_ _03933_ _04234_ VGND VGND VPWR VPWR _04235_ sky130_fd_sc_hd__xnor2_1
X_13780_ net507 net271 VGND VGND VPWR VPWR _05302_ sky130_fd_sc_hd__nand2_1
X_10992_ _02227_ _02262_ _02263_ VGND VGND VPWR VPWR _02264_ sky130_fd_sc_hd__nor3_2
X_12731_ _04104_ _04111_ _04110_ VGND VGND VPWR VPWR _04159_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_96_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15450_ _07121_ _07122_ _07117_ VGND VGND VPWR VPWR _07124_ sky130_fd_sc_hd__a21o_1
XFILLER_0_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12662_ _04079_ _04081_ _04036_ _04082_ VGND VGND VPWR VPWR _04083_ sky130_fd_sc_hd__a211oi_2
X_14401_ _05925_ _05924_ VGND VGND VPWR VPWR _05977_ sky130_fd_sc_hd__or2b_1
XFILLER_0_65_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11613_ net367 net153 net869 net378 VGND VGND VPWR VPWR _02940_ sky130_fd_sc_hd__a22o_1
X_15381_ _06955_ _07048_ VGND VGND VPWR VPWR _07049_ sky130_fd_sc_hd__xnor2_2
X_12593_ _03962_ _03961_ VGND VGND VPWR VPWR _04007_ sky130_fd_sc_hd__nor2_1
X_14332_ _05898_ _05899_ _05900_ VGND VGND VPWR VPWR _05901_ sky130_fd_sc_hd__or3_1
XFILLER_0_108_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11544_ _02764_ _02766_ _02765_ VGND VGND VPWR VPWR _02865_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_80_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14263_ _05819_ _05823_ _05824_ VGND VGND VPWR VPWR _05825_ sky130_fd_sc_hd__nand3_1
XFILLER_0_106_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11475_ _02629_ _02684_ _02789_ VGND VGND VPWR VPWR _02791_ sky130_fd_sc_hd__a21oi_2
X_16002_ _07675_ _07676_ _07722_ VGND VGND VPWR VPWR _07723_ sky130_fd_sc_hd__a21o_1
XFILLER_0_111_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13214_ net424 net185 net176 net509 VGND VGND VPWR VPWR _04686_ sky130_fd_sc_hd__a22o_1
XFILLER_0_150_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10426_ _01678_ _01688_ _01679_ VGND VGND VPWR VPWR _01690_ sky130_fd_sc_hd__and3_1
X_14194_ net312 net247 _05685_ _05684_ VGND VGND VPWR VPWR _05751_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_0_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13145_ _04608_ _04609_ _04543_ VGND VGND VPWR VPWR _04612_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10357_ net385 net372 net785 net793 VGND VGND VPWR VPWR _01621_ sky130_fd_sc_hd__and4_1
XFILLER_0_20_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13076_ _04533_ _04535_ VGND VGND VPWR VPWR _04536_ sky130_fd_sc_hd__xnor2_1
X_10288_ _01550_ _01557_ _01560_ VGND VGND VPWR VPWR _01561_ sky130_fd_sc_hd__nor3_1
X_12027_ _03240_ _03390_ VGND VGND VPWR VPWR _03391_ sky130_fd_sc_hd__or2_1
X_13978_ _05367_ _05517_ VGND VGND VPWR VPWR _05518_ sky130_fd_sc_hd__or2_1
X_12929_ _04373_ _04374_ _04369_ VGND VGND VPWR VPWR _04376_ sky130_fd_sc_hd__a21o_1
X_15717_ _07411_ net120 _07342_ _07343_ VGND VGND VPWR VPWR _07415_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_87_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15648_ _07339_ VGND VGND VPWR VPWR _00105_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_118_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_1_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_146_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_38_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15579_ _07258_ _07262_ _07263_ VGND VGND VPWR VPWR _07264_ sky130_fd_sc_hd__and3_1
XFILLER_0_7_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08120_ net213 net204 net540 net547 VGND VGND VPWR VPWR _02321_ sky130_fd_sc_hd__and4_1
XFILLER_0_83_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08953_ _00269_ _00270_ _00169_ _00240_ VGND VGND VPWR VPWR _00272_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_47_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08884_ net274 net268 net571 net580 VGND VGND VPWR VPWR _00203_ sky130_fd_sc_hd__nand4_1
XFILLER_0_2_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09505_ _00648_ _00817_ VGND VGND VPWR VPWR _00818_ sky130_fd_sc_hd__nor2_1
XFILLER_0_67_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09436_ net868 net647 net657 net302 VGND VGND VPWR VPWR _00749_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_78_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09367_ _00679_ _00680_ _00535_ VGND VGND VPWR VPWR _00681_ sky130_fd_sc_hd__a21o_1
XFILLER_0_35_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08318_ _04382_ _04458_ _04469_ VGND VGND VPWR VPWR _04480_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_74_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_50 net323 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_09298_ net209 net200 net620 VGND VGND VPWR VPWR _00613_ sky130_fd_sc_hd__nand3_2
XFILLER_0_35_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_61 net838 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_105_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08249_ _03593_ _03604_ _03701_ VGND VGND VPWR VPWR _03723_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_50_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11260_ net428 net379 net368 net513 VGND VGND VPWR VPWR _02556_ sky130_fd_sc_hd__a22o_1
XFILLER_0_120_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10211_ b_cos\[0\] VGND VGND VPWR VPWR _01495_ sky130_fd_sc_hd__inv_2
XFILLER_0_132_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11191_ _02392_ _02371_ _02479_ _02480_ VGND VGND VPWR VPWR _02481_ sky130_fd_sc_hd__o211ai_2
X_10142_ a_cos\[9\] b_sin\[9\] VGND VGND VPWR VPWR _01436_ sky130_fd_sc_hd__or2_1
X_10073_ _01371_ _01376_ VGND VGND VPWR VPWR _01377_ sky130_fd_sc_hd__xnor2_1
X_14950_ net350 net502 net541 net546 VGND VGND VPWR VPWR _06579_ sky130_fd_sc_hd__nand4_1
X_13901_ _05432_ _05433_ VGND VGND VPWR VPWR _05434_ sky130_fd_sc_hd__nand2_1
X_14881_ net388 net690 VGND VGND VPWR VPWR _06504_ sky130_fd_sc_hd__nand2_1
X_13832_ _05257_ _05272_ _05273_ VGND VGND VPWR VPWR _05359_ sky130_fd_sc_hd__and3_1
XFILLER_0_134_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13763_ _05280_ _05281_ _05282_ VGND VGND VPWR VPWR _05284_ sky130_fd_sc_hd__o21ai_1
X_10975_ net318 net417 VGND VGND VPWR VPWR _02246_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12714_ _04138_ _04139_ VGND VGND VPWR VPWR _04140_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15502_ _07160_ _07179_ VGND VGND VPWR VPWR _07180_ sky130_fd_sc_hd__xnor2_2
X_13694_ _05197_ _05205_ _05195_ VGND VGND VPWR VPWR _05208_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_85_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15433_ _07013_ _07014_ _07027_ _07028_ VGND VGND VPWR VPWR _07105_ sky130_fd_sc_hd__or4bb_1
X_12645_ _04059_ _04063_ VGND VGND VPWR VPWR _04065_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_150_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15364_ _07015_ _07029_ VGND VGND VPWR VPWR _07030_ sky130_fd_sc_hd__xnor2_2
X_12576_ net756 net765 net216 net207 VGND VGND VPWR VPWR _03989_ sky130_fd_sc_hd__and4_1
X_14315_ net380 net369 net595 net605 VGND VGND VPWR VPWR _05883_ sky130_fd_sc_hd__and4_1
XFILLER_0_142_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11527_ _02843_ _02845_ _02836_ VGND VGND VPWR VPWR _02847_ sky130_fd_sc_hd__a21o_1
X_15295_ _06939_ _06859_ VGND VGND VPWR VPWR _06955_ sky130_fd_sc_hd__or2b_1
XFILLER_0_40_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14246_ _05799_ _05807_ VGND VGND VPWR VPWR _05808_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11458_ _02770_ _02767_ _02769_ VGND VGND VPWR VPWR _02772_ sky130_fd_sc_hd__nand3_1
XFILLER_0_1_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10409_ _01671_ _01672_ VGND VGND VPWR VPWR _01673_ sky130_fd_sc_hd__xnor2_2
X_14177_ _05723_ _05671_ _05732_ VGND VGND VPWR VPWR _05733_ sky130_fd_sc_hd__nor3_1
XFILLER_0_104_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11389_ _02690_ _02696_ VGND VGND VPWR VPWR _02697_ sky130_fd_sc_hd__nand2_1
XFILLER_0_110_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13128_ _04590_ _04591_ _04588_ VGND VGND VPWR VPWR _04593_ sky130_fd_sc_hd__o21ai_1
X_13059_ a_sin\[2\] _04517_ _03521_ VGND VGND VPWR VPWR _04518_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09221_ net209 net200 net629 net620 VGND VGND VPWR VPWR _00537_ sky130_fd_sc_hd__nand4_1
XFILLER_0_124_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09152_ _00287_ _00288_ _00386_ VGND VGND VPWR VPWR _00469_ sky130_fd_sc_hd__nor3_2
XFILLER_0_72_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09083_ net250 net580 VGND VGND VPWR VPWR _00400_ sky130_fd_sc_hd__nand2_2
XFILLER_0_114_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput70 sin[2] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_55_Left_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09985_ _01229_ _01290_ VGND VGND VPWR VPWR _01291_ sky130_fd_sc_hd__xnor2_1
X_08936_ _00251_ _00254_ VGND VGND VPWR VPWR _00255_ sky130_fd_sc_hd__xnor2_2
X_08867_ _00185_ _00186_ VGND VGND VPWR VPWR _00187_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08798_ _00116_ _00117_ VGND VGND VPWR VPWR _00118_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_64_Left_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10760_ _02017_ _02018_ _02023_ VGND VGND VPWR VPWR _02024_ sky130_fd_sc_hd__nor3_1
X_09419_ _00643_ _00641_ VGND VGND VPWR VPWR _00733_ sky130_fd_sc_hd__or2b_1
XFILLER_0_66_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10691_ _01943_ _01944_ _01954_ VGND VGND VPWR VPWR _01955_ sky130_fd_sc_hd__nand3_2
XFILLER_0_47_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12430_ _03820_ _03821_ _03827_ VGND VGND VPWR VPWR _03828_ sky130_fd_sc_hd__nand3_2
XFILLER_0_74_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12361_ net712 net720 net214 net205 VGND VGND VPWR VPWR _03752_ sky130_fd_sc_hd__and4_1
XFILLER_0_50_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14100_ _05594_ _05649_ VGND VGND VPWR VPWR _05650_ sky130_fd_sc_hd__xor2_2
X_11312_ net758 net469 _02532_ _02531_ net477 VGND VGND VPWR VPWR _02612_ sky130_fd_sc_hd__a32o_1
XPHY_EDGE_ROW_73_Left_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15080_ _06614_ _06714_ _06719_ _06720_ VGND VGND VPWR VPWR _06721_ sky130_fd_sc_hd__o211ai_2
X_12292_ net155 net441 VGND VGND VPWR VPWR _03677_ sky130_fd_sc_hd__nand2_1
XFILLER_0_133_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14031_ _05552_ _05553_ _05574_ VGND VGND VPWR VPWR _05575_ sky130_fd_sc_hd__a21oi_1
X_11243_ net715 net722 net351 net503 VGND VGND VPWR VPWR _02537_ sky130_fd_sc_hd__nand4_1
XFILLER_0_30_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11174_ _02350_ _02456_ _02460_ _02461_ VGND VGND VPWR VPWR _02462_ sky130_fd_sc_hd__o211ai_2
X_10125_ _01420_ _01421_ VGND VGND VPWR VPWR _01422_ sky130_fd_sc_hd__xnor2_1
X_15982_ _07682_ _07630_ _07605_ VGND VGND VPWR VPWR _07702_ sky130_fd_sc_hd__o21bai_2
X_10056_ _01356_ _01359_ VGND VGND VPWR VPWR _01360_ sky130_fd_sc_hd__xnor2_1
X_14933_ _06555_ _06559_ VGND VGND VPWR VPWR _06560_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_82_Left_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14864_ _06482_ _06483_ _06474_ VGND VGND VPWR VPWR _06485_ sky130_fd_sc_hd__a21o_1
XFILLER_0_98_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13815_ _05338_ _05339_ VGND VGND VPWR VPWR _05341_ sky130_fd_sc_hd__xnor2_1
X_14795_ _06406_ _06409_ VGND VGND VPWR VPWR _06411_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_98_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13746_ _05165_ _05169_ _05167_ VGND VGND VPWR VPWR _05266_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_57_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10958_ _02225_ _02226_ VGND VGND VPWR VPWR _02227_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13677_ _05116_ _05190_ VGND VGND VPWR VPWR _05191_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_45_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10889_ _02149_ _02150_ _02151_ VGND VGND VPWR VPWR _02153_ sky130_fd_sc_hd__a21o_1
X_12628_ _03995_ _03997_ _03996_ VGND VGND VPWR VPWR _04046_ sky130_fd_sc_hd__or3_1
X_15416_ net468 net535 VGND VGND VPWR VPWR _07087_ sky130_fd_sc_hd__nand2_1
XFILLER_0_143_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15347_ _07008_ _07010_ _07005_ VGND VGND VPWR VPWR _07012_ sky130_fd_sc_hd__a21o_1
X_12559_ _03955_ _03967_ _03968_ _03969_ VGND VGND VPWR VPWR _03970_ sky130_fd_sc_hd__a211o_2
XPHY_EDGE_ROW_91_Left_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15278_ _06842_ _06821_ _06820_ VGND VGND VPWR VPWR _06937_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_124_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14229_ net149 net247 VGND VGND VPWR VPWR _05789_ sky130_fd_sc_hd__nand2_1
XFILLER_0_110_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout608 net30 VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__buf_4
Xfanout619 net621 VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_107_Right_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09770_ net286 net277 net646 net637 VGND VGND VPWR VPWR _01079_ sky130_fd_sc_hd__and4_1
XFILLER_0_28_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08721_ _08029_ _08030_ _08031_ VGND VGND VPWR VPWR _08032_ sky130_fd_sc_hd__nand3_1
X_08652_ _07961_ _07962_ _07958_ VGND VGND VPWR VPWR _07964_ sky130_fd_sc_hd__a21o_1
XFILLER_0_96_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08583_ net222 net601 _07063_ _07074_ VGND VGND VPWR VPWR _07368_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_44_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09204_ _00510_ _00519_ VGND VGND VPWR VPWR _00520_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_146_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09135_ _00445_ _00446_ _00451_ VGND VGND VPWR VPWR _00452_ sky130_fd_sc_hd__and3_1
XFILLER_0_72_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09066_ _00381_ _00382_ _00297_ _00281_ VGND VGND VPWR VPWR _00384_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_4_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_139_Left_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09968_ _01184_ _01188_ _01189_ _01273_ VGND VGND VPWR VPWR _01274_ sky130_fd_sc_hd__o31a_1
X_08919_ _00235_ _00236_ _00218_ VGND VGND VPWR VPWR _00238_ sky130_fd_sc_hd__a21oi_1
X_09899_ net286 net277 net627 net618 VGND VGND VPWR VPWR _01206_ sky130_fd_sc_hd__and4_1
XFILLER_0_99_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11930_ _03186_ _03172_ VGND VGND VPWR VPWR _03285_ sky130_fd_sc_hd__or2b_1
X_11861_ net613 net458 net449 net713 VGND VGND VPWR VPWR _03210_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_24_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13600_ _05012_ _05010_ VGND VGND VPWR VPWR _05107_ sky130_fd_sc_hd__or2b_1
X_10812_ _02072_ _02075_ VGND VGND VPWR VPWR _02076_ sky130_fd_sc_hd__xnor2_1
X_14580_ _06171_ _06172_ _06166_ VGND VGND VPWR VPWR _06174_ sky130_fd_sc_hd__a21o_1
X_11792_ _03013_ _03014_ _03134_ VGND VGND VPWR VPWR _03135_ sky130_fd_sc_hd__o21ai_1
X_13531_ net727 net273 _04961_ _04960_ VGND VGND VPWR VPWR _05031_ sky130_fd_sc_hd__a31o_1
XFILLER_0_55_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10743_ _01924_ _01925_ VGND VGND VPWR VPWR _02007_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_54_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16250_ clknet_4_10_0_clk _00039_ net342 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_125_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13462_ _04867_ _04876_ _04875_ VGND VGND VPWR VPWR _04956_ sky130_fd_sc_hd__a21o_1
X_10674_ net412 net725 net734 net401 VGND VGND VPWR VPWR _01938_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_47_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15201_ _06851_ _06852_ VGND VGND VPWR VPWR _06853_ sky130_fd_sc_hd__nor2_1
XFILLER_0_36_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12413_ _03806_ _03807_ _03786_ _03790_ VGND VGND VPWR VPWR _03809_ sky130_fd_sc_hd__o211a_1
X_16181_ _07853_ _07916_ VGND VGND VPWR VPWR _07917_ sky130_fd_sc_hd__xnor2_1
X_13393_ _04789_ _04791_ VGND VGND VPWR VPWR _04881_ sky130_fd_sc_hd__nand2_1
XFILLER_0_106_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15132_ _06767_ _06775_ _06776_ VGND VGND VPWR VPWR _06777_ sky130_fd_sc_hd__nand3_1
X_12344_ net747 net756 net187 net180 VGND VGND VPWR VPWR _03733_ sky130_fd_sc_hd__and4_1
XFILLER_0_105_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15063_ net366 net690 _06700_ _06701_ VGND VGND VPWR VPWR _06702_ sky130_fd_sc_hd__a22o_1
X_12275_ _03656_ _03657_ VGND VGND VPWR VPWR _03659_ sky130_fd_sc_hd__xnor2_1
X_14014_ net148 net139 net287 net278 VGND VGND VPWR VPWR _05556_ sky130_fd_sc_hd__and4_1
X_11226_ _02394_ _02401_ VGND VGND VPWR VPWR _02519_ sky130_fd_sc_hd__nor2_1
X_11157_ net615 net367 _02442_ _02443_ VGND VGND VPWR VPWR _02444_ sky130_fd_sc_hd__a22o_1
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10108_ a_cos\[4\] b_sin\[4\] VGND VGND VPWR VPWR _01407_ sky130_fd_sc_hd__nand2_1
X_15965_ _07617_ _07623_ VGND VGND VPWR VPWR _07684_ sky130_fd_sc_hd__and2b_1
X_11088_ _02262_ _02264_ _02367_ _02368_ VGND VGND VPWR VPWR _02369_ sky130_fd_sc_hd__o211ai_1
X_10039_ _01341_ _01343_ VGND VGND VPWR VPWR _01344_ sky130_fd_sc_hd__xnor2_1
X_14916_ _06442_ _06441_ _06539_ _06540_ VGND VGND VPWR VPWR _06543_ sky130_fd_sc_hd__a22o_1
X_15896_ _07521_ _07522_ VGND VGND VPWR VPWR _07609_ sky130_fd_sc_hd__and2_1
X_14847_ _06386_ _06385_ VGND VGND VPWR VPWR _06467_ sky130_fd_sc_hd__and2b_1
XFILLER_0_98_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14778_ _06369_ _06370_ _06390_ _06391_ VGND VGND VPWR VPWR _06392_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_129_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13729_ _05245_ _05246_ VGND VGND VPWR VPWR _05247_ sky130_fd_sc_hd__and2_1
XFILLER_0_105_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout405 net414 VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__buf_2
Xfanout416 net417 VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__clkbuf_4
X_09822_ _01128_ _01129_ VGND VGND VPWR VPWR _01130_ sky130_fd_sc_hd__nor2_1
Xfanout427 net430 VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__buf_2
Xfanout438 net49 VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__buf_2
Xfanout449 net450 VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__clkbuf_4
X_09753_ _01025_ _01024_ VGND VGND VPWR VPWR _01062_ sky130_fd_sc_hd__and2b_1
X_08704_ _07952_ _07954_ _08014_ VGND VGND VPWR VPWR _08015_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_146_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09684_ net157 net303 net627 net618 VGND VGND VPWR VPWR _00994_ sky130_fd_sc_hd__and4_1
XFILLER_0_69_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08635_ _07910_ _07921_ VGND VGND VPWR VPWR _07932_ sky130_fd_sc_hd__nor2_1
X_08566_ _06846_ _06835_ VGND VGND VPWR VPWR _07183_ sky130_fd_sc_hd__and2b_1
XFILLER_0_92_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08497_ net199 net602 _06278_ _06256_ VGND VGND VPWR VPWR _06432_ sky130_fd_sc_hd__a31o_1
XFILLER_0_37_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_146_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09118_ net183 net175 net668 VGND VGND VPWR VPWR _00435_ sky130_fd_sc_hd__and3_1
XFILLER_0_60_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10390_ _01648_ _01649_ _01653_ VGND VGND VPWR VPWR _01654_ sky130_fd_sc_hd__a21o_1
X_09049_ _00364_ _00365_ _00366_ VGND VGND VPWR VPWR _00367_ sky130_fd_sc_hd__nand3_1
XFILLER_0_130_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12060_ net471 net152 net143 net481 VGND VGND VPWR VPWR _03426_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_130_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11011_ _02279_ _02284_ VGND VGND VPWR VPWR _02285_ sky130_fd_sc_hd__xnor2_1
X_12962_ _04241_ _04410_ _04411_ VGND VGND VPWR VPWR _04412_ sky130_fd_sc_hd__and3_1
X_15750_ _07448_ _07449_ VGND VGND VPWR VPWR _07450_ sky130_fd_sc_hd__or2_2
X_14701_ net382 net371 net541 net549 VGND VGND VPWR VPWR _06307_ sky130_fd_sc_hd__and4_1
X_11913_ _03251_ _03265_ VGND VGND VPWR VPWR _03266_ sky130_fd_sc_hd__xor2_1
X_12893_ _04328_ _04334_ VGND VGND VPWR VPWR _04336_ sky130_fd_sc_hd__or2_1
X_15681_ _07367_ _07373_ _07374_ VGND VGND VPWR VPWR _07375_ sky130_fd_sc_hd__or3_1
X_14632_ _06158_ _06156_ VGND VGND VPWR VPWR _06231_ sky130_fd_sc_hd__or2b_1
XFILLER_0_129_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11844_ net358 net802 _03115_ _03117_ VGND VGND VPWR VPWR _03191_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_67_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14563_ _06153_ _06154_ VGND VGND VPWR VPWR _06155_ sky130_fd_sc_hd__and2b_1
XFILLER_0_68_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11775_ net378 net367 net802 VGND VGND VPWR VPWR _03117_ sky130_fd_sc_hd__o21a_1
XFILLER_0_55_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16302_ clknet_4_2_0_clk _00091_ net333 VGND VGND VPWR VPWR a_sin\[14\] sky130_fd_sc_hd__dfrtp_1
X_13514_ _05010_ _05012_ VGND VGND VPWR VPWR _05013_ sky130_fd_sc_hd__xnor2_2
X_10726_ _01946_ _01953_ VGND VGND VPWR VPWR _01990_ sky130_fd_sc_hd__or2b_1
X_14494_ _05892_ _05894_ _05895_ VGND VGND VPWR VPWR _06079_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_82_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13445_ net736 net276 _04865_ _04864_ VGND VGND VPWR VPWR _04938_ sky130_fd_sc_hd__a31o_1
X_16233_ clknet_4_14_0_clk _00022_ net344 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_126_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10657_ _01919_ _01920_ VGND VGND VPWR VPWR _01921_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_141_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13376_ net719 net291 net285 net727 VGND VGND VPWR VPWR _04863_ sky130_fd_sc_hd__a22oi_1
X_16164_ _07897_ _07898_ VGND VGND VPWR VPWR _07899_ sky130_fd_sc_hd__nor2_1
X_10588_ _01850_ _01851_ VGND VGND VPWR VPWR _01852_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12327_ _03711_ _03713_ _03707_ VGND VGND VPWR VPWR _03715_ sky130_fd_sc_hd__a21o_1
X_15115_ _06668_ _06669_ _06757_ VGND VGND VPWR VPWR _06759_ sky130_fd_sc_hd__a21o_1
X_16095_ _02388_ net671 VGND VGND VPWR VPWR _07825_ sky130_fd_sc_hd__nor2_1
X_15046_ _06680_ _06681_ _06683_ VGND VGND VPWR VPWR _06684_ sky130_fd_sc_hd__a21o_1
XFILLER_0_121_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12258_ _03517_ _03640_ VGND VGND VPWR VPWR _03641_ sky130_fd_sc_hd__or2_1
XFILLER_0_76_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11209_ _02500_ VGND VGND VPWR VPWR _00061_ sky130_fd_sc_hd__clkbuf_1
X_12189_ _03547_ _03565_ VGND VGND VPWR VPWR _03566_ sky130_fd_sc_hd__xor2_1
X_15948_ _07663_ _07664_ VGND VGND VPWR VPWR _07665_ sky130_fd_sc_hd__nor2_1
X_15879_ _07588_ _07589_ VGND VGND VPWR VPWR _07590_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08420_ _05546_ _05557_ _05579_ VGND VGND VPWR VPWR _05590_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_148_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08351_ _04741_ _04818_ _04829_ VGND VGND VPWR VPWR _04839_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_18_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08282_ net826 _04031_ _04064_ VGND VGND VPWR VPWR _04086_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_73_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout202 net203 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__clkbuf_4
Xfanout213 net218 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__clkbuf_4
Xfanout224 net225 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__buf_6
Xfanout235 net7 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__clkbuf_8
Xfanout246 net69 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__buf_6
Xfanout257 net260 VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__clkbuf_4
X_09805_ _00974_ _00977_ _01046_ _01113_ VGND VGND VPWR VPWR _01114_ sky130_fd_sc_hd__o31a_1
Xfanout268 net269 VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__clkbuf_4
Xfanout279 net281 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__clkbuf_4
X_09736_ _00983_ _01045_ VGND VGND VPWR VPWR _01046_ sky130_fd_sc_hd__xnor2_1
X_09667_ _00976_ _00977_ VGND VGND VPWR VPWR _00978_ sky130_fd_sc_hd__and2_1
XFILLER_0_96_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08618_ _03954_ _03976_ _07737_ VGND VGND VPWR VPWR _07748_ sky130_fd_sc_hd__a21oi_2
X_09598_ _00766_ _00838_ VGND VGND VPWR VPWR _00909_ sky130_fd_sc_hd__or2_1
XFILLER_0_139_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08549_ _06584_ _06573_ _06562_ _06519_ VGND VGND VPWR VPWR _06998_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_49_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11560_ _02751_ _02783_ _02882_ VGND VGND VPWR VPWR _02883_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_80_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10511_ _01658_ _01660_ _01659_ VGND VGND VPWR VPWR _01775_ sky130_fd_sc_hd__a21o_1
XFILLER_0_108_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11491_ _02722_ _02723_ _02806_ VGND VGND VPWR VPWR _02807_ sky130_fd_sc_hd__a21o_1
XFILLER_0_52_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13230_ _04702_ _00450_ _07488_ _04703_ VGND VGND VPWR VPWR _04704_ sky130_fd_sc_hd__or4_4
X_10442_ net412 net402 net734 net743 VGND VGND VPWR VPWR _01706_ sky130_fd_sc_hd__and4_1
XFILLER_0_150_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13161_ _04624_ _04628_ VGND VGND VPWR VPWR _04629_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_32_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10373_ _01629_ _01631_ _01630_ VGND VGND VPWR VPWR _01637_ sky130_fd_sc_hd__o21ai_1
X_12112_ _03480_ _03481_ VGND VGND VPWR VPWR _03482_ sky130_fd_sc_hd__xnor2_1
X_13092_ net711 net170 net161 net718 VGND VGND VPWR VPWR _04553_ sky130_fd_sc_hd__a22o_1
X_12043_ _03405_ _03406_ VGND VGND VPWR VPWR _03407_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_137_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout780 net783 VGND VGND VPWR VPWR net780 sky130_fd_sc_hd__clkbuf_4
Xfanout791 net796 VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__clkbuf_4
X_15802_ _07439_ _07440_ VGND VGND VPWR VPWR _07506_ sky130_fd_sc_hd__and2_1
X_13994_ net507 net247 VGND VGND VPWR VPWR _05534_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15733_ _07429_ _07430_ VGND VGND VPWR VPWR _07431_ sky130_fd_sc_hd__nor2_1
X_12945_ _04384_ _04391_ _04392_ VGND VGND VPWR VPWR _04394_ sky130_fd_sc_hd__nand3_2
XFILLER_0_88_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15664_ net497 net661 _07353_ _07354_ VGND VGND VPWR VPWR _07356_ sky130_fd_sc_hd__nand4_2
X_12876_ _03933_ _04039_ _04236_ _04318_ VGND VGND VPWR VPWR _04319_ sky130_fd_sc_hd__o211ai_1
X_14615_ _06205_ _06206_ _06211_ VGND VGND VPWR VPWR _06213_ sky130_fd_sc_hd__nand3_2
X_11827_ net319 net481 net471 net426 VGND VGND VPWR VPWR _03173_ sky130_fd_sc_hd__a22oi_2
X_15595_ net348 net499 net651 net661 VGND VGND VPWR VPWR _07282_ sky130_fd_sc_hd__nand4_1
X_14546_ _06108_ _06133_ VGND VGND VPWR VPWR _06137_ sky130_fd_sc_hd__nand2_1
X_11758_ net613 net466 VGND VGND VPWR VPWR _03098_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10709_ _01970_ _01971_ _01956_ VGND VGND VPWR VPWR _01973_ sky130_fd_sc_hd__a21o_1
X_14477_ net519 net434 net578 net586 VGND VGND VPWR VPWR _06061_ sky130_fd_sc_hd__and4_1
X_11689_ net512 net613 net485 net475 VGND VGND VPWR VPWR _03023_ sky130_fd_sc_hd__and4_1
XFILLER_0_24_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16216_ clknet_4_12_0_clk _00005_ net339 VGND VGND VPWR VPWR b_sin\[5\] sky130_fd_sc_hd__dfrtp_1
X_13428_ _04837_ _04919_ VGND VGND VPWR VPWR _04920_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_24_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13359_ net745 net754 net267 net258 VGND VGND VPWR VPWR _04844_ sky130_fd_sc_hd__and4_1
X_16147_ _07876_ _07880_ VGND VGND VPWR VPWR _07881_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_87_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16078_ _07736_ _07740_ _07805_ VGND VGND VPWR VPWR _07806_ sky130_fd_sc_hd__o21ai_2
X_15029_ _06663_ _06664_ VGND VGND VPWR VPWR _06665_ sky130_fd_sc_hd__xor2_1
XFILLER_0_127_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput2 alpha[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_1
X_09521_ net184 net174 net619 VGND VGND VPWR VPWR _00833_ sky130_fd_sc_hd__and3_1
XFILLER_0_79_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09452_ _00613_ _00680_ VGND VGND VPWR VPWR _00765_ sky130_fd_sc_hd__and2_1
XFILLER_0_148_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08403_ _04937_ _04927_ VGND VGND VPWR VPWR _05405_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09383_ _00695_ _00696_ VGND VGND VPWR VPWR _00697_ sky130_fd_sc_hd__and2_1
XFILLER_0_19_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08334_ _04097_ _04643_ VGND VGND VPWR VPWR _04654_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_46_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08265_ net293 net283 net590 net600 VGND VGND VPWR VPWR _03899_ sky130_fd_sc_hd__and4_1
XFILLER_0_6_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08196_ _03127_ _03138_ VGND VGND VPWR VPWR _03149_ sky130_fd_sc_hd__and2b_1
XFILLER_0_61_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09719_ _01027_ _01028_ VGND VGND VPWR VPWR _01029_ sky130_fd_sc_hd__nor2_1
X_10991_ _02260_ _02261_ _02157_ _02228_ VGND VGND VPWR VPWR _02263_ sky130_fd_sc_hd__o211a_1
XFILLER_0_96_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12730_ _04153_ _04156_ _04157_ VGND VGND VPWR VPWR _04158_ sky130_fd_sc_hd__or3_4
XFILLER_0_69_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12661_ _04034_ _04035_ _04026_ VGND VGND VPWR VPWR _04082_ sky130_fd_sc_hd__o21ba_1
X_11612_ net389 net869 _02856_ _02938_ VGND VGND VPWR VPWR _02939_ sky130_fd_sc_hd__a31o_1
X_14400_ _05918_ _05923_ VGND VGND VPWR VPWR _05976_ sky130_fd_sc_hd__or2b_1
X_12592_ _03988_ _03991_ _03989_ VGND VGND VPWR VPWR _04006_ sky130_fd_sc_hd__o21ba_1
X_15380_ _07045_ _07047_ VGND VGND VPWR VPWR _07048_ sky130_fd_sc_hd__xor2_2
XFILLER_0_108_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11543_ _02755_ _02758_ VGND VGND VPWR VPWR _02864_ sky130_fd_sc_hd__nand2_1
X_14331_ net521 net533 net542 net436 VGND VGND VPWR VPWR _05900_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_53_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14262_ _05815_ _05818_ _05817_ VGND VGND VPWR VPWR _05824_ sky130_fd_sc_hd__o21ai_1
X_11474_ _02682_ _02683_ VGND VGND VPWR VPWR _02789_ sky130_fd_sc_hd__and2b_1
XFILLER_0_40_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13213_ _04582_ _04584_ _04583_ net212 VGND VGND VPWR VPWR _04685_ sky130_fd_sc_hd__a22o_1
X_16001_ _07670_ _07674_ VGND VGND VPWR VPWR _07722_ sky130_fd_sc_hd__nor2_1
X_10425_ _01678_ _01679_ _01688_ VGND VGND VPWR VPWR _01689_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_33_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14193_ _05748_ _05749_ VGND VGND VPWR VPWR _05750_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13144_ _04543_ _04608_ _04609_ VGND VGND VPWR VPWR _04610_ sky130_fd_sc_hd__nand3_2
X_10356_ net383 net785 net793 net372 VGND VGND VPWR VPWR _01620_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_148_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13075_ net807 net249 _04428_ _04427_ VGND VGND VPWR VPWR _04535_ sky130_fd_sc_hd__a31oi_2
X_10287_ _01558_ _01559_ VGND VGND VPWR VPWR _01560_ sky130_fd_sc_hd__nor2_1
X_12026_ _03238_ _03316_ VGND VGND VPWR VPWR _03390_ sky130_fd_sc_hd__nand2_1
X_13977_ _05365_ _05443_ VGND VGND VPWR VPWR _05517_ sky130_fd_sc_hd__or2_1
XFILLER_0_87_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15716_ _07342_ _07343_ _07411_ net120 VGND VGND VPWR VPWR _07414_ sky130_fd_sc_hd__a211oi_1
X_12928_ _04369_ _04373_ _04374_ VGND VGND VPWR VPWR _04375_ sky130_fd_sc_hd__and3_1
XFILLER_0_76_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15647_ b_cos\[9\] _07338_ _06949_ VGND VGND VPWR VPWR _07339_ sky130_fd_sc_hd__mux2_1
X_12859_ _04279_ _04298_ _04299_ VGND VGND VPWR VPWR _04300_ sky130_fd_sc_hd__and3_1
XFILLER_0_146_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15578_ net356 net642 _07260_ _07261_ VGND VGND VPWR VPWR _07263_ sky130_fd_sc_hd__nand4_1
XFILLER_0_113_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14529_ net418 net706 VGND VGND VPWR VPWR _06118_ sky130_fd_sc_hd__and2_1
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08952_ _00169_ _00240_ _00269_ _00270_ VGND VGND VPWR VPWR _00271_ sky130_fd_sc_hd__a211oi_4
XPHY_EDGE_ROW_102_Left_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08883_ net274 net571 net580 net268 VGND VGND VPWR VPWR _00202_ sky130_fd_sc_hd__a22o_1
XFILLER_0_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09504_ _00647_ _00736_ VGND VGND VPWR VPWR _00817_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09435_ _00746_ _00747_ VGND VGND VPWR VPWR _00748_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_111_Left_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09366_ net194 _00613_ _00614_ VGND VGND VPWR VPWR _00680_ sky130_fd_sc_hd__nand3_1
XFILLER_0_75_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08317_ _04393_ _04447_ _04404_ VGND VGND VPWR VPWR _04469_ sky130_fd_sc_hd__nand3_1
XFILLER_0_129_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_40 net817 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_09297_ _00592_ _00611_ VGND VGND VPWR VPWR _00612_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_145_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_51 net355 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_62 net164 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08248_ _03593_ _03604_ _03701_ VGND VGND VPWR VPWR _03712_ sky130_fd_sc_hd__and3_1
XFILLER_0_117_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08179_ net188 net547 net557 net177 VGND VGND VPWR VPWR _02964_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_104_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10210_ b_cos\[0\] a_sin\[0\] VGND VGND VPWR VPWR _01494_ sky130_fd_sc_hd__nand2b_1
X_11190_ _02477_ _02478_ _02412_ VGND VGND VPWR VPWR _02480_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_120_Left_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10141_ _01435_ VGND VGND VPWR VPWR _00027_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_100_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10072_ _01307_ _01375_ VGND VGND VPWR VPWR _01376_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_27_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13900_ _05407_ _05408_ _05430_ _05431_ VGND VGND VPWR VPWR _05433_ sky130_fd_sc_hd__nand4_2
X_14880_ _06493_ _06502_ VGND VGND VPWR VPWR _06503_ sky130_fd_sc_hd__xor2_2
X_13831_ _05356_ _05357_ VGND VGND VPWR VPWR _05358_ sky130_fd_sc_hd__nor2_1
X_10974_ _02240_ _02243_ VGND VGND VPWR VPWR _02244_ sky130_fd_sc_hd__xnor2_1
X_13762_ _05280_ _05281_ _05282_ VGND VGND VPWR VPWR _05283_ sky130_fd_sc_hd__or3_1
X_15501_ _07177_ _07178_ VGND VGND VPWR VPWR _07179_ sky130_fd_sc_hd__xnor2_2
X_12713_ net805 net198 VGND VGND VPWR VPWR _04139_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13693_ _05207_ VGND VGND VPWR VPWR _00086_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_127_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15432_ _07102_ _07103_ VGND VGND VPWR VPWR _07104_ sky130_fd_sc_hd__nand2_2
X_12644_ _04060_ _04062_ VGND VGND VPWR VPWR _04063_ sky130_fd_sc_hd__xor2_2
XFILLER_0_150_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12575_ net756 net216 net207 net765 VGND VGND VPWR VPWR _03988_ sky130_fd_sc_hd__a22oi_2
X_15363_ _07027_ _07028_ VGND VGND VPWR VPWR _07029_ sky130_fd_sc_hd__and2_1
XFILLER_0_80_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14314_ net360 net707 VGND VGND VPWR VPWR _05881_ sky130_fd_sc_hd__nand2_1
X_11526_ _02836_ _02843_ _02845_ VGND VGND VPWR VPWR _02846_ sky130_fd_sc_hd__nand3_1
XFILLER_0_41_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15294_ _06951_ _06947_ _06952_ VGND VGND VPWR VPWR _06953_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_34_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14245_ _05800_ _05805_ VGND VGND VPWR VPWR _05807_ sky130_fd_sc_hd__xnor2_1
X_11457_ _02767_ _02769_ _02770_ VGND VGND VPWR VPWR _02771_ sky130_fd_sc_hd__a21o_1
XFILLER_0_68_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10408_ net393 net760 VGND VGND VPWR VPWR _01672_ sky130_fd_sc_hd__nand2_1
X_14176_ _05476_ _05731_ VGND VGND VPWR VPWR _05732_ sky130_fd_sc_hd__xor2_1
X_11388_ _02498_ _02691_ _02695_ VGND VGND VPWR VPWR _02696_ sky130_fd_sc_hd__a21oi_1
X_13127_ _04588_ _04590_ _04591_ VGND VGND VPWR VPWR _04592_ sky130_fd_sc_hd__or3_1
X_10339_ b_cos\[18\] a_sin\[18\] VGND VGND VPWR VPWR _01605_ sky130_fd_sc_hd__xnor2_1
X_13058_ _04422_ _04516_ VGND VGND VPWR VPWR _04517_ sky130_fd_sc_hd__xnor2_1
X_12009_ _03369_ _03370_ VGND VGND VPWR VPWR _03371_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09220_ net200 net629 net620 net209 VGND VGND VPWR VPWR _00536_ sky130_fd_sc_hd__a22o_1
XFILLER_0_146_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09151_ _00383_ _00467_ VGND VGND VPWR VPWR _00468_ sky130_fd_sc_hd__xor2_2
XFILLER_0_72_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09082_ net562 _00397_ _00398_ VGND VGND VPWR VPWR _00399_ sky130_fd_sc_hd__a21bo_2
XFILLER_0_44_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput60 sin[10] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__buf_1
XFILLER_0_102_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput71 sin[3] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__buf_1
XFILLER_0_141_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09984_ _01288_ _01289_ VGND VGND VPWR VPWR _01290_ sky130_fd_sc_hd__xnor2_1
X_08935_ net648 _00252_ _00253_ VGND VGND VPWR VPWR _00254_ sky130_fd_sc_hd__a21bo_1
X_08866_ _08080_ _08082_ VGND VGND VPWR VPWR _00186_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08797_ _08036_ _08038_ _00115_ VGND VGND VPWR VPWR _00117_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_74_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09418_ _00658_ _00731_ VGND VGND VPWR VPWR _00732_ sky130_fd_sc_hd__xnor2_2
X_10690_ _01946_ _01953_ VGND VGND VPWR VPWR _01954_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_137_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09349_ net267 net535 net545 net258 VGND VGND VPWR VPWR _00663_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_63_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12360_ net729 net197 VGND VGND VPWR VPWR _03751_ sky130_fd_sc_hd__nand2_1
XFILLER_0_62_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11311_ _02530_ _02545_ _02546_ _02549_ VGND VGND VPWR VPWR _02611_ sky130_fd_sc_hd__a31o_1
X_12291_ _03673_ _03675_ VGND VGND VPWR VPWR _03676_ sky130_fd_sc_hd__xor2_1
XFILLER_0_132_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14030_ _05572_ _05573_ VGND VGND VPWR VPWR _05574_ sky130_fd_sc_hd__nor2_1
X_11242_ net715 net351 net503 net722 VGND VGND VPWR VPWR _02536_ sky130_fd_sc_hd__a22o_1
X_11173_ _02458_ _02459_ _02457_ VGND VGND VPWR VPWR _02461_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_30_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10124_ _01412_ _01415_ _01413_ VGND VGND VPWR VPWR _01421_ sky130_fd_sc_hd__a21boi_1
X_15981_ _07699_ _07700_ VGND VGND VPWR VPWR _07701_ sky130_fd_sc_hd__nor2_1
X_10055_ _01357_ _01358_ VGND VGND VPWR VPWR _01359_ sky130_fd_sc_hd__xnor2_1
X_14932_ _06557_ _06558_ VGND VGND VPWR VPWR _06559_ sky130_fd_sc_hd__xor2_1
XFILLER_0_89_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14863_ _06474_ _06482_ _06483_ VGND VGND VPWR VPWR _06484_ sky130_fd_sc_hd__nand3_1
X_13814_ net718 net248 VGND VGND VPWR VPWR _05339_ sky130_fd_sc_hd__nand2_1
XFILLER_0_98_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14794_ _06407_ _06408_ VGND VGND VPWR VPWR _06409_ sky130_fd_sc_hd__nor2_1
XFILLER_0_85_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13745_ _05258_ _05263_ VGND VGND VPWR VPWR _05265_ sky130_fd_sc_hd__xnor2_2
X_10957_ _02222_ _02224_ _02203_ _02204_ VGND VGND VPWR VPWR _02226_ sky130_fd_sc_hd__a211o_1
X_13676_ _05187_ _05189_ VGND VGND VPWR VPWR _05190_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10888_ _02149_ _02150_ _02151_ VGND VGND VPWR VPWR _02152_ sky130_fd_sc_hd__nand3_1
XFILLER_0_39_884 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15415_ _07083_ _07084_ VGND VGND VPWR VPWR _07086_ sky130_fd_sc_hd__nor2_1
XFILLER_0_26_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12627_ _04043_ _04044_ VGND VGND VPWR VPWR _04045_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15346_ _07005_ _07008_ _07010_ VGND VGND VPWR VPWR _07011_ sky130_fd_sc_hd__nand3_1
X_12558_ _03917_ _03920_ _03919_ VGND VGND VPWR VPWR _03969_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_81_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11509_ _02808_ _02826_ VGND VGND VPWR VPWR _02827_ sky130_fd_sc_hd__xnor2_2
X_15277_ _06882_ _06935_ VGND VGND VPWR VPWR _06936_ sky130_fd_sc_hd__xor2_2
X_12489_ net765 net774 net190 net180 VGND VGND VPWR VPWR _03893_ sky130_fd_sc_hd__and4_1
XFILLER_0_123_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14228_ _05780_ _05787_ VGND VGND VPWR VPWR _05788_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_111_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14159_ _05656_ _05651_ _05712_ VGND VGND VPWR VPWR _05714_ sky130_fd_sc_hd__a21oi_1
Xfanout609 net610 VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__clkbuf_4
X_08720_ _07900_ _07910_ _07921_ VGND VGND VPWR VPWR _08031_ sky130_fd_sc_hd__o21bai_1
X_08651_ _07958_ _07961_ _07962_ VGND VGND VPWR VPWR _07963_ sky130_fd_sc_hd__and3_1
X_08582_ _06922_ _07259_ _07216_ _07249_ VGND VGND VPWR VPWR _07357_ sky130_fd_sc_hd__a211o_1
XFILLER_0_49_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09203_ _00517_ _00518_ VGND VGND VPWR VPWR _00519_ sky130_fd_sc_hd__and2b_1
XFILLER_0_119_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09134_ net620 _00447_ _00448_ _00449_ _00450_ VGND VGND VPWR VPWR _00451_ sky130_fd_sc_hd__a32o_1
XFILLER_0_146_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09065_ _00297_ _00281_ _00381_ _00382_ VGND VGND VPWR VPWR _00383_ sky130_fd_sc_hd__o211a_2
XFILLER_0_142_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09967_ _01192_ _01191_ VGND VGND VPWR VPWR _01273_ sky130_fd_sc_hd__or2b_1
X_08918_ _00218_ _00235_ _00236_ VGND VGND VPWR VPWR _00237_ sky130_fd_sc_hd__and3_1
X_09898_ net277 net627 net618 net286 VGND VGND VPWR VPWR _01205_ sky130_fd_sc_hd__a22oi_1
X_08849_ _00166_ _00167_ _00168_ VGND VGND VPWR VPWR _00169_ sky130_fd_sc_hd__nand3_4
X_11860_ _03095_ _03098_ _03096_ VGND VGND VPWR VPWR _03209_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_95_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10811_ _02073_ _02074_ VGND VGND VPWR VPWR _02075_ sky130_fd_sc_hd__nor2_1
X_11791_ _03011_ _03012_ VGND VGND VPWR VPWR _03134_ sky130_fd_sc_hd__or2_1
X_13530_ _04957_ _04973_ _04974_ _04977_ VGND VGND VPWR VPWR _05030_ sky130_fd_sc_hd__a31o_1
XFILLER_0_94_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10742_ _01985_ _01986_ _02004_ _02005_ VGND VGND VPWR VPWR _02006_ sky130_fd_sc_hd__or4_4
XFILLER_0_138_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13461_ _04934_ _04954_ VGND VGND VPWR VPWR _04955_ sky130_fd_sc_hd__xor2_2
X_10673_ net412 net401 net725 net734 VGND VGND VPWR VPWR _01937_ sky130_fd_sc_hd__and4_1
X_15200_ _06849_ _06850_ _06740_ _06742_ VGND VGND VPWR VPWR _06852_ sky130_fd_sc_hd__a211oi_1
X_12412_ _03786_ _03790_ _03806_ _03807_ VGND VGND VPWR VPWR _03808_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_125_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16180_ _07915_ _07886_ _07860_ VGND VGND VPWR VPWR _07916_ sky130_fd_sc_hd__o21ai_1
X_13392_ _04860_ _04879_ VGND VGND VPWR VPWR _04880_ sky130_fd_sc_hd__xor2_2
X_15131_ _06772_ _06773_ _06774_ VGND VGND VPWR VPWR _06776_ sky130_fd_sc_hd__a21o_1
X_12343_ net765 net171 VGND VGND VPWR VPWR _03732_ sky130_fd_sc_hd__nand2_1
XFILLER_0_106_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15062_ net388 net377 net673 net683 VGND VGND VPWR VPWR _06701_ sky130_fd_sc_hd__nand4_2
X_12274_ _03616_ _03619_ _03622_ VGND VGND VPWR VPWR _03657_ sky130_fd_sc_hd__o21a_1
X_14013_ net139 net287 net278 net148 VGND VGND VPWR VPWR _05555_ sky130_fd_sc_hd__a22oi_2
X_11225_ _02515_ _02516_ VGND VGND VPWR VPWR _02518_ sky130_fd_sc_hd__xnor2_1
X_11156_ net428 net513 net390 net379 VGND VGND VPWR VPWR _02443_ sky130_fd_sc_hd__nand4_2
XFILLER_0_4_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10107_ a_cos\[4\] b_sin\[4\] VGND VGND VPWR VPWR _01406_ sky130_fd_sc_hd__nor2_1
X_15964_ _07681_ VGND VGND VPWR VPWR _07682_ sky130_fd_sc_hd__clkbuf_2
X_11087_ _02364_ net842 _02329_ VGND VGND VPWR VPWR _02368_ sky130_fd_sc_hd__o21ai_2
X_10038_ _01261_ _01277_ _01342_ VGND VGND VPWR VPWR _01343_ sky130_fd_sc_hd__a21oi_1
X_14915_ _06442_ _06441_ _06539_ _06540_ VGND VGND VPWR VPWR _06542_ sky130_fd_sc_hd__nand4_1
X_15895_ _07605_ _07606_ VGND VGND VPWR VPWR _07608_ sky130_fd_sc_hd__nor2_2
X_14846_ _06463_ _06465_ VGND VGND VPWR VPWR _06466_ sky130_fd_sc_hd__nor2_1
XFILLER_0_81_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14777_ _06371_ _06372_ _06389_ VGND VGND VPWR VPWR _06391_ sky130_fd_sc_hd__nand3_2
X_11989_ _03195_ _03271_ _03250_ VGND VGND VPWR VPWR _03349_ sky130_fd_sc_hd__a21oi_4
X_13728_ _05243_ _05244_ VGND VGND VPWR VPWR _05246_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13659_ _05164_ _05170_ VGND VGND VPWR VPWR _05171_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_144_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_140_Right_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15329_ _06988_ _06989_ _06990_ VGND VGND VPWR VPWR _06992_ sky130_fd_sc_hd__nand3_1
XFILLER_0_112_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout406 net414 VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__clkbuf_4
Xfanout417 net50 VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__clkbuf_4
X_09821_ _01079_ _01082_ _01127_ VGND VGND VPWR VPWR _01129_ sky130_fd_sc_hd__o21a_1
Xfanout428 net430 VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__clkbuf_4
Xfanout439 net49 VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09752_ _01018_ _01023_ VGND VGND VPWR VPWR _01061_ sky130_fd_sc_hd__and2b_1
X_08703_ _08012_ _08013_ VGND VGND VPWR VPWR _08014_ sky130_fd_sc_hd__nand2_1
X_09683_ net303 net627 net618 net157 VGND VGND VPWR VPWR _00993_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_55_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08634_ net160 net307 net553 net563 VGND VGND VPWR VPWR _07921_ sky130_fd_sc_hd__and4_1
XFILLER_0_49_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08565_ _07129_ _07140_ _07161_ VGND VGND VPWR VPWR _07172_ sky130_fd_sc_hd__nand3_1
X_08496_ _06234_ _06245_ _06399_ VGND VGND VPWR VPWR _06421_ sky130_fd_sc_hd__nand3_1
XFILLER_0_49_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09117_ net193 net658 _00355_ _00354_ VGND VGND VPWR VPWR _00434_ sky130_fd_sc_hd__a31o_1
XFILLER_0_150_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_143_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09048_ _00255_ _00263_ _00262_ VGND VGND VPWR VPWR _00366_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_102_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11010_ _02281_ _02283_ VGND VGND VPWR VPWR _02284_ sky130_fd_sc_hd__nand2_1
XFILLER_0_130_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12961_ _04408_ _04409_ _04326_ _04309_ VGND VGND VPWR VPWR _04411_ sky130_fd_sc_hd__a211o_1
X_14700_ net382 net541 net549 net371 VGND VGND VPWR VPWR _06306_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_99_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11912_ _03256_ _03264_ VGND VGND VPWR VPWR _03265_ sky130_fd_sc_hd__xnor2_1
X_15680_ _07371_ _07372_ _07258_ VGND VGND VPWR VPWR _07374_ sky130_fd_sc_hd__a21oi_1
X_12892_ _04328_ _04334_ VGND VGND VPWR VPWR _04335_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14631_ _06227_ _06228_ _06183_ _06196_ VGND VGND VPWR VPWR _06230_ sky130_fd_sc_hd__o211a_1
X_11843_ _03115_ _03119_ VGND VGND VPWR VPWR _03190_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14562_ net354 net587 net597 net506 VGND VGND VPWR VPWR _06154_ sky130_fd_sc_hd__a22o_1
X_11774_ net378 net367 net802 VGND VGND VPWR VPWR _03115_ sky130_fd_sc_hd__nand3_2
X_16301_ clknet_4_2_0_clk _00090_ net332 VGND VGND VPWR VPWR a_sin\[13\] sky130_fd_sc_hd__dfrtp_1
X_13513_ _04859_ _04914_ _05011_ VGND VGND VPWR VPWR _05012_ sky130_fd_sc_hd__a21oi_2
X_10725_ _01947_ _01952_ VGND VGND VPWR VPWR _01989_ sky130_fd_sc_hd__or2b_1
X_14493_ _06076_ _06075_ _06077_ VGND VGND VPWR VPWR _06078_ sky130_fd_sc_hd__nand3_1
XFILLER_0_55_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16232_ clknet_4_15_0_clk _00021_ net344 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dfrtp_1
X_13444_ _04860_ _04879_ _04935_ VGND VGND VPWR VPWR _04936_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_126_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10656_ _01730_ _01732_ VGND VGND VPWR VPWR _01920_ sky130_fd_sc_hd__nor2_1
XFILLER_0_36_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16163_ _07846_ _07896_ VGND VGND VPWR VPWR _07898_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13375_ _04786_ _04794_ _04792_ VGND VGND VPWR VPWR _04862_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_106_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10587_ _01783_ _01817_ _01785_ VGND VGND VPWR VPWR _01851_ sky130_fd_sc_hd__nand3_1
XFILLER_0_140_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15114_ _06667_ _06652_ VGND VGND VPWR VPWR _06757_ sky130_fd_sc_hd__and2b_1
X_12326_ _03707_ _03711_ _03713_ VGND VGND VPWR VPWR _03714_ sky130_fd_sc_hd__nand3_1
XFILLER_0_23_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16094_ _07819_ _07822_ VGND VGND VPWR VPWR _07823_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15045_ net502 net537 VGND VGND VPWR VPWR _06683_ sky130_fd_sc_hd__and2_1
X_12257_ _03515_ _03581_ VGND VGND VPWR VPWR _03640_ sky130_fd_sc_hd__nand2_1
X_11208_ a_cos\[3\] _02499_ _02383_ VGND VGND VPWR VPWR _02500_ sky130_fd_sc_hd__mux2_1
X_12188_ _03563_ _03564_ VGND VGND VPWR VPWR _03565_ sky130_fd_sc_hd__xnor2_1
X_11139_ net731 net503 VGND VGND VPWR VPWR _02424_ sky130_fd_sc_hd__and2_1
X_15947_ net456 net448 net660 net671 VGND VGND VPWR VPWR _07664_ sky130_fd_sc_hd__and4_1
XFILLER_0_78_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15878_ net441 net687 VGND VGND VPWR VPWR _07589_ sky130_fd_sc_hd__nand2_1
X_14829_ b_cos\[0\] _06447_ _05291_ VGND VGND VPWR VPWR _06448_ sky130_fd_sc_hd__mux2_1
XFILLER_0_59_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08350_ _04752_ _04807_ _04763_ VGND VGND VPWR VPWR _04829_ sky130_fd_sc_hd__nand3_1
XFILLER_0_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08281_ _04020_ _04031_ _04064_ VGND VGND VPWR VPWR _04075_ sky130_fd_sc_hd__nor3b_2
XFILLER_0_128_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_879 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout203 net72 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__buf_2
Xfanout214 net839 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout225 net70 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__buf_4
Xfanout236 net239 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__buf_6
Xfanout247 net248 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__buf_4
X_09804_ _00983_ _00981_ _01045_ VGND VGND VPWR VPWR _01113_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_5_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout258 net260 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__buf_2
Xfanout269 net65 VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__clkbuf_2
X_09735_ _01043_ _01044_ VGND VGND VPWR VPWR _01045_ sky130_fd_sc_hd__xnor2_2
X_09666_ _00828_ _00826_ _00900_ VGND VGND VPWR VPWR _00977_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_97_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08617_ _07716_ _07726_ VGND VGND VPWR VPWR _07737_ sky130_fd_sc_hd__or2_1
X_09597_ _00853_ _00860_ VGND VGND VPWR VPWR _00908_ sky130_fd_sc_hd__and2_1
XFILLER_0_82_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08548_ _06944_ _06965_ net873 _06976_ VGND VGND VPWR VPWR _06987_ sky130_fd_sc_hd__a211o_1
XFILLER_0_65_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08479_ _05893_ _05806_ net874 VGND VGND VPWR VPWR _06234_ sky130_fd_sc_hd__nand3_1
XFILLER_0_107_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10510_ _01770_ _01772_ _01773_ VGND VGND VPWR VPWR _01774_ sky130_fd_sc_hd__nor3_1
XFILLER_0_24_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11490_ _02719_ _02721_ VGND VGND VPWR VPWR _02806_ sky130_fd_sc_hd__nor2_1
XFILLER_0_123_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10441_ net393 net751 VGND VGND VPWR VPWR _01705_ sky130_fd_sc_hd__nand2_1
XFILLER_0_122_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13160_ _04420_ _04625_ _04627_ VGND VGND VPWR VPWR _04628_ sky130_fd_sc_hd__o21a_1
X_10372_ _01633_ _01634_ _01635_ VGND VGND VPWR VPWR _01636_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_33_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12111_ net511 _02388_ VGND VGND VPWR VPWR _03481_ sky130_fd_sc_hd__or2_1
XFILLER_0_131_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13091_ _04548_ _04551_ VGND VGND VPWR VPWR _04552_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_130_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12042_ net511 net441 VGND VGND VPWR VPWR _03406_ sky130_fd_sc_hd__nand2_1
XFILLER_0_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15801_ _07493_ _07492_ VGND VGND VPWR VPWR _07505_ sky130_fd_sc_hd__and2b_1
Xfanout770 net771 VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__clkbuf_4
Xfanout781 net783 VGND VGND VPWR VPWR net781 sky130_fd_sc_hd__buf_2
Xfanout792 net796 VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__clkbuf_4
X_13993_ _05531_ _05532_ VGND VGND VPWR VPWR _05533_ sky130_fd_sc_hd__nor2_1
X_15732_ net865 net866 net661 net671 VGND VGND VPWR VPWR _07430_ sky130_fd_sc_hd__and4_1
X_12944_ _04388_ _04389_ _04390_ VGND VGND VPWR VPWR _04392_ sky130_fd_sc_hd__a21o_1
X_15663_ net497 net661 _07353_ _07354_ VGND VGND VPWR VPWR _07355_ sky130_fd_sc_hd__a22o_1
X_12875_ _04314_ _04316_ VGND VGND VPWR VPWR _04318_ sky130_fd_sc_hd__xnor2_2
X_14614_ _06207_ _06210_ VGND VGND VPWR VPWR _06211_ sky130_fd_sc_hd__xnor2_2
X_11826_ _03114_ _03121_ _03120_ VGND VGND VPWR VPWR _03172_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_68_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15594_ net348 net651 net661 net499 VGND VGND VPWR VPWR _07280_ sky130_fd_sc_hd__a22o_1
XFILLER_0_56_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14545_ _05939_ _06049_ _06081_ VGND VGND VPWR VPWR _06136_ sky130_fd_sc_hd__a21o_1
X_11757_ _03095_ _03096_ VGND VGND VPWR VPWR _03097_ sky130_fd_sc_hd__nor2_1
XFILLER_0_126_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10708_ _01956_ _01970_ _01971_ VGND VGND VPWR VPWR _01972_ sky130_fd_sc_hd__nand3_2
X_14476_ net519 net577 net586 net434 VGND VGND VPWR VPWR _06060_ sky130_fd_sc_hd__a22o_1
XFILLER_0_43_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11688_ net512 net485 net475 net613 VGND VGND VPWR VPWR _03022_ sky130_fd_sc_hd__a22oi_1
X_16215_ clknet_4_8_0_clk _00004_ net341 VGND VGND VPWR VPWR b_sin\[4\] sky130_fd_sc_hd__dfrtp_2
XFILLER_0_11_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13427_ _04915_ _04918_ VGND VGND VPWR VPWR _04919_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_126_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10639_ _01819_ _01900_ _01901_ VGND VGND VPWR VPWR _01903_ sky130_fd_sc_hd__nor3_1
XFILLER_0_141_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16146_ _07877_ _07879_ VGND VGND VPWR VPWR _07880_ sky130_fd_sc_hd__nor2_1
X_13358_ net745 net267 net258 net754 VGND VGND VPWR VPWR _04843_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_87_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12309_ net712 net834 net837 net721 VGND VGND VPWR VPWR _03695_ sky130_fd_sc_hd__a22oi_2
X_16077_ _07741_ _07742_ VGND VGND VPWR VPWR _07805_ sky130_fd_sc_hd__or2_1
X_13289_ net745 net276 VGND VGND VPWR VPWR _04768_ sky130_fd_sc_hd__nand2_1
X_15028_ _06456_ _06561_ _06560_ VGND VGND VPWR VPWR _06664_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 alpha[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09520_ net166 net638 _00769_ _00768_ VGND VGND VPWR VPWR _00832_ sky130_fd_sc_hd__a31o_1
XFILLER_0_79_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09451_ _00690_ _00692_ VGND VGND VPWR VPWR _00764_ sky130_fd_sc_hd__nand2_1
XFILLER_0_149_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08402_ _05220_ _05253_ _05231_ VGND VGND VPWR VPWR _05394_ sky130_fd_sc_hd__o21ba_1
X_09382_ _00693_ _00694_ _00686_ VGND VGND VPWR VPWR _00696_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_93_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08333_ _04589_ _04632_ VGND VGND VPWR VPWR _04643_ sky130_fd_sc_hd__nand2_1
X_08264_ net293 net590 net600 net283 VGND VGND VPWR VPWR _03888_ sky130_fd_sc_hd__a22o_1
XFILLER_0_7_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08195_ net163 net582 net590 net307 VGND VGND VPWR VPWR _03138_ sky130_fd_sc_hd__a22o_1
XFILLER_0_116_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09718_ _00952_ _00951_ VGND VGND VPWR VPWR _01028_ sky130_fd_sc_hd__and2b_1
X_10990_ _02157_ _02228_ _02260_ _02261_ VGND VGND VPWR VPWR _02262_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09649_ _00944_ _00959_ VGND VGND VPWR VPWR _00960_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12660_ _04072_ _04079_ _04080_ VGND VGND VPWR VPWR _04081_ sky130_fd_sc_hd__nand3_2
XFILLER_0_84_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11611_ net406 net396 net803 VGND VGND VPWR VPWR _02938_ sky130_fd_sc_hd__and3_1
XFILLER_0_93_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12591_ _04002_ _04003_ _04004_ VGND VGND VPWR VPWR _04005_ sky130_fd_sc_hd__nand3_4
XFILLER_0_37_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14330_ net419 net550 VGND VGND VPWR VPWR _05899_ sky130_fd_sc_hd__nand2_1
XFILLER_0_108_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11542_ _02859_ _02860_ _02861_ VGND VGND VPWR VPWR _02863_ sky130_fd_sc_hd__nand3_1
XFILLER_0_92_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14261_ _05820_ _05821_ _05822_ VGND VGND VPWR VPWR _05823_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_107_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11473_ _02727_ _02787_ VGND VGND VPWR VPWR _02788_ sky130_fd_sc_hd__xor2_2
XFILLER_0_80_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16000_ _07715_ _07714_ VGND VGND VPWR VPWR _07721_ sky130_fd_sc_hd__and2b_1
X_13212_ _04574_ _04576_ VGND VGND VPWR VPWR _04684_ sky130_fd_sc_hd__nand2_1
XFILLER_0_123_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10424_ _01686_ _01687_ VGND VGND VPWR VPWR _01688_ sky130_fd_sc_hd__xnor2_2
X_14192_ _05740_ _05747_ VGND VGND VPWR VPWR _05749_ sky130_fd_sc_hd__nand2_1
XFILLER_0_104_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13143_ _04606_ _04607_ _04499_ _04544_ VGND VGND VPWR VPWR _04609_ sky130_fd_sc_hd__a211o_1
X_10355_ net363 net810 VGND VGND VPWR VPWR _01619_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13074_ _04526_ _04532_ VGND VGND VPWR VPWR _04533_ sky130_fd_sc_hd__xor2_1
X_10286_ b_cos\[11\] a_sin\[11\] VGND VGND VPWR VPWR _01559_ sky130_fd_sc_hd__and2b_1
X_12025_ _03386_ _03387_ VGND VGND VPWR VPWR _03389_ sky130_fd_sc_hd__or2_1
XFILLER_0_73_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13976_ _05446_ _05515_ VGND VGND VPWR VPWR _05516_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15715_ _07387_ _07388_ _07410_ VGND VGND VPWR VPWR _07413_ sky130_fd_sc_hd__nor3_1
X_12927_ net729 net170 _04370_ _04372_ VGND VGND VPWR VPWR _04374_ sky130_fd_sc_hd__nand4_1
X_15646_ _07329_ _07337_ VGND VGND VPWR VPWR _07338_ sky130_fd_sc_hd__xnor2_1
X_12858_ _04294_ _04296_ _04297_ VGND VGND VPWR VPWR _04299_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11809_ _03136_ _03153_ VGND VGND VPWR VPWR _03154_ sky130_fd_sc_hd__xnor2_1
X_15577_ net356 net642 _07260_ _07261_ VGND VGND VPWR VPWR _07262_ sky130_fd_sc_hd__a22o_1
X_12789_ _04167_ _04084_ _04085_ _04132_ VGND VGND VPWR VPWR _04223_ sky130_fd_sc_hd__and4_1
XFILLER_0_83_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14528_ net519 net596 net606 net434 VGND VGND VPWR VPWR _06117_ sky130_fd_sc_hd__a22o_1
XFILLER_0_125_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14459_ _06026_ _06027_ _06039_ VGND VGND VPWR VPWR _06041_ sky130_fd_sc_hd__nor3b_2
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16129_ _07859_ _07860_ VGND VGND VPWR VPWR _07861_ sky130_fd_sc_hd__and2_1
XFILLER_0_11_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08951_ _00267_ _00268_ _00250_ VGND VGND VPWR VPWR _00270_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_121_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08882_ net259 net589 VGND VGND VPWR VPWR _00201_ sky130_fd_sc_hd__nand2_1
XFILLER_0_138_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09503_ _00287_ _00386_ _00288_ _00292_ VGND VGND VPWR VPWR _00816_ sky130_fd_sc_hd__or4b_4
XFILLER_0_149_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09434_ net272 net696 VGND VGND VPWR VPWR _00747_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09365_ net194 net621 _00613_ _00614_ VGND VGND VPWR VPWR _00679_ sky130_fd_sc_hd__a22o_1
X_08316_ _04393_ _04404_ _04447_ VGND VGND VPWR VPWR _04458_ sky130_fd_sc_hd__a21o_1
XFILLER_0_47_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09296_ _00609_ _00610_ VGND VGND VPWR VPWR _00611_ sky130_fd_sc_hd__nand2_1
XANTENNA_30 net579 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_41 _05587_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_52 net865 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_63 net355 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08247_ _03615_ _03690_ VGND VGND VPWR VPWR _03701_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_132_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08178_ net188 net177 net547 net557 VGND VGND VPWR VPWR _02953_ sky130_fd_sc_hd__and4_1
XFILLER_0_30_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10140_ net96 _01434_ net138 VGND VGND VPWR VPWR _01435_ sky130_fd_sc_hd__mux2_1
XFILLER_0_101_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10071_ _01373_ _01374_ VGND VGND VPWR VPWR _01375_ sky130_fd_sc_hd__xnor2_1
X_13830_ _05354_ _05355_ _05252_ _05279_ VGND VGND VPWR VPWR _05357_ sky130_fd_sc_hd__a211oi_1
X_13761_ _05163_ _05179_ _05181_ VGND VGND VPWR VPWR _05282_ sky130_fd_sc_hd__o21a_1
X_10973_ _02241_ _02242_ VGND VGND VPWR VPWR _02243_ sky130_fd_sc_hd__nor2_1
X_15500_ _02385_ net567 VGND VGND VPWR VPWR _07178_ sky130_fd_sc_hd__nor2_1
XFILLER_0_97_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12712_ _04136_ _04137_ VGND VGND VPWR VPWR _04138_ sky130_fd_sc_hd__nor2_1
X_13692_ a_sin\[9\] _05206_ _03521_ VGND VGND VPWR VPWR _05207_ sky130_fd_sc_hd__mux2_1
XFILLER_0_128_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15431_ _07100_ _07101_ _07081_ VGND VGND VPWR VPWR _07103_ sky130_fd_sc_hd__a21o_1
X_12643_ _04011_ _04061_ VGND VGND VPWR VPWR _04062_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_66_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15362_ _07023_ _07024_ _07026_ VGND VGND VPWR VPWR _07028_ sky130_fd_sc_hd__a21o_1
XFILLER_0_108_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12574_ _03936_ _03985_ VGND VGND VPWR VPWR _03986_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_81_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14313_ net391 net595 _05828_ _05826_ VGND VGND VPWR VPWR _05880_ sky130_fd_sc_hd__a31o_1
X_11525_ _02840_ _02841_ _02842_ VGND VGND VPWR VPWR _02845_ sky130_fd_sc_hd__a21o_1
X_15293_ _06851_ _06940_ VGND VGND VPWR VPWR _06952_ sky130_fd_sc_hd__nand2_1
XFILLER_0_80_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14244_ _05803_ _05804_ VGND VGND VPWR VPWR _05805_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11456_ net416 _02570_ _02669_ _01891_ VGND VGND VPWR VPWR _02770_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_150_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10407_ _01669_ _01670_ VGND VGND VPWR VPWR _01671_ sky130_fd_sc_hd__nor2_1
X_14175_ _05728_ _05729_ VGND VGND VPWR VPWR _05731_ sky130_fd_sc_hd__or2_1
XFILLER_0_1_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11387_ _02492_ _02693_ _02694_ VGND VGND VPWR VPWR _02695_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_21_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13126_ net799 net321 net68 VGND VGND VPWR VPWR _04591_ sky130_fd_sc_hd__and3_1
X_10338_ _01596_ _01601_ _01597_ VGND VGND VPWR VPWR _01604_ sky130_fd_sc_hd__a21boi_1
X_13057_ _04414_ _04515_ VGND VGND VPWR VPWR _04516_ sky130_fd_sc_hd__xnor2_2
X_10269_ b_cos\[9\] a_sin\[9\] VGND VGND VPWR VPWR _01544_ sky130_fd_sc_hd__or2b_1
XFILLER_0_108_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12008_ _03270_ _03273_ _03276_ VGND VGND VPWR VPWR _03370_ sky130_fd_sc_hd__a21o_1
X_13959_ _05480_ _05496_ VGND VGND VPWR VPWR _05497_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_124_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15629_ _07299_ _07318_ VGND VGND VPWR VPWR _07319_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_91_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09150_ _00390_ _00466_ VGND VGND VPWR VPWR _00467_ sky130_fd_sc_hd__xor2_2
XFILLER_0_71_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09081_ net266 net562 net571 net257 VGND VGND VPWR VPWR _00398_ sky130_fd_sc_hd__a22o_1
XFILLER_0_16_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput50 cos[2] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_25_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput61 sin[11] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_142_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput72 sin[4] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09983_ _01225_ _01228_ VGND VGND VPWR VPWR _01289_ sky130_fd_sc_hd__nor2_1
XFILLER_0_149_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08934_ net210 net648 net639 net220 VGND VGND VPWR VPWR _00253_ sky130_fd_sc_hd__a22o_1
X_08865_ _00183_ _00184_ VGND VGND VPWR VPWR _00185_ sky130_fd_sc_hd__and2_1
X_08796_ _08036_ _08038_ _00115_ VGND VGND VPWR VPWR _00116_ sky130_fd_sc_hd__and3_1
XFILLER_0_98_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09417_ _00728_ _00730_ VGND VGND VPWR VPWR _00731_ sky130_fd_sc_hd__xor2_2
XFILLER_0_82_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09348_ net273 net535 _00596_ _00595_ VGND VGND VPWR VPWR _00662_ sky130_fd_sc_hd__a31o_1
XFILLER_0_63_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09279_ net289 net696 net526 net280 VGND VGND VPWR VPWR _00594_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_62_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11310_ _02522_ _02523_ _02609_ VGND VGND VPWR VPWR _02610_ sky130_fd_sc_hd__a21o_1
X_12290_ _03605_ _03623_ _03674_ VGND VGND VPWR VPWR _03675_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_132_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11241_ _02533_ _02534_ VGND VGND VPWR VPWR _02535_ sky130_fd_sc_hd__xor2_1
XFILLER_0_31_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_120_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11172_ _02457_ _02458_ _02459_ VGND VGND VPWR VPWR _02460_ sky130_fd_sc_hd__or3_1
X_10123_ _01418_ _01419_ VGND VGND VPWR VPWR _01420_ sky130_fd_sc_hd__and2b_1
X_15980_ _07682_ _07698_ VGND VGND VPWR VPWR _07700_ sky130_fd_sc_hd__nor2_1
X_10054_ _00195_ net652 VGND VGND VPWR VPWR _01358_ sky130_fd_sc_hd__nor2_1
X_14931_ net443 net708 VGND VGND VPWR VPWR _06558_ sky130_fd_sc_hd__nand2_1
X_14862_ _06479_ _06480_ _06481_ VGND VGND VPWR VPWR _06483_ sky130_fd_sc_hd__a21o_1
XFILLER_0_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13813_ _05336_ _05337_ VGND VGND VPWR VPWR _05338_ sky130_fd_sc_hd__nor2_1
X_14793_ net405 net683 net691 net395 VGND VGND VPWR VPWR _06408_ sky130_fd_sc_hd__a22oi_2
XPHY_EDGE_ROW_121_Right_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13744_ _05261_ _05262_ VGND VGND VPWR VPWR _05263_ sky130_fd_sc_hd__xnor2_2
X_10956_ _02203_ _02204_ _02222_ _02224_ VGND VGND VPWR VPWR _02225_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_70_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13675_ _05183_ _05184_ _05186_ VGND VGND VPWR VPWR _05189_ sky130_fd_sc_hd__a21oi_1
X_10887_ _02038_ _02040_ _02039_ VGND VGND VPWR VPWR _02151_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_39_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15414_ net484 net474 net698 net526 VGND VGND VPWR VPWR _07084_ sky130_fd_sc_hd__and4_1
X_12626_ net781 net198 VGND VGND VPWR VPWR _04044_ sky130_fd_sc_hd__nand2_1
X_15345_ net357 net673 _07006_ _07007_ VGND VGND VPWR VPWR _07010_ sky130_fd_sc_hd__nand4_1
XFILLER_0_26_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12557_ _03919_ _03917_ _03920_ VGND VGND VPWR VPWR _03968_ sky130_fd_sc_hd__and3_1
XFILLER_0_54_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11508_ _02824_ _02825_ VGND VGND VPWR VPWR _02826_ sky130_fd_sc_hd__xnor2_2
X_15276_ _06932_ _06934_ VGND VGND VPWR VPWR _06935_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_124_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12488_ net765 net190 net180 net774 VGND VGND VPWR VPWR _03892_ sky130_fd_sc_hd__a22oi_2
X_14227_ _05781_ _05786_ VGND VGND VPWR VPWR _05787_ sky130_fd_sc_hd__xnor2_1
X_11439_ _02749_ _02750_ VGND VGND VPWR VPWR _02751_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14158_ _05656_ _05651_ _05712_ VGND VGND VPWR VPWR _05713_ sky130_fd_sc_hd__and3_1
X_13109_ net212 _04477_ _04481_ _04478_ VGND VGND VPWR VPWR _04572_ sky130_fd_sc_hd__a22o_1
X_14089_ _05636_ _05637_ VGND VGND VPWR VPWR _05638_ sky130_fd_sc_hd__and2b_1
XFILLER_0_119_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08650_ net169 net547 _07959_ _07960_ VGND VGND VPWR VPWR _07962_ sky130_fd_sc_hd__nand4_1
X_08581_ _07270_ _07292_ _07303_ net872 VGND VGND VPWR VPWR _07346_ sky130_fd_sc_hd__a22o_1
XFILLER_0_88_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09202_ _00514_ _00515_ _00516_ VGND VGND VPWR VPWR _00518_ sky130_fd_sc_hd__a21o_1
XFILLER_0_29_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09133_ net219 VGND VGND VPWR VPWR _00450_ sky130_fd_sc_hd__inv_2
XFILLER_0_97_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09064_ _00379_ _00380_ _00299_ VGND VGND VPWR VPWR _00382_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09966_ _01270_ _01271_ VGND VGND VPWR VPWR _01272_ sky130_fd_sc_hd__nand2_1
X_08917_ _00233_ _00234_ _00219_ VGND VGND VPWR VPWR _00236_ sky130_fd_sc_hd__a21o_1
X_09897_ _01202_ _01153_ _01203_ VGND VGND VPWR VPWR _01204_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_99_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08848_ _08056_ _08064_ _08063_ VGND VGND VPWR VPWR _00168_ sky130_fd_sc_hd__a21bo_1
X_08779_ net119 _08089_ VGND VGND VPWR VPWR _08090_ sky130_fd_sc_hd__or2_1
X_10810_ net761 net353 net505 net767 VGND VGND VPWR VPWR _02074_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_94_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11790_ _03131_ _03063_ _03129_ _03130_ VGND VGND VPWR VPWR _03133_ sky130_fd_sc_hd__o211a_1
XFILLER_0_39_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10741_ _02002_ _02003_ _01987_ _01988_ VGND VGND VPWR VPWR _02005_ sky130_fd_sc_hd__o211a_1
XFILLER_0_67_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13460_ _04936_ _04953_ VGND VGND VPWR VPWR _04954_ sky130_fd_sc_hd__xor2_2
X_10672_ net393 net742 VGND VGND VPWR VPWR _01936_ sky130_fd_sc_hd__nand2_1
X_12411_ _03791_ _03792_ _03805_ VGND VGND VPWR VPWR _03807_ sky130_fd_sc_hd__and3_1
XFILLER_0_35_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13391_ _04862_ _04878_ VGND VGND VPWR VPWR _04879_ sky130_fd_sc_hd__xor2_2
XFILLER_0_63_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15130_ _06772_ _06773_ _06774_ VGND VGND VPWR VPWR _06775_ sky130_fd_sc_hd__nand3_1
X_12342_ _03699_ _03702_ _03700_ VGND VGND VPWR VPWR _03731_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_23_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15061_ net388 net673 net682 net377 VGND VGND VPWR VPWR _06700_ sky130_fd_sc_hd__a22o_1
X_12273_ _03651_ _03655_ VGND VGND VPWR VPWR _03656_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_120_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14012_ _05487_ _05495_ _05493_ VGND VGND VPWR VPWR _05554_ sky130_fd_sc_hd__a21o_1
XFILLER_0_120_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11224_ _02396_ _02398_ _02400_ _02395_ VGND VGND VPWR VPWR _02516_ sky130_fd_sc_hd__o22a_1
XFILLER_0_120_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11155_ net428 net390 net379 net513 VGND VGND VPWR VPWR _02442_ sky130_fd_sc_hd__a22o_1
X_10106_ _01405_ VGND VGND VPWR VPWR _00022_ sky130_fd_sc_hd__clkbuf_1
X_15963_ _07605_ _07606_ VGND VGND VPWR VPWR _07681_ sky130_fd_sc_hd__or2_1
X_11086_ _02329_ _02364_ _02366_ VGND VGND VPWR VPWR _02367_ sky130_fd_sc_hd__or3_1
X_10037_ _01278_ _01259_ VGND VGND VPWR VPWR _01342_ sky130_fd_sc_hd__and2b_1
X_14914_ _06537_ _06538_ _06449_ _06451_ VGND VGND VPWR VPWR _06540_ sky130_fd_sc_hd__o211ai_1
X_15894_ _07254_ _07530_ VGND VGND VPWR VPWR _07606_ sky130_fd_sc_hd__nor2_2
X_14845_ _06390_ _06392_ _06462_ VGND VGND VPWR VPWR _06465_ sky130_fd_sc_hd__and3_1
XFILLER_0_86_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14776_ _06371_ _06372_ _06389_ VGND VGND VPWR VPWR _06390_ sky130_fd_sc_hd__a21o_2
X_11988_ _03256_ _03264_ _03347_ VGND VGND VPWR VPWR _03348_ sky130_fd_sc_hd__a21o_1
XFILLER_0_105_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13727_ _05243_ _05244_ VGND VGND VPWR VPWR _05245_ sky130_fd_sc_hd__or2_1
XFILLER_0_86_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10939_ net768 net489 net479 net779 VGND VGND VPWR VPWR _02206_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_86_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13658_ _05168_ _05169_ VGND VGND VPWR VPWR _05170_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_73_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12609_ _03880_ _04024_ VGND VGND VPWR VPWR _04025_ sky130_fd_sc_hd__or2_1
XFILLER_0_128_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13589_ _05092_ _05093_ _05073_ _05074_ VGND VGND VPWR VPWR _05095_ sky130_fd_sc_hd__a211o_1
XFILLER_0_42_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15328_ _06988_ _06989_ _06990_ VGND VGND VPWR VPWR _06991_ sky130_fd_sc_hd__a21o_1
X_15259_ net394 net644 net635 net404 VGND VGND VPWR VPWR _06916_ sky130_fd_sc_hd__a22o_1
XFILLER_0_22_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout407 net414 VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__buf_2
X_09820_ _01079_ _01082_ _01127_ VGND VGND VPWR VPWR _01128_ sky130_fd_sc_hd__nor3_1
XFILLER_0_111_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout418 net419 VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__buf_2
Xfanout429 net430 VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__buf_2
XFILLER_0_39_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09751_ _01058_ _01059_ VGND VGND VPWR VPWR _01060_ sky130_fd_sc_hd__xor2_1
X_08702_ _07716_ _08011_ VGND VGND VPWR VPWR _08013_ sky130_fd_sc_hd__or2_1
X_09682_ _00990_ _00991_ VGND VGND VPWR VPWR _00992_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_146_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08633_ net160 net552 net563 net307 VGND VGND VPWR VPWR _07910_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08564_ _07107_ _07150_ VGND VGND VPWR VPWR _07161_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08495_ _06234_ _06245_ _06399_ VGND VGND VPWR VPWR _06410_ sky130_fd_sc_hd__and3_1
XFILLER_0_64_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09116_ _00346_ _00348_ VGND VGND VPWR VPWR _00433_ sky130_fd_sc_hd__nand2_2
XFILLER_0_134_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09047_ _00362_ _00363_ _00357_ VGND VGND VPWR VPWR _00365_ sky130_fd_sc_hd__a21o_1
XFILLER_0_130_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09949_ _01072_ _01216_ _01254_ VGND VGND VPWR VPWR _01255_ sky130_fd_sc_hd__and3_1
X_12960_ _04326_ _04309_ _04408_ _04409_ VGND VGND VPWR VPWR _04410_ sky130_fd_sc_hd__o211ai_4
X_11911_ _03262_ _03263_ VGND VGND VPWR VPWR _03264_ sky130_fd_sc_hd__xor2_1
X_12891_ _04329_ _04333_ VGND VGND VPWR VPWR _04334_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_87_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14630_ _06183_ _06196_ _06227_ _06228_ VGND VGND VPWR VPWR _06229_ sky130_fd_sc_hd__a211oi_2
X_11842_ _03106_ _03108_ _03187_ VGND VGND VPWR VPWR _03189_ sky130_fd_sc_hd__nand3_1
X_14561_ net354 net506 net587 net597 VGND VGND VPWR VPWR _06153_ sky130_fd_sc_hd__and4_1
X_11773_ _03050_ _03053_ VGND VGND VPWR VPWR _03114_ sky130_fd_sc_hd__and2_1
X_13512_ _04911_ _04913_ VGND VGND VPWR VPWR _05011_ sky130_fd_sc_hd__nor2_1
X_16300_ clknet_4_2_0_clk _00089_ net335 VGND VGND VPWR VPWR a_sin\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_137_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10724_ _01914_ _01921_ VGND VGND VPWR VPWR _01988_ sky130_fd_sc_hd__or2b_1
X_14492_ _06074_ _06073_ _06072_ _06066_ VGND VGND VPWR VPWR _06077_ sky130_fd_sc_hd__a211o_1
X_16231_ clknet_4_15_0_clk _00020_ net344 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dfrtp_1
X_13443_ _04862_ _04878_ VGND VGND VPWR VPWR _04935_ sky130_fd_sc_hd__nor2_1
XFILLER_0_125_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10655_ _01915_ _01918_ VGND VGND VPWR VPWR _01919_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_137_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16162_ _07846_ _07896_ VGND VGND VPWR VPWR _07897_ sky130_fd_sc_hd__and2_1
XFILLER_0_24_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13374_ _04777_ _04779_ VGND VGND VPWR VPWR _04860_ sky130_fd_sc_hd__nand2_2
XFILLER_0_63_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10586_ _01819_ _01849_ VGND VGND VPWR VPWR _01850_ sky130_fd_sc_hd__or2_1
X_15113_ _06648_ _06745_ _06744_ VGND VGND VPWR VPWR _06756_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_2_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12325_ _03709_ _03710_ _03708_ VGND VGND VPWR VPWR _03713_ sky130_fd_sc_hd__o21ai_1
X_16093_ _07820_ _07821_ VGND VGND VPWR VPWR _07822_ sky130_fd_sc_hd__nor2_1
XFILLER_0_121_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15044_ net357 net350 net699 net528 VGND VGND VPWR VPWR _06681_ sky130_fd_sc_hd__nand4_1
X_12256_ _03636_ _03638_ VGND VGND VPWR VPWR _03639_ sky130_fd_sc_hd__nor2_1
X_11207_ _02494_ _02498_ VGND VGND VPWR VPWR _02499_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_79_Left_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12187_ net426 _02388_ VGND VGND VPWR VPWR _03564_ sky130_fd_sc_hd__nor2_1
X_11138_ net715 net724 net362 net351 VGND VGND VPWR VPWR _02423_ sky130_fd_sc_hd__nand4_1
XFILLER_0_92_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15946_ net456 net660 net671 net448 VGND VGND VPWR VPWR _07663_ sky130_fd_sc_hd__a22oi_1
X_11069_ net234 net416 VGND VGND VPWR VPWR _02348_ sky130_fd_sc_hd__nand2_1
XFILLER_0_92_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15877_ _07586_ _07587_ VGND VGND VPWR VPWR _07588_ sky130_fd_sc_hd__nor2_1
X_14828_ _06359_ _06446_ VGND VGND VPWR VPWR _06447_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14759_ _06304_ _06309_ VGND VGND VPWR VPWR _06371_ sky130_fd_sc_hd__or2b_1
XFILLER_0_46_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08280_ _04042_ _04053_ VGND VGND VPWR VPWR _04064_ sky130_fd_sc_hd__and2_1
XFILLER_0_41_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout204 net72 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__clkbuf_4
Xfanout215 net216 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__buf_4
Xfanout226 net227 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__clkbuf_4
Xfanout237 net239 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__buf_2
X_09803_ _00819_ _00822_ _01111_ VGND VGND VPWR VPWR _01112_ sky130_fd_sc_hd__a21o_1
Xfanout248 net251 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__buf_4
Xfanout259 net260 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__clkbuf_4
X_09734_ _00966_ _00969_ _00965_ VGND VGND VPWR VPWR _01044_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_66_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09665_ _00819_ _00822_ _00975_ VGND VGND VPWR VPWR _00976_ sky130_fd_sc_hd__a21o_1
X_08616_ net268 net702 _07705_ VGND VGND VPWR VPWR _07726_ sky130_fd_sc_hd__a21oi_1
X_09596_ _00859_ _00858_ VGND VGND VPWR VPWR _00907_ sky130_fd_sc_hd__and2b_1
XFILLER_0_49_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08547_ _06541_ _06551_ _06530_ VGND VGND VPWR VPWR _06976_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_92_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08478_ _05687_ _06179_ _06168_ _06135_ VGND VGND VPWR VPWR _06223_ sky130_fd_sc_hd__o211a_1
XFILLER_0_92_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10440_ _01701_ _01702_ _01697_ VGND VGND VPWR VPWR _01704_ sky130_fd_sc_hd__a21o_1
XFILLER_0_33_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10371_ net525 net440 net734 net743 VGND VGND VPWR VPWR _01635_ sky130_fd_sc_hd__and4_1
XFILLER_0_131_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12110_ _03476_ _03479_ VGND VGND VPWR VPWR _03480_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13090_ net291 _04549_ _04550_ VGND VGND VPWR VPWR _04551_ sky130_fd_sc_hd__a21bo_1
X_12041_ _03403_ _03404_ VGND VGND VPWR VPWR _03405_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout760 net761 VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__clkbuf_4
Xfanout771 net14 VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__buf_4
X_15800_ _07496_ _07501_ _07495_ VGND VGND VPWR VPWR _07504_ sky130_fd_sc_hd__o21bai_1
Xfanout782 net783 VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__clkbuf_4
X_13992_ net311 net422 net261 net252 VGND VGND VPWR VPWR _05532_ sky130_fd_sc_hd__and4_1
Xfanout793 net795 VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__clkbuf_4
X_12943_ _04388_ _04389_ _04390_ VGND VGND VPWR VPWR _04391_ sky130_fd_sc_hd__nand3_1
XFILLER_0_99_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15731_ net865 net661 net671 net866 VGND VGND VPWR VPWR _07429_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_99_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12874_ _04233_ _03933_ _04315_ VGND VGND VPWR VPWR _04316_ sky130_fd_sc_hd__o21a_1
X_15662_ net346 net499 net651 net642 VGND VGND VPWR VPWR _07354_ sky130_fd_sc_hd__nand4_2
XFILLER_0_87_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_850 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14613_ _06208_ _06209_ VGND VGND VPWR VPWR _06210_ sky130_fd_sc_hd__nor2_1
X_11825_ _03165_ _03164_ VGND VGND VPWR VPWR _03171_ sky130_fd_sc_hd__and2b_1
X_15593_ _07277_ _07278_ VGND VGND VPWR VPWR _07279_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_28_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14544_ _06082_ _06131_ _06133_ VGND VGND VPWR VPWR _06134_ sky130_fd_sc_hd__and3b_1
XFILLER_0_83_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11756_ net427 net511 net485 net475 VGND VGND VPWR VPWR _03096_ sky130_fd_sc_hd__and4_1
XFILLER_0_55_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10707_ _01963_ _01964_ _01969_ VGND VGND VPWR VPWR _01971_ sky130_fd_sc_hd__a21o_1
X_14475_ net418 net586 _05845_ _05844_ VGND VGND VPWR VPWR _06059_ sky130_fd_sc_hd__a22o_1
X_11687_ _02937_ _02946_ _02945_ VGND VGND VPWR VPWR _03021_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_11_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13426_ _04761_ _04816_ _04917_ VGND VGND VPWR VPWR _04918_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_64_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16214_ clknet_4_8_0_clk _00003_ net343 VGND VGND VPWR VPWR b_sin\[3\] sky130_fd_sc_hd__dfrtp_1
X_10638_ _01900_ _01901_ VGND VGND VPWR VPWR _01902_ sky130_fd_sc_hd__xor2_1
XFILLER_0_36_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16145_ _07818_ _07817_ VGND VGND VPWR VPWR _07879_ sky130_fd_sc_hd__and2b_1
X_13357_ _04765_ _04768_ _04766_ VGND VGND VPWR VPWR _04842_ sky130_fd_sc_hd__o21bai_2
X_10569_ _01831_ _01832_ VGND VGND VPWR VPWR _01833_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_140_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12308_ net730 net223 VGND VGND VPWR VPWR _03694_ sky130_fd_sc_hd__nand2_1
X_16076_ _07801_ _07803_ VGND VGND VPWR VPWR _07804_ sky130_fd_sc_hd__or2_1
X_13288_ _04765_ _04766_ VGND VGND VPWR VPWR _04767_ sky130_fd_sc_hd__or2_1
X_15027_ _06659_ _06662_ VGND VGND VPWR VPWR _06663_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_20_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12239_ _03616_ _03619_ VGND VGND VPWR VPWR _03620_ sky130_fd_sc_hd__xnor2_1
Xinput4 alpha[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_127_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15929_ _07641_ _07644_ VGND VGND VPWR VPWR _07645_ sky130_fd_sc_hd__xor2_1
X_09450_ _00761_ _00762_ VGND VGND VPWR VPWR _00763_ sky130_fd_sc_hd__nor2_1
XFILLER_0_149_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08401_ _05209_ _05362_ _05372_ VGND VGND VPWR VPWR _05383_ sky130_fd_sc_hd__nand3_2
XFILLER_0_59_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09381_ _00686_ _00693_ _00694_ VGND VGND VPWR VPWR _00695_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_148_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08332_ _04600_ _04611_ _04589_ _04622_ VGND VGND VPWR VPWR _04632_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_19_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08263_ net274 net702 VGND VGND VPWR VPWR _03877_ sky130_fd_sc_hd__nand2_1
XFILLER_0_129_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08194_ net163 net307 net582 net589 VGND VGND VPWR VPWR _03127_ sky130_fd_sc_hd__and4_1
XFILLER_0_6_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09717_ _00945_ _00950_ VGND VGND VPWR VPWR _01027_ sky130_fd_sc_hd__and2b_1
X_09648_ _00957_ _00958_ VGND VGND VPWR VPWR _00959_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09579_ _00874_ _00890_ VGND VGND VPWR VPWR _00891_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_96_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11610_ _02868_ _02870_ VGND VGND VPWR VPWR _02937_ sky130_fd_sc_hd__nand2_1
X_12590_ _03950_ _03949_ _03941_ VGND VGND VPWR VPWR _04004_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11541_ _02859_ _02860_ _02861_ VGND VGND VPWR VPWR _02862_ sky130_fd_sc_hd__a21o_1
XFILLER_0_147_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14260_ net520 net435 net560 net570 VGND VGND VPWR VPWR _05822_ sky130_fd_sc_hd__nand4_1
XFILLER_0_108_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11472_ _02784_ _02786_ VGND VGND VPWR VPWR _02787_ sky130_fd_sc_hd__xor2_2
X_13211_ _04596_ _04597_ _04598_ VGND VGND VPWR VPWR _04683_ sky130_fd_sc_hd__and3_1
X_10423_ _01613_ _01615_ _01614_ VGND VGND VPWR VPWR _01687_ sky130_fd_sc_hd__o21ba_1
X_14191_ _05740_ _05747_ VGND VGND VPWR VPWR _05748_ sky130_fd_sc_hd__or2_1
XFILLER_0_150_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13142_ _04499_ net126 _04606_ _04607_ VGND VGND VPWR VPWR _04608_ sky130_fd_sc_hd__o211ai_4
X_10354_ _01612_ _01617_ VGND VGND VPWR VPWR _01618_ sky130_fd_sc_hd__or2b_1
X_13073_ _04527_ _04531_ VGND VGND VPWR VPWR _04532_ sky130_fd_sc_hd__xor2_1
X_10285_ a_sin\[11\] b_cos\[11\] VGND VGND VPWR VPWR _01558_ sky130_fd_sc_hd__and2b_1
X_12024_ _03319_ _03385_ VGND VGND VPWR VPWR _03387_ sky130_fd_sc_hd__nor2_1
Xfanout590 net598 VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__clkbuf_2
X_13975_ _05511_ _05513_ VGND VGND VPWR VPWR _05515_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_87_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15714_ _07387_ _07388_ _07410_ VGND VGND VPWR VPWR _07411_ sky130_fd_sc_hd__o21a_1
X_12926_ net729 net170 _04370_ _04372_ VGND VGND VPWR VPWR _04373_ sky130_fd_sc_hd__a22o_1
XFILLER_0_76_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15645_ _06753_ _07331_ _07333_ _07335_ VGND VGND VPWR VPWR _07337_ sky130_fd_sc_hd__a211o_4
X_12857_ _04294_ _04296_ _04297_ VGND VGND VPWR VPWR _04298_ sky130_fd_sc_hd__nand3_4
XFILLER_0_56_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11808_ _03151_ _03152_ VGND VGND VPWR VPWR _03153_ sky130_fd_sc_hd__xnor2_1
X_12788_ _04084_ _04085_ _04125_ VGND VGND VPWR VPWR _04222_ sky130_fd_sc_hd__a21o_1
X_15576_ net376 net365 net632 net625 VGND VGND VPWR VPWR _07261_ sky130_fd_sc_hd__nand4_2
XFILLER_0_29_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14527_ _06115_ _06094_ VGND VGND VPWR VPWR _06116_ sky130_fd_sc_hd__xnor2_1
X_11739_ _02997_ _03076_ VGND VGND VPWR VPWR _03078_ sky130_fd_sc_hd__and2_1
XFILLER_0_138_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14458_ _06026_ _06027_ _06039_ VGND VGND VPWR VPWR _06040_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_113_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13409_ _04895_ _04896_ _04897_ VGND VGND VPWR VPWR _04899_ sky130_fd_sc_hd__nand3_1
XFILLER_0_4_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14389_ net380 net370 net578 net587 VGND VGND VPWR VPWR _05964_ sky130_fd_sc_hd__and4_1
XFILLER_0_113_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16128_ _07605_ _07848_ _07858_ VGND VGND VPWR VPWR _07860_ sky130_fd_sc_hd__o21bai_1
X_08950_ _00250_ _00267_ _00268_ VGND VGND VPWR VPWR _00269_ sky130_fd_sc_hd__and3_2
X_16059_ _07784_ _07775_ VGND VGND VPWR VPWR _07785_ sky130_fd_sc_hd__nor2_1
X_08881_ net563 _00122_ _00125_ _00123_ VGND VGND VPWR VPWR _00200_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_135_Right_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_16_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09502_ _00740_ _00814_ VGND VGND VPWR VPWR _00815_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09433_ _00744_ _00745_ VGND VGND VPWR VPWR _00746_ sky130_fd_sc_hd__nor2_1
XFILLER_0_78_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09364_ _00660_ _00677_ VGND VGND VPWR VPWR _00678_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_35_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08315_ _04415_ _04425_ _04436_ VGND VGND VPWR VPWR _04447_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_129_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_20 net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_09295_ _00607_ _00608_ _00593_ VGND VGND VPWR VPWR _00610_ sky130_fd_sc_hd__a21o_1
XANTENNA_31 net608 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_42 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_53 net515 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_25_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08246_ _03626_ _03680_ VGND VGND VPWR VPWR _03690_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_117_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08177_ net171 net564 VGND VGND VPWR VPWR _02942_ sky130_fd_sc_hd__nand2_1
XFILLER_0_104_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10070_ net262 net618 VGND VGND VPWR VPWR _01374_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_102_Right_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_34_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13760_ _05278_ net121 _05160_ _05183_ VGND VGND VPWR VPWR _05281_ sky130_fd_sc_hd__o211a_1
X_10972_ net429 net407 net397 net514 VGND VGND VPWR VPWR _02242_ sky130_fd_sc_hd__a22oi_2
X_12711_ net781 net215 net206 net790 VGND VGND VPWR VPWR _04137_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13691_ _05197_ _05205_ VGND VGND VPWR VPWR _05206_ sky130_fd_sc_hd__xor2_1
XFILLER_0_38_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12642_ _04013_ _04012_ VGND VGND VPWR VPWR _04061_ sky130_fd_sc_hd__nor2_1
X_15430_ _07081_ _07100_ _07101_ VGND VGND VPWR VPWR _07102_ sky130_fd_sc_hd__nand3_1
XFILLER_0_66_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15361_ _07023_ _07024_ _07026_ VGND VGND VPWR VPWR _07027_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_43_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12573_ _03982_ _03984_ VGND VGND VPWR VPWR _03985_ sky130_fd_sc_hd__and2b_1
XFILLER_0_136_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14312_ _05876_ _05877_ _05878_ VGND VGND VPWR VPWR _05879_ sky130_fd_sc_hd__and3_2
X_11524_ _02840_ _02841_ _02842_ VGND VGND VPWR VPWR _02843_ sky130_fd_sc_hd__nand3_1
X_15292_ _06851_ _06940_ VGND VGND VPWR VPWR _06951_ sky130_fd_sc_hd__nor2_1
XFILLER_0_135_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14243_ net798 net261 VGND VGND VPWR VPWR _05804_ sky130_fd_sc_hd__nand2_1
XFILLER_0_150_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11455_ _02764_ _02765_ _02766_ VGND VGND VPWR VPWR _02769_ sky130_fd_sc_hd__nand3_1
XFILLER_0_1_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10406_ net413 net402 net743 net752 VGND VGND VPWR VPWR _01670_ sky130_fd_sc_hd__and4_1
X_14174_ _05618_ _05664_ _05727_ VGND VGND VPWR VPWR _05729_ sky130_fd_sc_hd__nor3_1
XFILLER_0_150_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11386_ _02501_ _02600_ VGND VGND VPWR VPWR _02694_ sky130_fd_sc_hd__nor2_1
X_13125_ net799 net321 net68 VGND VGND VPWR VPWR _04590_ sky130_fd_sc_hd__a21oi_1
X_10337_ _01603_ VGND VGND VPWR VPWR _00055_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13056_ _04512_ _04514_ VGND VGND VPWR VPWR _04515_ sky130_fd_sc_hd__nand2_1
X_10268_ _01543_ VGND VGND VPWR VPWR _00046_ sky130_fd_sc_hd__clkbuf_1
X_12007_ _03346_ _03368_ VGND VGND VPWR VPWR _03369_ sky130_fd_sc_hd__xnor2_1
X_10199_ a_cos\[17\] b_sin\[17\] VGND VGND VPWR VPWR _01485_ sky130_fd_sc_hd__or2_1
X_13958_ _05487_ _05495_ VGND VGND VPWR VPWR _05496_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_88_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12909_ _04351_ _04352_ _04353_ VGND VGND VPWR VPWR _04354_ sky130_fd_sc_hd__a21o_1
XFILLER_0_88_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13889_ _05419_ _05420_ VGND VGND VPWR VPWR _05421_ sky130_fd_sc_hd__xor2_1
XFILLER_0_33_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15628_ _07300_ _07317_ VGND VGND VPWR VPWR _07318_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15559_ _07139_ _07137_ VGND VGND VPWR VPWR _07243_ sky130_fd_sc_hd__and2b_1
XFILLER_0_44_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09080_ net266 net257 net571 VGND VGND VPWR VPWR _00397_ sky130_fd_sc_hd__and3_1
XFILLER_0_32_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput40 cos[10] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__buf_2
XFILLER_0_3_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput51 cos[3] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__buf_1
Xinput62 sin[12] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_4
Xinput73 sin[5] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_4_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09982_ _01285_ _01287_ VGND VGND VPWR VPWR _01288_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08933_ net220 net210 net639 VGND VGND VPWR VPWR _00252_ sky130_fd_sc_hd__and3_1
XFILLER_0_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08864_ _00181_ _00182_ _08015_ VGND VGND VPWR VPWR _00184_ sky130_fd_sc_hd__a21o_1
X_08795_ _08103_ _08104_ VGND VGND VPWR VPWR _00115_ sky130_fd_sc_hd__xor2_1
XFILLER_0_79_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09416_ _00591_ _00640_ _00729_ VGND VGND VPWR VPWR _00730_ sky130_fd_sc_hd__a21o_1
XFILLER_0_66_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09347_ _00592_ _00611_ _00609_ VGND VGND VPWR VPWR _00661_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_47_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09278_ _00523_ _00530_ _00529_ VGND VGND VPWR VPWR _00593_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_90_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08229_ _03474_ _03485_ _03431_ VGND VGND VPWR VPWR _03507_ sky130_fd_sc_hd__a21o_1
XFILLER_0_16_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11240_ net758 net469 VGND VGND VPWR VPWR _02534_ sky130_fd_sc_hd__nand2_1
XFILLER_0_132_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11171_ net517 net803 net48 VGND VGND VPWR VPWR _02459_ sky130_fd_sc_hd__and3_1
XFILLER_0_101_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10122_ a_cos\[6\] b_sin\[6\] VGND VGND VPWR VPWR _01419_ sky130_fd_sc_hd__nand2_1
X_10053_ _01313_ _01314_ _01312_ VGND VGND VPWR VPWR _01357_ sky130_fd_sc_hd__o21a_1
X_14930_ net593 _06455_ _06556_ VGND VGND VPWR VPWR _06557_ sky130_fd_sc_hd__a21bo_1
X_14861_ _06479_ _06480_ _06481_ VGND VGND VPWR VPWR _06482_ sky130_fd_sc_hd__nand3_1
X_13812_ net609 net709 net264 net254 VGND VGND VPWR VPWR _05337_ sky130_fd_sc_hd__and4_1
XFILLER_0_98_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14792_ net404 net394 net683 net691 VGND VGND VPWR VPWR _06407_ sky130_fd_sc_hd__and4_1
XFILLER_0_97_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13743_ net727 net248 VGND VGND VPWR VPWR _05262_ sky130_fd_sc_hd__nand2_1
X_10955_ _02220_ _02221_ _02205_ VGND VGND VPWR VPWR _02224_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_51_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10886_ _02147_ _02148_ _02146_ VGND VGND VPWR VPWR _02150_ sky130_fd_sc_hd__o21ai_1
X_13674_ _05183_ _05184_ _05186_ VGND VGND VPWR VPWR _05187_ sky130_fd_sc_hd__and3_1
XFILLER_0_128_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15413_ net484 net698 net526 net474 VGND VGND VPWR VPWR _07083_ sky130_fd_sc_hd__a22oi_1
X_12625_ _04040_ _04041_ VGND VGND VPWR VPWR _04043_ sky130_fd_sc_hd__and2b_1
XFILLER_0_54_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12556_ _03964_ _03955_ _03966_ VGND VGND VPWR VPWR _03967_ sky130_fd_sc_hd__nand3_1
X_15344_ net357 net673 _07006_ _07007_ VGND VGND VPWR VPWR _07008_ sky130_fd_sc_hd__a22o_1
XFILLER_0_109_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11507_ net767 _02385_ VGND VGND VPWR VPWR _02825_ sky130_fd_sc_hd__nor2_1
X_12487_ net782 net172 VGND VGND VPWR VPWR _03891_ sky130_fd_sc_hd__nand2_1
X_15275_ _06783_ _06817_ _06816_ VGND VGND VPWR VPWR _06934_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_41_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14226_ _05783_ _05785_ VGND VGND VPWR VPWR _05786_ sky130_fd_sc_hd__xnor2_1
X_11438_ _02747_ _02748_ _02728_ VGND VGND VPWR VPWR _02750_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_1_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14157_ _05657_ _05711_ VGND VGND VPWR VPWR _05712_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_60_Left_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11369_ _02673_ _02674_ VGND VGND VPWR VPWR _02675_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13108_ _04470_ _04472_ VGND VGND VPWR VPWR _04571_ sky130_fd_sc_hd__nand2_1
XFILLER_0_119_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14088_ _05474_ _05569_ _05635_ VGND VGND VPWR VPWR _05637_ sky130_fd_sc_hd__a21o_1
X_13039_ _04492_ _04493_ _04494_ VGND VGND VPWR VPWR _04496_ sky130_fd_sc_hd__a21o_1
X_08580_ net825 _07009_ VGND VGND VPWR VPWR _07336_ sky130_fd_sc_hd__xor2_1
XFILLER_0_135_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09201_ _00514_ _00515_ _00516_ VGND VGND VPWR VPWR _00517_ sky130_fd_sc_hd__and3_1
XFILLER_0_8_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09132_ net321 net237 net620 VGND VGND VPWR VPWR _00449_ sky130_fd_sc_hd__o21a_1
XFILLER_0_17_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_878 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09063_ _00299_ _00379_ _00380_ VGND VGND VPWR VPWR _00381_ sky130_fd_sc_hd__nand3_1
XFILLER_0_60_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09965_ _01186_ _01189_ _01269_ VGND VGND VPWR VPWR _01271_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_110_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08916_ _00219_ _00233_ _00234_ VGND VGND VPWR VPWR _00235_ sky130_fd_sc_hd__nand3_1
X_09896_ net296 _01086_ VGND VGND VPWR VPWR _01203_ sky130_fd_sc_hd__nand2_1
X_08847_ _00164_ _00165_ _00157_ VGND VGND VPWR VPWR _00167_ sky130_fd_sc_hd__a21o_1
X_08778_ _04654_ _07661_ _07998_ VGND VGND VPWR VPWR _08089_ sky130_fd_sc_hd__nor3_1
XFILLER_0_79_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10740_ _01987_ _01988_ _02002_ _02003_ VGND VGND VPWR VPWR _02004_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_95_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10671_ _01932_ _01933_ _01928_ VGND VGND VPWR VPWR _01935_ sky130_fd_sc_hd__a21o_1
XFILLER_0_94_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12410_ _03791_ _03792_ _03805_ VGND VGND VPWR VPWR _03806_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_47_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13390_ _04867_ _04877_ VGND VGND VPWR VPWR _04878_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_62_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12341_ _03726_ _03729_ VGND VGND VPWR VPWR _03730_ sky130_fd_sc_hd__and2_1
X_15060_ net664 _06607_ _06610_ _06608_ VGND VGND VPWR VPWR _06699_ sky130_fd_sc_hd__a22o_1
XFILLER_0_50_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12272_ _03653_ _03654_ VGND VGND VPWR VPWR _03655_ sky130_fd_sc_hd__xor2_1
XFILLER_0_49_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14011_ _05528_ _05551_ VGND VGND VPWR VPWR _05553_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11223_ _02509_ _02514_ VGND VGND VPWR VPWR _02515_ sky130_fd_sc_hd__xnor2_1
X_11154_ net407 _02342_ _02346_ _02344_ VGND VGND VPWR VPWR _02440_ sky130_fd_sc_hd__a22o_1
X_10105_ net91 _01404_ net137 VGND VGND VPWR VPWR _01405_ sky130_fd_sc_hd__mux2_1
X_15962_ _07659_ _07678_ VGND VGND VPWR VPWR _07680_ sky130_fd_sc_hd__nor2_1
X_11085_ _02362_ _02363_ _02258_ _02330_ VGND VGND VPWR VPWR _02366_ sky130_fd_sc_hd__o211a_1
X_10036_ _01339_ _01340_ VGND VGND VPWR VPWR _01341_ sky130_fd_sc_hd__xor2_1
X_14913_ _06449_ _06451_ _06537_ _06538_ VGND VGND VPWR VPWR _06539_ sky130_fd_sc_hd__a211o_1
X_15893_ _07604_ VGND VGND VPWR VPWR _07605_ sky130_fd_sc_hd__clkbuf_4
X_14844_ _06390_ _06392_ _06462_ VGND VGND VPWR VPWR _06463_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_86_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14775_ _06380_ _06387_ VGND VGND VPWR VPWR _06389_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11987_ _03262_ _03263_ VGND VGND VPWR VPWR _03347_ sky130_fd_sc_hd__and2_1
X_13726_ _05137_ _05150_ _05136_ VGND VGND VPWR VPWR _05244_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10938_ _02131_ _02138_ _02137_ VGND VGND VPWR VPWR _02205_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13657_ net736 net247 VGND VGND VPWR VPWR _05169_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10869_ net724 net384 net373 net864 VGND VGND VPWR VPWR _02133_ sky130_fd_sc_hd__a22o_1
XFILLER_0_6_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12608_ net791 net162 net309 net805 VGND VGND VPWR VPWR _04024_ sky130_fd_sc_hd__a22oi_1
X_13588_ _05073_ _05074_ _05092_ _05093_ VGND VGND VPWR VPWR _05094_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_14_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15327_ net493 net698 VGND VGND VPWR VPWR _06990_ sky130_fd_sc_hd__and2_1
X_12539_ _03945_ _03946_ _03947_ VGND VGND VPWR VPWR _03948_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_124_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15258_ _06905_ _06914_ VGND VGND VPWR VPWR _06915_ sky130_fd_sc_hd__xor2_2
XFILLER_0_10_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14209_ _05705_ _05722_ _05766_ VGND VGND VPWR VPWR _05768_ sky130_fd_sc_hd__or3_1
X_15189_ _06838_ _06839_ VGND VGND VPWR VPWR _06840_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout408 net410 VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__buf_2
Xfanout419 net420 VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__clkbuf_2
X_09750_ _01019_ _01022_ _01020_ VGND VGND VPWR VPWR _01059_ sky130_fd_sc_hd__o21ba_1
X_08701_ _07716_ _08011_ VGND VGND VPWR VPWR _08012_ sky130_fd_sc_hd__nand2_1
X_09681_ net271 net666 VGND VGND VPWR VPWR _00991_ sky130_fd_sc_hd__nand2_1
XFILLER_0_146_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08632_ net298 net572 VGND VGND VPWR VPWR _07900_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08563_ _07052_ _07085_ VGND VGND VPWR VPWR _07150_ sky130_fd_sc_hd__nor2_1
X_08494_ _06300_ _06377_ _06388_ VGND VGND VPWR VPWR _06399_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_147_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09115_ _00413_ _00431_ VGND VGND VPWR VPWR _00432_ sky130_fd_sc_hd__xor2_2
XFILLER_0_45_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09046_ _00357_ _00362_ _00363_ VGND VGND VPWR VPWR _00364_ sky130_fd_sc_hd__nand3_1
XFILLER_0_103_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_8_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09948_ _01252_ _01253_ VGND VGND VPWR VPWR _01254_ sky130_fd_sc_hd__or2_1
X_09879_ net262 net253 net646 net656 VGND VGND VPWR VPWR _01186_ sky130_fd_sc_hd__and4_1
X_11910_ net231 net492 _03180_ _03179_ VGND VGND VPWR VPWR _03263_ sky130_fd_sc_hd__a31o_1
X_12890_ _04330_ _04332_ VGND VGND VPWR VPWR _04333_ sky130_fd_sc_hd__nand2_1
X_11841_ _03106_ _03108_ _03187_ VGND VGND VPWR VPWR _03188_ sky130_fd_sc_hd__a21o_1
XFILLER_0_67_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14560_ net495 net607 VGND VGND VPWR VPWR _06152_ sky130_fd_sc_hd__nand2_1
X_11772_ _03110_ _03111_ _03091_ _03092_ VGND VGND VPWR VPWR _03113_ sky130_fd_sc_hd__a211o_1
XFILLER_0_68_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13511_ _04955_ _05009_ VGND VGND VPWR VPWR _05010_ sky130_fd_sc_hd__xor2_2
X_10723_ _01920_ _01919_ VGND VGND VPWR VPWR _01987_ sky130_fd_sc_hd__or2b_1
XFILLER_0_55_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14491_ _06067_ _06068_ VGND VGND VPWR VPWR _06076_ sky130_fd_sc_hd__nor2_1
X_16230_ clknet_4_15_0_clk _00019_ net344 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfrtp_1
X_13442_ _04855_ _04856_ _04933_ VGND VGND VPWR VPWR _04934_ sky130_fd_sc_hd__a21o_1
X_10654_ _01916_ _01917_ VGND VGND VPWR VPWR _01918_ sky130_fd_sc_hd__and2b_1
XFILLER_0_91_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13373_ _04840_ _04858_ VGND VGND VPWR VPWR _04859_ sky130_fd_sc_hd__xor2_2
X_16161_ _07894_ _07895_ VGND VGND VPWR VPWR _07896_ sky130_fd_sc_hd__nor2_1
XFILLER_0_141_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10585_ _01821_ _01848_ VGND VGND VPWR VPWR _01849_ sky130_fd_sc_hd__nand2_1
XFILLER_0_134_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15112_ _06755_ VGND VGND VPWR VPWR _00099_ sky130_fd_sc_hd__clkbuf_1
X_12324_ _03708_ _03709_ _03710_ VGND VGND VPWR VPWR _03711_ sky130_fd_sc_hd__or3_1
X_16092_ _07735_ _07734_ VGND VGND VPWR VPWR _07821_ sky130_fd_sc_hd__and2b_1
X_15043_ net357 net699 net532 net350 VGND VGND VPWR VPWR _06680_ sky130_fd_sc_hd__a22o_1
X_12255_ _03585_ _03635_ VGND VGND VPWR VPWR _03638_ sky130_fd_sc_hd__nor2_1
XFILLER_0_121_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11206_ _02279_ _02281_ _02283_ _02381_ _02497_ VGND VGND VPWR VPWR _02498_ sky130_fd_sc_hd__a41o_2
XFILLER_0_121_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12186_ _03558_ _03562_ VGND VGND VPWR VPWR _03563_ sky130_fd_sc_hd__xnor2_1
X_11137_ net715 net362 net351 net724 VGND VGND VPWR VPWR _02422_ sky130_fd_sc_hd__a22o_1
X_11068_ _02345_ _02346_ VGND VGND VPWR VPWR _02347_ sky130_fd_sc_hd__xnor2_2
X_15945_ _07612_ _07615_ _07613_ VGND VGND VPWR VPWR _07662_ sky130_fd_sc_hd__o21ba_1
X_10019_ _01072_ VGND VGND VPWR VPWR _01324_ sky130_fd_sc_hd__inv_2
X_15876_ net456 net448 net671 net680 VGND VGND VPWR VPWR _07587_ sky130_fd_sc_hd__and4_1
XFILLER_0_25_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14827_ _06441_ _06445_ VGND VGND VPWR VPWR _06446_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_148_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14758_ _06328_ _06335_ VGND VGND VPWR VPWR _06370_ sky130_fd_sc_hd__and2_1
XFILLER_0_74_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13709_ _05223_ _05224_ VGND VGND VPWR VPWR _05225_ sky130_fd_sc_hd__xnor2_1
X_14689_ net411 net400 net691 net700 VGND VGND VPWR VPWR _06294_ sky130_fd_sc_hd__and4_1
XFILLER_0_144_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout205 net72 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__clkbuf_4
Xfanout216 net217 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__clkbuf_4
Xfanout227 net228 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__clkbuf_2
X_09802_ _00974_ _00975_ _01046_ VGND VGND VPWR VPWR _01111_ sky130_fd_sc_hd__or3_1
Xfanout238 net239 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__buf_2
Xfanout249 net250 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09733_ _01040_ _01042_ VGND VGND VPWR VPWR _01043_ sky130_fd_sc_hd__xnor2_2
X_09664_ _00815_ _00901_ VGND VGND VPWR VPWR _00975_ sky130_fd_sc_hd__or2_1
X_08615_ net268 net702 _07705_ VGND VGND VPWR VPWR _07716_ sky130_fd_sc_hd__and3_1
X_09595_ _00870_ _00892_ VGND VGND VPWR VPWR _00906_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08546_ _06878_ _06889_ _06954_ VGND VGND VPWR VPWR _06965_ sky130_fd_sc_hd__or3_4
XFILLER_0_77_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08477_ _05199_ _06201_ VGND VGND VPWR VPWR _06212_ sky130_fd_sc_hd__xor2_1
XFILLER_0_92_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_149_Right_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10370_ net525 net734 net743 net440 VGND VGND VPWR VPWR _01634_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_115_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09029_ net167 net686 _00345_ _00346_ VGND VGND VPWR VPWR _00347_ sky130_fd_sc_hd__a22o_1
XFILLER_0_142_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12040_ net315 net426 net456 net448 VGND VGND VPWR VPWR _03404_ sky130_fd_sc_hd__and4_1
XFILLER_0_103_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout750 net753 VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__clkbuf_2
Xfanout761 net762 VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__clkbuf_4
Xfanout772 net773 VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__clkbuf_4
X_13991_ net311 net261 net252 net422 VGND VGND VPWR VPWR _05531_ sky130_fd_sc_hd__a22oi_2
Xfanout783 net12 VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__buf_2
Xfanout794 net795 VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__clkbuf_2
X_15730_ _07373_ _07375_ VGND VGND VPWR VPWR _07428_ sky130_fd_sc_hd__or2b_1
X_12942_ _04286_ _04288_ _04287_ VGND VGND VPWR VPWR _04390_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_99_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15661_ net499 net651 net642 net346 VGND VGND VPWR VPWR _07353_ sky130_fd_sc_hd__a22o_1
X_12873_ _03931_ _03879_ VGND VGND VPWR VPWR _04315_ sky130_fd_sc_hd__or2b_1
X_14612_ net411 net700 net533 net400 VGND VGND VPWR VPWR _06209_ sky130_fd_sc_hd__a22oi_2
X_11824_ _03169_ VGND VGND VPWR VPWR _00068_ sky130_fd_sc_hd__clkbuf_1
X_15592_ net464 net697 VGND VGND VPWR VPWR _07278_ sky130_fd_sc_hd__nand2_1
XFILLER_0_95_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14543_ _06078_ _06132_ VGND VGND VPWR VPWR _06133_ sky130_fd_sc_hd__and2_1
XFILLER_0_138_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11755_ net427 net485 net475 net511 VGND VGND VPWR VPWR _03095_ sky130_fd_sc_hd__a22oi_2
X_10706_ _01963_ _01964_ _01969_ VGND VGND VPWR VPWR _01970_ sky130_fd_sc_hd__nand3_1
X_14474_ _05845_ _05843_ _05844_ VGND VGND VPWR VPWR _06057_ sky130_fd_sc_hd__nand3_1
XFILLER_0_125_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11686_ _02962_ _02970_ _02971_ VGND VGND VPWR VPWR _03020_ sky130_fd_sc_hd__and3_1
X_16213_ clknet_4_11_0_clk _00002_ net343 VGND VGND VPWR VPWR b_sin\[2\] sky130_fd_sc_hd__dfrtp_2
XFILLER_0_126_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13425_ _04814_ _04815_ VGND VGND VPWR VPWR _04917_ sky130_fd_sc_hd__and2b_1
XFILLER_0_114_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10637_ _01821_ _01848_ VGND VGND VPWR VPWR _01901_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16144_ _07809_ _07816_ VGND VGND VPWR VPWR _07877_ sky130_fd_sc_hd__and2b_1
X_13356_ _04762_ _04783_ _04781_ VGND VGND VPWR VPWR _04841_ sky130_fd_sc_hd__a21o_1
X_10568_ net392 net809 VGND VGND VPWR VPWR _01832_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_116_Right_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12307_ _03689_ _03691_ _03688_ VGND VGND VPWR VPWR _03693_ sky130_fd_sc_hd__o21ai_1
X_16075_ _07605_ _07788_ _07800_ VGND VGND VPWR VPWR _07803_ sky130_fd_sc_hd__o21a_1
X_13287_ net728 net736 net291 net285 VGND VGND VPWR VPWR _04766_ sky130_fd_sc_hd__and4_1
XFILLER_0_87_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10499_ net525 net752 net760 net440 VGND VGND VPWR VPWR _01763_ sky130_fd_sc_hd__a22o_1
X_15026_ _06661_ VGND VGND VPWR VPWR _06662_ sky130_fd_sc_hd__inv_2
XFILLER_0_121_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12238_ _03617_ _03618_ VGND VGND VPWR VPWR _03619_ sky130_fd_sc_hd__nor2_1
X_12169_ _03480_ _03481_ VGND VGND VPWR VPWR _03544_ sky130_fd_sc_hd__or2_1
Xinput5 alpha[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
X_15928_ _07642_ _07571_ _07643_ VGND VGND VPWR VPWR _07644_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15859_ _07567_ _07568_ VGND VGND VPWR VPWR _07569_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_148_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08400_ _04829_ _04818_ _04741_ VGND VGND VPWR VPWR _05372_ sky130_fd_sc_hd__a21o_1
X_09380_ _00691_ _00692_ _00688_ VGND VGND VPWR VPWR _00694_ sky130_fd_sc_hd__a21o_1
XFILLER_0_143_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08331_ _03398_ _04578_ _04567_ VGND VGND VPWR VPWR _04622_ sky130_fd_sc_hd__a21o_1
XFILLER_0_52_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08262_ _03800_ _03855_ VGND VGND VPWR VPWR _03866_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_61_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08193_ net298 net599 VGND VGND VPWR VPWR _03116_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09716_ _01024_ _01025_ VGND VGND VPWR VPWR _01026_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_98_Left_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09647_ _00408_ net535 VGND VGND VPWR VPWR _00958_ sky130_fd_sc_hd__or2_1
XFILLER_0_96_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09578_ _00888_ _00889_ VGND VGND VPWR VPWR _00890_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08529_ _06355_ _06344_ _06333_ VGND VGND VPWR VPWR _06780_ sky130_fd_sc_hd__o21ai_1
X_11540_ _02770_ _02767_ _02769_ _02773_ VGND VGND VPWR VPWR _02861_ sky130_fd_sc_hd__a31o_1
XFILLER_0_107_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11471_ _02652_ _02680_ _02785_ VGND VGND VPWR VPWR _02786_ sky130_fd_sc_hd__a21oi_2
X_13210_ _04680_ _04681_ VGND VGND VPWR VPWR _04682_ sky130_fd_sc_hd__nor2_1
X_10422_ _01680_ _01685_ VGND VGND VPWR VPWR _01686_ sky130_fd_sc_hd__xnor2_2
X_14190_ _05745_ _05746_ VGND VGND VPWR VPWR _05747_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13141_ _04604_ _04605_ _04569_ VGND VGND VPWR VPWR _04607_ sky130_fd_sc_hd__o21ai_2
X_10353_ _01613_ _01616_ VGND VGND VPWR VPWR _01617_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_131_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13072_ _04528_ _04529_ _04530_ VGND VGND VPWR VPWR _04531_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_103_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10284_ _01552_ _01553_ VGND VGND VPWR VPWR _01557_ sky130_fd_sc_hd__and2b_1
X_12023_ _03319_ _03385_ VGND VGND VPWR VPWR _03386_ sky130_fd_sc_hd__and2_1
Xfanout580 net581 VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__clkbuf_4
Xfanout591 net592 VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__clkbuf_4
X_13974_ _05432_ _05433_ _05435_ _05512_ VGND VGND VPWR VPWR _05513_ sky130_fd_sc_hd__a31oi_2
X_15713_ _07391_ _07409_ VGND VGND VPWR VPWR _07410_ sky130_fd_sc_hd__xnor2_1
X_12925_ net711 net720 net187 net178 VGND VGND VPWR VPWR _04372_ sky130_fd_sc_hd__nand4_2
X_15644_ _07144_ _07146_ _07246_ _07334_ _07245_ VGND VGND VPWR VPWR _07335_ sky130_fd_sc_hd__a32o_1
XFILLER_0_87_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12856_ _03821_ _03827_ _03820_ VGND VGND VPWR VPWR _04297_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_69_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_146_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11807_ net740 _02387_ VGND VGND VPWR VPWR _03152_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15575_ net365 net632 net625 net376 VGND VGND VPWR VPWR _07260_ sky130_fd_sc_hd__a22o_1
XFILLER_0_22_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12787_ _04192_ _04194_ _04220_ VGND VGND VPWR VPWR _04221_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_28_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14526_ net418 net606 VGND VGND VPWR VPWR _06115_ sky130_fd_sc_hd__nand2_1
X_11738_ _02997_ _03076_ VGND VGND VPWR VPWR _03077_ sky130_fd_sc_hd__nor2_1
X_14457_ _06037_ _06038_ VGND VGND VPWR VPWR _06039_ sky130_fd_sc_hd__nor2_1
X_11669_ _02974_ _02977_ VGND VGND VPWR VPWR _03001_ sky130_fd_sc_hd__nand2_1
XFILLER_0_126_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13408_ _04895_ _04896_ _04897_ VGND VGND VPWR VPWR _04898_ sky130_fd_sc_hd__a21o_1
XFILLER_0_98_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14388_ net361 net597 VGND VGND VPWR VPWR _05963_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16127_ _07605_ _07848_ _07858_ VGND VGND VPWR VPWR _07859_ sky130_fd_sc_hd__or3b_1
XFILLER_0_3_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13339_ _04729_ _04822_ VGND VGND VPWR VPWR _04823_ sky130_fd_sc_hd__xnor2_2
X_16058_ _07721_ VGND VGND VPWR VPWR _07784_ sky130_fd_sc_hd__inv_2
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15009_ _06642_ _06643_ VGND VGND VPWR VPWR _06644_ sky130_fd_sc_hd__nand2_1
X_08880_ _00121_ _00135_ _00136_ _00139_ VGND VGND VPWR VPWR _00199_ sky130_fd_sc_hd__a31o_1
XFILLER_0_79_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09501_ _00811_ _00813_ VGND VGND VPWR VPWR _00814_ sky130_fd_sc_hd__xor2_1
XFILLER_0_78_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09432_ net289 net280 net681 net689 VGND VGND VPWR VPWR _00745_ sky130_fd_sc_hd__and4_1
XFILLER_0_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09363_ _00661_ _00676_ VGND VGND VPWR VPWR _00677_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08314_ net324 net240 net531 net540 VGND VGND VPWR VPWR _04436_ sky130_fd_sc_hd__and4_1
XFILLER_0_75_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09294_ _00593_ _00607_ _00608_ VGND VGND VPWR VPWR _00609_ sky130_fd_sc_hd__nand3_1
XFILLER_0_62_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_10 net145 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_21 net430 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_145_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_32 net670 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08245_ _03637_ _03669_ VGND VGND VPWR VPWR _03680_ sky130_fd_sc_hd__xnor2_2
XANTENNA_43 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_54 net579 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08176_ _02474_ _02496_ _02485_ VGND VGND VPWR VPWR _02931_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_104_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10971_ net429 net514 net406 net397 VGND VGND VPWR VPWR _02241_ sky130_fd_sc_hd__and4_1
XFILLER_0_69_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12710_ net781 net790 net215 net206 VGND VGND VPWR VPWR _04136_ sky130_fd_sc_hd__and4_1
X_13690_ _05203_ _05204_ VGND VGND VPWR VPWR _05205_ sky130_fd_sc_hd__or2_1
XFILLER_0_66_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12641_ net781 net198 _04041_ _04040_ VGND VGND VPWR VPWR _04060_ sky130_fd_sc_hd__a31o_1
XFILLER_0_77_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15360_ _06918_ _06919_ _06923_ _07025_ VGND VGND VPWR VPWR _07026_ sky130_fd_sc_hd__a31o_1
X_12572_ _03982_ _03983_ _03975_ VGND VGND VPWR VPWR _03984_ sky130_fd_sc_hd__or3b_2
XFILLER_0_93_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14311_ _05868_ _05875_ _05874_ VGND VGND VPWR VPWR _05878_ sky130_fd_sc_hd__a21o_1
XFILLER_0_80_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11523_ _02736_ _02738_ _02737_ VGND VGND VPWR VPWR _02842_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_25_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15291_ _06950_ VGND VGND VPWR VPWR _00101_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_81_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14242_ _05727_ _05802_ VGND VGND VPWR VPWR _05803_ sky130_fd_sc_hd__xor2_1
X_11454_ _02764_ _02765_ _02766_ VGND VGND VPWR VPWR _02767_ sky130_fd_sc_hd__a21o_1
XFILLER_0_34_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10405_ net413 net743 net752 net402 VGND VGND VPWR VPWR _01669_ sky130_fd_sc_hd__a22oi_1
X_14173_ _05618_ _05664_ _05727_ VGND VGND VPWR VPWR _05728_ sky130_fd_sc_hd__o21a_1
X_11385_ _02501_ _02600_ VGND VGND VPWR VPWR _02693_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13124_ net141 net237 VGND VGND VPWR VPWR _04588_ sky130_fd_sc_hd__nand2_1
X_10336_ net106 _01602_ net133 VGND VGND VPWR VPWR _01603_ sky130_fd_sc_hd__mux2_1
XFILLER_0_131_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
X_13055_ _04510_ _04511_ _04410_ _04423_ VGND VGND VPWR VPWR _04514_ sky130_fd_sc_hd__o211ai_1
X_10267_ net115 _01542_ net133 VGND VGND VPWR VPWR _01543_ sky130_fd_sc_hd__mux2_1
X_12006_ _03348_ _03367_ VGND VGND VPWR VPWR _03368_ sky130_fd_sc_hd__xnor2_2
X_10198_ a_cos\[17\] b_sin\[17\] VGND VGND VPWR VPWR _01484_ sky130_fd_sc_hd__nand2_1
XFILLER_0_17_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13957_ _05493_ _05494_ VGND VGND VPWR VPWR _05495_ sky130_fd_sc_hd__nor2_1
X_12908_ net755 net299 VGND VGND VPWR VPWR _04353_ sky130_fd_sc_hd__and2_1
X_13888_ _05336_ _05339_ _05337_ VGND VGND VPWR VPWR _05420_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_33_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15627_ _07301_ _07316_ VGND VGND VPWR VPWR _07317_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_124_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12839_ _04276_ _04277_ VGND VGND VPWR VPWR _04278_ sky130_fd_sc_hd__and2b_1
XFILLER_0_146_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15558_ _07157_ _07241_ VGND VGND VPWR VPWR _07242_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_72_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14509_ _06088_ _06090_ _06095_ VGND VGND VPWR VPWR _06096_ sky130_fd_sc_hd__nand3_1
XFILLER_0_71_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15489_ _07083_ _07087_ _07084_ VGND VGND VPWR VPWR _07166_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_44_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput30 beta[1] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_140_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput41 cos[11] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_1
XFILLER_0_4_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput52 cos[4] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__buf_1
XFILLER_0_71_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput63 sin[13] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_2
Xinput74 sin[6] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__buf_1
XFILLER_0_142_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09981_ _01180_ _01199_ _01286_ VGND VGND VPWR VPWR _01287_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_110_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08932_ net201 net658 VGND VGND VPWR VPWR _00251_ sky130_fd_sc_hd__and2_1
XFILLER_0_149_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08863_ _08015_ _00181_ _00182_ VGND VGND VPWR VPWR _00183_ sky130_fd_sc_hd__nand3_2
XFILLER_0_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08794_ _08008_ _08009_ VGND VGND VPWR VPWR _08104_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09415_ _00639_ _00637_ VGND VGND VPWR VPWR _00729_ sky130_fd_sc_hd__and2b_1
XFILLER_0_66_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09346_ _00194_ net571 _00587_ _00659_ VGND VGND VPWR VPWR _00660_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_118_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09277_ _00510_ _00518_ _00517_ VGND VGND VPWR VPWR _00592_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_62_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08228_ _03431_ _03474_ _03485_ VGND VGND VPWR VPWR _03496_ sky130_fd_sc_hd__nand3_1
XFILLER_0_16_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08159_ net220 net685 VGND VGND VPWR VPWR _02746_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11170_ net517 net803 net48 VGND VGND VPWR VPWR _02458_ sky130_fd_sc_hd__a21oi_1
X_10121_ a_cos\[6\] b_sin\[6\] VGND VGND VPWR VPWR _01418_ sky130_fd_sc_hd__nor2_1
XFILLER_0_100_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10052_ net251 net643 VGND VGND VPWR VPWR _01356_ sky130_fd_sc_hd__nand2_1
X_14860_ _06381_ _06382_ _06383_ VGND VGND VPWR VPWR _06481_ sky130_fd_sc_hd__o21bai_1
X_13811_ net609 net264 net254 net709 VGND VGND VPWR VPWR _05336_ sky130_fd_sc_hd__a22oi_2
X_14791_ net392 net699 VGND VGND VPWR VPWR _06406_ sky130_fd_sc_hd__nand2_1
XFILLER_0_98_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13742_ _05259_ _05260_ VGND VGND VPWR VPWR _05261_ sky130_fd_sc_hd__nor2_1
X_10954_ _02205_ _02220_ _02221_ VGND VGND VPWR VPWR _02222_ sky130_fd_sc_hd__nand3_2
X_13673_ _05049_ _05100_ _05185_ VGND VGND VPWR VPWR _05186_ sky130_fd_sc_hd__a21o_1
X_10885_ _02146_ _02147_ _02148_ VGND VGND VPWR VPWR _02149_ sky130_fd_sc_hd__or3_1
X_15412_ _07004_ _07012_ _07011_ VGND VGND VPWR VPWR _07082_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_39_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12624_ net766 net216 net207 net774 VGND VGND VPWR VPWR _04041_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15343_ net377 net366 net653 net663 VGND VGND VPWR VPWR _07007_ sky130_fd_sc_hd__nand4_1
X_12555_ _03952_ _03953_ _03951_ VGND VGND VPWR VPWR _03966_ sky130_fd_sc_hd__a21o_1
XFILLER_0_65_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11506_ _02820_ _02823_ VGND VGND VPWR VPWR _02824_ sky130_fd_sc_hd__xnor2_2
X_15274_ _06904_ _06931_ VGND VGND VPWR VPWR _06932_ sky130_fd_sc_hd__xnor2_2
X_12486_ _03729_ _03884_ _03889_ VGND VGND VPWR VPWR _03890_ sky130_fd_sc_hd__a21oi_1
X_14225_ _05480_ _05726_ _05728_ VGND VGND VPWR VPWR _05785_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_1_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11437_ _02728_ _02747_ _02748_ VGND VGND VPWR VPWR _02749_ sky130_fd_sc_hd__and3_1
XFILLER_0_111_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14156_ _05708_ _05710_ VGND VGND VPWR VPWR _05711_ sky130_fd_sc_hd__xnor2_2
X_11368_ _02667_ _02668_ _02672_ VGND VGND VPWR VPWR _02674_ sky130_fd_sc_hd__a21oi_1
X_13107_ _04476_ _04495_ _04496_ VGND VGND VPWR VPWR _04570_ sky130_fd_sc_hd__nand3_2
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10319_ _01578_ _01581_ _01587_ VGND VGND VPWR VPWR _01588_ sky130_fd_sc_hd__or3_1
X_14087_ _05474_ _05569_ _05635_ VGND VGND VPWR VPWR _05636_ sky130_fd_sc_hd__and3_1
X_11299_ _02596_ _02597_ _02502_ _02483_ VGND VGND VPWR VPWR _02599_ sky130_fd_sc_hd__a211o_1
X_13038_ _04492_ _04493_ _04494_ VGND VGND VPWR VPWR _04495_ sky130_fd_sc_hd__nand3_4
XFILLER_0_135_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14989_ _06619_ _06620_ _06611_ VGND VGND VPWR VPWR _06622_ sky130_fd_sc_hd__a21o_1
XFILLER_0_89_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09200_ _00419_ _00421_ _00420_ VGND VGND VPWR VPWR _00516_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_146_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09131_ net321 net237 net219 net629 VGND VGND VPWR VPWR _00448_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_8_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09062_ _00377_ _00378_ _00275_ _00300_ VGND VGND VPWR VPWR _00380_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_8_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09964_ _01186_ _01189_ _01269_ VGND VGND VPWR VPWR _01270_ sky130_fd_sc_hd__or3_1
XFILLER_0_0_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08915_ _00231_ _00232_ _00224_ VGND VGND VPWR VPWR _00234_ sky130_fd_sc_hd__a21o_1
X_09895_ _01150_ VGND VGND VPWR VPWR _01202_ sky130_fd_sc_hd__inv_2
X_08846_ _00157_ _00164_ _00165_ VGND VGND VPWR VPWR _00166_ sky130_fd_sc_hd__nand3_2
X_08777_ _08086_ _08087_ VGND VGND VPWR VPWR _08088_ sky130_fd_sc_hd__and2_1
XFILLER_0_94_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10670_ _01928_ _01932_ _01933_ VGND VGND VPWR VPWR _01934_ sky130_fd_sc_hd__nand3_1
X_09329_ _00641_ _00643_ VGND VGND VPWR VPWR _00644_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_8_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12340_ _03727_ _03726_ _03728_ VGND VGND VPWR VPWR _03729_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_51_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12271_ net457 net801 VGND VGND VPWR VPWR _03654_ sky130_fd_sc_hd__nand2_1
X_14010_ _05528_ _05551_ VGND VGND VPWR VPWR _05552_ sky130_fd_sc_hd__nand2_1
X_11222_ _02512_ _02513_ VGND VGND VPWR VPWR _02514_ sky130_fd_sc_hd__xor2_1
XFILLER_0_31_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11153_ _02335_ _02337_ VGND VGND VPWR VPWR _02439_ sky130_fd_sc_hd__nand2_1
X_10104_ _01402_ _01403_ VGND VGND VPWR VPWR _01404_ sky130_fd_sc_hd__xnor2_1
X_15961_ _07659_ _07678_ VGND VGND VPWR VPWR _07679_ sky130_fd_sc_hd__and2_1
X_11084_ _02258_ _02330_ _02362_ _02363_ VGND VGND VPWR VPWR _02364_ sky130_fd_sc_hd__a211oi_2
X_10035_ _01256_ _01281_ VGND VGND VPWR VPWR _01340_ sky130_fd_sc_hd__or2_1
X_14912_ _06535_ _06536_ _06365_ VGND VGND VPWR VPWR _06538_ sky130_fd_sc_hd__a21oi_1
X_15892_ _07253_ _07530_ VGND VGND VPWR VPWR _07604_ sky130_fd_sc_hd__and2_1
X_14843_ _06460_ _06461_ VGND VGND VPWR VPWR _06462_ sky130_fd_sc_hd__nand2_1
XFILLER_0_81_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14774_ _06385_ _06386_ VGND VGND VPWR VPWR _06387_ sky130_fd_sc_hd__xnor2_1
X_11986_ _03343_ _03345_ VGND VGND VPWR VPWR _03346_ sky130_fd_sc_hd__nor2_1
XFILLER_0_105_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13725_ _05139_ _05241_ VGND VGND VPWR VPWR _05243_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_86_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10937_ _02117_ _02124_ VGND VGND VPWR VPWR _02204_ sky130_fd_sc_hd__and2_1
XFILLER_0_14_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13656_ _05165_ _05167_ VGND VGND VPWR VPWR _05168_ sky130_fd_sc_hd__nor2_1
X_10868_ _02045_ _02047_ _02046_ VGND VGND VPWR VPWR _02132_ sky130_fd_sc_hd__o21bai_1
X_12607_ _04014_ _04010_ VGND VGND VPWR VPWR _04023_ sky130_fd_sc_hd__or2b_1
XFILLER_0_144_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13587_ _05089_ _05091_ _05075_ VGND VGND VPWR VPWR _05093_ sky130_fd_sc_hd__a21o_1
XFILLER_0_137_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10799_ _02052_ _02053_ _02062_ VGND VGND VPWR VPWR _02063_ sky130_fd_sc_hd__and3_1
X_15326_ net348 net500 net682 net688 VGND VGND VPWR VPWR _06989_ sky130_fd_sc_hd__nand4_1
XFILLER_0_124_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12538_ net730 net739 net327 net243 VGND VGND VPWR VPWR _03947_ sky130_fd_sc_hd__nand4_2
XFILLER_0_121_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15257_ _06912_ _06913_ VGND VGND VPWR VPWR _06914_ sky130_fd_sc_hd__and2b_1
XFILLER_0_124_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12469_ _03773_ _03810_ _03869_ _03870_ VGND VGND VPWR VPWR _03871_ sky130_fd_sc_hd__a211o_4
XFILLER_0_1_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14208_ _05705_ _05722_ _05766_ VGND VGND VPWR VPWR _05767_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_111_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15188_ _02387_ net604 VGND VGND VPWR VPWR _06839_ sky130_fd_sc_hd__nor2_1
XFILLER_0_69_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14139_ _05601_ _05604_ VGND VGND VPWR VPWR _05692_ sky130_fd_sc_hd__or2_1
XFILLER_0_1_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout409 net410 VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__buf_1
X_08700_ _08009_ _08010_ VGND VGND VPWR VPWR _08011_ sky130_fd_sc_hd__and2_1
X_09680_ _00988_ _00989_ VGND VGND VPWR VPWR _00990_ sky130_fd_sc_hd__nor2_1
X_08631_ _07867_ _07878_ VGND VGND VPWR VPWR _07889_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08562_ net215 net206 net601 net703 VGND VGND VPWR VPWR _07140_ sky130_fd_sc_hd__nand4_1
X_08493_ _06311_ _06322_ _06366_ VGND VGND VPWR VPWR _06388_ sky130_fd_sc_hd__nand3_1
XFILLER_0_71_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09114_ _00429_ _00430_ VGND VGND VPWR VPWR _00431_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09045_ _00361_ _00359_ _00360_ VGND VGND VPWR VPWR _00363_ sky130_fd_sc_hd__nand3_2
XFILLER_0_4_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09947_ _01074_ _01251_ VGND VGND VPWR VPWR _01253_ sky130_fd_sc_hd__nor2_1
X_09878_ net262 net646 net656 net253 VGND VGND VPWR VPWR _01185_ sky130_fd_sc_hd__a22oi_1
X_08829_ _00144_ _00147_ _00148_ VGND VGND VPWR VPWR _00149_ sky130_fd_sc_hd__and3_1
XFILLER_0_99_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11840_ _03172_ _03186_ VGND VGND VPWR VPWR _03187_ sky130_fd_sc_hd__xor2_1
XFILLER_0_68_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11771_ _03091_ _03092_ _03110_ _03111_ VGND VGND VPWR VPWR _03112_ sky130_fd_sc_hd__o211ai_2
X_13510_ _05006_ _05008_ VGND VGND VPWR VPWR _05009_ sky130_fd_sc_hd__xor2_2
X_10722_ _01983_ _01984_ _01943_ _01955_ VGND VGND VPWR VPWR _01986_ sky130_fd_sc_hd__o211a_1
X_14490_ _06066_ _06072_ _06073_ _06074_ VGND VGND VPWR VPWR _06075_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_36_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13441_ _04852_ _04854_ VGND VGND VPWR VPWR _04933_ sky130_fd_sc_hd__nor2_1
X_10653_ net353 net777 net785 net506 VGND VGND VPWR VPWR _01917_ sky130_fd_sc_hd__a22o_1
XFILLER_0_36_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16160_ _07893_ _07847_ VGND VGND VPWR VPWR _07895_ sky130_fd_sc_hd__and2b_1
X_13372_ _04841_ _04857_ VGND VGND VPWR VPWR _04858_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_63_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10584_ _01826_ _01846_ _01847_ VGND VGND VPWR VPWR _01848_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_90_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15111_ b_cos\[3\] _06754_ _05291_ VGND VGND VPWR VPWR _06755_ sky130_fd_sc_hd__mux2_1
XFILLER_0_140_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12323_ net510 net834 net837 net612 VGND VGND VPWR VPWR _03710_ sky130_fd_sc_hd__a22oi_2
X_16091_ _07728_ _07733_ VGND VGND VPWR VPWR _07820_ sky130_fd_sc_hd__and2b_1
XFILLER_0_50_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15042_ _06675_ _06678_ VGND VGND VPWR VPWR _06679_ sky130_fd_sc_hd__xnor2_1
X_12254_ _03585_ _03635_ VGND VGND VPWR VPWR _03636_ sky130_fd_sc_hd__and2_1
X_11205_ _02275_ _02495_ _02380_ VGND VGND VPWR VPWR _02497_ sky130_fd_sc_hd__a21oi_1
X_12185_ _03559_ _03560_ VGND VGND VPWR VPWR _03562_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_118_Left_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11136_ _02416_ _02420_ VGND VGND VPWR VPWR _02421_ sky130_fd_sc_hd__xnor2_1
X_11067_ net513 net390 VGND VGND VPWR VPWR _02346_ sky130_fd_sc_hd__and2_1
X_15944_ _07610_ _07628_ _07626_ VGND VGND VPWR VPWR _07660_ sky130_fd_sc_hd__a21o_1
X_10018_ _01302_ _01303_ _01321_ VGND VGND VPWR VPWR _01323_ sky130_fd_sc_hd__nand3_1
X_15875_ net456 net671 net680 net448 VGND VGND VPWR VPWR _07586_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_25_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14826_ _06442_ _06444_ VGND VGND VPWR VPWR _06445_ sky130_fd_sc_hd__or2_1
XFILLER_0_59_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14757_ _06321_ _06327_ VGND VGND VPWR VPWR _06369_ sky130_fd_sc_hd__and2b_1
X_11969_ net613 net441 VGND VGND VPWR VPWR _03327_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13708_ net319 net295 VGND VGND VPWR VPWR _05224_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_127_Left_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14688_ net392 net532 VGND VGND VPWR VPWR _06293_ sky130_fd_sc_hd__nand2_1
X_13639_ _05142_ _05148_ VGND VGND VPWR VPWR _05149_ sky130_fd_sc_hd__xor2_1
XFILLER_0_26_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15309_ _06969_ VGND VGND VPWR VPWR _06970_ sky130_fd_sc_hd__inv_2
XFILLER_0_125_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16289_ clknet_4_11_0_clk _00078_ net342 VGND VGND VPWR VPWR a_sin\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_140_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_136_Left_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout206 net207 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__clkbuf_4
Xfanout217 net218 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__buf_6
XFILLER_0_1_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09801_ _01049_ _01109_ VGND VGND VPWR VPWR _01110_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_5_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout228 net235 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout239 net69 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__buf_2
X_09732_ _01041_ _00961_ VGND VGND VPWR VPWR _01042_ sky130_fd_sc_hd__and2_1
X_09663_ _00904_ _00973_ VGND VGND VPWR VPWR _00974_ sky130_fd_sc_hd__xnor2_2
X_08614_ net274 net702 _03888_ _03899_ VGND VGND VPWR VPWR _07705_ sky130_fd_sc_hd__a31o_1
X_09594_ _00867_ _00869_ VGND VGND VPWR VPWR _00905_ sky130_fd_sc_hd__nor2_1
XFILLER_0_139_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08545_ _06682_ _06933_ VGND VGND VPWR VPWR _06954_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_145_Left_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08476_ _05730_ _06190_ _05709_ VGND VGND VPWR VPWR _06201_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_18_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09028_ net185 net175 net668 net678 VGND VGND VPWR VPWR _00346_ sky130_fd_sc_hd__nand4_2
XFILLER_0_131_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout740 net744 VGND VGND VPWR VPWR net740 sky130_fd_sc_hd__clkbuf_4
Xfanout751 net753 VGND VGND VPWR VPWR net751 sky130_fd_sc_hd__clkbuf_4
Xfanout762 net15 VGND VGND VPWR VPWR net762 sky130_fd_sc_hd__buf_4
X_13990_ _05478_ _05497_ _05529_ VGND VGND VPWR VPWR _05530_ sky130_fd_sc_hd__a21o_1
Xfanout773 net13 VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout784 net12 VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__clkbuf_4
Xfanout795 net796 VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__buf_2
X_12941_ _04386_ _04387_ _04385_ VGND VGND VPWR VPWR _04389_ sky130_fd_sc_hd__o21ai_1
X_15660_ _07350_ _07351_ VGND VGND VPWR VPWR _07352_ sky130_fd_sc_hd__xnor2_1
X_12872_ _03873_ _04313_ VGND VGND VPWR VPWR _04314_ sky130_fd_sc_hd__xnor2_2
X_14611_ net411 net400 net700 net532 VGND VGND VPWR VPWR _06208_ sky130_fd_sc_hd__and4_1
X_11823_ a_cos\[10\] _03168_ _02383_ VGND VGND VPWR VPWR _03169_ sky130_fd_sc_hd__mux2_1
X_15591_ _07275_ _07276_ VGND VGND VPWR VPWR _07277_ sky130_fd_sc_hd__nor2_1
X_14542_ _06075_ _06077_ _06076_ VGND VGND VPWR VPWR _06132_ sky130_fd_sc_hd__a21o_1
XFILLER_0_95_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11754_ _03047_ _03055_ _03054_ VGND VGND VPWR VPWR _03093_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10705_ _01965_ _01968_ VGND VGND VPWR VPWR _01969_ sky130_fd_sc_hd__xnor2_1
X_14473_ _06054_ _06055_ VGND VGND VPWR VPWR _06056_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_127_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11685_ _02970_ VGND VGND VPWR VPWR _03019_ sky130_fd_sc_hd__inv_2
X_16212_ clknet_4_11_0_clk _00001_ net343 VGND VGND VPWR VPWR b_sin\[1\] sky130_fd_sc_hd__dfrtp_2
X_13424_ _04859_ _04914_ VGND VGND VPWR VPWR _04915_ sky130_fd_sc_hd__xor2_2
X_10636_ _01876_ _01854_ VGND VGND VPWR VPWR _01900_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16143_ _07874_ _07875_ VGND VGND VPWR VPWR _07876_ sky130_fd_sc_hd__xnor2_1
X_13355_ _04757_ _04758_ _04838_ VGND VGND VPWR VPWR _04840_ sky130_fd_sc_hd__a21o_1
X_10567_ _01824_ _01823_ VGND VGND VPWR VPWR _01831_ sky130_fd_sc_hd__and2b_1
XFILLER_0_122_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12306_ _03688_ _03689_ _03691_ VGND VGND VPWR VPWR _03692_ sky130_fd_sc_hd__or3_1
XFILLER_0_87_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16074_ _07605_ _07788_ _07800_ VGND VGND VPWR VPWR _07801_ sky130_fd_sc_hd__nor3_1
X_13286_ net728 net291 net282 net736 VGND VGND VPWR VPWR _04765_ sky130_fd_sc_hd__a22oi_2
X_10498_ net421 net770 VGND VGND VPWR VPWR _01762_ sky130_fd_sc_hd__and2_1
X_15025_ net593 _06455_ _06557_ _06558_ VGND VGND VPWR VPWR _06661_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_121_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12237_ _03557_ _03556_ VGND VGND VPWR VPWR _03618_ sky130_fd_sc_hd__and2b_1
XFILLER_0_20_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12168_ _03541_ _03542_ VGND VGND VPWR VPWR _03543_ sky130_fd_sc_hd__or2_1
X_11119_ _02394_ _02401_ VGND VGND VPWR VPWR _02402_ sky130_fd_sc_hd__xor2_1
X_12099_ net231 net457 net449 net315 VGND VGND VPWR VPWR _03468_ sky130_fd_sc_hd__a22oi_2
X_15927_ _07567_ _07568_ VGND VGND VPWR VPWR _07643_ sky130_fd_sc_hd__nor2_1
Xinput6 alpha[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_1
XFILLER_0_78_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15858_ _07461_ _07485_ VGND VGND VPWR VPWR _07568_ sky130_fd_sc_hd__and2_1
XFILLER_0_59_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14809_ _06405_ _06424_ _06425_ VGND VGND VPWR VPWR _06426_ sky130_fd_sc_hd__and3_1
X_15789_ _07415_ _07418_ _07414_ VGND VGND VPWR VPWR _07493_ sky130_fd_sc_hd__a21oi_1
X_08330_ _04141_ _04317_ VGND VGND VPWR VPWR _04611_ sky130_fd_sc_hd__and2_1
XFILLER_0_129_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08261_ _03811_ _03844_ VGND VGND VPWR VPWR _03855_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08192_ _03073_ _03094_ VGND VGND VPWR VPWR _03105_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09715_ _00946_ _00949_ _00947_ VGND VGND VPWR VPWR _01025_ sky130_fd_sc_hd__o21ba_1
X_09646_ _00953_ _00956_ VGND VGND VPWR VPWR _00957_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09577_ _00886_ _00887_ VGND VGND VPWR VPWR _00889_ sky130_fd_sc_hd__or2_1
XFILLER_0_78_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08528_ _06355_ _06333_ _06344_ VGND VGND VPWR VPWR _06769_ sky130_fd_sc_hd__or3_4
XFILLER_0_77_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08459_ _05752_ _05915_ _05904_ VGND VGND VPWR VPWR _06014_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11470_ _02678_ _02679_ VGND VGND VPWR VPWR _02785_ sky130_fd_sc_hd__and2b_1
XFILLER_0_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10421_ _01681_ _01684_ VGND VGND VPWR VPWR _01685_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_135_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13140_ _04569_ _04604_ _04605_ VGND VGND VPWR VPWR _04606_ sky130_fd_sc_hd__or3_4
X_10352_ _01614_ _01615_ VGND VGND VPWR VPWR _01616_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13071_ net763 net275 net269 net772 VGND VGND VPWR VPWR _04530_ sky130_fd_sc_hd__a22o_1
X_10283_ net858 VGND VGND VPWR VPWR _01556_ sky130_fd_sc_hd__inv_2
X_12022_ _03381_ _03384_ VGND VGND VPWR VPWR _03385_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout570 net34 VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__buf_2
Xfanout581 net588 VGND VGND VPWR VPWR net581 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout592 net598 VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__clkbuf_4
X_13973_ _05439_ _05436_ VGND VGND VPWR VPWR _05512_ sky130_fd_sc_hd__and2b_1
XFILLER_0_73_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12924_ net711 net187 net178 net720 VGND VGND VPWR VPWR _04370_ sky130_fd_sc_hd__a22o_1
X_15712_ _07392_ _07408_ VGND VGND VPWR VPWR _07409_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12855_ _04292_ _04293_ _04285_ VGND VGND VPWR VPWR _04296_ sky130_fd_sc_hd__a21o_1
X_15643_ _07154_ _07152_ VGND VGND VPWR VPWR _07334_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11806_ _03147_ _03150_ VGND VGND VPWR VPWR _03151_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_28_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15574_ net387 _07108_ _07191_ VGND VGND VPWR VPWR _07258_ sky130_fd_sc_hd__a21o_2
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12786_ _04193_ _04192_ _04195_ _04219_ VGND VGND VPWR VPWR _04220_ sky130_fd_sc_hd__o22a_1
X_14525_ net409 net706 VGND VGND VPWR VPWR _06114_ sky130_fd_sc_hd__nand2_1
X_11737_ _03072_ _03075_ VGND VGND VPWR VPWR _03076_ sky130_fd_sc_hd__xor2_1
XFILLER_0_126_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14456_ _06028_ _06029_ _06035_ VGND VGND VPWR VPWR _06038_ sky130_fd_sc_hd__and3_1
XFILLER_0_126_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11668_ _02922_ _02925_ _02923_ VGND VGND VPWR VPWR _03000_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_37_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13407_ net150 net193 VGND VGND VPWR VPWR _04897_ sky130_fd_sc_hd__and2_1
XFILLER_0_52_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10619_ net418 net809 _01881_ _01882_ VGND VGND VPWR VPWR _01883_ sky130_fd_sc_hd__and4_1
XFILLER_0_141_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14387_ _05906_ _05909_ _05907_ VGND VGND VPWR VPWR _05962_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_24_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11599_ net758 _02385_ VGND VGND VPWR VPWR _02925_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16126_ _07682_ _07857_ VGND VGND VPWR VPWR _07858_ sky130_fd_sc_hd__xnor2_1
X_13338_ net831 net830 VGND VGND VPWR VPWR _04822_ sky130_fd_sc_hd__xor2_2
XFILLER_0_110_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16057_ next_state _07780_ _07782_ _07783_ VGND VGND VPWR VPWR _00111_ sky130_fd_sc_hd__a31o_1
X_13269_ net754 net267 net258 net763 VGND VGND VPWR VPWR _04746_ sky130_fd_sc_hd__a22oi_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_121_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15008_ _06640_ _06641_ _06553_ _06537_ VGND VGND VPWR VPWR _06643_ sky130_fd_sc_hd__a211o_1
XFILLER_0_138_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09500_ _00658_ _00731_ _00812_ VGND VGND VPWR VPWR _00813_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_78_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09431_ net289 net681 net689 net280 VGND VGND VPWR VPWR _00744_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_149_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09362_ _00674_ _00675_ VGND VGND VPWR VPWR _00676_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_75_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08313_ net324 net531 net540 net240 VGND VGND VPWR VPWR _04425_ sky130_fd_sc_hd__a22oi_2
X_09293_ _00605_ _00606_ _00598_ VGND VGND VPWR VPWR _00608_ sky130_fd_sc_hd__a21o_1
XANTENNA_11 net155 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_22 net866 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_144_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08244_ _03647_ _03658_ VGND VGND VPWR VPWR _03669_ sky130_fd_sc_hd__nor2_1
XANTENNA_33 net670 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_44 net13 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_55 net608 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08175_ _02637_ _02659_ _02648_ VGND VGND VPWR VPWR _02920_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_42_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10970_ net615 net389 VGND VGND VPWR VPWR _02240_ sky130_fd_sc_hd__nand2_1
X_09629_ _00844_ _00864_ _00865_ VGND VGND VPWR VPWR _00940_ sky130_fd_sc_hd__nand3_1
XFILLER_0_97_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12640_ net791 net805 net191 net181 VGND VGND VPWR VPWR _04059_ sky130_fd_sc_hd__and4_1
XFILLER_0_84_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12571_ _03928_ _03981_ _03970_ _03980_ VGND VGND VPWR VPWR _03983_ sky130_fd_sc_hd__o211a_1
XFILLER_0_93_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14310_ _05831_ _05832_ _05825_ VGND VGND VPWR VPWR _05877_ sky130_fd_sc_hd__a21bo_1
X_11522_ _02837_ _02838_ _02839_ VGND VGND VPWR VPWR _02841_ sky130_fd_sc_hd__nand3_1
X_15290_ b_cos\[5\] _06948_ _06949_ VGND VGND VPWR VPWR _06950_ sky130_fd_sc_hd__mux2_1
XFILLER_0_34_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14241_ _05801_ _05742_ _05746_ VGND VGND VPWR VPWR _05802_ sky130_fd_sc_hd__mux2_1
X_11453_ net389 net154 VGND VGND VPWR VPWR _02766_ sky130_fd_sc_hd__and2_1
X_10404_ _01665_ _01666_ _01667_ VGND VGND VPWR VPWR _01668_ sky130_fd_sc_hd__nand3_1
X_14172_ _05479_ _05726_ VGND VGND VPWR VPWR _05727_ sky130_fd_sc_hd__xnor2_2
X_11384_ _02492_ _02493_ _02601_ VGND VGND VPWR VPWR _02691_ sky130_fd_sc_hd__and3_1
XFILLER_0_110_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13123_ _04483_ _04484_ _04485_ VGND VGND VPWR VPWR _04587_ sky130_fd_sc_hd__nor3_1
XFILLER_0_21_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10335_ _01598_ _01601_ VGND VGND VPWR VPWR _01602_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_103_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13054_ _04410_ _04423_ _04510_ _04511_ VGND VGND VPWR VPWR _04512_ sky130_fd_sc_hd__a211o_1
X_10266_ _01540_ _01541_ VGND VGND VPWR VPWR _01542_ sky130_fd_sc_hd__xnor2_2
X_12005_ _03364_ _03365_ VGND VGND VPWR VPWR _03367_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10197_ _01483_ VGND VGND VPWR VPWR _00035_ sky130_fd_sc_hd__clkbuf_1
X_13956_ _05488_ _05390_ _05491_ VGND VGND VPWR VPWR _05494_ sky130_fd_sc_hd__nor3_1
XFILLER_0_17_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12907_ net739 net746 net161 net308 VGND VGND VPWR VPWR _04352_ sky130_fd_sc_hd__nand4_2
X_13887_ _05412_ _05418_ VGND VGND VPWR VPWR _05419_ sky130_fd_sc_hd__xnor2_1
X_12838_ _04274_ _04275_ _04270_ VGND VGND VPWR VPWR _04277_ sky130_fd_sc_hd__a21o_1
X_15626_ _07313_ _07315_ VGND VGND VPWR VPWR _07316_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_57_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12769_ _04199_ _04200_ VGND VGND VPWR VPWR _04201_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15557_ _07237_ _07240_ VGND VGND VPWR VPWR _07241_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_127_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14508_ net418 net605 _06094_ _06092_ VGND VGND VPWR VPWR _06095_ sky130_fd_sc_hd__a31o_1
X_15488_ _07162_ _07163_ net443 net555 VGND VGND VPWR VPWR _07165_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_126_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput20 beta[0] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__buf_2
XFILLER_0_25_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput31 beta[2] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_1
X_14439_ _06017_ _06018_ VGND VGND VPWR VPWR _06019_ sky130_fd_sc_hd__and2b_1
XFILLER_0_126_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput42 cos[12] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_142_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput53 cos[5] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__buf_2
XFILLER_0_25_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput64 sin[14] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_2
Xinput75 sin[7] VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__buf_1
XFILLER_0_3_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16109_ _07769_ _07772_ _07839_ VGND VGND VPWR VPWR _07840_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_150_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09980_ _01198_ _01183_ VGND VGND VPWR VPWR _01286_ sky130_fd_sc_hd__and2b_1
XFILLER_0_149_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08931_ _00241_ _00249_ VGND VGND VPWR VPWR _00250_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08862_ _00179_ _00180_ _08076_ _08095_ VGND VGND VPWR VPWR _00182_ sky130_fd_sc_hd__o211ai_2
X_08793_ _08101_ _08102_ VGND VGND VPWR VPWR _08103_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09414_ _00678_ _00727_ VGND VGND VPWR VPWR _00728_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_94_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09345_ _00584_ _00586_ VGND VGND VPWR VPWR _00659_ sky130_fd_sc_hd__or2b_1
XFILLER_0_63_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09276_ _00572_ _00590_ VGND VGND VPWR VPWR _00591_ sky130_fd_sc_hd__xor2_2
XFILLER_0_118_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08227_ _03453_ _03463_ _03442_ VGND VGND VPWR VPWR _03485_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_117_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08158_ _02397_ _02419_ _02408_ VGND VGND VPWR VPWR _02735_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_31_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10120_ _01417_ VGND VGND VPWR VPWR _00024_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_101_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10051_ _01353_ _01354_ VGND VGND VPWR VPWR _01355_ sky130_fd_sc_hd__xor2_1
X_13810_ _05215_ _05218_ _05216_ VGND VGND VPWR VPWR _05335_ sky130_fd_sc_hd__o21ba_1
X_14790_ _06395_ _06404_ VGND VGND VPWR VPWR _06405_ sky130_fd_sc_hd__xor2_2
X_13741_ net709 net718 net264 net254 VGND VGND VPWR VPWR _05260_ sky130_fd_sc_hd__and4_1
X_10953_ _02218_ _02219_ _02210_ VGND VGND VPWR VPWR _02221_ sky130_fd_sc_hd__a21o_1
X_13672_ _05097_ _05099_ VGND VGND VPWR VPWR _05185_ sky130_fd_sc_hd__and2_1
X_10884_ net518 net233 net432 net318 VGND VGND VPWR VPWR _02148_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_85_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12623_ net766 net774 net216 net207 VGND VGND VPWR VPWR _04040_ sky130_fd_sc_hd__and4_1
X_15411_ _06994_ _06996_ VGND VGND VPWR VPWR _07081_ sky130_fd_sc_hd__nand2_1
XFILLER_0_109_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15342_ net377 net653 net663 net366 VGND VGND VPWR VPWR _07006_ sky130_fd_sc_hd__a22o_1
X_12554_ _03959_ _03963_ VGND VGND VPWR VPWR _03964_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_108_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11505_ _02716_ _02718_ _02821_ VGND VGND VPWR VPWR _02823_ sky130_fd_sc_hd__a21o_1
XFILLER_0_136_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15273_ _06929_ _06930_ VGND VGND VPWR VPWR _06931_ sky130_fd_sc_hd__xnor2_2
X_12485_ _03885_ _03886_ _03887_ VGND VGND VPWR VPWR _03889_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_124_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14224_ net312 _00195_ _05755_ _05782_ VGND VGND VPWR VPWR _05783_ sky130_fd_sc_hd__o31a_1
X_11436_ _02744_ _02745_ _02729_ VGND VGND VPWR VPWR _02748_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14155_ _05643_ _05646_ _05642_ VGND VGND VPWR VPWR _05710_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_1_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11367_ _02667_ _02668_ _02672_ VGND VGND VPWR VPWR _02673_ sky130_fd_sc_hd__and3_1
XFILLER_0_21_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13106_ _04566_ _04568_ VGND VGND VPWR VPWR _04569_ sky130_fd_sc_hd__or2_1
X_10318_ _01585_ _01586_ VGND VGND VPWR VPWR _01587_ sky130_fd_sc_hd__nor2_1
X_14086_ _05632_ _05634_ VGND VGND VPWR VPWR _05635_ sky130_fd_sc_hd__nand2_1
X_11298_ _02502_ _02483_ _02596_ _02597_ VGND VGND VPWR VPWR _02598_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_28_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13037_ _04384_ _04392_ _04391_ VGND VGND VPWR VPWR _04494_ sky130_fd_sc_hd__a21bo_1
X_10249_ a_sin\[6\] b_cos\[6\] VGND VGND VPWR VPWR _01527_ sky130_fd_sc_hd__or2b_1
XFILLER_0_119_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14988_ _06611_ _06619_ _06620_ VGND VGND VPWR VPWR _06621_ sky130_fd_sc_hd__nand3_2
X_13939_ _05137_ _05401_ VGND VGND VPWR VPWR _05475_ sky130_fd_sc_hd__or2_2
XFILLER_0_89_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15609_ _07271_ _07296_ VGND VGND VPWR VPWR _07297_ sky130_fd_sc_hd__xor2_1
XFILLER_0_91_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09130_ net321 net237 net219 VGND VGND VPWR VPWR _00447_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_44_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09061_ _00275_ _00300_ _00377_ _00378_ VGND VGND VPWR VPWR _00379_ sky130_fd_sc_hd__a211o_1
XFILLER_0_60_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09963_ _01267_ _01268_ VGND VGND VPWR VPWR _01269_ sky130_fd_sc_hd__and2_1
XFILLER_0_110_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08914_ _00224_ _00231_ _00232_ VGND VGND VPWR VPWR _00233_ sky130_fd_sc_hd__nand3_2
X_09894_ _01180_ _01199_ VGND VGND VPWR VPWR _01201_ sky130_fd_sc_hd__or2_1
X_08845_ _00161_ _00162_ _00163_ VGND VGND VPWR VPWR _00165_ sky130_fd_sc_hd__a21o_1
X_08776_ _07999_ _07998_ _08084_ _08085_ VGND VGND VPWR VPWR _08087_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_94_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_137_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09328_ _00502_ _00554_ _00642_ VGND VGND VPWR VPWR _00643_ sky130_fd_sc_hd__a21oi_2
Xclone23 net330 VGND VGND VPWR VPWR net834 sky130_fd_sc_hd__buf_4
XFILLER_0_63_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09259_ _00503_ _00521_ _00573_ VGND VGND VPWR VPWR _00574_ sky130_fd_sc_hd__a21o_1
XFILLER_0_133_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12270_ net231 net441 _03608_ _03652_ VGND VGND VPWR VPWR _03653_ sky130_fd_sc_hd__a31o_1
XFILLER_0_121_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11221_ net784 net445 VGND VGND VPWR VPWR _02513_ sky130_fd_sc_hd__nand2_1
XFILLER_0_120_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11152_ _02341_ _02360_ _02361_ VGND VGND VPWR VPWR _02438_ sky130_fd_sc_hd__nand3_2
X_10103_ _01394_ _01395_ _01396_ VGND VGND VPWR VPWR _01403_ sky130_fd_sc_hd__o21ai_1
X_15960_ _07660_ _07677_ VGND VGND VPWR VPWR _07678_ sky130_fd_sc_hd__xnor2_1
X_11083_ _02360_ _02361_ _02341_ VGND VGND VPWR VPWR _02363_ sky130_fd_sc_hd__a21oi_1
X_10034_ _01337_ _01338_ VGND VGND VPWR VPWR _01339_ sky130_fd_sc_hd__nor2_1
X_14911_ _06365_ _06535_ _06536_ VGND VGND VPWR VPWR _06537_ sky130_fd_sc_hd__and3_1
X_15891_ _07582_ _07601_ VGND VGND VPWR VPWR _07603_ sky130_fd_sc_hd__nor2_1
X_14842_ _06362_ _06459_ VGND VGND VPWR VPWR _06461_ sky130_fd_sc_hd__or2_1
XFILLER_0_98_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14773_ _06323_ _06325_ _06324_ VGND VGND VPWR VPWR _06386_ sky130_fd_sc_hd__o21ba_1
X_11985_ _03044_ _03272_ VGND VGND VPWR VPWR _03345_ sky130_fd_sc_hd__and2_1
XFILLER_0_58_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13724_ _05234_ _05240_ VGND VGND VPWR VPWR _05241_ sky130_fd_sc_hd__xnor2_1
X_10936_ _02123_ _02122_ VGND VGND VPWR VPWR _02203_ sky130_fd_sc_hd__and2b_1
XFILLER_0_105_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13655_ net718 net727 net264 net254 VGND VGND VPWR VPWR _05167_ sky130_fd_sc_hd__and4_1
XFILLER_0_128_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10867_ net362 net751 _02059_ _02058_ VGND VGND VPWR VPWR _02131_ sky130_fd_sc_hd__a31o_1
XFILLER_0_27_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12606_ _04006_ _04008_ VGND VGND VPWR VPWR _04022_ sky130_fd_sc_hd__or2b_1
X_13586_ _05075_ _05089_ _05091_ VGND VGND VPWR VPWR _05092_ sky130_fd_sc_hd__nand3_1
X_10798_ _02054_ _02061_ VGND VGND VPWR VPWR _02062_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_53_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12537_ net730 net327 net243 net739 VGND VGND VPWR VPWR _03946_ sky130_fd_sc_hd__a22o_1
X_15325_ net348 net682 net688 net500 VGND VGND VPWR VPWR _06988_ sky130_fd_sc_hd__a22o_1
XFILLER_0_136_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12468_ _03845_ _03846_ _03867_ _03868_ VGND VGND VPWR VPWR _03870_ sky130_fd_sc_hd__a2bb2oi_1
X_15256_ _06909_ _06910_ _06906_ VGND VGND VPWR VPWR _06913_ sky130_fd_sc_hd__a21o_1
XFILLER_0_34_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11419_ _02653_ _02661_ _02660_ VGND VGND VPWR VPWR _02729_ sky130_fd_sc_hd__a21o_1
XFILLER_0_22_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14207_ _05762_ _05765_ VGND VGND VPWR VPWR _05766_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_112_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15187_ _06834_ _06837_ VGND VGND VPWR VPWR _06838_ sky130_fd_sc_hd__xor2_1
X_12399_ net765 net772 net162 net309 VGND VGND VPWR VPWR _03794_ sky130_fd_sc_hd__and4_1
XFILLER_0_10_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14138_ _05689_ _05690_ VGND VGND VPWR VPWR _05691_ sky130_fd_sc_hd__nor2_1
XFILLER_0_39_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14069_ _05595_ _05549_ _05615_ VGND VGND VPWR VPWR _05616_ sky130_fd_sc_hd__a21o_1
XFILLER_0_146_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08630_ _07845_ _07856_ VGND VGND VPWR VPWR _07878_ sky130_fd_sc_hd__and2_1
XFILLER_0_146_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08561_ net215 net601 net703 net206 VGND VGND VPWR VPWR _07129_ sky130_fd_sc_hd__a22o_1
XFILLER_0_77_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08492_ _06311_ _06322_ _06366_ VGND VGND VPWR VPWR _06377_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09113_ _00427_ _00428_ _00414_ VGND VGND VPWR VPWR _00430_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_72_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09044_ _00359_ _00360_ _00361_ VGND VGND VPWR VPWR _00362_ sky130_fd_sc_hd__a21o_1
XFILLER_0_32_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09946_ _01074_ _01251_ VGND VGND VPWR VPWR _01252_ sky130_fd_sc_hd__and2_1
X_09877_ _01146_ _01149_ _01147_ VGND VGND VPWR VPWR _01184_ sky130_fd_sc_hd__o21ba_1
X_08828_ net169 net530 _00145_ _00146_ VGND VGND VPWR VPWR _00148_ sky130_fd_sc_hd__nand4_1
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08759_ _08051_ _08068_ _08069_ VGND VGND VPWR VPWR _08070_ sky130_fd_sc_hd__and3_1
X_11770_ _03108_ _03109_ _03093_ VGND VGND VPWR VPWR _03111_ sky130_fd_sc_hd__a21o_1
XFILLER_0_67_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10721_ _01943_ _01955_ _01983_ _01984_ VGND VGND VPWR VPWR _01985_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_82_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13440_ _04840_ _04858_ _04931_ VGND VGND VPWR VPWR _04932_ sky130_fd_sc_hd__a21o_1
XFILLER_0_119_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10652_ net353 net506 net777 net785 VGND VGND VPWR VPWR _01916_ sky130_fd_sc_hd__and4_1
XFILLER_0_125_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13371_ _04855_ _04856_ VGND VGND VPWR VPWR _04857_ sky130_fd_sc_hd__xnor2_2
X_10583_ _01843_ _01845_ _01827_ _01808_ VGND VGND VPWR VPWR _01847_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_63_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12322_ net509 net612 net329 net245 VGND VGND VPWR VPWR _03709_ sky130_fd_sc_hd__and4_1
X_15110_ _06751_ _06753_ VGND VGND VPWR VPWR _06754_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16090_ _07817_ _07818_ VGND VGND VPWR VPWR _07819_ sky130_fd_sc_hd__xor2_1
XFILLER_0_134_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15041_ net556 _06676_ _06677_ VGND VGND VPWR VPWR _06678_ sky130_fd_sc_hd__a21bo_1
X_12253_ _03633_ _03634_ VGND VGND VPWR VPWR _03635_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11204_ _02098_ _02184_ _02275_ _02276_ VGND VGND VPWR VPWR _02495_ sky130_fd_sc_hd__or4bb_1
XFILLER_0_31_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12184_ _03475_ _03473_ VGND VGND VPWR VPWR _03560_ sky130_fd_sc_hd__and2b_1
X_11135_ net486 _02417_ _02418_ VGND VGND VPWR VPWR _02420_ sky130_fd_sc_hd__a21bo_1
X_11066_ net407 _02342_ _02344_ VGND VGND VPWR VPWR _02345_ sky130_fd_sc_hd__a21bo_1
X_15943_ _07598_ _07599_ _07658_ VGND VGND VPWR VPWR _07659_ sky130_fd_sc_hd__o21ai_1
X_10017_ _01302_ _01303_ _01321_ VGND VGND VPWR VPWR _01322_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15874_ _07511_ _07514_ _07512_ VGND VGND VPWR VPWR _07584_ sky130_fd_sc_hd__o21ba_1
X_14825_ _06270_ _06273_ _06351_ _06352_ _06266_ VGND VGND VPWR VPWR _06444_ sky130_fd_sc_hd__o2111a_1
X_14756_ _06365_ _06367_ VGND VGND VPWR VPWR _06368_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11968_ _03324_ _03325_ VGND VGND VPWR VPWR _03326_ sky130_fd_sc_hd__nor2_1
XFILLER_0_129_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13707_ _05221_ _05222_ VGND VGND VPWR VPWR _05223_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10919_ _02184_ _02185_ VGND VGND VPWR VPWR _02186_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_129_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14687_ _06288_ _06290_ _06284_ VGND VGND VPWR VPWR _06292_ sky130_fd_sc_hd__a21o_1
X_11899_ _03190_ _03195_ _03250_ VGND VGND VPWR VPWR _03251_ sky130_fd_sc_hd__a21oi_2
X_13638_ _05146_ _05147_ VGND VGND VPWR VPWR _05148_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13569_ _04971_ VGND VGND VPWR VPWR _05073_ sky130_fd_sc_hd__inv_2
XFILLER_0_125_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15308_ net568 _06866_ _06869_ _06870_ VGND VGND VPWR VPWR _06969_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_14_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16288_ clknet_4_10_0_clk _00077_ net344 VGND VGND VPWR VPWR a_sin\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_2_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15239_ _06890_ _06891_ _06892_ VGND VGND VPWR VPWR _06894_ sky130_fd_sc_hd__nand3_1
XFILLER_0_10_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout207 net208 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__clkbuf_4
X_09800_ _01106_ _01108_ VGND VGND VPWR VPWR _01109_ sky130_fd_sc_hd__xnor2_2
Xfanout218 net71 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__buf_6
Xfanout229 net230 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__buf_4
X_09731_ _00959_ _00944_ VGND VGND VPWR VPWR _01041_ sky130_fd_sc_hd__or2b_1
XFILLER_0_66_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09662_ _00970_ _00972_ VGND VGND VPWR VPWR _00973_ sky130_fd_sc_hd__xnor2_2
X_08613_ _06660_ _07651_ _07672_ _07683_ _05719_ VGND VGND VPWR VPWR _07694_ sky130_fd_sc_hd__a2111oi_4
X_09593_ _00898_ _00899_ VGND VGND VPWR VPWR _00904_ sky130_fd_sc_hd__and2b_1
XFILLER_0_96_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08544_ _06682_ _06933_ VGND VGND VPWR VPWR _06944_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08475_ _06135_ _06168_ _06179_ _05687_ VGND VGND VPWR VPWR _06190_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_9_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09027_ net185 net668 net678 net175 VGND VGND VPWR VPWR _00345_ sky130_fd_sc_hd__a22o_1
XFILLER_0_5_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout730 net735 VGND VGND VPWR VPWR net730 sky130_fd_sc_hd__clkbuf_4
Xfanout741 net744 VGND VGND VPWR VPWR net741 sky130_fd_sc_hd__clkbuf_2
X_09929_ _01174_ _01235_ VGND VGND VPWR VPWR _01236_ sky130_fd_sc_hd__or2_1
Xfanout752 net753 VGND VGND VPWR VPWR net752 sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_130_Right_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout763 net764 VGND VGND VPWR VPWR net763 sky130_fd_sc_hd__clkbuf_4
Xfanout774 net13 VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__clkbuf_4
Xfanout785 net787 VGND VGND VPWR VPWR net785 sky130_fd_sc_hd__clkbuf_4
Xfanout796 net11 VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__buf_4
X_12940_ _04385_ _04386_ _04387_ VGND VGND VPWR VPWR _04388_ sky130_fd_sc_hd__or3_1
XFILLER_0_99_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12871_ _04311_ _04312_ VGND VGND VPWR VPWR _04313_ sky130_fd_sc_hd__nand2_1
X_14610_ net392 net541 VGND VGND VPWR VPWR _06207_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_842 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11822_ _03089_ _03167_ VGND VGND VPWR VPWR _03168_ sky130_fd_sc_hd__xor2_1
X_15590_ net484 net474 net681 net687 VGND VGND VPWR VPWR _07276_ sky130_fd_sc_hd__and4_1
XFILLER_0_68_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14541_ _06108_ _06109_ _06111_ _06130_ VGND VGND VPWR VPWR _06131_ sky130_fd_sc_hd__nor4_1
X_11753_ _03026_ _03034_ _03035_ VGND VGND VPWR VPWR _03092_ sky130_fd_sc_hd__and3_1
XFILLER_0_138_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10704_ _01966_ _01967_ VGND VGND VPWR VPWR _01968_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14472_ net391 net706 VGND VGND VPWR VPWR _06055_ sky130_fd_sc_hd__nand2_1
X_11684_ _03000_ _03016_ VGND VGND VPWR VPWR _03017_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_64_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16211_ clknet_4_11_0_clk _00000_ net342 VGND VGND VPWR VPWR b_sin\[0\] sky130_fd_sc_hd__dfrtp_2
X_13423_ _04911_ _04913_ VGND VGND VPWR VPWR _04914_ sky130_fd_sc_hd__xor2_2
X_10635_ _01819_ _01849_ VGND VGND VPWR VPWR _01899_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13354_ _04754_ _04756_ VGND VGND VPWR VPWR _04838_ sky130_fd_sc_hd__nor2_1
X_16142_ _07811_ _07815_ _07812_ VGND VGND VPWR VPWR _07875_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_107_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10566_ _01800_ _01799_ _01792_ VGND VGND VPWR VPWR _01830_ sky130_fd_sc_hd__a21o_1
X_12305_ net612 net834 net837 net712 VGND VGND VPWR VPWR _03691_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_122_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13285_ _04684_ _04692_ _04691_ VGND VGND VPWR VPWR _04764_ sky130_fd_sc_hd__a21o_1
X_16073_ _07608_ _07799_ VGND VGND VPWR VPWR _07800_ sky130_fd_sc_hd__xnor2_1
X_10497_ _01652_ _01651_ _01650_ VGND VGND VPWR VPWR _01761_ sky130_fd_sc_hd__o21ai_1
X_15024_ _06653_ _06658_ VGND VGND VPWR VPWR _06659_ sky130_fd_sc_hd__xor2_1
X_12236_ _03548_ _03555_ VGND VGND VPWR VPWR _03617_ sky130_fd_sc_hd__and2b_1
X_12167_ _03538_ _03540_ VGND VGND VPWR VPWR _03542_ sky130_fd_sc_hd__and2_1
X_11118_ _02395_ _02400_ VGND VGND VPWR VPWR _02401_ sky130_fd_sc_hd__xor2_2
X_12098_ _03426_ _03429_ _03427_ VGND VGND VPWR VPWR _03467_ sky130_fd_sc_hd__o21ba_1
X_15926_ _07567_ _07568_ VGND VGND VPWR VPWR _07642_ sky130_fd_sc_hd__nand2_1
XFILLER_0_127_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11049_ _02323_ _02324_ _02307_ VGND VGND VPWR VPWR _02326_ sky130_fd_sc_hd__a21o_1
XFILLER_0_127_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput7 alpha[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_1
X_15857_ _07565_ _07566_ VGND VGND VPWR VPWR _07567_ sky130_fd_sc_hd__or2_1
X_14808_ _06420_ _06422_ _06423_ VGND VGND VPWR VPWR _06425_ sky130_fd_sc_hd__a21o_1
XFILLER_0_59_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15788_ _07489_ _07491_ VGND VGND VPWR VPWR _07492_ sky130_fd_sc_hd__xor2_1
XFILLER_0_148_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14739_ _06343_ _06345_ _06348_ VGND VGND VPWR VPWR _06349_ sky130_fd_sc_hd__and3_1
XFILLER_0_143_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08260_ _03822_ _03833_ VGND VGND VPWR VPWR _03844_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08191_ _03073_ _03084_ net298 net702 VGND VGND VPWR VPWR _03094_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09714_ _01018_ _01023_ VGND VGND VPWR VPWR _01024_ sky130_fd_sc_hd__xnor2_1
X_09645_ _00954_ _00955_ VGND VGND VPWR VPWR _00956_ sky130_fd_sc_hd__nor2_1
X_09576_ _00886_ _00887_ VGND VGND VPWR VPWR _00888_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08527_ _06737_ _06748_ VGND VGND VPWR VPWR _06758_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_148_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08458_ _05948_ _05992_ VGND VGND VPWR VPWR _06003_ sky130_fd_sc_hd__xor2_2
XFILLER_0_147_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08389_ net196 net582 VGND VGND VPWR VPWR _05253_ sky130_fd_sc_hd__nand2_1
XFILLER_0_135_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10420_ _01682_ _01683_ VGND VGND VPWR VPWR _01684_ sky130_fd_sc_hd__nor2_1
XFILLER_0_104_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10351_ net383 net778 net785 net372 VGND VGND VPWR VPWR _01615_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_33_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13070_ net763 net267 VGND VGND VPWR VPWR _04529_ sky130_fd_sc_hd__nand2_1
X_10282_ _01555_ VGND VGND VPWR VPWR _00048_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_103_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12021_ _03382_ _03383_ VGND VGND VPWR VPWR _03384_ sky130_fd_sc_hd__nor2_1
Xfanout560 net561 VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__buf_2
Xfanout571 net579 VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__clkbuf_4
Xfanout582 net588 VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__clkbuf_4
X_13972_ _05508_ _05510_ VGND VGND VPWR VPWR _05511_ sky130_fd_sc_hd__xnor2_2
Xfanout593 net594 VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__buf_4
X_15711_ _07406_ _07407_ VGND VGND VPWR VPWR _07408_ sky130_fd_sc_hd__xnor2_1
X_12923_ _04280_ _04282_ _04281_ VGND VGND VPWR VPWR _04369_ sky130_fd_sc_hd__o21bai_1
X_15642_ _06749_ _06946_ _06943_ _07145_ _07332_ VGND VGND VPWR VPWR _07333_ sky130_fd_sc_hd__a2111oi_1
X_12854_ _04285_ _04292_ _04293_ VGND VGND VPWR VPWR _04294_ sky130_fd_sc_hd__nand3_2
X_11805_ _03009_ _03010_ _03148_ VGND VGND VPWR VPWR _03150_ sky130_fd_sc_hd__o21a_1
X_15573_ _07195_ _07197_ VGND VGND VPWR VPWR _07257_ sky130_fd_sc_hd__nand2_1
X_12785_ _04170_ _04187_ _04190_ _04217_ VGND VGND VPWR VPWR _04219_ sky130_fd_sc_hd__a211o_1
X_14524_ _06096_ _06100_ _06099_ VGND VGND VPWR VPWR _06112_ sky130_fd_sc_hd__a21oi_1
X_11736_ _02984_ _02987_ _03074_ VGND VGND VPWR VPWR _03075_ sky130_fd_sc_hd__o21a_1
XFILLER_0_139_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14455_ _06028_ _06029_ _06035_ VGND VGND VPWR VPWR _06037_ sky130_fd_sc_hd__a21oi_1
X_11667_ _02906_ _02927_ _02998_ VGND VGND VPWR VPWR _02999_ sky130_fd_sc_hd__a21bo_1
X_13406_ net141 net799 net210 net201 VGND VGND VPWR VPWR _04896_ sky130_fd_sc_hd__nand4_2
XFILLER_0_3_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10618_ net520 net787 net795 net435 VGND VGND VPWR VPWR _01882_ sky130_fd_sc_hd__a22o_1
X_14386_ _05956_ _05958_ _05957_ VGND VGND VPWR VPWR _05961_ sky130_fd_sc_hd__a21o_1
X_11598_ _02922_ _02923_ VGND VGND VPWR VPWR _02924_ sky130_fd_sc_hd__nand2_1
XFILLER_0_107_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16125_ _07854_ _07855_ VGND VGND VPWR VPWR _07857_ sky130_fd_sc_hd__nand2_1
XFILLER_0_141_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13337_ _04740_ _04820_ VGND VGND VPWR VPWR _04821_ sky130_fd_sc_hd__xnor2_1
X_10549_ _01810_ _01811_ _01812_ VGND VGND VPWR VPWR _01813_ sky130_fd_sc_hd__nor3b_1
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16056_ b_cos\[15\] net863 VGND VGND VPWR VPWR _07783_ sky130_fd_sc_hd__and2_1
X_13268_ net754 net276 _04662_ _04661_ net282 VGND VGND VPWR VPWR _04745_ sky130_fd_sc_hd__a32o_1
XFILLER_0_20_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15007_ _06553_ _06537_ _06640_ _06641_ VGND VGND VPWR VPWR _06642_ sky130_fd_sc_hd__o211ai_2
X_12219_ _03343_ _03587_ _03597_ VGND VGND VPWR VPWR _03598_ sky130_fd_sc_hd__or3b_1
X_13199_ _04667_ _04668_ _04669_ VGND VGND VPWR VPWR _04670_ sky130_fd_sc_hd__a21o_1
XFILLER_0_20_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15909_ _07621_ _07622_ VGND VGND VPWR VPWR _07623_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09430_ _00693_ _00695_ VGND VGND VPWR VPWR _00743_ sky130_fd_sc_hd__nand2_1
XFILLER_0_63_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09361_ _00408_ net568 VGND VGND VPWR VPWR _00675_ sky130_fd_sc_hd__or2_1
X_08312_ net224 net548 VGND VGND VPWR VPWR _04415_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09292_ _00598_ _00605_ _00606_ VGND VGND VPWR VPWR _00607_ sky130_fd_sc_hd__nand3_1
XFILLER_0_74_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_12 net156 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08243_ net188 net177 net539 net547 VGND VGND VPWR VPWR _03658_ sky130_fd_sc_hd__and4_1
XFILLER_0_7_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_23 net515 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_34 net675 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_45 net20 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_145_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_56 net677 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08174_ _02877_ _02888_ _02724_ VGND VGND VPWR VPWR _02909_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09628_ _00937_ _00926_ _00927_ VGND VGND VPWR VPWR _00939_ sky130_fd_sc_hd__and3_2
XFILLER_0_38_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09559_ _00795_ _00797_ VGND VGND VPWR VPWR _00871_ sky130_fd_sc_hd__or2b_1
XFILLER_0_66_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12570_ _03970_ _03980_ _03928_ _03981_ VGND VGND VPWR VPWR _03982_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_65_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11521_ _02837_ _02838_ _02839_ VGND VGND VPWR VPWR _02840_ sky130_fd_sc_hd__a21o_1
XFILLER_0_65_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11452_ net406 net396 net869 net803 VGND VGND VPWR VPWR _02765_ sky130_fd_sc_hd__nand4_1
X_14240_ net140 net252 _05683_ VGND VGND VPWR VPWR _05801_ sky130_fd_sc_hd__and3_1
XFILLER_0_123_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10403_ _01662_ _01664_ _01663_ VGND VGND VPWR VPWR _01667_ sky130_fd_sc_hd__o21ai_1
X_14171_ _05628_ _05725_ VGND VGND VPWR VPWR _05726_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_12_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11383_ _02598_ _02689_ VGND VGND VPWR VPWR _02690_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_150_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13122_ _04582_ _04585_ VGND VGND VPWR VPWR _04586_ sky130_fd_sc_hd__xnor2_1
X_10334_ b_cos\[16\] _01599_ _01600_ VGND VGND VPWR VPWR _01601_ sky130_fd_sc_hd__o21a_1
X_13053_ _04508_ _04509_ _04339_ VGND VGND VPWR VPWR _04511_ sky130_fd_sc_hd__a21oi_1
X_10265_ _01532_ _01535_ _01533_ VGND VGND VPWR VPWR _01541_ sky130_fd_sc_hd__a21bo_1
X_12004_ _03349_ _03363_ VGND VGND VPWR VPWR _03365_ sky130_fd_sc_hd__and2_1
X_10196_ net86 _01482_ net134 VGND VGND VPWR VPWR _01483_ sky130_fd_sc_hd__mux2_1
XFILLER_0_108_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout390 net53 VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_21_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13955_ _05488_ _05390_ _05491_ VGND VGND VPWR VPWR _05493_ sky130_fd_sc_hd__o21a_1
X_12906_ net738 net161 net308 net746 VGND VGND VPWR VPWR _04351_ sky130_fd_sc_hd__a22o_1
X_13886_ _05415_ _05417_ VGND VGND VPWR VPWR _05418_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15625_ _02387_ net555 VGND VGND VPWR VPWR _07315_ sky130_fd_sc_hd__or2_1
X_12837_ _04270_ _04274_ _04275_ VGND VGND VPWR VPWR _04276_ sky130_fd_sc_hd__and3_1
X_15556_ _07080_ _07136_ _07239_ VGND VGND VPWR VPWR _07240_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_139_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12768_ _04178_ _04177_ VGND VGND VPWR VPWR _04200_ sky130_fd_sc_hd__and2b_1
XFILLER_0_44_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14507_ _06092_ _06093_ VGND VGND VPWR VPWR _06094_ sky130_fd_sc_hd__nor2_1
XFILLER_0_16_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11719_ _03054_ _03055_ VGND VGND VPWR VPWR _03056_ sky130_fd_sc_hd__or2b_1
X_15487_ net443 net555 _07162_ _07163_ VGND VGND VPWR VPWR _07164_ sky130_fd_sc_hd__o2bb2a_1
X_12699_ _04079_ _04080_ _04072_ VGND VGND VPWR VPWR _04124_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_30_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14438_ net361 net587 _06015_ _06016_ VGND VGND VPWR VPWR _06018_ sky130_fd_sc_hd__a22o_1
Xinput10 alpha[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput21 beta[10] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_4_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput32 beta[3] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput43 cos[13] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_1
Xinput54 cos[6] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_1
XFILLER_0_40_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput65 sin[15] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__dlymetal6s2s_1
X_14369_ net523 net438 net699 net533 VGND VGND VPWR VPWR _05942_ sky130_fd_sc_hd__and4_1
Xinput76 sin[8] VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_149_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16108_ _07767_ _07768_ VGND VGND VPWR VPWR _07839_ sky130_fd_sc_hd__nor2_1
XFILLER_0_122_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08930_ _00247_ _00248_ VGND VGND VPWR VPWR _00249_ sky130_fd_sc_hd__or2b_1
X_16039_ _07762_ _07763_ VGND VGND VPWR VPWR _07764_ sky130_fd_sc_hd__nand2_1
X_08861_ _08076_ _08095_ _00179_ _00180_ VGND VGND VPWR VPWR _00181_ sky130_fd_sc_hd__a211o_1
X_08792_ _08096_ _08100_ VGND VGND VPWR VPWR _08102_ sky130_fd_sc_hd__nand2_1
X_09413_ _00723_ _00726_ VGND VGND VPWR VPWR _00727_ sky130_fd_sc_hd__xor2_1
XFILLER_0_47_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09344_ _00572_ _00590_ _00657_ VGND VGND VPWR VPWR _00658_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09275_ _00574_ _00589_ VGND VGND VPWR VPWR _00590_ sky130_fd_sc_hd__xor2_2
X_08226_ _03442_ _03453_ _03463_ VGND VGND VPWR VPWR _03474_ sky130_fd_sc_hd__or3_1
XFILLER_0_90_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08157_ _02463_ _02517_ _02452_ VGND VGND VPWR VPWR _02724_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_71_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10050_ net270 net624 _01244_ _01243_ VGND VGND VPWR VPWR _01354_ sky130_fd_sc_hd__a31o_1
X_13740_ net709 net264 net254 net718 VGND VGND VPWR VPWR _05259_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_97_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10952_ _02210_ _02218_ _02219_ VGND VGND VPWR VPWR _02220_ sky130_fd_sc_hd__nand3_1
XFILLER_0_39_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13671_ _05159_ _05160_ _05181_ _05182_ VGND VGND VPWR VPWR _05184_ sky130_fd_sc_hd__a22o_1
X_10883_ net517 net233 net432 net317 VGND VGND VPWR VPWR _02147_ sky130_fd_sc_hd__and4_1
XFILLER_0_38_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15410_ _07059_ _07079_ VGND VGND VPWR VPWR _07080_ sky130_fd_sc_hd__xor2_2
X_12622_ _03986_ _04038_ VGND VGND VPWR VPWR _04039_ sky130_fd_sc_hd__or2_1
XFILLER_0_66_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15341_ net388 net653 _06916_ _06796_ net635 VGND VGND VPWR VPWR _07005_ sky130_fd_sc_hd__a32o_1
XFILLER_0_38_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12553_ _03960_ _03961_ _03962_ VGND VGND VPWR VPWR _03963_ sky130_fd_sc_hd__o21ba_1
X_11504_ _02709_ _02715_ VGND VGND VPWR VPWR _02821_ sky130_fd_sc_hd__and2_1
X_15272_ _06795_ _06812_ _06811_ VGND VGND VPWR VPWR _06930_ sky130_fd_sc_hd__a21bo_1
X_12484_ net739 net747 net214 net205 VGND VGND VPWR VPWR _03887_ sky130_fd_sc_hd__and4_1
XFILLER_0_22_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14223_ _05753_ _05754_ VGND VGND VPWR VPWR _05782_ sky130_fd_sc_hd__or2_1
XFILLER_0_34_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11435_ _02729_ _02744_ _02745_ VGND VGND VPWR VPWR _02747_ sky130_fd_sc_hd__nand3_1
XFILLER_0_1_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14154_ _05706_ _05707_ VGND VGND VPWR VPWR _05708_ sky130_fd_sc_hd__xnor2_2
X_11366_ _01890_ _02669_ _02671_ _02570_ net416 VGND VGND VPWR VPWR _02672_ sky130_fd_sc_hd__o32ai_4
XFILLER_0_0_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13105_ _04564_ _04565_ _04546_ VGND VGND VPWR VPWR _04568_ sky130_fd_sc_hd__a21oi_1
X_10317_ b_cos\[15\] a_sin\[15\] VGND VGND VPWR VPWR _01586_ sky130_fd_sc_hd__and2b_1
X_14085_ _05476_ _05631_ VGND VGND VPWR VPWR _05634_ sky130_fd_sc_hd__or2_1
X_11297_ _02593_ _02595_ _02504_ VGND VGND VPWR VPWR _02597_ sky130_fd_sc_hd__a21o_1
X_13036_ _04489_ _04490_ _04482_ VGND VGND VPWR VPWR _04493_ sky130_fd_sc_hd__a21o_1
X_10248_ b_cos\[6\] a_sin\[6\] VGND VGND VPWR VPWR _01526_ sky130_fd_sc_hd__or2b_1
X_10179_ _01466_ _01467_ VGND VGND VPWR VPWR _01468_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14987_ _06615_ _06616_ _06618_ VGND VGND VPWR VPWR _06620_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13938_ _05136_ _05401_ VGND VGND VPWR VPWR _05474_ sky130_fd_sc_hd__nand2_4
XFILLER_0_135_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13869_ _05137_ _05322_ _05136_ VGND VGND VPWR VPWR _05399_ sky130_fd_sc_hd__a21o_1
XFILLER_0_147_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15608_ _07294_ _07295_ VGND VGND VPWR VPWR _07296_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15539_ _07217_ _07218_ _07219_ VGND VGND VPWR VPWR _07221_ sky130_fd_sc_hd__nand3_1
XFILLER_0_29_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09060_ _00375_ _00376_ _00319_ VGND VGND VPWR VPWR _00378_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_8_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09962_ _01206_ _01208_ _01266_ VGND VGND VPWR VPWR _01268_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_110_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08913_ _00228_ _00229_ _00230_ VGND VGND VPWR VPWR _00232_ sky130_fd_sc_hd__a21o_1
XFILLER_0_110_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09893_ _01180_ _01199_ VGND VGND VPWR VPWR _01200_ sky130_fd_sc_hd__nand2_1
XFILLER_0_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08844_ _00161_ _00162_ _00163_ VGND VGND VPWR VPWR _00164_ sky130_fd_sc_hd__nand3_1
XFILLER_0_85_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08775_ _07999_ _07998_ _08084_ _08085_ VGND VGND VPWR VPWR _08086_ sky130_fd_sc_hd__or4_4
XFILLER_0_79_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09327_ _00551_ _00553_ VGND VGND VPWR VPWR _00642_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09258_ _00505_ _00520_ VGND VGND VPWR VPWR _00573_ sky130_fd_sc_hd__nor2_1
XFILLER_0_145_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08209_ net298 net599 _03138_ _03127_ VGND VGND VPWR VPWR _03290_ sky130_fd_sc_hd__a31o_1
X_09189_ _00433_ _00440_ _00504_ VGND VGND VPWR VPWR _00505_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_62_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11220_ _02398_ _02510_ _02511_ VGND VGND VPWR VPWR _02512_ sky130_fd_sc_hd__a21o_1
X_11151_ _02435_ _02436_ VGND VGND VPWR VPWR _02437_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10102_ _01400_ _01401_ VGND VGND VPWR VPWR _01402_ sky130_fd_sc_hd__nand2_1
X_11082_ _02341_ _02360_ _02361_ VGND VGND VPWR VPWR _02362_ sky130_fd_sc_hd__and3_1
X_10033_ _01336_ _01322_ _01323_ VGND VGND VPWR VPWR _01338_ sky130_fd_sc_hd__and3_1
X_14910_ _06533_ _06534_ _06433_ _06452_ VGND VGND VPWR VPWR _06536_ sky130_fd_sc_hd__o211ai_1
X_15890_ _07582_ _07601_ VGND VGND VPWR VPWR _07602_ sky130_fd_sc_hd__and2_1
X_14841_ _06362_ _06459_ VGND VGND VPWR VPWR _06460_ sky130_fd_sc_hd__nand2_1
XFILLER_0_98_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14772_ _06381_ _06384_ VGND VGND VPWR VPWR _06385_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11984_ _03342_ _03272_ VGND VGND VPWR VPWR _03343_ sky130_fd_sc_hd__nor2_2
XFILLER_0_58_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13723_ _05142_ _05239_ VGND VGND VPWR VPWR _05240_ sky130_fd_sc_hd__xor2_1
X_10935_ _02199_ _02200_ VGND VGND VPWR VPWR _02202_ sky130_fd_sc_hd__nor2_1
XFILLER_0_85_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13654_ net718 net264 net254 net727 VGND VGND VPWR VPWR _05165_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_14_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10866_ _02052_ _02053_ _02062_ VGND VGND VPWR VPWR _02130_ sky130_fd_sc_hd__nand3_2
XFILLER_0_66_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12605_ _04005_ _04017_ _04018_ _04019_ VGND VGND VPWR VPWR _04021_ sky130_fd_sc_hd__a211o_2
XFILLER_0_6_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13585_ _05087_ _05088_ _05081_ VGND VGND VPWR VPWR _05091_ sky130_fd_sc_hd__a21o_1
X_10797_ _02055_ _02060_ VGND VGND VPWR VPWR _02061_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_54_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15324_ _06984_ _06985_ VGND VGND VPWR VPWR _06986_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_124_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12536_ net748 net221 VGND VGND VPWR VPWR _03945_ sky130_fd_sc_hd__and2_1
XFILLER_0_109_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15255_ _06906_ _06909_ _06910_ VGND VGND VPWR VPWR _06912_ sky130_fd_sc_hd__and3_1
X_12467_ _03845_ _03846_ _03867_ _03868_ VGND VGND VPWR VPWR _03869_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_1_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14206_ _05680_ _05699_ _05764_ VGND VGND VPWR VPWR _05765_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_144_Right_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11418_ _02644_ _02646_ VGND VGND VPWR VPWR _02728_ sky130_fd_sc_hd__nand2_1
X_15186_ _06659_ _06662_ _06836_ VGND VGND VPWR VPWR _06837_ sky130_fd_sc_hd__a21boi_1
X_12398_ net780 net299 VGND VGND VPWR VPWR _03793_ sky130_fd_sc_hd__nand2_1
XFILLER_0_111_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14137_ _05623_ _05681_ _05688_ VGND VGND VPWR VPWR _05690_ sky130_fd_sc_hd__o21a_1
X_11349_ _02557_ _02559_ VGND VGND VPWR VPWR _02653_ sky130_fd_sc_hd__nand2_1
X_14068_ _05597_ _05614_ VGND VGND VPWR VPWR _05615_ sky130_fd_sc_hd__xnor2_1
X_13019_ _04471_ _04472_ _04467_ VGND VGND VPWR VPWR _04474_ sky130_fd_sc_hd__a21o_1
XFILLER_0_146_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08560_ _07052_ _07085_ _07107_ VGND VGND VPWR VPWR _07118_ sky130_fd_sc_hd__o21ai_1
X_08491_ _06333_ _06344_ _06355_ VGND VGND VPWR VPWR _06366_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_119_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09112_ _00414_ _00427_ _00428_ VGND VGND VPWR VPWR _00429_ sky130_fd_sc_hd__and3_1
XFILLER_0_127_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09043_ _00257_ _00258_ _00259_ VGND VGND VPWR VPWR _00361_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_142_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_111_Right_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09945_ _01242_ _01250_ VGND VGND VPWR VPWR _01251_ sky130_fd_sc_hd__xnor2_1
X_09876_ _01145_ _01155_ _01182_ VGND VGND VPWR VPWR _01183_ sky130_fd_sc_hd__a21bo_1
X_08827_ net169 net530 _00145_ _00146_ VGND VGND VPWR VPWR _00147_ sky130_fd_sc_hd__a22o_1
X_08758_ _08065_ _08066_ _08067_ VGND VGND VPWR VPWR _08069_ sky130_fd_sc_hd__a21o_1
X_08689_ _07998_ _08000_ VGND VGND VPWR VPWR _08001_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_67_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10720_ _01972_ _01973_ _01982_ VGND VGND VPWR VPWR _01984_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_83_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10651_ net495 net793 VGND VGND VPWR VPWR _01915_ sky130_fd_sc_hd__nand2_1
X_13370_ net772 _00193_ VGND VGND VPWR VPWR _04856_ sky130_fd_sc_hd__nor2_1
XFILLER_0_91_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10582_ _01808_ _01827_ _01845_ _01843_ VGND VGND VPWR VPWR _01846_ sky130_fd_sc_hd__a211o_1
XFILLER_0_106_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12321_ net712 net223 VGND VGND VPWR VPWR _03708_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15040_ net494 net546 net556 net487 VGND VGND VPWR VPWR _06677_ sky130_fd_sc_hd__a22o_1
XFILLER_0_133_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12252_ _03632_ _03586_ VGND VGND VPWR VPWR _03634_ sky130_fd_sc_hd__and2b_1
X_11203_ _02492_ _02493_ VGND VGND VPWR VPWR _02494_ sky130_fd_sc_hd__nand2_1
X_12183_ _03467_ _03472_ VGND VGND VPWR VPWR _03559_ sky130_fd_sc_hd__and2b_1
X_11134_ net741 net494 net486 net750 VGND VGND VPWR VPWR _02418_ sky130_fd_sc_hd__a22o_1
XFILLER_0_101_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11065_ net318 net407 net397 net429 VGND VGND VPWR VPWR _02344_ sky130_fd_sc_hd__a22o_1
X_15942_ _07593_ _07597_ VGND VGND VPWR VPWR _07658_ sky130_fd_sc_hd__or2_1
X_10016_ _01305_ _01320_ VGND VGND VPWR VPWR _01321_ sky130_fd_sc_hd__xnor2_1
X_15873_ _07510_ _07524_ _07526_ VGND VGND VPWR VPWR _07583_ sky130_fd_sc_hd__o21bai_2
X_14824_ _06351_ VGND VGND VPWR VPWR _06442_ sky130_fd_sc_hd__inv_2
XFILLER_0_25_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_884 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14755_ _06337_ _06339_ _06364_ VGND VGND VPWR VPWR _06367_ sky130_fd_sc_hd__and3_1
X_11967_ net426 net511 net456 net448 VGND VGND VPWR VPWR _03325_ sky130_fd_sc_hd__and4_1
XFILLER_0_129_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13706_ net228 net149 net868 net302 VGND VGND VPWR VPWR _05222_ sky130_fd_sc_hd__and4_1
X_10918_ _02099_ _02024_ _02098_ VGND VGND VPWR VPWR _02185_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_58_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14686_ _06284_ _06288_ _06290_ VGND VGND VPWR VPWR _06291_ sky130_fd_sc_hd__nand3_1
XFILLER_0_86_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11898_ _03194_ _03048_ VGND VGND VPWR VPWR _03250_ sky130_fd_sc_hd__and2b_2
X_13637_ net149 net165 VGND VGND VPWR VPWR _05147_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10849_ net776 net489 net479 net784 VGND VGND VPWR VPWR _02113_ sky130_fd_sc_hd__and4_1
XFILLER_0_128_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_143_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13568_ _05070_ _05071_ VGND VGND VPWR VPWR _05072_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_125_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15307_ _06961_ _06967_ VGND VGND VPWR VPWR _06968_ sky130_fd_sc_hd__xor2_2
X_12519_ _03883_ _03898_ VGND VGND VPWR VPWR _03926_ sky130_fd_sc_hd__xnor2_1
X_16287_ clknet_4_5_0_clk _00076_ net334 VGND VGND VPWR VPWR a_cos\[18\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_140_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13499_ net312 net165 _04994_ _04995_ VGND VGND VPWR VPWR _04997_ sky130_fd_sc_hd__nand4_1
XFILLER_0_2_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15238_ _06890_ _06891_ _06892_ VGND VGND VPWR VPWR _06893_ sky130_fd_sc_hd__a21o_1
XFILLER_0_74_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15169_ _06783_ _06816_ _06817_ VGND VGND VPWR VPWR _06818_ sky130_fd_sc_hd__nand3_1
XFILLER_0_2_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout208 net72 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__buf_4
Xfanout219 net225 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__clkbuf_4
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
X_09730_ _01038_ _01039_ VGND VGND VPWR VPWR _01040_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_5_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09661_ _00895_ _00897_ _00971_ VGND VGND VPWR VPWR _00972_ sky130_fd_sc_hd__a21oi_2
X_08612_ _04654_ _07661_ VGND VGND VPWR VPWR _07683_ sky130_fd_sc_hd__nor2_1
X_09592_ _00903_ VGND VGND VPWR VPWR _00010_ sky130_fd_sc_hd__clkbuf_1
X_08543_ _06867_ _06922_ VGND VGND VPWR VPWR _06933_ sky130_fd_sc_hd__or2b_4
XFILLER_0_77_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08474_ _05665_ _05676_ _05590_ VGND VGND VPWR VPWR _06179_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_37_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09026_ _00251_ _00253_ _00252_ net648 VGND VGND VPWR VPWR _00344_ sky130_fd_sc_hd__a22o_1
XFILLER_0_103_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout720 net726 VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__clkbuf_4
Xfanout731 net732 VGND VGND VPWR VPWR net731 sky130_fd_sc_hd__clkbuf_4
X_09928_ _01049_ _01109_ _01119_ VGND VGND VPWR VPWR _01235_ sky130_fd_sc_hd__a21oi_1
Xfanout742 net744 VGND VGND VPWR VPWR net742 sky130_fd_sc_hd__clkbuf_4
Xfanout753 net16 VGND VGND VPWR VPWR net753 sky130_fd_sc_hd__clkbuf_8
Xfanout764 net771 VGND VGND VPWR VPWR net764 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout775 net13 VGND VGND VPWR VPWR net775 sky130_fd_sc_hd__clkbuf_2
Xfanout786 net787 VGND VGND VPWR VPWR net786 sky130_fd_sc_hd__clkbuf_2
Xfanout797 net798 VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__buf_2
X_09859_ _01099_ _01070_ _01071_ VGND VGND VPWR VPWR _01167_ sky130_fd_sc_hd__nand3_1
X_12870_ _04309_ _04310_ _03871_ _03876_ VGND VGND VPWR VPWR _04312_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_99_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11821_ _03090_ _03166_ VGND VGND VPWR VPWR _03167_ sky130_fd_sc_hd__xnor2_1
X_14540_ _06101_ _06112_ _06129_ _06128_ _06121_ VGND VGND VPWR VPWR _06130_ sky130_fd_sc_hd__o32a_1
X_11752_ _03034_ VGND VGND VPWR VPWR _03091_ sky130_fd_sc_hd__inv_2
XFILLER_0_68_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10703_ net412 net716 net725 net401 VGND VGND VPWR VPWR _01967_ sky130_fd_sc_hd__a22oi_1
X_14471_ _06052_ _06053_ VGND VGND VPWR VPWR _06054_ sky130_fd_sc_hd__and2b_1
X_11683_ _03001_ _03015_ VGND VGND VPWR VPWR _03016_ sky130_fd_sc_hd__xnor2_1
X_16210_ _07948_ VGND VGND VPWR VPWR _00114_ sky130_fd_sc_hd__clkbuf_1
X_13422_ _04784_ _04813_ _04912_ VGND VGND VPWR VPWR _04913_ sky130_fd_sc_hd__a21oi_2
X_10634_ _01854_ _01875_ _01897_ VGND VGND VPWR VPWR _01898_ sky130_fd_sc_hd__and3b_1
XFILLER_0_24_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16141_ _07872_ _07873_ VGND VGND VPWR VPWR _07874_ sky130_fd_sc_hd__or2b_1
XFILLER_0_141_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13353_ _04743_ _04760_ _04836_ VGND VGND VPWR VPWR _04837_ sky130_fd_sc_hd__a21o_1
XFILLER_0_51_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10565_ _01800_ _01792_ _01799_ VGND VGND VPWR VPWR _01829_ sky130_fd_sc_hd__nand3_1
XFILLER_0_63_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12304_ net611 net711 net329 net245 VGND VGND VPWR VPWR _03689_ sky130_fd_sc_hd__and4_1
X_16072_ _07789_ _07798_ VGND VGND VPWR VPWR _07799_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13284_ _04673_ _04675_ VGND VGND VPWR VPWR _04762_ sky130_fd_sc_hd__nand2_1
X_10496_ _01652_ _01650_ _01651_ VGND VGND VPWR VPWR _01760_ sky130_fd_sc_hd__or3_1
XFILLER_0_32_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15023_ _06654_ _06657_ VGND VGND VPWR VPWR _06658_ sky130_fd_sc_hd__xor2_1
XFILLER_0_121_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12235_ _03613_ _03614_ VGND VGND VPWR VPWR _03616_ sky130_fd_sc_hd__xnor2_1
X_12166_ _03538_ _03540_ VGND VGND VPWR VPWR _03541_ sky130_fd_sc_hd__nor2_1
X_11117_ _02396_ _02398_ _02399_ VGND VGND VPWR VPWR _02400_ sky130_fd_sc_hd__o21ai_2
X_12097_ _03425_ _03436_ _03465_ VGND VGND VPWR VPWR _03466_ sky130_fd_sc_hd__a21bo_1
X_15925_ _07638_ _07639_ VGND VGND VPWR VPWR _07641_ sky130_fd_sc_hd__nor2_1
X_11048_ _02307_ _02323_ _02324_ VGND VGND VPWR VPWR _02325_ sky130_fd_sc_hd__nand3_1
Xinput8 alpha[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_2
XFILLER_0_36_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15856_ _07538_ _07539_ _07563_ VGND VGND VPWR VPWR _07566_ sky130_fd_sc_hd__nor3_1
XFILLER_0_36_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14807_ _06420_ _06422_ _06423_ VGND VGND VPWR VPWR _06424_ sky130_fd_sc_hd__nand3_4
X_15787_ _07391_ _07409_ _07490_ VGND VGND VPWR VPWR _07491_ sky130_fd_sc_hd__a21o_1
X_12999_ _04449_ _04450_ _04451_ VGND VGND VPWR VPWR _04452_ sky130_fd_sc_hd__a21o_1
XFILLER_0_98_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14738_ _06346_ _06347_ VGND VGND VPWR VPWR _06348_ sky130_fd_sc_hd__and2_1
XFILLER_0_143_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14669_ _06269_ _06268_ _06041_ _06026_ VGND VGND VPWR VPWR _06272_ sky130_fd_sc_hd__a211o_1
XFILLER_0_117_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08190_ net163 net592 net603 net307 VGND VGND VPWR VPWR _03084_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_6_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_58_Left_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09713_ _01021_ _01022_ VGND VGND VPWR VPWR _01023_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09644_ _00882_ _00881_ VGND VGND VPWR VPWR _00955_ sky130_fd_sc_hd__and2b_1
XFILLER_0_93_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09575_ _00193_ net545 VGND VGND VPWR VPWR _00887_ sky130_fd_sc_hd__or2_1
XFILLER_0_89_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08526_ net197 net703 VGND VGND VPWR VPWR _06748_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_67_Left_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08457_ _05959_ _05981_ VGND VGND VPWR VPWR _05992_ sky130_fd_sc_hd__xor2_2
XFILLER_0_148_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08388_ _05220_ _05231_ VGND VGND VPWR VPWR _05242_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10350_ net383 net372 net777 net785 VGND VGND VPWR VPWR _01614_ sky130_fd_sc_hd__and4_1
XFILLER_0_131_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09009_ _00325_ _00326_ VGND VGND VPWR VPWR _00327_ sky130_fd_sc_hd__xor2_1
X_10281_ net99 _01554_ net133 VGND VGND VPWR VPWR _01555_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_76_Left_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12020_ _03311_ _03309_ VGND VGND VPWR VPWR _03383_ sky130_fd_sc_hd__and2b_1
Xfanout550 net870 VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__buf_2
Xfanout561 net35 VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__buf_4
Xfanout572 net579 VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__buf_2
X_13971_ _05509_ _05430_ VGND VGND VPWR VPWR _05510_ sky130_fd_sc_hd__and2_1
Xfanout583 net588 VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__buf_2
Xfanout594 net598 VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__clkbuf_2
X_15710_ _02387_ net546 VGND VGND VPWR VPWR _07407_ sky130_fd_sc_hd__or2_1
X_12922_ _04272_ _04275_ VGND VGND VPWR VPWR _04368_ sky130_fd_sc_hd__nand2_1
X_15641_ _07144_ _07246_ VGND VGND VPWR VPWR _07332_ sky130_fd_sc_hd__nand2_1
X_12853_ _04289_ _04290_ _04291_ VGND VGND VPWR VPWR _04293_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_85_Left_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11804_ _03002_ _03008_ VGND VGND VPWR VPWR _03148_ sky130_fd_sc_hd__nand2_1
X_15572_ _07255_ VGND VGND VPWR VPWR _07256_ sky130_fd_sc_hd__clkbuf_2
X_12784_ _04198_ _04216_ _04188_ VGND VGND VPWR VPWR _04217_ sky130_fd_sc_hd__or3b_1
X_14523_ _06106_ _06110_ VGND VGND VPWR VPWR _06111_ sky130_fd_sc_hd__nand2_1
XFILLER_0_95_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11735_ _02988_ _02904_ VGND VGND VPWR VPWR _03074_ sky130_fd_sc_hd__or2b_1
X_14454_ _05978_ _06034_ VGND VGND VPWR VPWR _06035_ sky130_fd_sc_hd__xnor2_1
X_11666_ _02907_ _02926_ VGND VGND VPWR VPWR _02998_ sky130_fd_sc_hd__or2b_1
X_13405_ net799 net210 net201 net141 VGND VGND VPWR VPWR _04895_ sky130_fd_sc_hd__a22o_1
XFILLER_0_36_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10617_ net519 net434 net787 net795 VGND VGND VPWR VPWR _01881_ sky130_fd_sc_hd__nand4_1
XFILLER_0_4_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14385_ _05956_ _05957_ _05958_ VGND VGND VPWR VPWR _05960_ sky130_fd_sc_hd__nand3_4
XFILLER_0_107_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11597_ _02917_ _02918_ _02921_ VGND VGND VPWR VPWR _02923_ sky130_fd_sc_hd__nand3_1
X_16124_ _07849_ _07853_ VGND VGND VPWR VPWR _07855_ sky130_fd_sc_hd__or2_1
XFILLER_0_141_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13336_ _04817_ _04819_ VGND VGND VPWR VPWR _04820_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_94_Left_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10548_ _01771_ _01803_ _01804_ VGND VGND VPWR VPWR _01812_ sky130_fd_sc_hd__and3_1
XFILLER_0_134_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16055_ _07776_ _07779_ VGND VGND VPWR VPWR _07782_ sky130_fd_sc_hd__or2_1
X_13267_ _04660_ _04675_ _04677_ _04680_ VGND VGND VPWR VPWR _04744_ sky130_fd_sc_hd__a31o_1
X_10479_ _01628_ _01741_ _01742_ VGND VGND VPWR VPWR _01743_ sky130_fd_sc_hd__and3_1
XFILLER_0_110_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15006_ _06637_ _06638_ _06463_ VGND VGND VPWR VPWR _06641_ sky130_fd_sc_hd__a21o_1
X_12218_ _03423_ _03596_ VGND VGND VPWR VPWR _03597_ sky130_fd_sc_hd__xnor2_1
X_13198_ net728 net300 VGND VGND VPWR VPWR _04669_ sky130_fd_sc_hd__and2_1
XFILLER_0_47_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12149_ _03522_ VGND VGND VPWR VPWR _00073_ sky130_fd_sc_hd__clkbuf_1
X_15908_ _07619_ _07620_ net491 net631 VGND VGND VPWR VPWR _07622_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_78_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15839_ net455 net447 net680 net687 VGND VGND VPWR VPWR _07547_ sky130_fd_sc_hd__and4_1
XFILLER_0_63_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09360_ _00671_ _00673_ VGND VGND VPWR VPWR _00674_ sky130_fd_sc_hd__xor2_2
X_08311_ _02278_ _02267_ _02256_ VGND VGND VPWR VPWR _04404_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_47_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09291_ _00602_ _00603_ _00604_ VGND VGND VPWR VPWR _00606_ sky130_fd_sc_hd__a21o_1
XFILLER_0_75_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_13 net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08242_ net188 net539 net547 net177 VGND VGND VPWR VPWR _03647_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_145_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_24 net546 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_35 net675 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_46 net94 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_57 net677 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08173_ _02724_ _02877_ _02888_ VGND VGND VPWR VPWR _02899_ sky130_fd_sc_hd__nand3_4
XFILLER_0_15_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09627_ _00926_ _00927_ _00937_ VGND VGND VPWR VPWR _00938_ sky130_fd_sc_hd__a21oi_1
X_09558_ _00867_ _00869_ VGND VGND VPWR VPWR _00870_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_66_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08509_ _06530_ _06541_ _06551_ VGND VGND VPWR VPWR _06562_ sky130_fd_sc_hd__and3_1
XFILLER_0_136_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09489_ _00785_ _00801_ VGND VGND VPWR VPWR _00802_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11520_ net614 net493 VGND VGND VPWR VPWR _02839_ sky130_fd_sc_hd__and2_1
XFILLER_0_81_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11451_ net396 net869 net803 net406 VGND VGND VPWR VPWR _02764_ sky130_fd_sc_hd__a22o_1
XFILLER_0_92_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10402_ _01630_ _01631_ _01629_ VGND VGND VPWR VPWR _01666_ sky130_fd_sc_hd__o21bai_1
X_14170_ _05661_ _05724_ VGND VGND VPWR VPWR _05725_ sky130_fd_sc_hd__xor2_2
X_11382_ _02606_ _02688_ VGND VGND VPWR VPWR _02689_ sky130_fd_sc_hd__xor2_1
X_13121_ net212 _04583_ _04584_ VGND VGND VPWR VPWR _04585_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_33_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10333_ b_cos\[16\] _01599_ _01585_ _01591_ VGND VGND VPWR VPWR _01600_ sky130_fd_sc_hd__a211o_1
X_13052_ _04339_ _04508_ _04509_ VGND VGND VPWR VPWR _04510_ sky130_fd_sc_hd__and3_1
X_10264_ _01538_ _01539_ VGND VGND VPWR VPWR _01540_ sky130_fd_sc_hd__nand2_1
X_12003_ _03349_ _03363_ VGND VGND VPWR VPWR _03364_ sky130_fd_sc_hd__nor2_1
X_10195_ _01478_ _01481_ VGND VGND VPWR VPWR _01482_ sky130_fd_sc_hd__xnor2_1
Xfanout380 net381 VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__clkbuf_4
Xfanout391 net392 VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__clkbuf_4
X_13954_ _05489_ _05490_ VGND VGND VPWR VPWR _05491_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_88_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12905_ _04347_ _04348_ VGND VGND VPWR VPWR _04350_ sky130_fd_sc_hd__xnor2_1
X_13885_ net709 net248 VGND VGND VPWR VPWR _05417_ sky130_fd_sc_hd__nand2_1
X_12836_ net738 net170 _04271_ _04272_ VGND VGND VPWR VPWR _04275_ sky130_fd_sc_hd__nand4_1
X_15624_ _07311_ _07312_ VGND VGND VPWR VPWR _07313_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_33_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15555_ _07133_ _07135_ VGND VGND VPWR VPWR _07239_ sky130_fd_sc_hd__nor2_1
X_12767_ net790 net221 VGND VGND VPWR VPWR _04199_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14506_ net519 net587 net596 net434 VGND VGND VPWR VPWR _06093_ sky130_fd_sc_hd__a22oi_1
X_11718_ _03052_ _03053_ _03048_ VGND VGND VPWR VPWR _03055_ sky130_fd_sc_hd__a21o_1
X_15486_ net460 net451 net536 net545 VGND VGND VPWR VPWR _07163_ sky130_fd_sc_hd__and4_1
X_12698_ _04115_ _04120_ _04121_ _04122_ VGND VGND VPWR VPWR _04123_ sky130_fd_sc_hd__o211a_1
XFILLER_0_71_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14437_ net361 net587 _06015_ _06016_ VGND VGND VPWR VPWR _06017_ sky130_fd_sc_hd__and4_1
Xinput11 alpha[1] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_1
X_11649_ _02954_ _02955_ _02977_ _02978_ VGND VGND VPWR VPWR _02980_ sky130_fd_sc_hd__nand4_2
Xinput22 beta[11] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput33 beta[4] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_109_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput44 cos[14] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_2
Xinput55 cos[7] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__buf_1
X_14368_ _05930_ _05935_ _05931_ VGND VGND VPWR VPWR _05941_ sky130_fd_sc_hd__nor3_2
Xinput66 sin[16] VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput77 sin[9] VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__buf_1
XFILLER_0_141_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16107_ _07836_ _07837_ VGND VGND VPWR VPWR _07838_ sky130_fd_sc_hd__or2_1
X_13319_ _04797_ _04798_ _04799_ VGND VGND VPWR VPWR _04801_ sky130_fd_sc_hd__nand3_1
XFILLER_0_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14299_ _05862_ _05863_ _05864_ VGND VGND VPWR VPWR _05865_ sky130_fd_sc_hd__nand3_1
XFILLER_0_0_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16038_ _07605_ _07700_ _07761_ VGND VGND VPWR VPWR _07763_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_58_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08860_ _00177_ _00178_ _00119_ VGND VGND VPWR VPWR _00180_ sky130_fd_sc_hd__a21oi_2
X_08791_ _08096_ _08100_ VGND VGND VPWR VPWR _08101_ sky130_fd_sc_hd__or2_1
X_09412_ _00612_ _00724_ _00725_ VGND VGND VPWR VPWR _00726_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_48_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09343_ _00574_ _00589_ VGND VGND VPWR VPWR _00657_ sky130_fd_sc_hd__nand2_1
XFILLER_0_118_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09274_ _00587_ _00588_ VGND VGND VPWR VPWR _00589_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_117_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08225_ net323 net659 net669 net236 VGND VGND VPWR VPWR _03463_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_16_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08156_ _02550_ _02561_ _02702_ VGND VGND VPWR VPWR _02713_ sky130_fd_sc_hd__nand3_1
XFILLER_0_15_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08989_ _00305_ _00306_ VGND VGND VPWR VPWR _00307_ sky130_fd_sc_hd__or2_1
XFILLER_0_98_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10951_ _02215_ _02216_ _02217_ VGND VGND VPWR VPWR _02219_ sky130_fd_sc_hd__a21o_1
X_13670_ _05159_ _05160_ _05181_ _05182_ VGND VGND VPWR VPWR _05183_ sky130_fd_sc_hd__nand4_2
X_10882_ net417 net429 VGND VGND VPWR VPWR _02146_ sky130_fd_sc_hd__nand2_1
X_12621_ _04034_ _04036_ _03984_ _04037_ VGND VGND VPWR VPWR _04038_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_149_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_125_Right_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15340_ _06908_ _06910_ VGND VGND VPWR VPWR _07004_ sky130_fd_sc_hd__nand2_1
X_12552_ net774 net782 net190 net180 VGND VGND VPWR VPWR _03962_ sky130_fd_sc_hd__and4_1
XFILLER_0_93_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11503_ _02817_ _02819_ VGND VGND VPWR VPWR _02820_ sky130_fd_sc_hd__xnor2_2
X_15271_ _06915_ _06928_ VGND VGND VPWR VPWR _06929_ sky130_fd_sc_hd__xnor2_2
X_12483_ net756 net197 VGND VGND VPWR VPWR _03886_ sky130_fd_sc_hd__nand2_1
XFILLER_0_124_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14222_ _05628_ _05725_ _05658_ VGND VGND VPWR VPWR _05781_ sky130_fd_sc_hd__o21a_1
XFILLER_0_124_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11434_ _02742_ _02743_ _02734_ VGND VGND VPWR VPWR _02745_ sky130_fd_sc_hd__a21o_1
XFILLER_0_123_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14153_ _05597_ _05614_ _05616_ VGND VGND VPWR VPWR _05707_ sky130_fd_sc_hd__a21bo_1
X_11365_ net416 net146 net517 net432 VGND VGND VPWR VPWR _02671_ sky130_fd_sc_hd__o2bb2a_1
X_13104_ _04546_ _04564_ _04565_ VGND VGND VPWR VPWR _04566_ sky130_fd_sc_hd__and3_1
X_10316_ a_sin\[15\] b_cos\[15\] VGND VGND VPWR VPWR _01585_ sky130_fd_sc_hd__and2b_1
X_14084_ _05476_ _05631_ VGND VGND VPWR VPWR _05632_ sky130_fd_sc_hd__nand2_1
XFILLER_0_95_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11296_ _02504_ _02593_ _02595_ VGND VGND VPWR VPWR _02596_ sky130_fd_sc_hd__nand3_1
X_13035_ _04482_ _04489_ _04490_ VGND VGND VPWR VPWR _04492_ sky130_fd_sc_hd__nand3_2
X_10247_ _01525_ VGND VGND VPWR VPWR _00043_ sky130_fd_sc_hd__clkbuf_1
X_10178_ a_cos\[14\] b_sin\[14\] VGND VGND VPWR VPWR _01467_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14986_ _06615_ _06616_ _06618_ VGND VGND VPWR VPWR _06619_ sky130_fd_sc_hd__nand3_1
X_13937_ _05449_ _05471_ VGND VGND VPWR VPWR _05473_ sky130_fd_sc_hd__or2_1
XFILLER_0_88_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13868_ _05376_ _05377_ _05396_ VGND VGND VPWR VPWR _05398_ sky130_fd_sc_hd__nor3_1
XFILLER_0_44_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12819_ net747 net161 net308 net755 VGND VGND VPWR VPWR _04256_ sky130_fd_sc_hd__a22oi_2
X_15607_ _07291_ _07293_ _07272_ _07273_ VGND VGND VPWR VPWR _07295_ sky130_fd_sc_hd__a211o_1
XFILLER_0_146_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13799_ _05139_ _05322_ VGND VGND VPWR VPWR _05323_ sky130_fd_sc_hd__xnor2_1
X_15538_ _07217_ _07218_ _07219_ VGND VGND VPWR VPWR _07220_ sky130_fd_sc_hd__a21o_1
XFILLER_0_60_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15469_ _06941_ _07049_ VGND VGND VPWR VPWR _07145_ sky130_fd_sc_hd__nand2_1
XFILLER_0_71_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09961_ _01206_ _01208_ _01266_ VGND VGND VPWR VPWR _01267_ sky130_fd_sc_hd__or3_1
XFILLER_0_69_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08912_ _00228_ _00229_ _00230_ VGND VGND VPWR VPWR _00231_ sky130_fd_sc_hd__nand3_1
XFILLER_0_0_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09892_ _01183_ _01198_ VGND VGND VPWR VPWR _01199_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08843_ _08057_ _08059_ _08058_ VGND VGND VPWR VPWR _00163_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08774_ _08082_ _08083_ _07995_ _08005_ VGND VGND VPWR VPWR _08085_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_79_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09326_ _00591_ _00640_ VGND VGND VPWR VPWR _00641_ sky130_fd_sc_hd__xor2_2
XFILLER_0_90_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09257_ _00498_ _00499_ _00571_ VGND VGND VPWR VPWR _00572_ sky130_fd_sc_hd__a21o_1
XFILLER_0_8_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08208_ _03236_ _03268_ VGND VGND VPWR VPWR _03279_ sky130_fd_sc_hd__xnor2_1
X_09188_ _00434_ _00439_ VGND VGND VPWR VPWR _00504_ sky130_fd_sc_hd__and2_1
XFILLER_0_90_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08139_ _02452_ net841 _02517_ VGND VGND VPWR VPWR _02528_ sky130_fd_sc_hd__nand3_1
XFILLER_0_121_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11150_ _02433_ _02434_ _02414_ VGND VGND VPWR VPWR _02436_ sky130_fd_sc_hd__a21oi_1
X_10101_ a_cos\[3\] b_sin\[3\] VGND VGND VPWR VPWR _01401_ sky130_fd_sc_hd__nand2_1
X_11081_ _02357_ _02358_ _02359_ VGND VGND VPWR VPWR _02361_ sky130_fd_sc_hd__a21o_1
X_10032_ _01322_ _01323_ _01336_ VGND VGND VPWR VPWR _01337_ sky130_fd_sc_hd__a21oi_1
X_14840_ _06457_ _06458_ VGND VGND VPWR VPWR _06459_ sky130_fd_sc_hd__and2_1
X_14771_ _06382_ _06383_ VGND VGND VPWR VPWR _06384_ sky130_fd_sc_hd__nor2_1
X_11983_ _03043_ VGND VGND VPWR VPWR _03342_ sky130_fd_sc_hd__inv_2
X_13722_ _05237_ _05238_ VGND VGND VPWR VPWR _05239_ sky130_fd_sc_hd__xor2_1
XFILLER_0_105_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10934_ _02126_ _02128_ _02198_ VGND VGND VPWR VPWR _02200_ sky130_fd_sc_hd__and3_1
XFILLER_0_86_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13653_ _05076_ _05080_ _05077_ VGND VGND VPWR VPWR _05164_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_39_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10865_ _02126_ _02127_ _02108_ _02109_ VGND VGND VPWR VPWR _02129_ sky130_fd_sc_hd__a211o_1
X_12604_ _03955_ _03966_ _03964_ VGND VGND VPWR VPWR _04019_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_94_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13584_ _05081_ _05087_ _05088_ VGND VGND VPWR VPWR _05089_ sky130_fd_sc_hd__nand3_2
XFILLER_0_38_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10796_ _02056_ _02059_ VGND VGND VPWR VPWR _02060_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_5_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15323_ net468 net545 VGND VGND VPWR VPWR _06985_ sky130_fd_sc_hd__nand2_1
XFILLER_0_137_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12535_ _03909_ _03908_ _03907_ VGND VGND VPWR VPWR _03944_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_30_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15254_ net357 net682 _06907_ _06908_ VGND VGND VPWR VPWR _06910_ sky130_fd_sc_hd__nand4_1
X_12466_ _03864_ _03865_ _03847_ VGND VGND VPWR VPWR _03868_ sky130_fd_sc_hd__a21o_1
XFILLER_0_81_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14205_ _05700_ _05678_ VGND VGND VPWR VPWR _05764_ sky130_fd_sc_hd__and2b_1
X_11417_ _02707_ _02726_ VGND VGND VPWR VPWR _02727_ sky130_fd_sc_hd__xor2_2
X_15185_ _06653_ _06658_ VGND VGND VPWR VPWR _06836_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12397_ _03730_ _03738_ VGND VGND VPWR VPWR _03792_ sky130_fd_sc_hd__or2b_1
XFILLER_0_105_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14136_ _05623_ _05681_ _05688_ VGND VGND VPWR VPWR _05689_ sky130_fd_sc_hd__nor3_1
X_11348_ _02630_ _02651_ VGND VGND VPWR VPWR _02652_ sky130_fd_sc_hd__xor2_1
XFILLER_0_10_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14067_ _05612_ _05613_ VGND VGND VPWR VPWR _05614_ sky130_fd_sc_hd__xnor2_1
X_11279_ _02569_ _02575_ _02576_ VGND VGND VPWR VPWR _02577_ sky130_fd_sc_hd__nand3_1
X_13018_ _04467_ _04471_ _04472_ VGND VGND VPWR VPWR _04473_ sky130_fd_sc_hd__and3_1
XFILLER_0_55_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14969_ net360 net532 _06598_ _06599_ VGND VGND VPWR VPWR _06600_ sky130_fd_sc_hd__a22o_1
X_08490_ net328 net244 net565 net575 VGND VGND VPWR VPWR _06355_ sky130_fd_sc_hd__and4_1
XFILLER_0_71_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09111_ _00425_ _00426_ _00418_ VGND VGND VPWR VPWR _00428_ sky130_fd_sc_hd__a21o_1
XFILLER_0_134_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09042_ net817 _00358_ net220 net629 VGND VGND VPWR VPWR _00360_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_32_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmax_cap130 _08074_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_111_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09944_ _01077_ _01249_ VGND VGND VPWR VPWR _01250_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_110_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09875_ _01181_ _01154_ VGND VGND VPWR VPWR _01182_ sky130_fd_sc_hd__nand2_1
X_08826_ net185 net175 net684 net693 VGND VGND VPWR VPWR _00146_ sky130_fd_sc_hd__nand4_2
X_08757_ _08065_ _08066_ _08067_ VGND VGND VPWR VPWR _08068_ sky130_fd_sc_hd__nand3_4
XFILLER_0_67_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08688_ _04654_ _07661_ _07999_ VGND VGND VPWR VPWR _08000_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_95_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10650_ net488 net810 VGND VGND VPWR VPWR _01914_ sky130_fd_sc_hd__nand2_1
XFILLER_0_137_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09309_ _00536_ _00538_ _00537_ VGND VGND VPWR VPWR _00624_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_119_884 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10581_ _01828_ _01843_ _01844_ VGND VGND VPWR VPWR _01845_ sky130_fd_sc_hd__nor3_1
XFILLER_0_134_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12320_ _03688_ _03691_ _03689_ VGND VGND VPWR VPWR _03707_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_91_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12251_ _03586_ _03632_ VGND VGND VPWR VPWR _03633_ sky130_fd_sc_hd__and2b_1
X_11202_ _02488_ _02491_ _02378_ VGND VGND VPWR VPWR _02493_ sky130_fd_sc_hd__a21bo_1
X_12182_ _03556_ _03557_ VGND VGND VPWR VPWR _03558_ sky130_fd_sc_hd__xor2_1
X_11133_ net741 net750 net494 VGND VGND VPWR VPWR _02417_ sky130_fd_sc_hd__and3_1
X_11064_ net318 net429 net397 VGND VGND VPWR VPWR _02342_ sky130_fd_sc_hd__and3_1
X_15941_ _07641_ _07644_ VGND VGND VPWR VPWR _07657_ sky130_fd_sc_hd__and2_1
X_10015_ _01318_ _01319_ VGND VGND VPWR VPWR _01320_ sky130_fd_sc_hd__xnor2_1
X_15872_ _07554_ _07556_ _07560_ VGND VGND VPWR VPWR _07582_ sky130_fd_sc_hd__o21ai_1
X_14823_ _06360_ _06440_ VGND VGND VPWR VPWR _06441_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_98_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14754_ _06337_ _06339_ _06364_ VGND VGND VPWR VPWR _06365_ sky130_fd_sc_hd__a21oi_1
X_11966_ net426 net456 net448 net511 VGND VGND VPWR VPWR _03324_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_58_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13705_ net149 net868 net302 net228 VGND VGND VPWR VPWR _05221_ sky130_fd_sc_hd__a22oi_2
X_10917_ _02182_ _02183_ VGND VGND VPWR VPWR _02184_ sky130_fd_sc_hd__nand2_1
X_14685_ _06286_ _06287_ _06285_ VGND VGND VPWR VPWR _06290_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_129_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11897_ _03177_ _03185_ VGND VGND VPWR VPWR _03249_ sky130_fd_sc_hd__and2_1
X_13636_ _05143_ _05145_ VGND VGND VPWR VPWR _05146_ sky130_fd_sc_hd__or2_1
X_10848_ net776 net489 net479 net784 VGND VGND VPWR VPWR _02112_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_67_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13567_ _04990_ _05001_ _04989_ VGND VGND VPWR VPWR _05071_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_125_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10779_ _02037_ _02041_ _02042_ VGND VGND VPWR VPWR _02043_ sky130_fd_sc_hd__nand3_1
X_12518_ _03917_ _03922_ _03923_ _03924_ VGND VGND VPWR VPWR _03925_ sky130_fd_sc_hd__a211oi_4
X_15306_ _06964_ _06966_ VGND VGND VPWR VPWR _06967_ sky130_fd_sc_hd__xor2_2
XFILLER_0_41_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16286_ clknet_4_5_0_clk _00075_ net334 VGND VGND VPWR VPWR a_cos\[17\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_125_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13498_ net312 net167 _04994_ _04995_ VGND VGND VPWR VPWR _04996_ sky130_fd_sc_hd__a22o_1
XFILLER_0_124_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12449_ _03761_ _03769_ VGND VGND VPWR VPWR _03849_ sky130_fd_sc_hd__or2b_1
X_15237_ net494 net528 VGND VGND VPWR VPWR _06892_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15168_ _06814_ _06815_ _06784_ _06729_ VGND VGND VPWR VPWR _06817_ sky130_fd_sc_hd__a211o_1
X_14119_ _05476_ _05669_ VGND VGND VPWR VPWR _05670_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout209 net210 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__clkbuf_4
X_15099_ _06650_ _06740_ _06741_ VGND VGND VPWR VPWR _06742_ sky130_fd_sc_hd__nor3_4
XFILLER_0_5_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_105_Left_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09660_ _00893_ _00894_ VGND VGND VPWR VPWR _00971_ sky130_fd_sc_hd__nor2_1
X_08611_ _05199_ _05709_ _04654_ _07661_ VGND VGND VPWR VPWR _07672_ sky130_fd_sc_hd__o211a_1
X_09591_ b_sin\[10\] _00902_ _00475_ VGND VGND VPWR VPWR _00903_ sky130_fd_sc_hd__mux2_1
X_08542_ _06867_ _06900_ _06911_ VGND VGND VPWR VPWR _06922_ sky130_fd_sc_hd__or3_4
X_08473_ _06146_ _06135_ _06157_ VGND VGND VPWR VPWR _06168_ sky130_fd_sc_hd__nand3_2
XFILLER_0_106_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_114_Left_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09025_ _00244_ _00246_ VGND VGND VPWR VPWR _00343_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout710 net717 VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__clkbuf_2
Xfanout721 net726 VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_123_Left_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout732 net735 VGND VGND VPWR VPWR net732 sky130_fd_sc_hd__clkbuf_2
X_09927_ _01112_ _01114_ _01233_ VGND VGND VPWR VPWR _01234_ sky130_fd_sc_hd__a21o_1
Xfanout743 net744 VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__buf_2
Xfanout754 net762 VGND VGND VPWR VPWR net754 sky130_fd_sc_hd__clkbuf_4
Xfanout765 net771 VGND VGND VPWR VPWR net765 sky130_fd_sc_hd__clkbuf_4
Xfanout776 net779 VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__clkbuf_4
X_09858_ _01096_ _01098_ VGND VGND VPWR VPWR _01166_ sky130_fd_sc_hd__or2_1
Xfanout787 net12 VGND VGND VPWR VPWR net787 sky130_fd_sc_hd__buf_2
Xfanout798 net800 VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__clkbuf_4
X_08809_ net300 net553 VGND VGND VPWR VPWR _00129_ sky130_fd_sc_hd__and2_1
X_09789_ _01006_ _01097_ _01012_ VGND VGND VPWR VPWR _01098_ sky130_fd_sc_hd__o21a_1
X_11820_ _03164_ _03165_ VGND VGND VPWR VPWR _03166_ sky130_fd_sc_hd__xnor2_1
X_11751_ _03075_ _03072_ VGND VGND VPWR VPWR _03090_ sky130_fd_sc_hd__and2b_1
XFILLER_0_56_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_132_Left_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10702_ net412 net401 net716 net725 VGND VGND VPWR VPWR _01966_ sky130_fd_sc_hd__and4_1
X_14470_ net409 net595 net605 net399 VGND VGND VPWR VPWR _06053_ sky130_fd_sc_hd__a22o_1
X_11682_ _03013_ _03014_ VGND VGND VPWR VPWR _03015_ sky130_fd_sc_hd__xnor2_1
X_13421_ _04811_ _04812_ VGND VGND VPWR VPWR _04912_ sky130_fd_sc_hd__and2b_1
X_10633_ _01874_ _01876_ _01877_ _01896_ VGND VGND VPWR VPWR _01897_ sky130_fd_sc_hd__and4_1
XFILLER_0_102_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16140_ _07790_ _07795_ _07871_ VGND VGND VPWR VPWR _07873_ sky130_fd_sc_hd__o21ai_1
X_13352_ _04759_ _04744_ VGND VGND VPWR VPWR _04836_ sky130_fd_sc_hd__and2b_1
X_10564_ _01822_ _01825_ VGND VGND VPWR VPWR _01828_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_140_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12303_ net720 net223 VGND VGND VPWR VPWR _03688_ sky130_fd_sc_hd__nand2_1
XFILLER_0_122_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16071_ _07611_ _07797_ VGND VGND VPWR VPWR _07798_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_134_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13283_ _04743_ _04760_ VGND VGND VPWR VPWR _04761_ sky130_fd_sc_hd__xor2_1
XFILLER_0_134_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10495_ _01757_ _01758_ VGND VGND VPWR VPWR _01759_ sky130_fd_sc_hd__xnor2_1
X_15022_ _06655_ _06656_ VGND VGND VPWR VPWR _06657_ sky130_fd_sc_hd__nand2_1
X_12234_ _03551_ _03554_ _03552_ VGND VGND VPWR VPWR _03614_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_121_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_141_Left_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12165_ _03346_ _03499_ _03343_ VGND VGND VPWR VPWR _03540_ sky130_fd_sc_hd__a21o_1
XFILLER_0_20_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11116_ net767 net470 net463 net776 VGND VGND VPWR VPWR _02399_ sky130_fd_sc_hd__a22o_1
X_12096_ _03464_ _03435_ VGND VGND VPWR VPWR _03465_ sky130_fd_sc_hd__nand2_1
X_15924_ _07636_ _07637_ _07580_ _07581_ VGND VGND VPWR VPWR _07639_ sky130_fd_sc_hd__o211a_1
X_11047_ _02320_ _02322_ _02313_ VGND VGND VPWR VPWR _02324_ sky130_fd_sc_hd__a21o_1
Xinput9 alpha[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_1
X_15855_ _07538_ _07539_ _07563_ VGND VGND VPWR VPWR _07565_ sky130_fd_sc_hd__o21a_1
X_14806_ _06292_ _06297_ _06291_ VGND VGND VPWR VPWR _06423_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_59_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15786_ _07408_ _07392_ VGND VGND VPWR VPWR _07490_ sky130_fd_sc_hd__and2b_1
X_12998_ net746 net300 VGND VGND VPWR VPWR _04451_ sky130_fd_sc_hd__and2_1
XFILLER_0_98_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14737_ _06243_ _06248_ _06250_ VGND VGND VPWR VPWR _06347_ sky130_fd_sc_hd__or3_1
X_11949_ _03284_ _03305_ VGND VGND VPWR VPWR _03306_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_86_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14668_ _06026_ _06041_ _06268_ _06269_ VGND VGND VPWR VPWR _06271_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13619_ net423 net297 VGND VGND VPWR VPWR _05127_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14599_ _06186_ _06194_ VGND VGND VPWR VPWR _06195_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_27_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16269_ clknet_4_15_0_clk _00058_ net345 VGND VGND VPWR VPWR a_cos\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_140_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09712_ net248 net696 VGND VGND VPWR VPWR _01022_ sky130_fd_sc_hd__nand2_1
X_09643_ _00875_ _00880_ VGND VGND VPWR VPWR _00954_ sky130_fd_sc_hd__and2b_1
X_09574_ _00883_ _00885_ VGND VGND VPWR VPWR _00886_ sky130_fd_sc_hd__xnor2_1
X_08525_ _06715_ _06726_ VGND VGND VPWR VPWR _06737_ sky130_fd_sc_hd__and2b_1
XFILLER_0_78_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08456_ _05438_ _05970_ VGND VGND VPWR VPWR _05981_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_148_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08387_ net217 net208 net565 net575 VGND VGND VPWR VPWR _05231_ sky130_fd_sc_hd__and4_1
XFILLER_0_73_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09008_ net273 net562 VGND VGND VPWR VPWR _00326_ sky130_fd_sc_hd__nand2_1
XFILLER_0_61_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10280_ _01552_ _01553_ VGND VGND VPWR VPWR _01554_ sky130_fd_sc_hd__xnor2_2
Xfanout540 net543 VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__buf_2
Xfanout551 net36 VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__buf_4
Xfanout562 net566 VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__clkbuf_4
X_13970_ _05428_ _05411_ VGND VGND VPWR VPWR _05509_ sky130_fd_sc_hd__or2b_1
Xfanout573 net579 VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__buf_2
Xfanout584 net585 VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__clkbuf_4
Xfanout595 net596 VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__buf_2
X_12921_ _04279_ _04298_ _04299_ VGND VGND VPWR VPWR _04367_ sky130_fd_sc_hd__nand3_2
X_15640_ _06749_ _06750_ _06854_ _07330_ VGND VGND VPWR VPWR _07331_ sky130_fd_sc_hd__and4_1
X_12852_ _04289_ _04290_ _04291_ VGND VGND VPWR VPWR _04292_ sky130_fd_sc_hd__nand3_1
XFILLER_0_69_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11803_ _03144_ _03146_ VGND VGND VPWR VPWR _03147_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_29_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12783_ _04209_ _04213_ _04215_ VGND VGND VPWR VPWR _04216_ sky130_fd_sc_hd__a21oi_1
X_15571_ _07253_ _07254_ VGND VGND VPWR VPWR _07255_ sky130_fd_sc_hd__or2b_1
X_14522_ _06104_ _06105_ _06098_ VGND VGND VPWR VPWR _06110_ sky130_fd_sc_hd__a21o_1
X_11734_ _02999_ _03071_ VGND VGND VPWR VPWR _03072_ sky130_fd_sc_hd__xor2_1
XFILLER_0_83_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14453_ _06032_ _06033_ VGND VGND VPWR VPWR _06034_ sky130_fd_sc_hd__nor2_1
X_11665_ _02989_ _02991_ VGND VGND VPWR VPWR _02997_ sky130_fd_sc_hd__or2_1
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_126_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13404_ net800 _00447_ _04803_ _00450_ VGND VGND VPWR VPWR _04893_ sky130_fd_sc_hd__a22o_2
X_10616_ _01859_ _01879_ VGND VGND VPWR VPWR _01880_ sky130_fd_sc_hd__nor2_1
X_14384_ _05949_ _05955_ _05954_ VGND VGND VPWR VPWR _05958_ sky130_fd_sc_hd__a21o_1
X_11596_ _02917_ _02918_ _02921_ VGND VGND VPWR VPWR _02922_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13335_ _04657_ _04722_ _04721_ VGND VGND VPWR VPWR _04819_ sky130_fd_sc_hd__a21boi_1
X_16123_ _07849_ _07853_ VGND VGND VPWR VPWR _07854_ sky130_fd_sc_hd__nand2_1
X_10547_ _01774_ _01809_ _01802_ _01808_ VGND VGND VPWR VPWR _01811_ sky130_fd_sc_hd__o211a_1
X_13266_ _04652_ _04653_ _04742_ VGND VGND VPWR VPWR _04743_ sky130_fd_sc_hd__a21o_1
X_16054_ _07776_ _07779_ VGND VGND VPWR VPWR _07780_ sky130_fd_sc_hd__nand2_1
XFILLER_0_110_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10478_ _01740_ _01739_ _01695_ _01691_ VGND VGND VPWR VPWR _01742_ sky130_fd_sc_hd__o211ai_2
X_15005_ _06463_ _06637_ _06638_ VGND VGND VPWR VPWR _06640_ sky130_fd_sc_hd__nand3_2
X_12217_ _03594_ _03595_ VGND VGND VPWR VPWR _03596_ sky130_fd_sc_hd__or2_1
X_13197_ net710 net719 net159 net310 VGND VGND VPWR VPWR _04668_ sky130_fd_sc_hd__nand4_1
X_12148_ a_cos\[15\] _03520_ _03521_ VGND VGND VPWR VPWR _03522_ sky130_fd_sc_hd__mux2_1
XFILLER_0_138_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12079_ _03371_ _03340_ _03341_ VGND VGND VPWR VPWR _03447_ sky130_fd_sc_hd__nor3_1
X_15907_ net491 net631 _07619_ _07620_ VGND VGND VPWR VPWR _07621_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_139_Right_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15838_ net455 net680 net687 net447 VGND VGND VPWR VPWR _07546_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_149_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15769_ _07469_ _07470_ VGND VGND VPWR VPWR _07471_ sky130_fd_sc_hd__xnor2_2
X_08310_ _02278_ _02256_ _02267_ VGND VGND VPWR VPWR _04393_ sky130_fd_sc_hd__or3_1
XFILLER_0_59_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09290_ _00602_ _00603_ _00604_ VGND VGND VPWR VPWR _00605_ sky130_fd_sc_hd__nand3_2
XFILLER_0_129_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08241_ net169 net557 VGND VGND VPWR VPWR _03637_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_14 net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_25 net551 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_36 net717 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_47 net871 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_880 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08172_ _02800_ _02811_ _02866_ VGND VGND VPWR VPWR _02888_ sky130_fd_sc_hd__a21o_1
XANTENNA_58 net744 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_42_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput110 net110 VGND VGND VPWR VPWR Q[3] sky130_fd_sc_hd__buf_2
XFILLER_0_88_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_106_Right_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09626_ _00935_ _00936_ VGND VGND VPWR VPWR _00937_ sky130_fd_sc_hd__nor2_1
XFILLER_0_97_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09557_ _00868_ _00779_ VGND VGND VPWR VPWR _00869_ sky130_fd_sc_hd__nor2_1
X_08508_ _06497_ _06508_ _06410_ _06486_ VGND VGND VPWR VPWR _06551_ sky130_fd_sc_hd__a211o_1
X_09488_ _00786_ _00800_ VGND VGND VPWR VPWR _00801_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08439_ net196 net591 VGND VGND VPWR VPWR _05795_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11450_ _02761_ _02762_ VGND VGND VPWR VPWR _02763_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10401_ _01662_ _01663_ _01664_ VGND VGND VPWR VPWR _01665_ sky130_fd_sc_hd__or3_1
X_11381_ _02608_ _02687_ VGND VGND VPWR VPWR _02688_ sky130_fd_sc_hd__xnor2_1
X_13120_ net151 net219 net212 net230 VGND VGND VPWR VPWR _04584_ sky130_fd_sc_hd__a22o_1
X_10332_ a_sin\[16\] VGND VGND VPWR VPWR _01599_ sky130_fd_sc_hd__inv_2
XFILLER_0_21_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13051_ _04506_ _04507_ _04406_ _04408_ VGND VGND VPWR VPWR _04509_ sky130_fd_sc_hd__o211ai_2
X_10263_ a_sin\[8\] b_cos\[8\] VGND VGND VPWR VPWR _01539_ sky130_fd_sc_hd__or2b_1
X_12002_ _03354_ _03362_ VGND VGND VPWR VPWR _03363_ sky130_fd_sc_hd__xnor2_1
X_10194_ _01479_ _01480_ VGND VGND VPWR VPWR _01481_ sky130_fd_sc_hd__and2b_1
Xfanout370 net371 VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__clkbuf_2
Xfanout381 net382 VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__buf_4
Xfanout392 net53 VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__buf_4
X_13953_ _05387_ net797 _01087_ VGND VGND VPWR VPWR _05490_ sky130_fd_sc_hd__and3b_1
XFILLER_0_17_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12904_ net783 net275 VGND VGND VPWR VPWR _04348_ sky130_fd_sc_hd__nand2_1
X_13884_ _05413_ _05414_ VGND VGND VPWR VPWR _05415_ sky130_fd_sc_hd__nor2_1
X_15623_ _07168_ _07171_ VGND VGND VPWR VPWR _07312_ sky130_fd_sc_hd__and2_1
X_12835_ net738 net170 _04271_ _04272_ VGND VGND VPWR VPWR _04274_ sky130_fd_sc_hd__a22o_1
XFILLER_0_56_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15554_ _07181_ _07236_ VGND VGND VPWR VPWR _07237_ sky130_fd_sc_hd__xnor2_2
X_12766_ _04171_ _04197_ VGND VGND VPWR VPWR _04198_ sky130_fd_sc_hd__xor2_1
X_14505_ net519 net434 net587 net596 VGND VGND VPWR VPWR _06092_ sky130_fd_sc_hd__and4_1
X_11717_ _03048_ _03052_ _03053_ VGND VGND VPWR VPWR _03054_ sky130_fd_sc_hd__and3_1
X_12697_ _04069_ _04076_ _04074_ VGND VGND VPWR VPWR _04122_ sky130_fd_sc_hd__o21ai_1
X_15485_ net460 net536 net545 net451 VGND VGND VPWR VPWR _07162_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_126_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14436_ net380 net569 net578 net369 VGND VGND VPWR VPWR _06016_ sky130_fd_sc_hd__a22o_1
X_11648_ _02954_ _02955_ _02977_ _02978_ VGND VGND VPWR VPWR _02979_ sky130_fd_sc_hd__a22o_1
XFILLER_0_140_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput12 alpha[2] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_4
Xinput23 beta[12] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_4
XFILLER_0_141_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput34 beta[5] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_114_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput45 cos[15] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_4
X_14367_ _05932_ _05934_ VGND VGND VPWR VPWR _05940_ sky130_fd_sc_hd__nor2_1
X_11579_ _02826_ _02808_ VGND VGND VPWR VPWR _02903_ sky130_fd_sc_hd__and2b_1
Xinput56 cos[8] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__buf_1
XFILLER_0_3_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput67 sin[17] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__clkbuf_1
Xinput78 start VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__buf_1
X_16106_ _07831_ _07832_ _07834_ VGND VGND VPWR VPWR _07837_ sky130_fd_sc_hd__and3_1
X_13318_ _04797_ _04798_ _04799_ VGND VGND VPWR VPWR _04800_ sky130_fd_sc_hd__a21o_1
X_14298_ net521 net542 net550 net436 VGND VGND VPWR VPWR _05864_ sky130_fd_sc_hd__a22o_1
XFILLER_0_58_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16037_ _07605_ _07700_ _07761_ VGND VGND VPWR VPWR _07762_ sky130_fd_sc_hd__or3_1
XFILLER_0_149_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13249_ _04608_ _04610_ _04723_ _04724_ VGND VGND VPWR VPWR _04725_ sky130_fd_sc_hd__a211o_1
XFILLER_0_0_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08790_ _08098_ _08099_ VGND VGND VPWR VPWR _08100_ sky130_fd_sc_hd__xor2_1
XFILLER_0_79_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09411_ _00633_ _00635_ VGND VGND VPWR VPWR _00725_ sky130_fd_sc_hd__or2b_1
X_09342_ _00568_ _00645_ VGND VGND VPWR VPWR _00656_ sky130_fd_sc_hd__or2_1
X_09273_ _00408_ net571 VGND VGND VPWR VPWR _00588_ sky130_fd_sc_hd__nor2_1
XFILLER_0_63_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08224_ net320 net236 net658 net669 VGND VGND VPWR VPWR _03453_ sky130_fd_sc_hd__and4_1
XFILLER_0_133_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08155_ _02615_ _02692_ VGND VGND VPWR VPWR _02702_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_132_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08988_ net266 net259 net571 net580 VGND VGND VPWR VPWR _00306_ sky130_fd_sc_hd__and4_1
X_10950_ _02215_ _02216_ _02217_ VGND VGND VPWR VPWR _02218_ sky130_fd_sc_hd__nand3_1
X_09609_ _00918_ _00919_ VGND VGND VPWR VPWR _00920_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_97_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10881_ _02141_ _02144_ VGND VGND VPWR VPWR _02145_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_66_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12620_ _03982_ _03983_ _03975_ VGND VGND VPWR VPWR _04037_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_65_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12551_ net774 net190 net180 net782 VGND VGND VPWR VPWR _03961_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_65_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11502_ net767 net444 _02711_ _02818_ VGND VGND VPWR VPWR _02819_ sky130_fd_sc_hd__a31o_1
XFILLER_0_109_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12482_ net739 net214 net205 net747 VGND VGND VPWR VPWR _03885_ sky130_fd_sc_hd__a22oi_1
X_15270_ _06926_ _06927_ VGND VGND VPWR VPWR _06928_ sky130_fd_sc_hd__xor2_1
XFILLER_0_34_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14221_ _05735_ _05759_ _05734_ VGND VGND VPWR VPWR _05780_ sky130_fd_sc_hd__a21o_1
XFILLER_0_62_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11433_ _02734_ _02742_ _02743_ VGND VGND VPWR VPWR _02744_ sky130_fd_sc_hd__nand3_2
XFILLER_0_110_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14152_ _05704_ _05705_ VGND VGND VPWR VPWR _05706_ sky130_fd_sc_hd__or2_1
X_11364_ net416 net803 VGND VGND VPWR VPWR _02669_ sky130_fd_sc_hd__nand2_2
XFILLER_0_22_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13103_ _04562_ _04563_ _04547_ VGND VGND VPWR VPWR _04565_ sky130_fd_sc_hd__a21o_1
X_10315_ _01584_ VGND VGND VPWR VPWR _00052_ sky130_fd_sc_hd__clkbuf_1
X_14083_ _05619_ _05630_ VGND VGND VPWR VPWR _05631_ sky130_fd_sc_hd__xor2_1
X_11295_ _02591_ _02592_ _02477_ _02479_ VGND VGND VPWR VPWR _02595_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_131_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13034_ _04486_ _04487_ _04488_ VGND VGND VPWR VPWR _04490_ sky130_fd_sc_hd__a21o_1
X_10246_ net112 _01524_ net136 VGND VGND VPWR VPWR _01525_ sky130_fd_sc_hd__mux2_1
XFILLER_0_119_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10177_ a_cos\[14\] b_sin\[14\] VGND VGND VPWR VPWR _01466_ sky130_fd_sc_hd__and2_1
X_14985_ _06510_ _06512_ _06511_ VGND VGND VPWR VPWR _06618_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_89_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13936_ _05449_ _05471_ VGND VGND VPWR VPWR _05472_ sky130_fd_sc_hd__nand2_1
XFILLER_0_88_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13867_ _05376_ _05377_ _05396_ VGND VGND VPWR VPWR _05397_ sky130_fd_sc_hd__o21a_1
X_15606_ _07272_ _07273_ _07291_ _07293_ VGND VGND VPWR VPWR _07294_ sky130_fd_sc_hd__o211ai_2
X_12818_ net763 net299 VGND VGND VPWR VPWR _04255_ sky130_fd_sc_hd__nand2_1
X_13798_ _05317_ _05321_ VGND VGND VPWR VPWR _05322_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15537_ net493 net681 VGND VGND VPWR VPWR _07219_ sky130_fd_sc_hd__and2_1
X_12749_ net790 net221 _04177_ _04178_ VGND VGND VPWR VPWR _04179_ sky130_fd_sc_hd__a31o_1
XFILLER_0_44_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15468_ _07053_ _07143_ VGND VGND VPWR VPWR _07144_ sky130_fd_sc_hd__xor2_2
XFILLER_0_72_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14419_ net523 net690 net700 net438 VGND VGND VPWR VPWR _05997_ sky130_fd_sc_hd__a22o_1
XFILLER_0_25_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15399_ _07066_ _07064_ _07065_ VGND VGND VPWR VPWR _07068_ sky130_fd_sc_hd__and3_1
XFILLER_0_13_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09960_ _01264_ _01265_ VGND VGND VPWR VPWR _01266_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_110_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08911_ _00127_ _00129_ _00128_ VGND VGND VPWR VPWR _00230_ sky130_fd_sc_hd__a21bo_1
X_09891_ _01196_ _01197_ VGND VGND VPWR VPWR _01198_ sky130_fd_sc_hd__xnor2_1
X_08842_ _00159_ net829 _00158_ VGND VGND VPWR VPWR _00162_ sky130_fd_sc_hd__o21ai_1
X_08773_ _07995_ _08005_ _08082_ _08083_ VGND VGND VPWR VPWR _08084_ sky130_fd_sc_hd__o211a_1
XFILLER_0_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09325_ _00637_ _00639_ VGND VGND VPWR VPWR _00640_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_63_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09256_ _00495_ _00497_ VGND VGND VPWR VPWR _00571_ sky130_fd_sc_hd__nor2_1
Xclone26 net246 VGND VGND VPWR VPWR net837 sky130_fd_sc_hd__buf_4
XFILLER_0_47_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08207_ _03246_ _03257_ VGND VGND VPWR VPWR _03268_ sky130_fd_sc_hd__nor2_1
XFILLER_0_16_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09187_ _00425_ _00427_ VGND VGND VPWR VPWR _00503_ sky130_fd_sc_hd__nand2_1
XFILLER_0_105_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08138_ _02474_ _02506_ VGND VGND VPWR VPWR _02517_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_31_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10100_ a_cos\[3\] b_sin\[3\] VGND VGND VPWR VPWR _01400_ sky130_fd_sc_hd__or2_1
X_11080_ _02357_ _02358_ _02359_ VGND VGND VPWR VPWR _02360_ sky130_fd_sc_hd__nand3_4
X_10031_ _01334_ _01335_ VGND VGND VPWR VPWR _01336_ sky130_fd_sc_hd__nor2_1
X_14770_ net350 net504 net559 net567 VGND VGND VPWR VPWR _06383_ sky130_fd_sc_hd__and4_1
X_11982_ _03320_ _03339_ VGND VGND VPWR VPWR _03341_ sky130_fd_sc_hd__nor2_1
X_13721_ net140 net165 VGND VGND VPWR VPWR _05238_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10933_ _02126_ _02128_ _02198_ VGND VGND VPWR VPWR _02199_ sky130_fd_sc_hd__a21oi_2
X_13652_ _05092_ _05094_ VGND VGND VPWR VPWR _05163_ sky130_fd_sc_hd__and2_1
X_10864_ _02108_ _02109_ _02126_ _02127_ VGND VGND VPWR VPWR _02128_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_85_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12603_ _03964_ _03955_ _03966_ VGND VGND VPWR VPWR _04018_ sky130_fd_sc_hd__and3_1
XFILLER_0_27_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13583_ _05084_ _05085_ _05086_ VGND VGND VPWR VPWR _05088_ sky130_fd_sc_hd__a21o_1
X_10795_ _02057_ _02058_ VGND VGND VPWR VPWR _02059_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15322_ _06982_ _06983_ VGND VGND VPWR VPWR _06984_ sky130_fd_sc_hd__nor2_1
X_12534_ _03907_ _03909_ _03908_ VGND VGND VPWR VPWR _03942_ sky130_fd_sc_hd__or3_1
XFILLER_0_136_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15253_ net357 net682 _06907_ _06908_ VGND VGND VPWR VPWR _06909_ sky130_fd_sc_hd__a22o_1
X_12465_ _03847_ _03864_ _03865_ VGND VGND VPWR VPWR _03867_ sky130_fd_sc_hd__nand3_2
X_14204_ _05760_ _05761_ VGND VGND VPWR VPWR _05762_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_50_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11416_ _02708_ _02725_ VGND VGND VPWR VPWR _02726_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_22_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12396_ _03731_ _03737_ VGND VGND VPWR VPWR _03791_ sky130_fd_sc_hd__or2b_1
X_15184_ _06832_ _06833_ VGND VGND VPWR VPWR _06834_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_61_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14135_ _05685_ _05686_ VGND VGND VPWR VPWR _05688_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11347_ _02649_ _02650_ VGND VGND VPWR VPWR _02651_ sky130_fd_sc_hd__nor2_1
XFILLER_0_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14066_ net507 _00194_ VGND VGND VPWR VPWR _05613_ sky130_fd_sc_hd__nor2_1
XFILLER_0_120_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11278_ _02574_ _02571_ _02573_ VGND VGND VPWR VPWR _02576_ sky130_fd_sc_hd__nand3_1
X_13017_ net720 net170 _04468_ _04470_ VGND VGND VPWR VPWR _04472_ sky130_fd_sc_hd__nand4_2
X_10229_ _01509_ a_sin\[2\] _01502_ VGND VGND VPWR VPWR _01510_ sky130_fd_sc_hd__a21o_1
XFILLER_0_146_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14968_ net377 net366 net690 net699 VGND VGND VPWR VPWR _06599_ sky130_fd_sc_hd__nand4_2
XFILLER_0_77_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13919_ net422 net263 net252 net507 VGND VGND VPWR VPWR _05453_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_89_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14899_ _06503_ _06522_ _06523_ VGND VGND VPWR VPWR _06524_ sky130_fd_sc_hd__and3_1
XFILLER_0_71_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09110_ _00418_ _00425_ _00426_ VGND VGND VPWR VPWR _00427_ sky130_fd_sc_hd__nand3_1
XFILLER_0_57_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09041_ net220 net629 net817 _00358_ VGND VGND VPWR VPWR _00359_ sky130_fd_sc_hd__a211o_1
XFILLER_0_143_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmax_cap120 _07413_ VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_130_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmax_cap131 _06113_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__buf_1
XFILLER_0_130_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09943_ _01211_ _01248_ VGND VGND VPWR VPWR _01249_ sky130_fd_sc_hd__xor2_1
XFILLER_0_96_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09874_ _00932_ _01007_ _00986_ VGND VGND VPWR VPWR _01181_ sky130_fd_sc_hd__a21bo_2
X_08825_ net185 net684 net693 net175 VGND VGND VPWR VPWR _00145_ sky130_fd_sc_hd__a22o_1
X_08756_ _07971_ _07979_ _07978_ VGND VGND VPWR VPWR _08067_ sky130_fd_sc_hd__a21bo_1
X_08687_ _04097_ _04643_ VGND VGND VPWR VPWR _07999_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09308_ _00526_ _00528_ VGND VGND VPWR VPWR _00623_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10580_ _01829_ _01830_ _01842_ VGND VGND VPWR VPWR _01844_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_35_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09239_ _00502_ _00554_ VGND VGND VPWR VPWR _00555_ sky130_fd_sc_hd__xor2_2
XFILLER_0_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_134_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12250_ _03629_ _03631_ VGND VGND VPWR VPWR _03632_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_121_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11201_ _02378_ _02488_ _02491_ VGND VGND VPWR VPWR _02492_ sky130_fd_sc_hd__nand3b_2
XFILLER_0_31_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12181_ _03468_ _03471_ _03469_ VGND VGND VPWR VPWR _03557_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11132_ net759 net476 VGND VGND VPWR VPWR _02416_ sky130_fd_sc_hd__and2_1
XFILLER_0_102_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15940_ _07646_ _07652_ _07655_ VGND VGND VPWR VPWR _07656_ sky130_fd_sc_hd__a21o_1
X_11063_ _02331_ _02340_ VGND VGND VPWR VPWR _02341_ sky130_fd_sc_hd__xor2_2
X_10014_ _00195_ net662 VGND VGND VPWR VPWR _01319_ sky130_fd_sc_hd__nor2_1
X_15871_ _07541_ _07562_ VGND VGND VPWR VPWR _07581_ sky130_fd_sc_hd__nand2_1
X_14822_ _06437_ _06439_ VGND VGND VPWR VPWR _06440_ sky130_fd_sc_hd__xnor2_1
X_14753_ _06362_ _06363_ VGND VGND VPWR VPWR _06364_ sky130_fd_sc_hd__or2_1
X_11965_ _03252_ _03255_ _03253_ VGND VGND VPWR VPWR _03323_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13704_ _05217_ _05218_ VGND VGND VPWR VPWR _05219_ sky130_fd_sc_hd__xnor2_1
X_10916_ _02179_ _02180_ _02106_ VGND VGND VPWR VPWR _02183_ sky130_fd_sc_hd__a21o_1
X_14684_ _06285_ _06286_ _06287_ VGND VGND VPWR VPWR _06288_ sky130_fd_sc_hd__or3_1
X_11896_ _03183_ _03184_ VGND VGND VPWR VPWR _03248_ sky130_fd_sc_hd__and2_1
XFILLER_0_67_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13635_ net140 net798 net183 net173 VGND VGND VPWR VPWR _05145_ sky130_fd_sc_hd__and4_1
XFILLER_0_73_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10847_ _02054_ _02061_ VGND VGND VPWR VPWR _02111_ sky130_fd_sc_hd__or2b_1
XFILLER_0_54_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13566_ _05056_ _05069_ VGND VGND VPWR VPWR _05070_ sky130_fd_sc_hd__xnor2_2
X_10778_ _02039_ _02040_ _02038_ VGND VGND VPWR VPWR _02042_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_81_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15305_ net443 net573 VGND VGND VPWR VPWR _06966_ sky130_fd_sc_hd__nand2_1
XFILLER_0_42_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12517_ _03724_ _03725_ _03739_ VGND VGND VPWR VPWR _03924_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_82_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16285_ clknet_4_4_0_clk _00074_ net334 VGND VGND VPWR VPWR a_cos\[16\] sky130_fd_sc_hd__dfrtp_1
X_13497_ net229 net150 net183 net173 VGND VGND VPWR VPWR _04995_ sky130_fd_sc_hd__nand4_2
X_15236_ net348 net499 net688 net698 VGND VGND VPWR VPWR _06891_ sky130_fd_sc_hd__nand4_2
X_12448_ _03762_ _03768_ VGND VGND VPWR VPWR _03848_ sky130_fd_sc_hd__or2b_1
XFILLER_0_2_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15167_ _06784_ _06729_ _06814_ _06815_ VGND VGND VPWR VPWR _06816_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_140_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12379_ _03759_ _03760_ _03770_ VGND VGND VPWR VPWR _03772_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_1_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14118_ _05659_ _05668_ VGND VGND VPWR VPWR _05669_ sky130_fd_sc_hd__xnor2_1
X_15098_ _06738_ _06739_ _06651_ _06635_ VGND VGND VPWR VPWR _06741_ sky130_fd_sc_hd__a211oi_4
X_14049_ _05585_ _05584_ VGND VGND VPWR VPWR _05594_ sky130_fd_sc_hd__or2b_1
X_08610_ _04676_ _05188_ VGND VGND VPWR VPWR _07661_ sky130_fd_sc_hd__nand2_1
X_09590_ _00827_ _00901_ VGND VGND VPWR VPWR _00902_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08541_ _06693_ _06704_ _06857_ VGND VGND VPWR VPWR _06911_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_77_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08472_ _05633_ _06124_ _06113_ _06047_ VGND VGND VPWR VPWR _06157_ sky130_fd_sc_hd__a211o_1
XFILLER_0_106_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09024_ _00264_ _00265_ _00266_ VGND VGND VPWR VPWR _00342_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout700 net701 VGND VGND VPWR VPWR net700 sky130_fd_sc_hd__clkbuf_2
Xfanout711 net717 VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__buf_4
X_09926_ _01110_ _01175_ VGND VGND VPWR VPWR _01233_ sky130_fd_sc_hd__or2_1
Xfanout722 net726 VGND VGND VPWR VPWR net722 sky130_fd_sc_hd__clkbuf_4
Xfanout733 net735 VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__buf_1
Xfanout744 net17 VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__clkbuf_8
Xfanout755 net762 VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__clkbuf_2
Xfanout766 net771 VGND VGND VPWR VPWR net766 sky130_fd_sc_hd__clkbuf_2
X_09857_ _01163_ _01142_ _01143_ VGND VGND VPWR VPWR _01165_ sky130_fd_sc_hd__and3_1
Xfanout777 net779 VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__clkbuf_4
Xfanout788 net789 VGND VGND VPWR VPWR net788 sky130_fd_sc_hd__clkbuf_4
Xfanout799 net800 VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_99_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08808_ net160 net867 net539 net544 VGND VGND VPWR VPWR _00128_ sky130_fd_sc_hd__nand4_1
X_09788_ _01009_ VGND VGND VPWR VPWR _01097_ sky130_fd_sc_hd__inv_2
X_08739_ _08048_ _08049_ VGND VGND VPWR VPWR _08050_ sky130_fd_sc_hd__and2b_1
XFILLER_0_68_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11750_ _03079_ _03086_ _03077_ VGND VGND VPWR VPWR _03089_ sky130_fd_sc_hd__o21ba_1
X_10701_ net393 net864 VGND VGND VPWR VPWR _01965_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11681_ net749 _02387_ VGND VGND VPWR VPWR _03014_ sky130_fd_sc_hd__or2_1
XFILLER_0_49_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13420_ _04880_ _04910_ VGND VGND VPWR VPWR _04911_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_64_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10632_ _01887_ _01893_ _01895_ VGND VGND VPWR VPWR _01896_ sky130_fd_sc_hd__a21o_1
XFILLER_0_125_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13351_ _04738_ _04821_ VGND VGND VPWR VPWR _04835_ sky130_fd_sc_hd__or2b_1
X_10563_ _01802_ _01807_ _01806_ VGND VGND VPWR VPWR _01827_ sky130_fd_sc_hd__a21o_1
XFILLER_0_107_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12302_ _03687_ VGND VGND VPWR VPWR _00076_ sky130_fd_sc_hd__clkbuf_1
X_16070_ _07756_ _07796_ VGND VGND VPWR VPWR _07797_ sky130_fd_sc_hd__xor2_1
XFILLER_0_106_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13282_ _04744_ _04759_ VGND VGND VPWR VPWR _04760_ sky130_fd_sc_hd__xnor2_1
X_10494_ net53 net786 VGND VGND VPWR VPWR _01758_ sky130_fd_sc_hd__nand2_1
XFILLER_0_106_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15021_ net468 net461 net573 net584 VGND VGND VPWR VPWR _06656_ sky130_fd_sc_hd__nand4_1
X_12233_ _03611_ _03612_ VGND VGND VPWR VPWR _03613_ sky130_fd_sc_hd__or2b_1
XFILLER_0_133_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12164_ _03346_ _03537_ VGND VGND VPWR VPWR _03538_ sky130_fd_sc_hd__xnor2_1
X_11115_ net767 net463 VGND VGND VPWR VPWR _02398_ sky130_fd_sc_hd__nand2_1
X_12095_ _03195_ _03271_ _03250_ VGND VGND VPWR VPWR _03464_ sky130_fd_sc_hd__a21o_1
X_15923_ _07580_ _07581_ _07636_ _07637_ VGND VGND VPWR VPWR _07638_ sky130_fd_sc_hd__a211oi_1
X_11046_ _02313_ _02320_ _02322_ VGND VGND VPWR VPWR _02323_ sky130_fd_sc_hd__nand3_2
XFILLER_0_127_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15854_ _07541_ _07562_ VGND VGND VPWR VPWR _07563_ sky130_fd_sc_hd__xnor2_1
X_14805_ _06418_ _06419_ _06411_ VGND VGND VPWR VPWR _06422_ sky130_fd_sc_hd__a21o_1
X_15785_ _07486_ _07487_ VGND VGND VPWR VPWR _07489_ sky130_fd_sc_hd__and2b_1
X_12997_ net730 net737 net161 net867 VGND VGND VPWR VPWR _04450_ sky130_fd_sc_hd__nand4_1
X_14736_ _06248_ _06250_ _06243_ VGND VGND VPWR VPWR _06346_ sky130_fd_sc_hd__o21ai_1
X_11948_ _03286_ _03304_ VGND VGND VPWR VPWR _03305_ sky130_fd_sc_hd__xnor2_1
X_14667_ _06026_ _06041_ _06268_ _06269_ VGND VGND VPWR VPWR _06270_ sky130_fd_sc_hd__o211a_1
XFILLER_0_129_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11879_ _03227_ _03228_ _03133_ _03157_ VGND VGND VPWR VPWR _03230_ sky130_fd_sc_hd__a211o_1
XFILLER_0_7_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13618_ _05124_ _05125_ VGND VGND VPWR VPWR _05126_ sky130_fd_sc_hd__nor2_1
X_14598_ _06187_ _06193_ VGND VGND VPWR VPWR _06194_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_82_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13549_ net799 net193 _04980_ _04982_ VGND VGND VPWR VPWR _05051_ sky130_fd_sc_hd__a22o_1
XFILLER_0_54_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16268_ clknet_4_15_0_clk _00057_ net344 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_124_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15219_ _06865_ _06871_ VGND VGND VPWR VPWR _06872_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_11_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16199_ _07810_ _07868_ VGND VGND VPWR VPWR _07937_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09711_ _01019_ _01020_ VGND VGND VPWR VPWR _01021_ sky130_fd_sc_hd__nor2_1
X_09642_ _00951_ _00952_ VGND VGND VPWR VPWR _00953_ sky130_fd_sc_hd__xor2_1
XFILLER_0_78_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09573_ _00793_ _00794_ _00884_ VGND VGND VPWR VPWR _00885_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_78_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08524_ net215 net591 net601 net206 VGND VGND VPWR VPWR _06726_ sky130_fd_sc_hd__a22o_1
XFILLER_0_148_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08455_ _05459_ _05448_ VGND VGND VPWR VPWR _05970_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08386_ net217 net565 net575 net208 VGND VGND VPWR VPWR _05220_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_135_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09007_ net552 _00323_ _00324_ VGND VGND VPWR VPWR _00325_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_5_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout530 net534 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__clkbuf_4
Xfanout541 net543 VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__clkbuf_4
Xfanout552 net561 VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__buf_4
X_09909_ _01074_ _01214_ VGND VGND VPWR VPWR _01216_ sky130_fd_sc_hd__or2_1
Xfanout563 net566 VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__clkbuf_2
Xfanout574 net579 VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__clkbuf_2
Xfanout585 net588 VGND VGND VPWR VPWR net585 sky130_fd_sc_hd__buf_2
X_12920_ _04364_ _04365_ VGND VGND VPWR VPWR _04366_ sky130_fd_sc_hd__nand2_1
Xfanout596 net597 VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__buf_1
XFILLER_0_69_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12851_ _03815_ _03817_ _03816_ VGND VGND VPWR VPWR _04291_ sky130_fd_sc_hd__o21bai_1
X_11802_ _03145_ VGND VGND VPWR VPWR _03146_ sky130_fd_sc_hd__inv_2
X_15570_ _07025_ _07185_ VGND VGND VPWR VPWR _07254_ sky130_fd_sc_hd__or2_2
X_12782_ _04209_ _04213_ _04183_ _04214_ VGND VGND VPWR VPWR _04215_ sky130_fd_sc_hd__o211a_1
X_14521_ _06072_ _06107_ _06104_ _06106_ VGND VGND VPWR VPWR _06109_ sky130_fd_sc_hd__o211a_1
XFILLER_0_95_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11733_ _03069_ _03070_ VGND VGND VPWR VPWR _03071_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14452_ net495 net707 _06030_ _06031_ VGND VGND VPWR VPWR _06033_ sky130_fd_sc_hd__o2bb2a_1
X_11664_ _02995_ VGND VGND VPWR VPWR _00066_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13403_ net800 net220 net818 VGND VGND VPWR VPWR _04892_ sky130_fd_sc_hd__and3_2
XFILLER_0_52_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10615_ net418 net795 _01878_ _01858_ VGND VGND VPWR VPWR _01879_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_64_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14383_ _05910_ _05911_ _05905_ VGND VGND VPWR VPWR _05957_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_118_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11595_ _02919_ _02819_ _02816_ VGND VGND VPWR VPWR _02921_ sky130_fd_sc_hd__a21o_1
X_16122_ _07611_ _07852_ VGND VGND VPWR VPWR _07853_ sky130_fd_sc_hd__xnor2_2
X_13334_ _04761_ _04816_ VGND VGND VPWR VPWR _04817_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_107_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10546_ _01802_ _01808_ _01774_ _01809_ VGND VGND VPWR VPWR _01810_ sky130_fd_sc_hd__a211oi_2
X_16053_ _07652_ _07777_ _07778_ VGND VGND VPWR VPWR _07779_ sky130_fd_sc_hd__a21o_1
X_13265_ _04648_ _04651_ VGND VGND VPWR VPWR _04742_ sky130_fd_sc_hd__nor2_1
XFILLER_0_51_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10477_ _01691_ _01695_ _01739_ _01740_ VGND VGND VPWR VPWR _01741_ sky130_fd_sc_hd__a211o_1
X_15004_ _06635_ _06636_ _06531_ _06554_ VGND VGND VPWR VPWR _06638_ sky130_fd_sc_hd__o211ai_2
X_12216_ _03487_ _03588_ _03592_ VGND VGND VPWR VPWR _03595_ sky130_fd_sc_hd__nor3_1
XFILLER_0_20_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13196_ net709 net159 net310 net719 VGND VGND VPWR VPWR _04667_ sky130_fd_sc_hd__a22o_1
X_12147_ _02170_ VGND VGND VPWR VPWR _03521_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_138_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12078_ _03369_ _03370_ VGND VGND VPWR VPWR _03446_ sky130_fd_sc_hd__and2_1
X_15906_ net346 net498 net622 VGND VGND VPWR VPWR _07620_ sky130_fd_sc_hd__o21ai_2
X_11029_ _02302_ _02303_ VGND VGND VPWR VPWR _02304_ sky130_fd_sc_hd__or2_1
XFILLER_0_2_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15837_ _07429_ _07432_ _07430_ VGND VGND VPWR VPWR _07545_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_59_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15768_ net442 net527 VGND VGND VPWR VPWR _07470_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14719_ _06323_ _06326_ VGND VGND VPWR VPWR _06327_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_87_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15699_ net459 net450 net697 net527 VGND VGND VPWR VPWR _07395_ sky130_fd_sc_hd__and4_1
X_08240_ _02822_ _02844_ _02833_ VGND VGND VPWR VPWR _03626_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_74_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_15 net235 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_26 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_37 net864 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08171_ _02800_ net880 _02866_ VGND VGND VPWR VPWR _02877_ sky130_fd_sc_hd__nand3_2
XANTENNA_48 net186 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_59 net753 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput100 net100 VGND VGND VPWR VPWR Q[11] sky130_fd_sc_hd__clkbuf_4
Xoutput111 net111 VGND VGND VPWR VPWR Q[4] sky130_fd_sc_hd__buf_2
XFILLER_0_101_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09625_ _00761_ _00928_ _00934_ VGND VGND VPWR VPWR _00936_ sky130_fd_sc_hd__o21a_1
XFILLER_0_78_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09556_ _00776_ _00774_ VGND VGND VPWR VPWR _00868_ sky130_fd_sc_hd__and2b_1
XFILLER_0_78_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08507_ _06410_ _06486_ _06497_ _06508_ VGND VGND VPWR VPWR _06541_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_66_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09487_ _00798_ _00799_ VGND VGND VPWR VPWR _00800_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_65_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08438_ _05763_ _05774_ VGND VGND VPWR VPWR _05784_ sky130_fd_sc_hd__and2b_1
XFILLER_0_108_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08369_ _04872_ _04894_ VGND VGND VPWR VPWR _05035_ sky130_fd_sc_hd__or2b_1
XFILLER_0_123_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10400_ net524 net716 net725 net439 VGND VGND VPWR VPWR _01664_ sky130_fd_sc_hd__a22oi_2
X_11380_ _02685_ _02686_ VGND VGND VPWR VPWR _02687_ sky130_fd_sc_hd__xor2_1
XFILLER_0_116_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10331_ _01596_ _01597_ VGND VGND VPWR VPWR _01598_ sky130_fd_sc_hd__nand2_1
X_13050_ _04406_ _04408_ _04506_ _04507_ VGND VGND VPWR VPWR _04508_ sky130_fd_sc_hd__a211o_2
X_10262_ b_cos\[8\] a_sin\[8\] VGND VGND VPWR VPWR _01538_ sky130_fd_sc_hd__or2b_1
X_12001_ _03356_ _03361_ VGND VGND VPWR VPWR _03362_ sky130_fd_sc_hd__xnor2_1
X_10193_ a_cos\[16\] b_sin\[16\] VGND VGND VPWR VPWR _01480_ sky130_fd_sc_hd__nand2_1
Xfanout360 net364 VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_108_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout371 net374 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__buf_6
XFILLER_0_17_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout382 net385 VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__buf_4
X_13952_ net139 net295 VGND VGND VPWR VPWR _05489_ sky130_fd_sc_hd__nand2_1
Xfanout393 net53 VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__clkbuf_4
X_12903_ _04345_ _04346_ VGND VGND VPWR VPWR _04347_ sky130_fd_sc_hd__nor2_1
X_13883_ net507 net609 net261 net254 VGND VGND VPWR VPWR _05414_ sky130_fd_sc_hd__and4_1
X_15622_ _07309_ _07310_ VGND VGND VPWR VPWR _07311_ sky130_fd_sc_hd__xnor2_1
X_12834_ net720 net729 net187 net178 VGND VGND VPWR VPWR _04272_ sky130_fd_sc_hd__nand4_1
XFILLER_0_69_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15553_ _07234_ _07235_ VGND VGND VPWR VPWR _07236_ sky130_fd_sc_hd__xnor2_2
X_12765_ _04186_ _04184_ VGND VGND VPWR VPWR _04197_ sky130_fd_sc_hd__or2b_1
XFILLER_0_139_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14504_ _06089_ _06060_ _06087_ VGND VGND VPWR VPWR _06090_ sky130_fd_sc_hd__a21bo_1
X_11716_ net358 net153 _03049_ _03050_ VGND VGND VPWR VPWR _03053_ sky130_fd_sc_hd__nand4_1
X_15484_ _07100_ _07102_ VGND VGND VPWR VPWR _07160_ sky130_fd_sc_hd__and2_1
X_12696_ _04074_ _04069_ _04076_ VGND VGND VPWR VPWR _04121_ sky130_fd_sc_hd__or3_1
XFILLER_0_84_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14435_ net380 net369 net569 net578 VGND VGND VPWR VPWR _06015_ sky130_fd_sc_hd__nand4_1
X_11647_ _02974_ _02976_ _02956_ VGND VGND VPWR VPWR _02978_ sky130_fd_sc_hd__a21o_1
Xinput13 alpha[3] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_64_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput24 beta[13] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput35 beta[6] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_1
X_14366_ _05892_ _05896_ _05936_ _05938_ VGND VGND VPWR VPWR _05939_ sky130_fd_sc_hd__o211ai_4
Xinput46 cos[16] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__dlymetal6s2s_1
X_11578_ _02803_ _02890_ VGND VGND VPWR VPWR _02902_ sky130_fd_sc_hd__nor2_1
Xinput57 cos[9] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__buf_1
Xinput68 sin[18] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__clkbuf_2
X_16105_ _07831_ _07832_ _07834_ VGND VGND VPWR VPWR _07836_ sky130_fd_sc_hd__a21oi_1
X_13317_ net229 net194 VGND VGND VPWR VPWR _04799_ sky130_fd_sc_hd__and2_1
XFILLER_0_24_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10529_ _01764_ _01762_ _01763_ VGND VGND VPWR VPWR _01793_ sky130_fd_sc_hd__nand3_1
X_14297_ net419 net560 VGND VGND VPWR VPWR _05863_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16036_ _07608_ _07760_ VGND VGND VPWR VPWR _07761_ sky130_fd_sc_hd__xnor2_1
X_13248_ _04721_ _04722_ _04657_ VGND VGND VPWR VPWR _04724_ sky130_fd_sc_hd__a21oi_1
X_13179_ _04646_ _04647_ VGND VGND VPWR VPWR _04648_ sky130_fd_sc_hd__xnor2_1
X_09410_ _00543_ _00634_ _00633_ VGND VGND VPWR VPWR _00724_ sky130_fd_sc_hd__and3_1
X_09341_ _00647_ _00650_ _00654_ VGND VGND VPWR VPWR _00655_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_47_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09272_ _00584_ _00586_ VGND VGND VPWR VPWR _00587_ sky130_fd_sc_hd__xor2_4
XFILLER_0_118_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08223_ net220 net679 VGND VGND VPWR VPWR _03442_ sky130_fd_sc_hd__nand2_1
XFILLER_0_145_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08154_ _02626_ _02681_ VGND VGND VPWR VPWR _02692_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08987_ net266 net571 net580 net259 VGND VGND VPWR VPWR _00305_ sky130_fd_sc_hd__a22oi_1
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_97_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09608_ net296 net647 VGND VGND VPWR VPWR _00919_ sky130_fd_sc_hd__nand2_1
X_10880_ _02142_ _02143_ VGND VGND VPWR VPWR _02144_ sky130_fd_sc_hd__nor2_1
X_09539_ _00849_ _00850_ VGND VGND VPWR VPWR _00851_ sky130_fd_sc_hd__nor2_1
XFILLER_0_66_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12550_ net791 net172 VGND VGND VPWR VPWR _03960_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11501_ net462 _02710_ VGND VGND VPWR VPWR _02818_ sky130_fd_sc_hd__and2_1
XFILLER_0_53_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12481_ _03726_ _03728_ _03727_ VGND VGND VPWR VPWR _03884_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_46_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14220_ _05777_ _05778_ VGND VGND VPWR VPWR _05779_ sky130_fd_sc_hd__or2_1
XFILLER_0_80_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11432_ _02739_ _02740_ _02741_ VGND VGND VPWR VPWR _02743_ sky130_fd_sc_hd__a21o_1
XFILLER_0_110_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14151_ _05637_ _05640_ _05702_ _05703_ VGND VGND VPWR VPWR _05705_ sky130_fd_sc_hd__a211oi_2
X_11363_ _02664_ _02665_ _02666_ VGND VGND VPWR VPWR _02668_ sky130_fd_sc_hd__nand3_1
X_13102_ _04547_ _04562_ _04563_ VGND VGND VPWR VPWR _04564_ sky130_fd_sc_hd__nand3_1
X_10314_ net103 _01583_ net133 VGND VGND VPWR VPWR _01584_ sky130_fd_sc_hd__mux2_1
X_14082_ _05479_ _05629_ VGND VGND VPWR VPWR _05630_ sky130_fd_sc_hd__xor2_1
X_11294_ _02477_ _02479_ _02591_ _02592_ VGND VGND VPWR VPWR _02593_ sky130_fd_sc_hd__a211o_1
X_13033_ _04486_ _04487_ _04488_ VGND VGND VPWR VPWR _04489_ sky130_fd_sc_hd__nand3_1
X_10245_ _01522_ _01523_ VGND VGND VPWR VPWR _01524_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_28_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10176_ _01465_ VGND VGND VPWR VPWR _00032_ sky130_fd_sc_hd__clkbuf_1
X_14984_ _06613_ _06614_ _06612_ VGND VGND VPWR VPWR _06616_ sky130_fd_sc_hd__o21ai_1
Xfanout190 net191 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__clkbuf_4
X_13935_ _05451_ _05469_ VGND VGND VPWR VPWR _05471_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_135_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13866_ _05379_ _05395_ VGND VGND VPWR VPWR _05396_ sky130_fd_sc_hd__xor2_1
X_15605_ _07289_ _07290_ _07274_ VGND VGND VPWR VPWR _07293_ sky130_fd_sc_hd__a21o_1
XFILLER_0_147_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12817_ _04252_ _04253_ VGND VGND VPWR VPWR _04254_ sky130_fd_sc_hd__nor2_1
X_13797_ _05142_ _05320_ VGND VGND VPWR VPWR _05321_ sky130_fd_sc_hd__xor2_4
XFILLER_0_127_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15536_ net348 net499 net661 net672 VGND VGND VPWR VPWR _07218_ sky130_fd_sc_hd__nand4_1
X_12748_ net775 net781 net882 net845 VGND VGND VPWR VPWR _04178_ sky130_fd_sc_hd__and4_1
XFILLER_0_17_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15467_ _07055_ _07142_ VGND VGND VPWR VPWR _07143_ sky130_fd_sc_hd__xor2_2
X_12679_ _04094_ _04095_ _04100_ VGND VGND VPWR VPWR _04102_ sky130_fd_sc_hd__nand3_1
XFILLER_0_71_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14418_ net523 net438 net690 net699 VGND VGND VPWR VPWR _05996_ sky130_fd_sc_hd__nand4_1
XFILLER_0_114_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15398_ _07064_ _07065_ _07066_ VGND VGND VPWR VPWR _07067_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_12_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14349_ net381 net369 net587 net597 VGND VGND VPWR VPWR _05920_ sky130_fd_sc_hd__and4_1
XFILLER_0_8_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08910_ _00227_ _00225_ _00226_ VGND VGND VPWR VPWR _00229_ sky130_fd_sc_hd__nand3_1
XFILLER_0_0_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16019_ _02388_ net680 VGND VGND VPWR VPWR _07742_ sky130_fd_sc_hd__or2_1
X_09890_ _00194_ net676 VGND VGND VPWR VPWR _01197_ sky130_fd_sc_hd__or2_1
XFILLER_0_110_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08841_ _00158_ _00159_ _00160_ VGND VGND VPWR VPWR _00161_ sky130_fd_sc_hd__or3_1
XFILLER_0_85_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08772_ _08080_ _08081_ _07748_ VGND VGND VPWR VPWR _08083_ sky130_fd_sc_hd__a21o_1
XFILLER_0_109_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09324_ _00522_ _00550_ _00638_ VGND VGND VPWR VPWR _00639_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_36_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09255_ _00484_ _00501_ _00569_ VGND VGND VPWR VPWR _00570_ sky130_fd_sc_hd__a21o_1
XFILLER_0_7_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08206_ net163 net576 net580 net307 VGND VGND VPWR VPWR _03257_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_8_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09186_ _00484_ _00501_ VGND VGND VPWR VPWR _00502_ sky130_fd_sc_hd__xor2_2
XFILLER_0_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08137_ _02485_ _02496_ VGND VGND VPWR VPWR _02506_ sky130_fd_sc_hd__nor2_1
XFILLER_0_71_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10030_ _01324_ _01253_ _01333_ VGND VGND VPWR VPWR _01335_ sky130_fd_sc_hd__o21a_1
XFILLER_0_98_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11981_ _03320_ _03339_ VGND VGND VPWR VPWR _03340_ sky130_fd_sc_hd__and2_1
X_13720_ _05236_ VGND VGND VPWR VPWR _05237_ sky130_fd_sc_hd__buf_2
XFILLER_0_98_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10932_ _02196_ _02197_ VGND VGND VPWR VPWR _02198_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13651_ _05044_ _05045_ _05161_ VGND VGND VPWR VPWR _05162_ sky130_fd_sc_hd__o21ai_1
X_10863_ _02110_ _02111_ _02125_ VGND VGND VPWR VPWR _02127_ sky130_fd_sc_hd__nand3_2
X_12602_ _04015_ _04005_ _04016_ VGND VGND VPWR VPWR _04017_ sky130_fd_sc_hd__nand3_2
X_13582_ _05084_ _05085_ _05086_ VGND VGND VPWR VPWR _05087_ sky130_fd_sc_hd__nand3_2
X_10794_ net384 net373 net864 net742 VGND VGND VPWR VPWR _02058_ sky130_fd_sc_hd__and4_1
XFILLER_0_109_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15321_ net484 net476 net528 net535 VGND VGND VPWR VPWR _06983_ sky130_fd_sc_hd__and4_1
X_12533_ _03939_ _03940_ VGND VGND VPWR VPWR _03941_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_53_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15252_ net377 net366 net663 net673 VGND VGND VPWR VPWR _06908_ sky130_fd_sc_hd__nand4_1
X_12464_ _03848_ _03849_ _03863_ VGND VGND VPWR VPWR _03865_ sky130_fd_sc_hd__nand3_1
X_14203_ _05674_ _05703_ VGND VGND VPWR VPWR _05761_ sky130_fd_sc_hd__or2_1
XFILLER_0_112_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11415_ _02722_ _02723_ VGND VGND VPWR VPWR _02725_ sky130_fd_sc_hd__xnor2_2
X_15183_ _06654_ _06657_ _06656_ VGND VGND VPWR VPWR _06833_ sky130_fd_sc_hd__o21ai_1
X_12395_ _03787_ _03788_ VGND VGND VPWR VPWR _03790_ sky130_fd_sc_hd__or2b_1
XFILLER_0_105_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14134_ net311 net247 VGND VGND VPWR VPWR _05686_ sky130_fd_sc_hd__nand2_1
XFILLER_0_104_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11346_ _02646_ _02647_ _02631_ VGND VGND VPWR VPWR _02650_ sky130_fd_sc_hd__a21oi_1
X_14065_ _05608_ _05610_ VGND VGND VPWR VPWR _05612_ sky130_fd_sc_hd__xnor2_1
X_11277_ _02571_ _02573_ _02574_ VGND VGND VPWR VPWR _02575_ sky130_fd_sc_hd__a21o_1
X_13016_ net720 net170 _04468_ _04470_ VGND VGND VPWR VPWR _04471_ sky130_fd_sc_hd__a22o_1
X_10228_ b_cos\[2\] VGND VGND VPWR VPWR _01509_ sky130_fd_sc_hd__inv_2
X_10159_ _01443_ _01445_ _01442_ VGND VGND VPWR VPWR _01451_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_146_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14967_ net376 net690 net699 net365 VGND VGND VPWR VPWR _06598_ sky130_fd_sc_hd__a22o_1
X_13918_ _05380_ _05384_ _05381_ VGND VGND VPWR VPWR _05452_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_49_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14898_ _06518_ _06520_ _06521_ VGND VGND VPWR VPWR _06523_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13849_ _05303_ _05311_ VGND VGND VPWR VPWR _05377_ sky130_fd_sc_hd__and2_1
XFILLER_0_147_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15519_ _07196_ _07197_ _07192_ VGND VGND VPWR VPWR _07199_ sky130_fd_sc_hd__a21o_1
XFILLER_0_29_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_143_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_840 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09040_ net320 net236 net620 VGND VGND VPWR VPWR _00358_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_44_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap121 _05279_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__buf_1
XFILLER_0_4_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap132 _01774_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__buf_1
X_09942_ _01246_ _01247_ VGND VGND VPWR VPWR _01248_ sky130_fd_sc_hd__or2_1
X_09873_ _01132_ _01135_ _01139_ VGND VGND VPWR VPWR _01180_ sky130_fd_sc_hd__o21ai_1
X_08824_ _08052_ _08054_ _08053_ VGND VGND VPWR VPWR _00144_ sky130_fd_sc_hd__o21bai_1
X_08755_ _08063_ _08064_ _08056_ VGND VGND VPWR VPWR _08066_ sky130_fd_sc_hd__a21o_1
XFILLER_0_68_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08686_ _04042_ _07997_ VGND VGND VPWR VPWR _07998_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_136_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09307_ _00620_ _00621_ VGND VGND VPWR VPWR _00622_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09238_ _00551_ _00553_ VGND VGND VPWR VPWR _00554_ sky130_fd_sc_hd__xor2_2
XFILLER_0_23_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09169_ _00413_ _00431_ _00429_ VGND VGND VPWR VPWR _00485_ sky130_fd_sc_hd__a21o_1
XFILLER_0_32_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11200_ _02489_ net48 _02490_ _02487_ VGND VGND VPWR VPWR _02491_ sky130_fd_sc_hd__a22o_1
XFILLER_0_114_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12180_ _03548_ _03555_ VGND VGND VPWR VPWR _03556_ sky130_fd_sc_hd__xnor2_1
X_11131_ _02331_ _02339_ _02338_ VGND VGND VPWR VPWR _02415_ sky130_fd_sc_hd__a21o_1
XFILLER_0_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11062_ _02338_ _02339_ VGND VGND VPWR VPWR _02340_ sky130_fd_sc_hd__and2b_1
X_10013_ _01316_ _01317_ VGND VGND VPWR VPWR _01318_ sky130_fd_sc_hd__or2b_1
X_15870_ _07561_ _07544_ VGND VGND VPWR VPWR _07580_ sky130_fd_sc_hd__or2b_1
XFILLER_0_99_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14821_ _06343_ _06438_ VGND VGND VPWR VPWR _06439_ sky130_fd_sc_hd__nand2_1
XFILLER_0_98_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14752_ net461 net708 _06361_ VGND VGND VPWR VPWR _06363_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_99_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11964_ _03251_ _03265_ _03267_ VGND VGND VPWR VPWR _03321_ sky130_fd_sc_hd__o21bai_2
X_13703_ net610 net272 VGND VGND VPWR VPWR _05218_ sky130_fd_sc_hd__nand2_1
X_10915_ _02106_ _02179_ _02180_ VGND VGND VPWR VPWR _02182_ sky130_fd_sc_hd__nand3_2
X_14683_ net518 net664 net674 net433 VGND VGND VPWR VPWR _06287_ sky130_fd_sc_hd__a22oi_2
X_11895_ _03235_ _03234_ VGND VGND VPWR VPWR _03247_ sky130_fd_sc_hd__and2b_1
XFILLER_0_129_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13634_ net798 net183 net173 net140 VGND VGND VPWR VPWR _05143_ sky130_fd_sc_hd__a22oi_1
X_10846_ _02055_ _02060_ VGND VGND VPWR VPWR _02110_ sky130_fd_sc_hd__or2b_1
XFILLER_0_39_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13565_ _05058_ _05067_ VGND VGND VPWR VPWR _05069_ sky130_fd_sc_hd__xnor2_2
X_10777_ _02038_ _02039_ _02040_ VGND VGND VPWR VPWR _02041_ sky130_fd_sc_hd__or3_1
X_15304_ net554 _06962_ _06963_ VGND VGND VPWR VPWR _06964_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_82_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12516_ _03724_ _03725_ _03739_ VGND VGND VPWR VPWR _03923_ sky130_fd_sc_hd__and3_1
X_16284_ clknet_4_4_0_clk _00073_ net337 VGND VGND VPWR VPWR a_cos\[15\] sky130_fd_sc_hd__dfrtp_1
X_13496_ net150 net183 net173 net229 VGND VGND VPWR VPWR _04994_ sky130_fd_sc_hd__a22o_1
XFILLER_0_14_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15235_ net348 net688 net698 net499 VGND VGND VPWR VPWR _06890_ sky130_fd_sc_hd__a22o_1
X_12447_ _03797_ _03798_ _03799_ _03804_ VGND VGND VPWR VPWR _03847_ sky130_fd_sc_hd__a22o_1
XFILLER_0_34_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15166_ _06811_ _06812_ _06795_ VGND VGND VPWR VPWR _06815_ sky130_fd_sc_hd__a21o_1
X_12378_ _03759_ _03760_ _03770_ VGND VGND VPWR VPWR _03771_ sky130_fd_sc_hd__and3_1
X_14117_ _05479_ _05667_ VGND VGND VPWR VPWR _05668_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11329_ _02554_ _02562_ _02560_ VGND VGND VPWR VPWR _02631_ sky130_fd_sc_hd__a21o_1
X_15097_ _06651_ _06635_ _06738_ _06739_ VGND VGND VPWR VPWR _06740_ sky130_fd_sc_hd__o211a_4
XFILLER_0_120_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14048_ _05527_ _05525_ _05586_ VGND VGND VPWR VPWR _05593_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_82_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15999_ _07720_ VGND VGND VPWR VPWR _00110_ sky130_fd_sc_hd__clkbuf_1
X_08540_ _06878_ _06889_ VGND VGND VPWR VPWR _06900_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08471_ _06058_ _06080_ VGND VGND VPWR VPWR _06146_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09023_ _00321_ _00340_ VGND VGND VPWR VPWR _00341_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_28_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout701 net21 VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__clkbuf_4
Xfanout712 net717 VGND VGND VPWR VPWR net712 sky130_fd_sc_hd__buf_2
X_09925_ _01178_ _01231_ VGND VGND VPWR VPWR _01232_ sky130_fd_sc_hd__xor2_1
Xfanout723 net726 VGND VGND VPWR VPWR net723 sky130_fd_sc_hd__clkbuf_2
Xfanout734 net735 VGND VGND VPWR VPWR net734 sky130_fd_sc_hd__clkbuf_4
Xfanout745 net753 VGND VGND VPWR VPWR net745 sky130_fd_sc_hd__buf_2
Xfanout756 net762 VGND VGND VPWR VPWR net756 sky130_fd_sc_hd__clkbuf_4
X_09856_ _01142_ _01143_ _01163_ VGND VGND VPWR VPWR _01164_ sky130_fd_sc_hd__a21oi_1
Xfanout767 net771 VGND VGND VPWR VPWR net767 sky130_fd_sc_hd__clkbuf_4
Xfanout778 net779 VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_0_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout789 net796 VGND VGND VPWR VPWR net789 sky130_fd_sc_hd__clkbuf_2
X_08807_ net160 net539 net544 net867 VGND VGND VPWR VPWR _00127_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_37_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09787_ _01074_ _01095_ VGND VGND VPWR VPWR _01096_ sky130_fd_sc_hd__xnor2_1
X_08738_ _08046_ _08047_ _08043_ VGND VGND VPWR VPWR _08049_ sky130_fd_sc_hd__a21o_1
XFILLER_0_68_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08669_ _07978_ _07979_ _07971_ VGND VGND VPWR VPWR _07981_ sky130_fd_sc_hd__a21o_1
X_10700_ _01961_ _01962_ _01957_ VGND VGND VPWR VPWR _01964_ sky130_fd_sc_hd__a21o_1
X_11680_ _03011_ _03012_ VGND VGND VPWR VPWR _03013_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_95_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10631_ _01887_ _01893_ _01894_ VGND VGND VPWR VPWR _01895_ sky130_fd_sc_hd__o21a_1
XFILLER_0_107_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13350_ _04823_ _04828_ _04833_ VGND VGND VPWR VPWR _04834_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_46_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10562_ _01822_ _01825_ VGND VGND VPWR VPWR _01826_ sky130_fd_sc_hd__nor2_1
X_12301_ a_cos\[18\] _03686_ _03521_ VGND VGND VPWR VPWR _03687_ sky130_fd_sc_hd__mux2_1
XFILLER_0_23_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13281_ _04757_ _04758_ VGND VGND VPWR VPWR _04759_ sky130_fd_sc_hd__xnor2_1
X_10493_ _01747_ _01746_ VGND VGND VPWR VPWR _01757_ sky130_fd_sc_hd__and2b_1
X_15020_ net468 net573 net584 net460 VGND VGND VPWR VPWR _06655_ sky130_fd_sc_hd__a22o_1
X_12232_ _03529_ _03533_ _03610_ VGND VGND VPWR VPWR _03612_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_121_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12163_ _03527_ _03536_ VGND VGND VPWR VPWR _03537_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_102_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11114_ net776 net470 VGND VGND VPWR VPWR _02396_ sky130_fd_sc_hd__nand2_1
X_12094_ _03415_ _03416_ _03461_ VGND VGND VPWR VPWR _03462_ sky130_fd_sc_hd__a21o_1
X_15922_ _07539_ _07566_ _07634_ _07635_ VGND VGND VPWR VPWR _07637_ sky130_fd_sc_hd__o211a_1
X_11045_ _02317_ _02318_ _02319_ VGND VGND VPWR VPWR _02322_ sky130_fd_sc_hd__a21o_1
X_15853_ _07544_ _07561_ VGND VGND VPWR VPWR _07562_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_36_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14804_ _06411_ _06418_ _06419_ VGND VGND VPWR VPWR _06420_ sky130_fd_sc_hd__nand3_2
X_12996_ net729 net161 net867 net737 VGND VGND VPWR VPWR _04449_ sky130_fd_sc_hd__a22o_1
X_15784_ _07484_ _07485_ _07388_ _07413_ VGND VGND VPWR VPWR _07487_ sky130_fd_sc_hd__a211o_1
XFILLER_0_99_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14735_ _06341_ _06342_ _06281_ _06252_ VGND VGND VPWR VPWR _06345_ sky130_fd_sc_hd__o211ai_2
X_11947_ _03302_ _03303_ VGND VGND VPWR VPWR _03304_ sky130_fd_sc_hd__nand2_1
XFILLER_0_143_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14666_ _06259_ _06253_ _06258_ VGND VGND VPWR VPWR _06269_ sky130_fd_sc_hd__or3_1
X_11878_ _03133_ _03157_ _03227_ _03228_ VGND VGND VPWR VPWR _03229_ sky130_fd_sc_hd__o211a_1
XFILLER_0_39_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13617_ net228 net312 net868 net304 VGND VGND VPWR VPWR _05125_ sky130_fd_sc_hd__and4_1
X_10829_ _02002_ _02004_ _01998_ VGND VGND VPWR VPWR _02093_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_55_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14597_ _06188_ _06192_ VGND VGND VPWR VPWR _06193_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13548_ net193 _04980_ _04982_ VGND VGND VPWR VPWR _05050_ sky130_fd_sc_hd__nand3_1
XFILLER_0_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16267_ clknet_4_0_0_clk _00056_ net331 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_113_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13479_ _04957_ _04973_ _04974_ VGND VGND VPWR VPWR _04975_ sky130_fd_sc_hd__nand3_1
XFILLER_0_42_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15218_ _06869_ _06870_ VGND VGND VPWR VPWR _06871_ sky130_fd_sc_hd__xor2_4
XFILLER_0_140_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16198_ _07756_ _07851_ _07747_ VGND VGND VPWR VPWR _07936_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_10_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15149_ net404 net394 net644 VGND VGND VPWR VPWR _06796_ sky130_fd_sc_hd__and3_1
XFILLER_0_11_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09710_ net263 net255 net676 net686 VGND VGND VPWR VPWR _01020_ sky130_fd_sc_hd__and4_1
XFILLER_0_93_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09641_ _00876_ _00879_ _00877_ VGND VGND VPWR VPWR _00952_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_93_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09572_ _00787_ _00792_ VGND VGND VPWR VPWR _00884_ sky130_fd_sc_hd__and2b_1
XFILLER_0_78_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08523_ net215 net206 net591 net601 VGND VGND VPWR VPWR _06715_ sky130_fd_sc_hd__and4_1
XFILLER_0_148_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08454_ net196 net591 _05774_ _05763_ VGND VGND VPWR VPWR _05959_ sky130_fd_sc_hd__a31o_1
XFILLER_0_93_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08385_ _04829_ _04741_ _04818_ VGND VGND VPWR VPWR _05209_ sky130_fd_sc_hd__nand3_1
XFILLER_0_9_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09006_ net292 net870 net552 net282 VGND VGND VPWR VPWR _00324_ sky130_fd_sc_hd__a22o_1
XFILLER_0_115_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout520 net521 VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__clkbuf_2
Xfanout531 net534 VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__clkbuf_2
Xfanout542 net543 VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__buf_2
X_09908_ _01074_ _01214_ VGND VGND VPWR VPWR _01215_ sky130_fd_sc_hd__nand2_1
Xfanout553 net561 VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__buf_2
Xfanout564 net566 VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__clkbuf_4
Xfanout575 net576 VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__buf_4
Xfanout586 net587 VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__buf_2
X_09839_ net286 net277 net637 net627 VGND VGND VPWR VPWR _01147_ sky130_fd_sc_hd__and4_1
Xfanout597 net598 VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__buf_2
X_12850_ _04287_ _04288_ _04286_ VGND VGND VPWR VPWR _04290_ sky130_fd_sc_hd__o21ai_1
X_11801_ _03003_ _03006_ _03004_ VGND VGND VPWR VPWR _03145_ sky130_fd_sc_hd__o21ba_1
X_12781_ _04181_ _04171_ _04182_ VGND VGND VPWR VPWR _04214_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_69_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14520_ _06104_ _06106_ _06072_ _06107_ VGND VGND VPWR VPWR _06108_ sky130_fd_sc_hd__a211oi_1
X_11732_ _03066_ _03067_ _03068_ VGND VGND VPWR VPWR _03070_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_139_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_54_Left_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14451_ _06030_ _06031_ net495 net707 VGND VGND VPWR VPWR _06032_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_83_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11663_ a_cos\[8\] _02994_ _02383_ VGND VGND VPWR VPWR _02995_ sky130_fd_sc_hd__mux2_1
XFILLER_0_37_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13402_ _04881_ _04890_ VGND VGND VPWR VPWR _04891_ sky130_fd_sc_hd__xnor2_2
X_10614_ _01857_ VGND VGND VPWR VPWR _01878_ sky130_fd_sc_hd__inv_2
XFILLER_0_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14382_ _05949_ _05954_ _05955_ VGND VGND VPWR VPWR _05956_ sky130_fd_sc_hd__nand3_2
X_11594_ _02812_ _02813_ _02814_ VGND VGND VPWR VPWR _02919_ sky130_fd_sc_hd__a21o_1
XFILLER_0_36_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16121_ _07756_ _07851_ VGND VGND VPWR VPWR _07852_ sky130_fd_sc_hd__xor2_2
XFILLER_0_107_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13333_ _04814_ _04815_ VGND VGND VPWR VPWR _04816_ sky130_fd_sc_hd__xnor2_2
X_10545_ _01770_ _01773_ _01772_ VGND VGND VPWR VPWR _01809_ sky130_fd_sc_hd__o21a_1
XFILLER_0_134_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16052_ _07657_ _07655_ _07717_ VGND VGND VPWR VPWR _07778_ sky130_fd_sc_hd__o21a_1
X_13264_ _04637_ _04656_ _04739_ VGND VGND VPWR VPWR _04740_ sky130_fd_sc_hd__a21o_1
XFILLER_0_122_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10476_ _01726_ _01727_ _01738_ VGND VGND VPWR VPWR _01740_ sky130_fd_sc_hd__nor3b_2
X_15003_ _06531_ _06554_ _06635_ _06636_ VGND VGND VPWR VPWR _06637_ sky130_fd_sc_hd__a211o_2
XFILLER_0_122_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12215_ _03487_ _03588_ _03592_ VGND VGND VPWR VPWR _03594_ sky130_fd_sc_hd__o21a_1
XFILLER_0_110_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13195_ _04663_ _04664_ VGND VGND VPWR VPWR _04666_ sky130_fd_sc_hd__xor2_1
XFILLER_0_121_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_63_Left_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12146_ _03515_ _03519_ VGND VGND VPWR VPWR _03520_ sky130_fd_sc_hd__xor2_1
X_12077_ _03443_ _03419_ _03421_ VGND VGND VPWR VPWR _03445_ sky130_fd_sc_hd__or3_1
X_15905_ net346 net498 net622 VGND VGND VPWR VPWR _07619_ sky130_fd_sc_hd__and3_1
X_11028_ _02222_ _02225_ _02301_ VGND VGND VPWR VPWR _02303_ sky130_fd_sc_hd__a21oi_1
X_15836_ _07543_ _07445_ VGND VGND VPWR VPWR _07544_ sky130_fd_sc_hd__nand2_1
XFILLER_0_63_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12979_ _04428_ _04429_ VGND VGND VPWR VPWR _04430_ sky130_fd_sc_hd__xnor2_1
X_15767_ _07467_ _07468_ VGND VGND VPWR VPWR _07469_ sky130_fd_sc_hd__nor2_1
XFILLER_0_86_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_72_Left_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14718_ _06324_ _06325_ VGND VGND VPWR VPWR _06326_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15698_ net459 net697 net527 net450 VGND VGND VPWR VPWR _07394_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_75_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14649_ _06231_ _06232_ _06248_ _06249_ VGND VGND VPWR VPWR _06250_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_145_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_16 net306 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_120_Right_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_27 net870 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08170_ _02822_ _02855_ VGND VGND VPWR VPWR _02866_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_6_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_38 net744 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_49 net263 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16319_ clknet_4_6_0_clk _00108_ net335 VGND VGND VPWR VPWR b_cos\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_3_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput101 net101 VGND VGND VPWR VPWR Q[12] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_112_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput112 net112 VGND VGND VPWR VPWR Q[5] sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_81_Left_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09624_ _00761_ _00928_ _00934_ VGND VGND VPWR VPWR _00935_ sky130_fd_sc_hd__nor3_1
X_09555_ _00844_ _00866_ VGND VGND VPWR VPWR _00867_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_90_Left_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08506_ _05948_ _06432_ _06443_ VGND VGND VPWR VPWR _06530_ sky130_fd_sc_hd__and3_1
X_09486_ _00193_ net554 VGND VGND VPWR VPWR _00799_ sky130_fd_sc_hd__or2_1
XFILLER_0_77_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08437_ net217 net575 net583 net208 VGND VGND VPWR VPWR _05774_ sky130_fd_sc_hd__a22o_1
XFILLER_0_65_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08368_ _05014_ VGND VGND VPWR VPWR _05024_ sky130_fd_sc_hd__inv_2
XFILLER_0_18_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08299_ _04262_ VGND VGND VPWR VPWR _04273_ sky130_fd_sc_hd__inv_2
XFILLER_0_144_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10330_ a_sin\[17\] b_cos\[17\] VGND VGND VPWR VPWR _01597_ sky130_fd_sc_hd__or2b_1
XFILLER_0_33_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10261_ _01537_ VGND VGND VPWR VPWR _00045_ sky130_fd_sc_hd__clkbuf_1
X_12000_ _03357_ _03360_ VGND VGND VPWR VPWR _03361_ sky130_fd_sc_hd__xnor2_1
X_10192_ a_cos\[16\] b_sin\[16\] VGND VGND VPWR VPWR _01479_ sky130_fd_sc_hd__nor2_1
XFILLER_0_100_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout350 net352 VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__clkbuf_4
Xfanout361 net364 VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_108_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout372 net374 VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__clkbuf_4
X_13951_ net139 _05387_ VGND VGND VPWR VPWR _05488_ sky130_fd_sc_hd__and2_1
Xfanout383 net385 VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__clkbuf_4
Xfanout394 net403 VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__clkbuf_4
X_12902_ net764 net773 net294 net284 VGND VGND VPWR VPWR _04346_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_129_Left_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13882_ net508 net261 net254 net609 VGND VGND VPWR VPWR _05413_ sky130_fd_sc_hd__a22oi_2
X_12833_ net720 net187 net178 net729 VGND VGND VPWR VPWR _04271_ sky130_fd_sc_hd__a22o_1
X_15621_ _07163_ _07165_ VGND VGND VPWR VPWR _07310_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12764_ _04188_ _04190_ _04191_ _04166_ VGND VGND VPWR VPWR _04195_ sky130_fd_sc_hd__o22a_1
X_15552_ _07104_ _07132_ _07130_ VGND VGND VPWR VPWR _07235_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_57_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14503_ _06061_ VGND VGND VPWR VPWR _06089_ sky130_fd_sc_hd__inv_2
X_11715_ net358 net153 _03049_ _03050_ VGND VGND VPWR VPWR _03052_ sky130_fd_sc_hd__a22o_1
X_15483_ _07076_ _07077_ _07158_ VGND VGND VPWR VPWR _07159_ sky130_fd_sc_hd__a21o_1
X_12695_ _04116_ _04117_ _04118_ VGND VGND VPWR VPWR _04120_ sky130_fd_sc_hd__and3_1
XFILLER_0_126_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14434_ net391 net569 _05952_ _05951_ VGND VGND VPWR VPWR _06013_ sky130_fd_sc_hd__a31o_1
X_11646_ _02956_ _02974_ _02976_ VGND VGND VPWR VPWR _02977_ sky130_fd_sc_hd__nand3_1
XFILLER_0_25_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput14 alpha[4] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
X_14365_ _05930_ _05935_ _05931_ VGND VGND VPWR VPWR _05938_ sky130_fd_sc_hd__or3_2
Xinput25 beta[14] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_142_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput36 beta[7] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
X_11577_ _02900_ _02896_ _02892_ VGND VGND VPWR VPWR _02901_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_25_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput47 cos[17] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_1
X_13316_ net150 net142 net839 net201 VGND VGND VPWR VPWR _04798_ sky130_fd_sc_hd__nand4_1
XFILLER_0_80_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16104_ _07833_ _07745_ VGND VGND VPWR VPWR _07834_ sky130_fd_sc_hd__or2_1
Xinput58 rstb VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_2
Xinput69 sin[1] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__buf_6
X_10528_ _01790_ _01791_ VGND VGND VPWR VPWR _01792_ sky130_fd_sc_hd__xnor2_1
X_14296_ net521 net436 net541 net550 VGND VGND VPWR VPWR _05862_ sky130_fd_sc_hd__nand4_1
XFILLER_0_150_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13247_ _04657_ _04721_ _04722_ VGND VGND VPWR VPWR _04723_ sky130_fd_sc_hd__and3_1
X_16035_ _07749_ _07758_ VGND VGND VPWR VPWR _07760_ sky130_fd_sc_hd__xnor2_1
X_10459_ _01721_ _01722_ VGND VGND VPWR VPWR _01723_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13178_ _04528_ _04529_ _04531_ _04527_ VGND VGND VPWR VPWR _04647_ sky130_fd_sc_hd__o22a_1
X_12129_ _03343_ _03439_ _03500_ VGND VGND VPWR VPWR _03501_ sky130_fd_sc_hd__or3_1
X_15819_ _07510_ _07524_ VGND VGND VPWR VPWR _07525_ sky130_fd_sc_hd__xor2_1
X_09340_ _00566_ _00646_ VGND VGND VPWR VPWR _00654_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09271_ _00492_ _00494_ _00585_ VGND VGND VPWR VPWR _00586_ sky130_fd_sc_hd__a21o_1
XFILLER_0_7_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08222_ _02746_ _02768_ _02757_ VGND VGND VPWR VPWR _03431_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_117_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08153_ _02637_ _02670_ VGND VGND VPWR VPWR _02681_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_71_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08986_ _00220_ _00222_ _00221_ net553 VGND VGND VPWR VPWR _00304_ sky130_fd_sc_hd__a22o_1
XFILLER_0_3_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09607_ _00916_ _00917_ VGND VGND VPWR VPWR _00918_ sky130_fd_sc_hd__nor2_1
X_09538_ net289 net280 net667 net676 VGND VGND VPWR VPWR _00850_ sky130_fd_sc_hd__and4_1
XFILLER_0_149_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09469_ _00778_ _00779_ _00780_ _00781_ VGND VGND VPWR VPWR _00782_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_93_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11500_ _02815_ _02816_ VGND VGND VPWR VPWR _02817_ sky130_fd_sc_hd__nor2_1
X_12480_ _03880_ _03882_ VGND VGND VPWR VPWR _03883_ sky130_fd_sc_hd__and2_1
XFILLER_0_80_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11431_ _02739_ _02740_ _02741_ VGND VGND VPWR VPWR _02742_ sky130_fd_sc_hd__nand3_1
XFILLER_0_117_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14150_ _05702_ _05703_ _05637_ _05640_ VGND VGND VPWR VPWR _05704_ sky130_fd_sc_hd__o211a_1
XFILLER_0_61_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11362_ _02664_ _02665_ _02666_ VGND VGND VPWR VPWR _02667_ sky130_fd_sc_hd__a21o_1
X_13101_ _04560_ _04561_ _04552_ VGND VGND VPWR VPWR _04563_ sky130_fd_sc_hd__a21o_1
X_10313_ _01581_ _01582_ VGND VGND VPWR VPWR _01583_ sky130_fd_sc_hd__nor2_1
X_14081_ _05626_ _05628_ VGND VGND VPWR VPWR _05629_ sky130_fd_sc_hd__xor2_1
X_11293_ _02589_ _02590_ _02526_ VGND VGND VPWR VPWR _02592_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_104_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13032_ _04385_ _04387_ _04386_ VGND VGND VPWR VPWR _04488_ sky130_fd_sc_hd__o21bai_1
X_10244_ _01514_ _01517_ _01515_ VGND VGND VPWR VPWR _01523_ sky130_fd_sc_hd__a21bo_1
X_10175_ net83 _01464_ net135 VGND VGND VPWR VPWR _01465_ sky130_fd_sc_hd__mux2_1
Xfanout180 net181 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__clkbuf_4
X_14983_ _06612_ _06613_ _06614_ VGND VGND VPWR VPWR _06615_ sky130_fd_sc_hd__or3_1
Xfanout191 net192 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__buf_2
X_13934_ _05467_ _05468_ VGND VGND VPWR VPWR _05469_ sky130_fd_sc_hd__nand2_1
XFILLER_0_88_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13865_ _05385_ _05393_ VGND VGND VPWR VPWR _05395_ sky130_fd_sc_hd__xnor2_1
X_15604_ _07274_ _07289_ _07290_ VGND VGND VPWR VPWR _07291_ sky130_fd_sc_hd__nand3_2
X_12816_ net788 net275 _04250_ VGND VGND VPWR VPWR _04253_ sky130_fd_sc_hd__and3_1
XFILLER_0_29_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13796_ _05237_ _05319_ VGND VGND VPWR VPWR _05320_ sky130_fd_sc_hd__xor2_4
XFILLER_0_56_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15535_ net348 net661 net672 net499 VGND VGND VPWR VPWR _07217_ sky130_fd_sc_hd__a22o_1
X_12747_ net775 net882 net845 net781 VGND VGND VPWR VPWR _04177_ sky130_fd_sc_hd__a22o_1
XFILLER_0_72_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12678_ _04094_ _04095_ _04100_ VGND VGND VPWR VPWR _04101_ sky130_fd_sc_hd__a21o_1
XFILLER_0_60_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15466_ _07057_ _07141_ VGND VGND VPWR VPWR _07142_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_25_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14417_ net420 net533 VGND VGND VPWR VPWR _05995_ sky130_fd_sc_hd__and2_1
X_11629_ net614 net485 net474 net713 VGND VGND VPWR VPWR _02958_ sky130_fd_sc_hd__a22oi_1
X_15397_ _06982_ _06985_ _06983_ VGND VGND VPWR VPWR _07066_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_8_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14348_ net361 net607 VGND VGND VPWR VPWR _05919_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14279_ net419 net586 VGND VGND VPWR VPWR _05843_ sky130_fd_sc_hd__and2_1
XFILLER_0_122_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16018_ _07736_ _07740_ VGND VGND VPWR VPWR _07741_ sky130_fd_sc_hd__xnor2_1
X_08840_ net320 net236 net639 net629 VGND VGND VPWR VPWR _00160_ sky130_fd_sc_hd__and4_1
X_08771_ _07748_ _08080_ _08081_ VGND VGND VPWR VPWR _08082_ sky130_fd_sc_hd__nand3_2
XFILLER_0_18_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09323_ _00546_ _00549_ VGND VGND VPWR VPWR _00638_ sky130_fd_sc_hd__nor2_1
XFILLER_0_87_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09254_ _00500_ _00485_ VGND VGND VPWR VPWR _00569_ sky130_fd_sc_hd__and2b_1
XFILLER_0_90_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_882 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08205_ net163 net307 net572 net580 VGND VGND VPWR VPWR _03246_ sky130_fd_sc_hd__and4_1
XFILLER_0_105_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09185_ _00485_ _00500_ VGND VGND VPWR VPWR _00501_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_7_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08136_ net213 net531 net540 net204 VGND VGND VPWR VPWR _02496_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_44_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08969_ _00285_ _00286_ _00191_ VGND VGND VPWR VPWR _00288_ sky130_fd_sc_hd__a21boi_2
X_11980_ _03321_ _03338_ VGND VGND VPWR VPWR _03339_ sky130_fd_sc_hd__xnor2_1
X_10931_ _02169_ _02195_ VGND VGND VPWR VPWR _02197_ sky130_fd_sc_hd__or2_1
X_13650_ _05041_ _05043_ VGND VGND VPWR VPWR _05161_ sky130_fd_sc_hd__or2b_1
X_10862_ _02110_ _02111_ _02125_ VGND VGND VPWR VPWR _02126_ sky130_fd_sc_hd__a21o_2
XFILLER_0_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12601_ _04003_ _04004_ _04002_ VGND VGND VPWR VPWR _04016_ sky130_fd_sc_hd__a21o_1
XFILLER_0_66_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13581_ _04964_ _04966_ _04965_ VGND VGND VPWR VPWR _05086_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_149_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10793_ net384 net864 net742 net373 VGND VGND VPWR VPWR _02057_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_137_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12532_ net765 net197 VGND VGND VPWR VPWR _03940_ sky130_fd_sc_hd__nand2_1
X_15320_ net487 net528 net535 net476 VGND VGND VPWR VPWR _06982_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_137_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12463_ _03848_ _03849_ _03863_ VGND VGND VPWR VPWR _03864_ sky130_fd_sc_hd__a21o_1
X_15251_ net377 net663 net673 net366 VGND VGND VPWR VPWR _06907_ sky130_fd_sc_hd__a22o_1
XFILLER_0_136_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14202_ _05735_ _05759_ VGND VGND VPWR VPWR _05760_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_62_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11414_ net776 _02385_ VGND VGND VPWR VPWR _02723_ sky130_fd_sc_hd__nor2_1
X_15182_ _06826_ _06831_ VGND VGND VPWR VPWR _06832_ sky130_fd_sc_hd__xnor2_1
X_12394_ _03785_ _03780_ VGND VGND VPWR VPWR _03788_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14133_ _05682_ _05683_ _05684_ VGND VGND VPWR VPWR _05685_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_50_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11345_ _02631_ _02646_ _02647_ VGND VGND VPWR VPWR _02649_ sky130_fd_sc_hd__and3_1
XFILLER_0_50_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14064_ _05538_ _05609_ VGND VGND VPWR VPWR _05610_ sky130_fd_sc_hd__nor2_1
X_11276_ _02457_ _02458_ _02459_ VGND VGND VPWR VPWR _02574_ sky130_fd_sc_hd__o21ba_1
X_13015_ net611 net711 net187 net178 VGND VGND VPWR VPWR _04470_ sky130_fd_sc_hd__nand4_2
X_10227_ _01506_ _01507_ VGND VGND VPWR VPWR _01508_ sky130_fd_sc_hd__nand2_1
X_10158_ _01448_ _01449_ VGND VGND VPWR VPWR _01450_ sky130_fd_sc_hd__nor2_1
X_14966_ _06504_ _06506_ _06505_ VGND VGND VPWR VPWR _06597_ sky130_fd_sc_hd__o21bai_1
X_10089_ a_cos\[0\] b_sin\[0\] _01388_ _01389_ VGND VGND VPWR VPWR _01391_ sky130_fd_sc_hd__a22oi_1
X_13917_ _05450_ _05397_ VGND VGND VPWR VPWR _05451_ sky130_fd_sc_hd__or2_1
XFILLER_0_89_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14897_ _06518_ _06520_ _06521_ VGND VGND VPWR VPWR _06522_ sky130_fd_sc_hd__nand3_4
X_13848_ _05310_ _05309_ VGND VGND VPWR VPWR _05376_ sky130_fd_sc_hd__and2b_1
XFILLER_0_71_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13779_ _05299_ _05300_ VGND VGND VPWR VPWR _05301_ sky130_fd_sc_hd__nor2_1
X_15518_ _07192_ _07196_ _07197_ VGND VGND VPWR VPWR _07198_ sky130_fd_sc_hd__nand3_1
XFILLER_0_17_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
X_15449_ _07117_ _07121_ _07122_ VGND VGND VPWR VPWR _07123_ sky130_fd_sc_hd__nand3_1
XFILLER_0_115_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap122 _03157_ VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__buf_1
XFILLER_0_40_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09941_ net270 net633 _01245_ VGND VGND VPWR VPWR _01247_ sky130_fd_sc_hd__and3_1
XFILLER_0_110_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09872_ _01168_ _01169_ _01171_ VGND VGND VPWR VPWR _01179_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_29_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08823_ _08045_ _08047_ VGND VGND VPWR VPWR _00143_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08754_ _08056_ _08063_ _08064_ VGND VGND VPWR VPWR _08065_ sky130_fd_sc_hd__nand3_2
X_08685_ _07995_ _07996_ VGND VGND VPWR VPWR _07997_ sky130_fd_sc_hd__or2b_4
XFILLER_0_95_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09306_ _00541_ _00619_ _00617_ _00618_ VGND VGND VPWR VPWR _00621_ sky130_fd_sc_hd__a211o_1
XFILLER_0_76_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09237_ _00432_ _00459_ _00552_ VGND VGND VPWR VPWR _00553_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_90_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09168_ _00194_ net589 _00407_ _00483_ VGND VGND VPWR VPWR _00484_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_44_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08119_ net196 net557 VGND VGND VPWR VPWR _02310_ sky130_fd_sc_hd__nand2_1
XFILLER_0_133_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09099_ net538 _00323_ _00415_ VGND VGND VPWR VPWR _00416_ sky130_fd_sc_hd__a21bo_1
X_11130_ _02320_ _02323_ VGND VGND VPWR VPWR _02414_ sky130_fd_sc_hd__nand2_1
X_11061_ _02336_ _02337_ _02333_ VGND VGND VPWR VPWR _02339_ sky130_fd_sc_hd__a21o_1
X_10012_ _01268_ _01271_ _01315_ VGND VGND VPWR VPWR _01317_ sky130_fd_sc_hd__a21o_1
X_14820_ _06343_ _06345_ _06348_ VGND VGND VPWR VPWR _06438_ sky130_fd_sc_hd__nand3_1
X_14751_ net461 net708 _06361_ VGND VGND VPWR VPWR _06362_ sky130_fd_sc_hd__and3_1
X_11963_ _03296_ _03298_ _03303_ VGND VGND VPWR VPWR _03320_ sky130_fd_sc_hd__o21ai_1
X_13702_ _05215_ _05216_ VGND VGND VPWR VPWR _05217_ sky130_fd_sc_hd__nor2_1
X_10914_ _02177_ _02178_ _02091_ _02107_ VGND VGND VPWR VPWR _02180_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_98_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14682_ net518 net431 net663 net674 VGND VGND VPWR VPWR _06286_ sky130_fd_sc_hd__and4_1
X_11894_ _03238_ _03241_ _03244_ VGND VGND VPWR VPWR _03245_ sky130_fd_sc_hd__a21o_1
X_13633_ _05141_ VGND VGND VPWR VPWR _05142_ sky130_fd_sc_hd__clkbuf_4
X_10845_ _02077_ _02083_ VGND VGND VPWR VPWR _02109_ sky130_fd_sc_hd__and2_1
XFILLER_0_132_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10776_ net517 net317 net429 net432 VGND VGND VPWR VPWR _02040_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_26_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13564_ _05065_ _05066_ VGND VGND VPWR VPWR _05067_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15303_ net460 net554 net568 net451 VGND VGND VPWR VPWR _06963_ sky130_fd_sc_hd__a22o_1
X_12515_ _03919_ _03917_ _03920_ VGND VGND VPWR VPWR _03922_ sky130_fd_sc_hd__nand3_2
X_13495_ _04895_ _04897_ _04896_ VGND VGND VPWR VPWR _04993_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_109_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16283_ clknet_4_7_0_clk _00072_ net337 VGND VGND VPWR VPWR a_cos\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_125_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12446_ _03842_ _03843_ _03759_ _03812_ VGND VGND VPWR VPWR _03846_ sky130_fd_sc_hd__o211a_1
X_15234_ _06886_ _06887_ VGND VGND VPWR VPWR _06888_ sky130_fd_sc_hd__xor2_1
XFILLER_0_112_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12377_ _03761_ _03769_ VGND VGND VPWR VPWR _03770_ sky130_fd_sc_hd__xnor2_2
X_15165_ _06795_ _06811_ _06812_ VGND VGND VPWR VPWR _06814_ sky130_fd_sc_hd__nand3_1
XFILLER_0_22_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14116_ _05664_ _05666_ VGND VGND VPWR VPWR _05667_ sky130_fd_sc_hd__nor2_1
XFILLER_0_120_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11328_ _02543_ _02545_ VGND VGND VPWR VPWR _02630_ sky130_fd_sc_hd__nand2_1
X_15096_ _06735_ _06736_ _06670_ VGND VGND VPWR VPWR _06739_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11259_ _02450_ _02453_ _02451_ net407 VGND VGND VPWR VPWR _02555_ sky130_fd_sc_hd__a22o_1
X_14047_ _05518_ _05520_ _05591_ VGND VGND VPWR VPWR _05592_ sky130_fd_sc_hd__a21o_1
X_15998_ b_cos\[14\] _07719_ _06949_ VGND VGND VPWR VPWR _07720_ sky130_fd_sc_hd__mux2_1
X_14949_ net350 net541 net546 net502 VGND VGND VPWR VPWR _06578_ sky130_fd_sc_hd__a22o_1
XFILLER_0_82_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08470_ _06047_ net131 _06124_ _05633_ VGND VGND VPWR VPWR _06135_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_106_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09022_ _00338_ _00339_ VGND VGND VPWR VPWR _00340_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout702 net705 VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_1_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09924_ _01229_ _01230_ VGND VGND VPWR VPWR _01231_ sky130_fd_sc_hd__nor2_1
Xfanout713 net717 VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__buf_2
XFILLER_0_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout724 net726 VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__buf_4
Xfanout735 net18 VGND VGND VPWR VPWR net735 sky130_fd_sc_hd__buf_4
Xfanout746 net753 VGND VGND VPWR VPWR net746 sky130_fd_sc_hd__clkbuf_2
Xfanout757 net762 VGND VGND VPWR VPWR net757 sky130_fd_sc_hd__clkbuf_2
X_09855_ _01161_ _01162_ VGND VGND VPWR VPWR _01163_ sky130_fd_sc_hd__and2_1
Xfanout768 net771 VGND VGND VPWR VPWR net768 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout779 net13 VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_99_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08806_ _00124_ _00125_ VGND VGND VPWR VPWR _00126_ sky130_fd_sc_hd__xnor2_1
X_09786_ _01076_ _01094_ VGND VGND VPWR VPWR _01095_ sky130_fd_sc_hd__xnor2_1
X_08737_ _08043_ _08046_ _08047_ VGND VGND VPWR VPWR _08048_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_134_Right_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08668_ _07971_ _07978_ _07979_ VGND VGND VPWR VPWR _07980_ sky130_fd_sc_hd__nand3_2
XFILLER_0_96_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08599_ _07455_ _07509_ VGND VGND VPWR VPWR _07542_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10630_ _01866_ _01867_ VGND VGND VPWR VPWR _01894_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_91_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10561_ net392 net809 _01823_ _01824_ VGND VGND VPWR VPWR _01825_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_11_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_101_Left_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12300_ _03648_ _03685_ VGND VGND VPWR VPWR _03686_ sky130_fd_sc_hd__xnor2_1
X_13280_ net780 _00193_ VGND VGND VPWR VPWR _04758_ sky130_fd_sc_hd__nor2_1
X_10492_ _01655_ _01647_ _01654_ VGND VGND VPWR VPWR _01756_ sky130_fd_sc_hd__nand3_1
XFILLER_0_51_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12231_ _03529_ _03533_ _03610_ VGND VGND VPWR VPWR _03611_ sky130_fd_sc_hd__nor3_1
X_12162_ _03349_ _03535_ VGND VGND VPWR VPWR _03536_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_31_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11113_ net784 net453 VGND VGND VPWR VPWR _02395_ sky130_fd_sc_hd__nand2_1
XFILLER_0_102_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12093_ _03411_ _03414_ VGND VGND VPWR VPWR _03461_ sky130_fd_sc_hd__nor2_1
X_15921_ _07634_ _07635_ _07539_ _07566_ VGND VGND VPWR VPWR _07636_ sky130_fd_sc_hd__a211oi_1
X_11044_ _02317_ _02318_ _02319_ VGND VGND VPWR VPWR _02320_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_110_Left_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15852_ _07559_ _07560_ VGND VGND VPWR VPWR _07561_ sky130_fd_sc_hd__nand2_1
X_14803_ _06415_ _06416_ _06417_ VGND VGND VPWR VPWR _06419_ sky130_fd_sc_hd__a21o_1
X_15783_ _07388_ _07413_ _07484_ _07485_ VGND VGND VPWR VPWR _07486_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12995_ _04445_ _04446_ VGND VGND VPWR VPWR _04448_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14734_ _06281_ _06252_ _06341_ _06342_ VGND VGND VPWR VPWR _06343_ sky130_fd_sc_hd__a211o_4
XFILLER_0_98_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11946_ _03299_ _03300_ VGND VGND VPWR VPWR _03303_ sky130_fd_sc_hd__or2_1
XFILLER_0_59_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14665_ _06259_ _06258_ _06253_ VGND VGND VPWR VPWR _06268_ sky130_fd_sc_hd__o21ai_1
X_11877_ _03204_ _03205_ _03226_ VGND VGND VPWR VPWR _03228_ sky130_fd_sc_hd__nand3_1
X_13616_ net228 net868 net304 net312 VGND VGND VPWR VPWR _05124_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_67_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10828_ _02089_ _02090_ _02034_ _02006_ VGND VGND VPWR VPWR _02092_ sky130_fd_sc_hd__o211ai_2
X_14596_ _06189_ _06191_ VGND VGND VPWR VPWR _06192_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13547_ _05029_ _05048_ VGND VGND VPWR VPWR _05049_ sky130_fd_sc_hd__xor2_2
X_10759_ _01736_ _02021_ _02022_ VGND VGND VPWR VPWR _02023_ sky130_fd_sc_hd__a21boi_1
X_16266_ clknet_4_0_0_clk _00055_ net331 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_125_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13478_ _04971_ _04972_ _04963_ VGND VGND VPWR VPWR _04974_ sky130_fd_sc_hd__a21o_1
XFILLER_0_35_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15217_ net445 net585 VGND VGND VPWR VPWR _06870_ sky130_fd_sc_hd__nand2_2
X_12429_ _03823_ _03826_ VGND VGND VPWR VPWR _03827_ sky130_fd_sc_hd__xnor2_2
X_16197_ _07724_ _07852_ _07854_ VGND VGND VPWR VPWR _07935_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_124_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15148_ _06785_ _06794_ VGND VGND VPWR VPWR _06795_ sky130_fd_sc_hd__xor2_1
X_15079_ _06717_ _06718_ _06716_ VGND VGND VPWR VPWR _06720_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_120_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09640_ _00945_ _00950_ VGND VGND VPWR VPWR _00951_ sky130_fd_sc_hd__xnor2_1
X_09571_ _00881_ _00882_ VGND VGND VPWR VPWR _00883_ sky130_fd_sc_hd__xor2_1
X_08522_ _06388_ _06377_ _06300_ VGND VGND VPWR VPWR _06704_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08453_ net704 _05937_ VGND VGND VPWR VPWR _05948_ sky130_fd_sc_hd__nand2_1
XFILLER_0_148_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08384_ _04676_ _05188_ VGND VGND VPWR VPWR _05199_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_9_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09005_ net292 net282 net870 VGND VGND VPWR VPWR _00323_ sky130_fd_sc_hd__and3_1
XFILLER_0_103_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout510 net515 VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__buf_2
Xfanout521 net522 VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__clkbuf_2
X_09907_ _01204_ _01213_ VGND VGND VPWR VPWR _01214_ sky130_fd_sc_hd__xor2_1
Xfanout532 net534 VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__buf_4
Xfanout543 net37 VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__clkbuf_4
Xfanout554 net556 VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__clkbuf_4
Xfanout565 net566 VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__buf_2
Xfanout576 net579 VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__buf_6
X_09838_ net277 net637 net627 net286 VGND VGND VPWR VPWR _01146_ sky130_fd_sc_hd__a22oi_1
Xfanout587 net588 VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__clkbuf_4
Xfanout598 net31 VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__clkbuf_4
X_09769_ net277 net646 net637 net286 VGND VGND VPWR VPWR _01078_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_69_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11800_ _03137_ _03143_ VGND VGND VPWR VPWR _03144_ sky130_fd_sc_hd__xor2_1
X_12780_ _04208_ _04210_ _04211_ _04212_ VGND VGND VPWR VPWR _04213_ sky130_fd_sc_hd__and4_1
XFILLER_0_139_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11731_ _03066_ _03067_ _03068_ VGND VGND VPWR VPWR _03069_ sky130_fd_sc_hd__and3_1
XFILLER_0_96_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14450_ net354 net597 net607 net504 VGND VGND VPWR VPWR _06031_ sky130_fd_sc_hd__a22oi_1
X_11662_ _02901_ _02993_ VGND VGND VPWR VPWR _02994_ sky130_fd_sc_hd__xnor2_1
X_13401_ _04888_ _04889_ VGND VGND VPWR VPWR _04890_ sky130_fd_sc_hd__nand2_1
XFILLER_0_138_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10613_ _01871_ _01872_ _01865_ VGND VGND VPWR VPWR _01877_ sky130_fd_sc_hd__a21o_1
X_14381_ _05945_ _05947_ _05946_ VGND VGND VPWR VPWR _05955_ sky130_fd_sc_hd__a21o_1
XFILLER_0_119_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11593_ _02914_ _02915_ _02916_ VGND VGND VPWR VPWR _02918_ sky130_fd_sc_hd__nand3_1
XFILLER_0_64_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16120_ _07793_ _07850_ VGND VGND VPWR VPWR _07851_ sky130_fd_sc_hd__xor2_2
XFILLER_0_52_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13332_ _04682_ _04717_ _04716_ VGND VGND VPWR VPWR _04815_ sky130_fd_sc_hd__a21bo_1
X_10544_ _01802_ _01806_ _01807_ VGND VGND VPWR VPWR _01808_ sky130_fd_sc_hd__nand3_2
XFILLER_0_122_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16051_ _07647_ _07718_ VGND VGND VPWR VPWR _07777_ sky130_fd_sc_hd__nor2_1
X_13263_ _04655_ _04638_ VGND VGND VPWR VPWR _04739_ sky130_fd_sc_hd__and2b_1
X_10475_ _01726_ _01727_ _01738_ VGND VGND VPWR VPWR _01739_ sky130_fd_sc_hd__o21ba_1
X_15002_ _06633_ _06634_ _06569_ VGND VGND VPWR VPWR _06636_ sky130_fd_sc_hd__a21oi_1
X_12214_ _03349_ _03591_ VGND VGND VPWR VPWR _03592_ sky130_fd_sc_hd__xnor2_2
X_13194_ net754 net273 VGND VGND VPWR VPWR _04664_ sky130_fd_sc_hd__nand2_1
X_12145_ _03393_ _03516_ _03517_ VGND VGND VPWR VPWR _03519_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_20_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12076_ _03419_ _03421_ _03443_ VGND VGND VPWR VPWR _03444_ sky130_fd_sc_hd__o21ai_1
X_15904_ _07517_ _07519_ VGND VGND VPWR VPWR _07617_ sky130_fd_sc_hd__nor2_1
X_11027_ _02222_ _02225_ _02301_ VGND VGND VPWR VPWR _02302_ sky130_fd_sc_hd__and3_1
X_15835_ _07442_ _07428_ VGND VGND VPWR VPWR _07543_ sky130_fd_sc_hd__or2b_1
XFILLER_0_99_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15766_ net459 net450 net687 net697 VGND VGND VPWR VPWR _07468_ sky130_fd_sc_hd__and4_1
X_12978_ net807 net249 VGND VGND VPWR VPWR _04429_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14717_ net354 net569 net574 net504 VGND VGND VPWR VPWR _06325_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_59_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11929_ _03221_ _03222_ _03283_ VGND VGND VPWR VPWR _03284_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_74_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15697_ net467 net697 _07277_ _07276_ VGND VGND VPWR VPWR _07393_ sky130_fd_sc_hd__a31o_1
XFILLER_0_137_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14648_ _06233_ _06235_ _06247_ VGND VGND VPWR VPWR _06249_ sky130_fd_sc_hd__and3_1
XFILLER_0_145_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_17 net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_28 net561 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_83_872 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_39 net804 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_15_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14579_ _06166_ _06171_ _06172_ VGND VGND VPWR VPWR _06173_ sky130_fd_sc_hd__nand3_1
XFILLER_0_144_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16318_ clknet_4_2_0_clk _00107_ net335 VGND VGND VPWR VPWR b_cos\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16249_ clknet_4_11_0_clk _00038_ net342 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_140_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput102 net102 VGND VGND VPWR VPWR Q[13] sky130_fd_sc_hd__clkbuf_4
Xoutput113 net113 VGND VGND VPWR VPWR Q[6] sky130_fd_sc_hd__buf_2
XFILLER_0_2_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09623_ _00830_ _00933_ VGND VGND VPWR VPWR _00934_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09554_ _00864_ _00865_ VGND VGND VPWR VPWR _00866_ sky130_fd_sc_hd__nand2_1
X_08505_ _06410_ _06486_ _06497_ _06508_ VGND VGND VPWR VPWR _06519_ sky130_fd_sc_hd__o211a_1
X_09485_ _00795_ _00797_ VGND VGND VPWR VPWR _00798_ sky130_fd_sc_hd__xor2_1
XFILLER_0_144_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08436_ net217 net208 net575 net582 VGND VGND VPWR VPWR _05763_ sky130_fd_sc_hd__and4_1
XFILLER_0_18_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08367_ _04861_ _04981_ _04992_ _05003_ VGND VGND VPWR VPWR _05014_ sky130_fd_sc_hd__a211o_1
XFILLER_0_74_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08298_ _04229_ _04240_ _04251_ VGND VGND VPWR VPWR _04262_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_18_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10260_ net114 _01536_ net136 VGND VGND VPWR VPWR _01537_ sky130_fd_sc_hd__mux2_1
XFILLER_0_131_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10191_ _01473_ _01475_ _01472_ VGND VGND VPWR VPWR _01478_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_100_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout340 net341 VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__clkbuf_2
Xfanout351 net352 VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__clkbuf_4
Xfanout362 net364 VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__clkbuf_4
X_13950_ _05485_ _05486_ VGND VGND VPWR VPWR _05487_ sky130_fd_sc_hd__nor2_1
Xfanout373 net374 VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__clkbuf_4
Xfanout384 net385 VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__clkbuf_4
Xfanout395 net403 VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__clkbuf_2
X_12901_ net764 net294 net284 net773 VGND VGND VPWR VPWR _04345_ sky130_fd_sc_hd__a22oi_1
X_13881_ _05299_ _05302_ _05300_ VGND VGND VPWR VPWR _05412_ sky130_fd_sc_hd__o21ba_1
X_15620_ _07302_ _07308_ VGND VGND VPWR VPWR _07309_ sky130_fd_sc_hd__xnor2_1
X_12832_ _03823_ _03825_ _03824_ VGND VGND VPWR VPWR _04270_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_68_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15551_ _07232_ _07233_ VGND VGND VPWR VPWR _07234_ sky130_fd_sc_hd__nand2_1
X_12763_ _04166_ _04193_ VGND VGND VPWR VPWR _04194_ sky130_fd_sc_hd__xor2_1
XFILLER_0_56_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14502_ _06061_ _06087_ _06060_ VGND VGND VPWR VPWR _06088_ sky130_fd_sc_hd__or3b_1
XFILLER_0_68_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11714_ net378 net367 net144 net802 VGND VGND VPWR VPWR _03050_ sky130_fd_sc_hd__nand4_1
X_15482_ _07072_ _07075_ VGND VGND VPWR VPWR _07158_ sky130_fd_sc_hd__and2b_1
X_12694_ _04113_ _04114_ _04105_ _04112_ VGND VGND VPWR VPWR _04118_ sky130_fd_sc_hd__a211o_1
X_14433_ _06008_ _06010_ _06009_ VGND VGND VPWR VPWR _06012_ sky130_fd_sc_hd__a21o_1
XFILLER_0_126_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11645_ _02972_ _02973_ _02957_ VGND VGND VPWR VPWR _02976_ sky130_fd_sc_hd__a21o_1
XFILLER_0_140_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput15 alpha[5] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14364_ _05930_ _05931_ _05935_ VGND VGND VPWR VPWR _05936_ sky130_fd_sc_hd__o21ai_2
Xinput26 beta[15] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_1
X_11576_ _02801_ _02891_ VGND VGND VPWR VPWR _02900_ sky130_fd_sc_hd__xnor2_1
Xinput37 beta[8] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_1
Xinput48 cos[18] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_4
X_16103_ _07743_ _07727_ VGND VGND VPWR VPWR _07833_ sky130_fd_sc_hd__and2b_1
X_13315_ net142 net209 net203 net150 VGND VGND VPWR VPWR _04797_ sky130_fd_sc_hd__a22o_1
Xinput59 sin[0] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__buf_6
XFILLER_0_3_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10527_ net392 net794 VGND VGND VPWR VPWR _01791_ sky130_fd_sc_hd__nand2_1
XFILLER_0_122_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14295_ _05851_ _05858_ _05859_ VGND VGND VPWR VPWR _05861_ sky130_fd_sc_hd__and3_1
X_16034_ _07611_ _07757_ VGND VGND VPWR VPWR _07758_ sky130_fd_sc_hd__xnor2_1
X_13246_ _04718_ _04719_ _04604_ _04658_ VGND VGND VPWR VPWR _04722_ sky130_fd_sc_hd__a211o_1
X_10458_ _01681_ _01683_ _01682_ VGND VGND VPWR VPWR _01722_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_149_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13177_ _04639_ _04645_ VGND VGND VPWR VPWR _04646_ sky130_fd_sc_hd__xnor2_1
X_10389_ _01650_ _01651_ _01652_ VGND VGND VPWR VPWR _01653_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_20_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12128_ _03423_ _03499_ VGND VGND VPWR VPWR _03500_ sky130_fd_sc_hd__xnor2_1
X_12059_ _03354_ _03362_ _03424_ VGND VGND VPWR VPWR _03425_ sky130_fd_sc_hd__a21o_1
X_15818_ _07515_ _07523_ VGND VGND VPWR VPWR _07524_ sky130_fd_sc_hd__xnor2_2
X_15749_ net356 net623 _07369_ _07370_ VGND VGND VPWR VPWR _07449_ sky130_fd_sc_hd__and4_1
X_09270_ _00486_ _00491_ VGND VGND VPWR VPWR _00585_ sky130_fd_sc_hd__and2_1
XFILLER_0_63_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08221_ net879 _02866_ _02800_ VGND VGND VPWR VPWR _03420_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_90_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08152_ _02648_ _02659_ VGND VGND VPWR VPWR _02670_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08985_ _00219_ _00233_ _00234_ _00237_ VGND VGND VPWR VPWR _00303_ sky130_fd_sc_hd__a31o_1
X_09606_ net157 net303 net638 net628 VGND VGND VPWR VPWR _00917_ sky130_fd_sc_hd__and4_1
XFILLER_0_97_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09537_ net289 net667 net681 net280 VGND VGND VPWR VPWR _00849_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_149_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09468_ _00700_ _00720_ _00721_ VGND VGND VPWR VPWR _00781_ sky130_fd_sc_hd__nand3_1
XFILLER_0_54_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08419_ _04108_ _05568_ VGND VGND VPWR VPWR _05579_ sky130_fd_sc_hd__or2_1
XFILLER_0_81_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09399_ _00599_ _00601_ _00600_ VGND VGND VPWR VPWR _00713_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_19_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11430_ _02638_ _02640_ _02639_ VGND VGND VPWR VPWR _02741_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_34_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11361_ net233 net389 VGND VGND VPWR VPWR _02666_ sky130_fd_sc_hd__and2_1
XFILLER_0_22_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13100_ _04552_ _04560_ _04561_ VGND VGND VPWR VPWR _04562_ sky130_fd_sc_hd__nand3_2
X_10312_ _01571_ _01577_ _01580_ VGND VGND VPWR VPWR _01582_ sky130_fd_sc_hd__nor3_1
XFILLER_0_104_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14080_ _05627_ VGND VGND VPWR VPWR _05628_ sky130_fd_sc_hd__buf_2
X_11292_ _02526_ _02589_ _02590_ VGND VGND VPWR VPWR _02591_ sky130_fd_sc_hd__and3_1
X_13031_ _04484_ _04485_ _04483_ VGND VGND VPWR VPWR _04487_ sky130_fd_sc_hd__o21ai_1
X_10243_ _01520_ _01521_ VGND VGND VPWR VPWR _01522_ sky130_fd_sc_hd__nand2_1
XFILLER_0_119_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10174_ _01462_ _01463_ VGND VGND VPWR VPWR _01464_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14982_ net516 net431 net645 net634 VGND VGND VPWR VPWR _06614_ sky130_fd_sc_hd__and4_2
Xfanout170 net172 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__clkbuf_4
Xfanout181 net182 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__clkbuf_4
Xfanout192 net74 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__clkbuf_4
X_13933_ _05465_ _05466_ VGND VGND VPWR VPWR _05468_ sky130_fd_sc_hd__or2_1
XFILLER_0_89_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13864_ _05391_ _05392_ VGND VGND VPWR VPWR _05393_ sky130_fd_sc_hd__xor2_1
X_15603_ _07287_ _07288_ _07279_ VGND VGND VPWR VPWR _07290_ sky130_fd_sc_hd__a21o_1
X_12815_ net788 net274 _04250_ VGND VGND VPWR VPWR _04252_ sky130_fd_sc_hd__a21oi_1
X_13795_ net798 net165 VGND VGND VPWR VPWR _05319_ sky130_fd_sc_hd__nand2_2
X_15534_ _07213_ _07214_ VGND VGND VPWR VPWR _07215_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_96_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12746_ _04144_ _04175_ VGND VGND VPWR VPWR _04176_ sky130_fd_sc_hd__xnor2_1
X_15465_ _07137_ _07139_ VGND VGND VPWR VPWR _07141_ sky130_fd_sc_hd__xnor2_2
X_12677_ _04096_ _04098_ _04099_ VGND VGND VPWR VPWR _04100_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_72_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14416_ _05943_ _05944_ _05942_ VGND VGND VPWR VPWR _05994_ sky130_fd_sc_hd__o21bai_1
X_11628_ _02864_ _02872_ _02871_ VGND VGND VPWR VPWR _02957_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_37_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15396_ net443 net567 _07061_ _07062_ VGND VGND VPWR VPWR _07065_ sky130_fd_sc_hd__nand4_2
XFILLER_0_13_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14347_ _05869_ _05873_ _05870_ VGND VGND VPWR VPWR _05918_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_107_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11559_ _02778_ _02782_ VGND VGND VPWR VPWR _02882_ sky130_fd_sc_hd__nor2_1
XFILLER_0_80_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14278_ net419 net577 _05822_ _05821_ VGND VGND VPWR VPWR _05842_ sky130_fd_sc_hd__a22o_1
XFILLER_0_110_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16017_ _07738_ _07739_ VGND VGND VPWR VPWR _07740_ sky130_fd_sc_hd__nor2_1
X_13229_ net321 net237 net799 VGND VGND VPWR VPWR _04703_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_20_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08770_ _08078_ _08079_ _07991_ _07993_ VGND VGND VPWR VPWR _08081_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_79_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09322_ _00612_ _00636_ VGND VGND VPWR VPWR _00637_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_148_Left_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_850 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09253_ _00482_ _00558_ _00567_ VGND VGND VPWR VPWR _00568_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_146_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08204_ net298 net590 VGND VGND VPWR VPWR _03236_ sky130_fd_sc_hd__nand2_1
X_09184_ _00498_ _00499_ VGND VGND VPWR VPWR _00500_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_16_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08135_ net213 net204 net531 net539 VGND VGND VPWR VPWR _02485_ sky130_fd_sc_hd__and4_1
XFILLER_0_114_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08968_ _00191_ _00285_ _00286_ VGND VGND VPWR VPWR _00287_ sky130_fd_sc_hd__and3b_1
X_08899_ _00133_ _00135_ VGND VGND VPWR VPWR _00218_ sky130_fd_sc_hd__nand2_1
X_10930_ _02169_ _02195_ VGND VGND VPWR VPWR _02196_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10861_ _02117_ _02124_ VGND VGND VPWR VPWR _02125_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12600_ _04010_ _04014_ VGND VGND VPWR VPWR _04015_ sky130_fd_sc_hd__xnor2_1
X_13580_ net508 net297 _05082_ _05083_ VGND VGND VPWR VPWR _05085_ sky130_fd_sc_hd__nand4_2
XFILLER_0_27_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10792_ net362 net751 VGND VGND VPWR VPWR _02056_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12531_ _03937_ _03938_ VGND VGND VPWR VPWR _03939_ sky130_fd_sc_hd__nor2_1
XFILLER_0_109_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15250_ net388 net663 _06797_ _06796_ net653 VGND VGND VPWR VPWR _06906_ sky130_fd_sc_hd__a32o_1
X_12462_ _03857_ _03862_ VGND VGND VPWR VPWR _03863_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_35_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14201_ _05737_ _05758_ VGND VGND VPWR VPWR _05759_ sky130_fd_sc_hd__xor2_1
X_11413_ _02719_ _02721_ VGND VGND VPWR VPWR _02722_ sky130_fd_sc_hd__xor2_2
X_15181_ _06829_ _06830_ VGND VGND VPWR VPWR _06831_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_117_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12393_ net807 net293 VGND VGND VPWR VPWR _03787_ sky130_fd_sc_hd__nand2_1
X_14132_ net227 net149 net261 net252 VGND VGND VPWR VPWR _05684_ sky130_fd_sc_hd__and4_1
XFILLER_0_105_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11344_ _02644_ _02645_ _02636_ VGND VGND VPWR VPWR _02647_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14063_ _05540_ _05539_ VGND VGND VPWR VPWR _05609_ sky130_fd_sc_hd__and2b_1
X_11275_ _01891_ _02570_ net416 net146 VGND VGND VPWR VPWR _02573_ sky130_fd_sc_hd__o211ai_1
XPHY_EDGE_ROW_148_Right_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13014_ net611 net187 net178 net711 VGND VGND VPWR VPWR _04468_ sky130_fd_sc_hd__a22o_1
X_10226_ a_sin\[3\] b_cos\[3\] VGND VGND VPWR VPWR _01507_ sky130_fd_sc_hd__or2b_1
X_10157_ a_cos\[11\] b_sin\[11\] VGND VGND VPWR VPWR _01449_ sky130_fd_sc_hd__nor2_1
X_14965_ _06496_ _06499_ VGND VGND VPWR VPWR _06596_ sky130_fd_sc_hd__nand2_1
X_10088_ a_cos\[0\] b_sin\[0\] _01388_ _01389_ VGND VGND VPWR VPWR _01390_ sky130_fd_sc_hd__and4_1
X_13916_ _05379_ _05395_ VGND VGND VPWR VPWR _05450_ sky130_fd_sc_hd__nor2_1
X_14896_ _06411_ _06419_ _06418_ VGND VGND VPWR VPWR _06521_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_89_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13847_ _05363_ _05361_ VGND VGND VPWR VPWR _05375_ sky130_fd_sc_hd__and2b_1
XFILLER_0_71_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13778_ net311 net422 net287 net278 VGND VGND VPWR VPWR _05300_ sky130_fd_sc_hd__and4_1
XFILLER_0_85_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15517_ net356 net651 _07193_ _07195_ VGND VGND VPWR VPWR _07197_ sky130_fd_sc_hd__nand4_2
XFILLER_0_45_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12729_ _04134_ _04135_ _04150_ VGND VGND VPWR VPWR _04157_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_72_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15448_ net356 net663 _07119_ _07120_ VGND VGND VPWR VPWR _07122_ sky130_fd_sc_hd__nand4_2
XFILLER_0_143_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15379_ _06861_ _06938_ _07046_ VGND VGND VPWR VPWR _07047_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_142_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap123 _07535_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__buf_1
XFILLER_0_111_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09940_ net270 net633 _01245_ VGND VGND VPWR VPWR _01246_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_115_Right_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09871_ _01172_ _01173_ VGND VGND VPWR VPWR _01178_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08822_ _08051_ _08068_ _08069_ VGND VGND VPWR VPWR _00142_ sky130_fd_sc_hd__nand3_2
X_08753_ _08060_ _08061_ _08062_ VGND VGND VPWR VPWR _08064_ sky130_fd_sc_hd__a21o_1
XFILLER_0_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08684_ _07993_ _07994_ net826 _04075_ VGND VGND VPWR VPWR _07996_ sky130_fd_sc_hd__a211o_1
XFILLER_0_0_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09305_ _00617_ _00618_ _00541_ _00619_ VGND VGND VPWR VPWR _00620_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_146_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09236_ _00457_ _00458_ VGND VGND VPWR VPWR _00552_ sky130_fd_sc_hd__and2b_1
XFILLER_0_118_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09167_ _00404_ _00406_ VGND VGND VPWR VPWR _00483_ sky130_fd_sc_hd__or2b_1
XFILLER_0_50_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08118_ _02234_ _02245_ _02288_ VGND VGND VPWR VPWR _02299_ sky130_fd_sc_hd__a21o_1
XFILLER_0_31_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09098_ net292 net538 net544 net282 VGND VGND VPWR VPWR _00415_ sky130_fd_sc_hd__a22o_1
XFILLER_0_32_878 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11060_ _02333_ _02336_ _02337_ VGND VGND VPWR VPWR _02338_ sky130_fd_sc_hd__and3_1
XFILLER_0_101_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10011_ _01268_ _01271_ _01315_ VGND VGND VPWR VPWR _01316_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14750_ net468 net708 _06330_ _06331_ VGND VGND VPWR VPWR _06361_ sky130_fd_sc_hd__a31o_1
XFILLER_0_99_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11962_ _03314_ _03313_ VGND VGND VPWR VPWR _03319_ sky130_fd_sc_hd__and2b_1
X_13701_ net423 net507 net288 net279 VGND VGND VPWR VPWR _05216_ sky130_fd_sc_hd__and4_1
X_10913_ _02091_ _02107_ _02177_ _02178_ VGND VGND VPWR VPWR _02179_ sky130_fd_sc_hd__a211o_1
X_14681_ net417 net683 VGND VGND VPWR VPWR _06285_ sky130_fd_sc_hd__nand2_1
X_11893_ _03171_ _03237_ VGND VGND VPWR VPWR _03244_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13632_ _04980_ _05050_ VGND VGND VPWR VPWR _05141_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10844_ _02071_ _02076_ VGND VGND VPWR VPWR _02108_ sky130_fd_sc_hd__and2b_1
XFILLER_0_67_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13563_ _05063_ _05064_ _05060_ VGND VGND VPWR VPWR _05066_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_41_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10775_ net517 net432 net317 net429 VGND VGND VPWR VPWR _02039_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15302_ net460 net451 net568 VGND VGND VPWR VPWR _06962_ sky130_fd_sc_hd__and3_1
X_12514_ _03915_ _03916_ _03914_ VGND VGND VPWR VPWR _03920_ sky130_fd_sc_hd__a21o_1
XFILLER_0_109_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16282_ clknet_4_7_0_clk _00071_ net337 VGND VGND VPWR VPWR a_cos\[13\] sky130_fd_sc_hd__dfrtp_1
X_13494_ _04885_ _04887_ VGND VGND VPWR VPWR _04991_ sky130_fd_sc_hd__nand2_2
X_15233_ net468 net555 VGND VGND VPWR VPWR _06887_ sky130_fd_sc_hd__nand2_1
X_12445_ _03759_ _03812_ _03842_ _03843_ VGND VGND VPWR VPWR _03845_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_81_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15164_ _06808_ _06809_ _06810_ VGND VGND VPWR VPWR _06812_ sky130_fd_sc_hd__a21o_1
X_12376_ _03762_ _03768_ VGND VGND VPWR VPWR _03769_ sky130_fd_sc_hd__xnor2_2
X_14115_ _05628_ _05663_ VGND VGND VPWR VPWR _05666_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11327_ _02610_ _02628_ VGND VGND VPWR VPWR _02629_ sky130_fd_sc_hd__xor2_2
X_15095_ _06670_ _06735_ _06736_ VGND VGND VPWR VPWR _06738_ sky130_fd_sc_hd__nand3_2
XFILLER_0_10_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14046_ _05516_ _05587_ VGND VGND VPWR VPWR _05591_ sky130_fd_sc_hd__or2_1
X_11258_ _02443_ _02445_ VGND VGND VPWR VPWR _02554_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10209_ _01493_ VGND VGND VPWR VPWR _00037_ sky130_fd_sc_hd__clkbuf_1
X_11189_ _02412_ _02477_ _02478_ VGND VGND VPWR VPWR _02479_ sky130_fd_sc_hd__nand3_4
X_15997_ _07656_ _07718_ VGND VGND VPWR VPWR _07719_ sky130_fd_sc_hd__xnor2_1
X_14948_ _06575_ _06576_ VGND VGND VPWR VPWR _06577_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14879_ _06500_ _06501_ VGND VGND VPWR VPWR _06502_ sky130_fd_sc_hd__and2b_1
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09021_ _00336_ _00337_ _00322_ VGND VGND VPWR VPWR _00339_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_122_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09923_ _01227_ _01228_ _01169_ _01179_ VGND VGND VPWR VPWR _01230_ sky130_fd_sc_hd__o211a_1
Xfanout703 net704 VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__buf_2
Xfanout714 net717 VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__clkbuf_2
Xfanout725 net726 VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__buf_2
Xfanout736 net744 VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__clkbuf_4
Xfanout747 net753 VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__clkbuf_4
X_09854_ _01159_ _01160_ VGND VGND VPWR VPWR _01162_ sky130_fd_sc_hd__nand2_1
Xfanout758 net762 VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__clkbuf_4
Xfanout769 net770 VGND VGND VPWR VPWR net769 sky130_fd_sc_hd__clkbuf_4
X_08805_ net274 net580 VGND VGND VPWR VPWR _00125_ sky130_fd_sc_hd__and2_1
X_09785_ _01092_ _01093_ VGND VGND VPWR VPWR _01094_ sky130_fd_sc_hd__nor2_1
X_08736_ net169 net539 _08044_ _08045_ VGND VGND VPWR VPWR _08047_ sky130_fd_sc_hd__nand4_1
X_08667_ _07975_ _07976_ _07977_ VGND VGND VPWR VPWR _07979_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08598_ _07455_ _07509_ _07172_ _07520_ VGND VGND VPWR VPWR _07531_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_64_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10560_ net410 net399 net786 net794 VGND VGND VPWR VPWR _01824_ sky130_fd_sc_hd__and4_1
XFILLER_0_106_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09219_ _00450_ _00449_ _00447_ net620 VGND VGND VPWR VPWR _00535_ sky130_fd_sc_hd__a22o_2
X_10491_ _01745_ _01754_ VGND VGND VPWR VPWR _01755_ sky130_fd_sc_hd__nor2_1
X_12230_ _03606_ _03609_ VGND VGND VPWR VPWR _03610_ sky130_fd_sc_hd__xor2_1
XFILLER_0_133_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12161_ _03495_ _03534_ VGND VGND VPWR VPWR _03535_ sky130_fd_sc_hd__xor2_1
XFILLER_0_32_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11112_ net486 _02308_ _02312_ _02309_ VGND VGND VPWR VPWR _02394_ sky130_fd_sc_hd__a22o_1
X_12092_ _03455_ _03454_ VGND VGND VPWR VPWR _03460_ sky130_fd_sc_hd__and2b_1
X_15920_ _07633_ _07602_ _07603_ VGND VGND VPWR VPWR _07635_ sky130_fd_sc_hd__or3_1
X_11043_ _02211_ _02214_ _02213_ VGND VGND VPWR VPWR _02319_ sky130_fd_sc_hd__a21bo_1
X_15851_ _07557_ _07558_ VGND VGND VPWR VPWR _07560_ sky130_fd_sc_hd__or2_1
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
X_14802_ _06415_ _06416_ _06417_ VGND VGND VPWR VPWR _06418_ sky130_fd_sc_hd__nand3_1
X_15782_ _07460_ _07461_ _07482_ _07483_ VGND VGND VPWR VPWR _07485_ sky130_fd_sc_hd__nand4_2
X_12994_ net772 net275 VGND VGND VPWR VPWR _04446_ sky130_fd_sc_hd__and2_1
XFILLER_0_98_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14733_ _06315_ _06316_ _06339_ _06340_ VGND VGND VPWR VPWR _06342_ sky130_fd_sc_hd__a2bb2oi_1
XFILLER_0_87_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11945_ _03299_ _03300_ VGND VGND VPWR VPWR _03302_ sky130_fd_sc_hd__nand2_1
X_14664_ _06264_ _06265_ VGND VGND VPWR VPWR _06266_ sky130_fd_sc_hd__and2_1
X_11876_ _03204_ _03205_ _03226_ VGND VGND VPWR VPWR _03227_ sky130_fd_sc_hd__a21o_1
XFILLER_0_67_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13615_ _05120_ _05121_ VGND VGND VPWR VPWR _05123_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_129_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10827_ _02034_ _02006_ _02089_ _02090_ VGND VGND VPWR VPWR _02091_ sky130_fd_sc_hd__a211o_1
X_14595_ net380 net559 net569 net369 VGND VGND VPWR VPWR _06191_ sky130_fd_sc_hd__a22oi_2
X_13546_ _05030_ _05047_ VGND VGND VPWR VPWR _05048_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_82_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10758_ _01726_ _01740_ _02020_ _02019_ VGND VGND VPWR VPWR _02022_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_42_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16265_ clknet_4_0_0_clk _00054_ net331 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__dfrtp_1
X_13477_ _04963_ _04971_ _04972_ VGND VGND VPWR VPWR _04973_ sky130_fd_sc_hd__nand3_1
XFILLER_0_124_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10689_ _01947_ _01952_ VGND VGND VPWR VPWR _01953_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_2_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15216_ net568 _06866_ _06868_ VGND VGND VPWR VPWR _06869_ sky130_fd_sc_hd__a21bo_2
XFILLER_0_113_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12428_ _03824_ _03825_ VGND VGND VPWR VPWR _03826_ sky130_fd_sc_hd__nor2_1
X_16196_ _07894_ _07933_ VGND VGND VPWR VPWR _07934_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15147_ _06792_ _06793_ VGND VGND VPWR VPWR _06794_ sky130_fd_sc_hd__and2b_1
XFILLER_0_23_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12359_ _03747_ _03748_ _03742_ VGND VGND VPWR VPWR _03750_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15078_ _06716_ _06717_ _06718_ VGND VGND VPWR VPWR _06719_ sky130_fd_sc_hd__or3_1
X_14029_ _05570_ _05571_ VGND VGND VPWR VPWR _05573_ sky130_fd_sc_hd__and2_1
X_09570_ _00788_ _00791_ _00789_ VGND VGND VPWR VPWR _00882_ sky130_fd_sc_hd__o21ba_1
X_08521_ _06388_ _06300_ _06377_ VGND VGND VPWR VPWR _06693_ sky130_fd_sc_hd__nand3_1
XFILLER_0_78_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08452_ net189 net181 net602 VGND VGND VPWR VPWR _05937_ sky130_fd_sc_hd__and3_1
XFILLER_0_77_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08383_ _05144_ _05177_ VGND VGND VPWR VPWR _05188_ sky130_fd_sc_hd__or2b_1
XFILLER_0_46_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09004_ _00241_ _00248_ _00247_ VGND VGND VPWR VPWR _00322_ sky130_fd_sc_hd__a21o_1
XFILLER_0_60_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xwire2 _07694_ VGND VGND VPWR VPWR net862 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout500 net501 VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_111_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout511 net515 VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__clkbuf_4
X_09906_ _01181_ _01212_ VGND VGND VPWR VPWR _01213_ sky130_fd_sc_hd__xnor2_1
Xfanout522 net523 VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_6_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout533 net534 VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__buf_2
Xfanout544 net870 VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__buf_4
Xfanout555 net556 VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__clkbuf_2
Xfanout566 net34 VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__buf_4
X_09837_ _01083_ _01090_ _01144_ VGND VGND VPWR VPWR _01145_ sky130_fd_sc_hd__a21o_1
Xfanout577 net578 VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__buf_2
Xfanout588 net32 VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__clkbuf_4
Xfanout599 net600 VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__clkbuf_4
X_09768_ _00932_ _01007_ _00986_ VGND VGND VPWR VPWR _01077_ sky130_fd_sc_hd__a21boi_4
X_08719_ _08026_ _08027_ _08028_ VGND VGND VPWR VPWR _08030_ sky130_fd_sc_hd__nand3_1
XFILLER_0_96_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09699_ _00830_ _01008_ VGND VGND VPWR VPWR _01009_ sky130_fd_sc_hd__xnor2_2
X_11730_ _02979_ _02980_ _02982_ _02983_ _02928_ VGND VGND VPWR VPWR _03068_ sky130_fd_sc_hd__a32o_1
XFILLER_0_95_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11661_ _02902_ _02992_ VGND VGND VPWR VPWR _02993_ sky130_fd_sc_hd__xor2_2
XFILLER_0_95_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13400_ _04886_ _04887_ _04882_ VGND VGND VPWR VPWR _04889_ sky130_fd_sc_hd__a21o_1
XFILLER_0_92_840 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10612_ _01871_ _01874_ _01856_ VGND VGND VPWR VPWR _01876_ sky130_fd_sc_hd__a21o_1
X_14380_ _05952_ _05953_ VGND VGND VPWR VPWR _05954_ sky130_fd_sc_hd__xnor2_2
X_11592_ _02914_ _02915_ _02916_ VGND VGND VPWR VPWR _02917_ sky130_fd_sc_hd__a21o_1
XFILLER_0_24_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13331_ _04784_ _04813_ VGND VGND VPWR VPWR _04814_ sky130_fd_sc_hd__xnor2_2
X_10543_ _01786_ _01787_ _01801_ VGND VGND VPWR VPWR _01807_ sky130_fd_sc_hd__a21o_1
XFILLER_0_107_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16050_ _07721_ _07775_ VGND VGND VPWR VPWR _07776_ sky130_fd_sc_hd__xnor2_2
X_13262_ _04635_ _04726_ _04725_ VGND VGND VPWR VPWR _04738_ sky130_fd_sc_hd__a21bo_1
X_10474_ _01736_ _01737_ VGND VGND VPWR VPWR _01738_ sky130_fd_sc_hd__nor2_1
X_15001_ _06569_ _06633_ _06634_ VGND VGND VPWR VPWR _06635_ sky130_fd_sc_hd__and3_4
X_12213_ _03495_ _03590_ VGND VGND VPWR VPWR _03591_ sky130_fd_sc_hd__xor2_2
X_13193_ net282 _04661_ _04662_ VGND VGND VPWR VPWR _04663_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_20_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_872 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12144_ _03397_ _03386_ _03456_ VGND VGND VPWR VPWR _03517_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_138_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12075_ _03440_ _03441_ VGND VGND VPWR VPWR _03443_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15903_ _07614_ _07615_ VGND VGND VPWR VPWR _07616_ sky130_fd_sc_hd__xnor2_1
X_11026_ _02298_ _02300_ VGND VGND VPWR VPWR _02301_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15834_ _07478_ _07479_ _07540_ VGND VGND VPWR VPWR _07541_ sky130_fd_sc_hd__o21ai_2
X_12977_ _04331_ _04426_ _04427_ VGND VGND VPWR VPWR _04428_ sky130_fd_sc_hd__a21oi_1
X_15765_ net459 net687 net697 net450 VGND VGND VPWR VPWR _07467_ sky130_fd_sc_hd__a22oi_1
X_14716_ net350 net504 net567 net574 VGND VGND VPWR VPWR _06324_ sky130_fd_sc_hd__and4_1
X_11928_ _03218_ _03220_ VGND VGND VPWR VPWR _03283_ sky130_fd_sc_hd__or2b_1
XFILLER_0_129_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15696_ _07291_ _07294_ VGND VGND VPWR VPWR _07392_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14647_ _06233_ _06235_ _06247_ VGND VGND VPWR VPWR _06248_ sky130_fd_sc_hd__a21oi_2
X_11859_ _03110_ _03112_ VGND VGND VPWR VPWR _03208_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_18 net364 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_29 net566 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14578_ _06169_ _06170_ _06167_ VGND VGND VPWR VPWR _06172_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_55_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13529_ _04951_ _04952_ _05028_ VGND VGND VPWR VPWR _05029_ sky130_fd_sc_hd__o21ai_2
X_16317_ clknet_4_3_0_clk _00106_ net335 VGND VGND VPWR VPWR b_cos\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_12_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16248_ clknet_4_5_0_clk _00037_ net334 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_125_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput103 net103 VGND VGND VPWR VPWR Q[14] sky130_fd_sc_hd__clkbuf_4
Xoutput114 net114 VGND VGND VPWR VPWR Q[7] sky130_fd_sc_hd__buf_2
X_16179_ _07861_ VGND VGND VPWR VPWR _07915_ sky130_fd_sc_hd__inv_2
XFILLER_0_88_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09622_ _00929_ _00932_ VGND VGND VPWR VPWR _00933_ sky130_fd_sc_hd__xor2_1
X_09553_ _00862_ _00863_ _00845_ _00846_ VGND VGND VPWR VPWR _00865_ sky130_fd_sc_hd__a211o_1
XFILLER_0_78_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08504_ _05926_ _06014_ _06003_ VGND VGND VPWR VPWR _06508_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_144_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09484_ _00668_ _00670_ _00796_ VGND VGND VPWR VPWR _00797_ sky130_fd_sc_hd__a21o_1
XFILLER_0_53_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08435_ _05351_ _05264_ _05340_ VGND VGND VPWR VPWR _05752_ sky130_fd_sc_hd__nand3_1
XFILLER_0_59_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08366_ _04502_ _04513_ _04523_ VGND VGND VPWR VPWR _05003_ sky130_fd_sc_hd__and3_1
XFILLER_0_80_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08297_ net189 net179 net576 net582 VGND VGND VPWR VPWR _04251_ sky130_fd_sc_hd__and4_1
XFILLER_0_6_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10190_ _01477_ VGND VGND VPWR VPWR _00034_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_131_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout330 net59 VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__buf_8
Xfanout341 net345 VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__buf_4
Xfanout352 net355 VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__buf_2
XFILLER_0_17_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout363 net364 VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__buf_2
Xfanout374 net375 VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__buf_2
Xfanout385 net386 VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__clkbuf_2
Xfanout396 net403 VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__clkbuf_4
X_12900_ _04269_ _04277_ _04276_ VGND VGND VPWR VPWR _04344_ sky130_fd_sc_hd__a21o_1
X_13880_ _05313_ _05315_ VGND VGND VPWR VPWR _05411_ sky130_fd_sc_hd__nand2_1
X_12831_ net747 net170 _03838_ _03837_ VGND VGND VPWR VPWR _04269_ sky130_fd_sc_hd__a31o_1
XFILLER_0_33_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15550_ _07207_ _07208_ _07230_ _07231_ VGND VGND VPWR VPWR _07233_ sky130_fd_sc_hd__nand4_2
X_12762_ _04123_ _04133_ VGND VGND VPWR VPWR _04193_ sky130_fd_sc_hd__or2b_1
X_14501_ net418 net595 VGND VGND VPWR VPWR _06087_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11713_ net367 net144 net802 net378 VGND VGND VPWR VPWR _03049_ sky130_fd_sc_hd__a22o_1
X_15481_ _07156_ VGND VGND VPWR VPWR _07157_ sky130_fd_sc_hd__inv_2
X_12693_ _04105_ _04112_ _04113_ _04114_ VGND VGND VPWR VPWR _04117_ sky130_fd_sc_hd__o211ai_1
X_14432_ _06008_ _06009_ _06010_ VGND VGND VPWR VPWR _06011_ sky130_fd_sc_hd__nand3_2
X_11644_ _02957_ _02972_ _02973_ VGND VGND VPWR VPWR _02974_ sky130_fd_sc_hd__nand3_1
XFILLER_0_83_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14363_ _05932_ _05934_ VGND VGND VPWR VPWR _05935_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_24_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput16 alpha[6] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__buf_1
X_11575_ _02898_ VGND VGND VPWR VPWR _00065_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_80_843 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput27 beta[16] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__dlymetal6s2s_1
X_16102_ _07763_ _07766_ _07829_ _07830_ VGND VGND VPWR VPWR _07832_ sky130_fd_sc_hd__a211o_1
Xinput38 beta[9] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_1
X_13314_ _04786_ _04794_ VGND VGND VPWR VPWR _04795_ sky130_fd_sc_hd__xor2_2
Xinput49 cos[1] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__buf_2
X_10526_ _01788_ _01789_ VGND VGND VPWR VPWR _01790_ sky130_fd_sc_hd__nor2_1
X_14294_ _05833_ _05834_ _05850_ VGND VGND VPWR VPWR _05859_ sky130_fd_sc_hd__a21o_1
XFILLER_0_33_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16033_ _07755_ _07756_ VGND VGND VPWR VPWR _07757_ sky130_fd_sc_hd__xor2_1
X_13245_ _04604_ _04658_ _04718_ net822 VGND VGND VPWR VPWR _04721_ sky130_fd_sc_hd__o211ai_2
X_10457_ _01715_ _01720_ VGND VGND VPWR VPWR _01721_ sky130_fd_sc_hd__xor2_1
XFILLER_0_122_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13176_ _04642_ _04644_ VGND VGND VPWR VPWR _04645_ sky130_fd_sc_hd__xor2_1
X_10388_ net525 net440 net743 net752 VGND VGND VPWR VPWR _01652_ sky130_fd_sc_hd__and4_1
X_12127_ _03488_ _03498_ VGND VGND VPWR VPWR _03499_ sky130_fd_sc_hd__xnor2_1
X_12058_ _03356_ _03361_ VGND VGND VPWR VPWR _03424_ sky130_fd_sc_hd__and2b_1
XFILLER_0_74_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11009_ _01910_ _02103_ _02282_ VGND VGND VPWR VPWR _02283_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15817_ _07521_ _07522_ VGND VGND VPWR VPWR _07523_ sky130_fd_sc_hd__xor2_2
XFILLER_0_90_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15748_ net356 net623 _07369_ _07370_ VGND VGND VPWR VPWR _07448_ sky130_fd_sc_hd__a22oi_1
X_15679_ _07258_ _07371_ _07372_ VGND VGND VPWR VPWR _07373_ sky130_fd_sc_hd__and3_1
XFILLER_0_118_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08220_ _02899_ _02909_ _03007_ VGND VGND VPWR VPWR _03409_ sky130_fd_sc_hd__nand3_2
XFILLER_0_56_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08151_ net188 net557 net564 net179 VGND VGND VPWR VPWR _02659_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08984_ net250 net599 _00211_ _00301_ VGND VGND VPWR VPWR _00302_ sky130_fd_sc_hd__a31o_1
X_09605_ net303 net638 net628 net157 VGND VGND VPWR VPWR _00916_ sky130_fd_sc_hd__a22oi_1
X_09536_ _00764_ _00772_ VGND VGND VPWR VPWR _00848_ sky130_fd_sc_hd__nand2_1
X_09467_ _00698_ _00699_ VGND VGND VPWR VPWR _00780_ sky130_fd_sc_hd__or2b_1
X_08418_ net163 net603 net704 net309 VGND VGND VPWR VPWR _05568_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_19_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09398_ net297 net677 _00709_ _00710_ VGND VGND VPWR VPWR _00712_ sky130_fd_sc_hd__nand4_2
XFILLER_0_93_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08349_ _04752_ _04763_ _04807_ VGND VGND VPWR VPWR _04818_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_129_Right_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11360_ net406 net396 net154 net146 VGND VGND VPWR VPWR _02665_ sky130_fd_sc_hd__nand4_2
XFILLER_0_34_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10311_ _01571_ _01577_ _01580_ VGND VGND VPWR VPWR _01581_ sky130_fd_sc_hd__o21a_1
X_11291_ _02587_ _02588_ _02472_ _02527_ VGND VGND VPWR VPWR _02590_ sky130_fd_sc_hd__a211o_1
X_13030_ _04483_ _04484_ _04485_ VGND VGND VPWR VPWR _04486_ sky130_fd_sc_hd__or3_1
X_10242_ a_sin\[5\] b_cos\[5\] VGND VGND VPWR VPWR _01521_ sky130_fd_sc_hd__or2b_1
XFILLER_0_30_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10173_ _01455_ _01457_ _01454_ VGND VGND VPWR VPWR _01463_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout160 net871 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__clkbuf_4
X_14981_ net431 net644 net634 net516 VGND VGND VPWR VPWR _06613_ sky130_fd_sc_hd__a22oi_2
Xfanout171 net172 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__clkbuf_4
Xfanout182 net75 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__buf_4
X_13932_ _05465_ _05466_ VGND VGND VPWR VPWR _05467_ sky130_fd_sc_hd__nand2_1
Xfanout193 net195 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_89_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13863_ net226 net295 _05306_ _05305_ VGND VGND VPWR VPWR _05392_ sky130_fd_sc_hd__a31o_1
X_12814_ _04248_ _04249_ VGND VGND VPWR VPWR _04250_ sky130_fd_sc_hd__nor2_1
X_15602_ _07279_ _07287_ _07288_ VGND VGND VPWR VPWR _07289_ sky130_fd_sc_hd__nand3_1
X_13794_ net140 net165 _05237_ _05235_ VGND VGND VPWR VPWR _05317_ sky130_fd_sc_hd__a31o_1
XFILLER_0_57_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12745_ _04146_ _04145_ VGND VGND VPWR VPWR _04175_ sky130_fd_sc_hd__nor2_1
X_15533_ net464 net527 VGND VGND VPWR VPWR _07214_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15464_ _06979_ _07039_ _07138_ VGND VGND VPWR VPWR _07139_ sky130_fd_sc_hd__a21oi_2
X_12676_ net757 net766 net325 net843 VGND VGND VPWR VPWR _04099_ sky130_fd_sc_hd__and4_1
X_14415_ _05960_ _05971_ _05961_ VGND VGND VPWR VPWR _05993_ sky130_fd_sc_hd__nand3_2
XFILLER_0_127_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11627_ _02843_ _02846_ VGND VGND VPWR VPWR _02956_ sky130_fd_sc_hd__nand2_1
X_15395_ net443 net567 _07061_ _07062_ VGND VGND VPWR VPWR _07064_ sky130_fd_sc_hd__a22o_1
XFILLER_0_25_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14346_ _05912_ _05914_ _05913_ VGND VGND VPWR VPWR _05917_ sky130_fd_sc_hd__a21o_1
XFILLER_0_135_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11558_ _02852_ _02880_ VGND VGND VPWR VPWR _02881_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_69_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10509_ _01756_ _01769_ _01768_ VGND VGND VPWR VPWR _01773_ sky130_fd_sc_hd__a21oi_1
X_14277_ _05822_ _05820_ _05821_ VGND VGND VPWR VPWR _05841_ sky130_fd_sc_hd__nand3_1
X_11489_ _02707_ _02726_ _02804_ VGND VGND VPWR VPWR _02805_ sky130_fd_sc_hd__a21o_1
X_16016_ _07669_ _07668_ VGND VGND VPWR VPWR _07739_ sky130_fd_sc_hd__and2b_1
X_13228_ net142 VGND VGND VPWR VPWR _04702_ sky130_fd_sc_hd__inv_2
XFILLER_0_0_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13159_ _04515_ _04626_ VGND VGND VPWR VPWR _04627_ sky130_fd_sc_hd__or2_1
XFILLER_0_85_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_69_Left_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09321_ _00633_ _00635_ VGND VGND VPWR VPWR _00636_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09252_ _00557_ _00555_ VGND VGND VPWR VPWR _00567_ sky130_fd_sc_hd__and2b_1
XFILLER_0_146_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08203_ _02615_ _02692_ VGND VGND VPWR VPWR _03225_ sky130_fd_sc_hd__or2b_1
XFILLER_0_7_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09183_ _00408_ net580 VGND VGND VPWR VPWR _00499_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08134_ net196 net547 VGND VGND VPWR VPWR _02474_ sky130_fd_sc_hd__nand2_1
XFILLER_0_16_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08967_ _00283_ _00284_ _00196_ VGND VGND VPWR VPWR _00286_ sky130_fd_sc_hd__a21o_1
X_08898_ _00141_ _00173_ _00174_ VGND VGND VPWR VPWR _00217_ sky130_fd_sc_hd__nor3_1
XFILLER_0_98_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10860_ _02122_ _02123_ VGND VGND VPWR VPWR _02124_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09519_ _00830_ _00773_ VGND VGND VPWR VPWR _00831_ sky130_fd_sc_hd__nor2_1
X_10791_ _01965_ _01967_ _01966_ VGND VGND VPWR VPWR _02055_ sky130_fd_sc_hd__o21ba_1
X_12530_ net748 net756 net216 net207 VGND VGND VPWR VPWR _03938_ sky130_fd_sc_hd__and4_1
XFILLER_0_109_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12461_ _03858_ _03861_ VGND VGND VPWR VPWR _03862_ sky130_fd_sc_hd__xnor2_1
X_14200_ _05739_ _05757_ VGND VGND VPWR VPWR _05758_ sky130_fd_sc_hd__xor2_1
X_11412_ _02619_ _02620_ _02720_ VGND VGND VPWR VPWR _02721_ sky130_fd_sc_hd__o21a_1
XFILLER_0_50_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15180_ net443 net593 VGND VGND VPWR VPWR _06830_ sky130_fd_sc_hd__nand2_1
X_12392_ _03780_ _03785_ VGND VGND VPWR VPWR _03786_ sky130_fd_sc_hd__or2b_1
XFILLER_0_105_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14131_ net149 net261 VGND VGND VPWR VPWR _05683_ sky130_fd_sc_hd__nand2_1
X_11343_ _02636_ _02644_ _02645_ VGND VGND VPWR VPWR _02646_ sky130_fd_sc_hd__nand3_1
XFILLER_0_132_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14062_ _05606_ _05607_ VGND VGND VPWR VPWR _05608_ sky130_fd_sc_hd__xor2_2
X_11274_ net416 net146 _01890_ _02570_ VGND VGND VPWR VPWR _02571_ sky130_fd_sc_hd__a211o_1
XFILLER_0_120_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13013_ _04379_ _04381_ _04380_ VGND VGND VPWR VPWR _04467_ sky130_fd_sc_hd__o21bai_1
X_10225_ b_cos\[3\] a_sin\[3\] VGND VGND VPWR VPWR _01506_ sky130_fd_sc_hd__or2b_1
X_10156_ a_cos\[11\] b_sin\[11\] VGND VGND VPWR VPWR _01448_ sky130_fd_sc_hd__and2_1
XFILLER_0_146_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14964_ _06503_ _06522_ _06523_ VGND VGND VPWR VPWR _06594_ sky130_fd_sc_hd__nand3_2
X_10087_ a_cos\[1\] b_sin\[1\] VGND VGND VPWR VPWR _01389_ sky130_fd_sc_hd__or2_1
X_13915_ _05425_ _05426_ _05447_ VGND VGND VPWR VPWR _05449_ sky130_fd_sc_hd__o21ai_1
X_14895_ _06516_ _06517_ _06509_ VGND VGND VPWR VPWR _06520_ sky130_fd_sc_hd__a21o_1
X_13846_ _05371_ _05368_ _05373_ VGND VGND VPWR VPWR _05374_ sky130_fd_sc_hd__a21o_1
XFILLER_0_97_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13777_ net311 net287 net278 net422 VGND VGND VPWR VPWR _05299_ sky130_fd_sc_hd__a22oi_2
X_10989_ _02258_ _02259_ _02239_ VGND VGND VPWR VPWR _02261_ sky130_fd_sc_hd__a21oi_2
X_15516_ net356 net650 _07193_ _07195_ VGND VGND VPWR VPWR _07196_ sky130_fd_sc_hd__a22o_1
X_12728_ _04154_ _04155_ VGND VGND VPWR VPWR _04156_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_127_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12659_ _04030_ _04078_ _04069_ _04077_ VGND VGND VPWR VPWR _04080_ sky130_fd_sc_hd__a211o_1
X_15447_ net356 net663 _07119_ _07120_ VGND VGND VPWR VPWR _07121_ sky130_fd_sc_hd__a22o_1
XFILLER_0_127_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15378_ _06937_ _06936_ VGND VGND VPWR VPWR _07046_ sky130_fd_sc_hd__and2b_1
XFILLER_0_40_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14329_ net523 net438 net532 net542 VGND VGND VPWR VPWR _05898_ sky130_fd_sc_hd__and4_1
XFILLER_0_40_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap124 _03276_ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__buf_1
XFILLER_0_96_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09870_ _01177_ VGND VGND VPWR VPWR _00014_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_110_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08821_ _00139_ _00140_ VGND VGND VPWR VPWR _00141_ sky130_fd_sc_hd__or2_1
X_08752_ _08060_ _08061_ _08062_ VGND VGND VPWR VPWR _08063_ sky130_fd_sc_hd__nand3_1
X_08683_ net826 _04075_ _07993_ _07994_ VGND VGND VPWR VPWR _07995_ sky130_fd_sc_hd__o211a_1
XFILLER_0_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09304_ _00534_ VGND VGND VPWR VPWR _00619_ sky130_fd_sc_hd__inv_2
XFILLER_0_48_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09235_ _00522_ _00550_ VGND VGND VPWR VPWR _00551_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_8_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09166_ _00394_ _00411_ _00481_ VGND VGND VPWR VPWR _00482_ sky130_fd_sc_hd__a21o_1
XFILLER_0_32_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08117_ _02256_ _02267_ _02278_ VGND VGND VPWR VPWR _02288_ sky130_fd_sc_hd__o21bai_1
X_09097_ _00343_ _00350_ _00349_ VGND VGND VPWR VPWR _00414_ sky130_fd_sc_hd__a21o_1
XFILLER_0_102_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10010_ _01313_ _01314_ VGND VGND VPWR VPWR _01315_ sky130_fd_sc_hd__xnor2_1
X_09999_ _01181_ _01249_ VGND VGND VPWR VPWR _01304_ sky130_fd_sc_hd__and2_1
XFILLER_0_99_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11961_ _00652_ _03317_ _03318_ VGND VGND VPWR VPWR _00070_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_25_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13700_ net423 net288 net279 net507 VGND VGND VPWR VPWR _05215_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_86_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10912_ _02166_ _02167_ _02176_ VGND VGND VPWR VPWR _02178_ sky130_fd_sc_hd__o21ba_1
X_14680_ _06199_ _06202_ _06200_ VGND VGND VPWR VPWR _06284_ sky130_fd_sc_hd__o21bai_1
X_11892_ next_state _03242_ _03243_ VGND VGND VPWR VPWR _00069_ sky130_fd_sc_hd__a21oi_1
X_13631_ _05062_ _05064_ VGND VGND VPWR VPWR _05140_ sky130_fd_sc_hd__and2_1
X_10843_ _02091_ _02092_ _02095_ VGND VGND VPWR VPWR _02107_ sky130_fd_sc_hd__nand3_1
XFILLER_0_128_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13562_ _05060_ _05063_ _05064_ VGND VGND VPWR VPWR _05065_ sky130_fd_sc_hd__and3_1
XFILLER_0_39_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10774_ net50 net514 VGND VGND VPWR VPWR _02038_ sky130_fd_sc_hd__nand2_1
X_12513_ _03918_ _03894_ VGND VGND VPWR VPWR _03919_ sky130_fd_sc_hd__xnor2_1
X_15301_ net468 net555 _06885_ _06763_ net537 VGND VGND VPWR VPWR _06961_ sky130_fd_sc_hd__a32o_1
XFILLER_0_54_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16281_ clknet_4_6_0_clk _00070_ net338 VGND VGND VPWR VPWR a_cos\[12\] sky130_fd_sc_hd__dfrtp_1
X_13493_ _04988_ _04989_ VGND VGND VPWR VPWR _04990_ sky130_fd_sc_hd__nand2_2
XFILLER_0_82_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12444_ _03830_ _03831_ _03841_ VGND VGND VPWR VPWR _03843_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_81_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15232_ net537 _06763_ _06885_ VGND VGND VPWR VPWR _06886_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_35_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15163_ _06808_ _06809_ _06810_ VGND VGND VPWR VPWR _06811_ sky130_fd_sc_hd__nand3_1
XFILLER_0_105_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12375_ _03763_ _03766_ VGND VGND VPWR VPWR _03768_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_133_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14114_ _05628_ _05663_ VGND VGND VPWR VPWR _05664_ sky130_fd_sc_hd__nor2_1
X_11326_ _02611_ _02627_ VGND VGND VPWR VPWR _02628_ sky130_fd_sc_hd__xnor2_2
X_15094_ _06733_ _06734_ _06629_ _06672_ VGND VGND VPWR VPWR _06736_ sky130_fd_sc_hd__a211o_1
X_14045_ _05589_ VGND VGND VPWR VPWR _00091_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_120_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11257_ _02465_ _02466_ _02467_ VGND VGND VPWR VPWR _02553_ sky130_fd_sc_hd__and3_1
X_10208_ net88 _01492_ net134 VGND VGND VPWR VPWR _01493_ sky130_fd_sc_hd__mux2_1
X_11188_ _02475_ _02476_ net835 _02413_ VGND VGND VPWR VPWR _02478_ sky130_fd_sc_hd__a211o_4
X_10139_ _01432_ _01433_ VGND VGND VPWR VPWR _01434_ sky130_fd_sc_hd__xnor2_1
X_15996_ _07657_ _07717_ VGND VGND VPWR VPWR _07718_ sky130_fd_sc_hd__xnor2_1
X_14947_ net470 net584 VGND VGND VPWR VPWR _06576_ sky130_fd_sc_hd__and2_1
XFILLER_0_89_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14878_ _06498_ _06499_ _06494_ VGND VGND VPWR VPWR _06501_ sky130_fd_sc_hd__a21o_1
XFILLER_0_106_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13829_ _05252_ _05279_ _05354_ _05355_ VGND VGND VPWR VPWR _05356_ sky130_fd_sc_hd__o211a_1
XFILLER_0_119_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_143_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09020_ _00322_ _00336_ _00337_ VGND VGND VPWR VPWR _00338_ sky130_fd_sc_hd__and3_1
XFILLER_0_73_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09922_ _01169_ _01179_ _01227_ _01228_ VGND VGND VPWR VPWR _01229_ sky130_fd_sc_hd__a211oi_2
Xfanout704 net705 VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__buf_2
XFILLER_0_0_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout715 net717 VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__buf_4
Xfanout726 net19 VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__clkbuf_8
Xfanout737 net744 VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__clkbuf_2
X_09853_ _01159_ _01160_ VGND VGND VPWR VPWR _01161_ sky130_fd_sc_hd__or2_1
Xfanout748 net753 VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__buf_2
Xfanout759 net762 VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__dlymetal6s2s_1
X_08804_ net563 _00122_ _00123_ VGND VGND VPWR VPWR _00124_ sky130_fd_sc_hd__a21bo_1
X_09784_ _01077_ _01091_ VGND VGND VPWR VPWR _01093_ sky130_fd_sc_hd__and2_1
XFILLER_0_56_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08735_ net169 net539 _08044_ _08045_ VGND VGND VPWR VPWR _08046_ sky130_fd_sc_hd__a22o_1
X_08666_ _07975_ _07976_ _07977_ VGND VGND VPWR VPWR _07978_ sky130_fd_sc_hd__nand3_1
X_08597_ _07129_ _07140_ _07161_ VGND VGND VPWR VPWR _07520_ sky130_fd_sc_hd__a21o_1
XFILLER_0_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09218_ net219 net620 net819 VGND VGND VPWR VPWR _00534_ sky130_fd_sc_hd__and3_2
X_10490_ _01748_ _01750_ _01753_ VGND VGND VPWR VPWR _01754_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_32_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09149_ _00392_ _00465_ VGND VGND VPWR VPWR _00466_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_15_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12160_ _03532_ _03533_ VGND VGND VPWR VPWR _03534_ sky130_fd_sc_hd__or2_1
X_11111_ _02307_ _02323_ _02324_ _02327_ VGND VGND VPWR VPWR _02393_ sky130_fd_sc_hd__a31o_1
X_12091_ _03459_ VGND VGND VPWR VPWR _00072_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11042_ _02314_ _02315_ _02316_ VGND VGND VPWR VPWR _02318_ sky130_fd_sc_hd__nand3_1
XFILLER_0_36_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15850_ _07557_ _07558_ VGND VGND VPWR VPWR _07559_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14801_ _06285_ _06287_ _06286_ VGND VGND VPWR VPWR _06417_ sky130_fd_sc_hd__o21bai_1
X_15781_ _07460_ _07461_ _07482_ _07483_ VGND VGND VPWR VPWR _07484_ sky130_fd_sc_hd__a22o_1
X_12993_ net294 _04443_ _04444_ VGND VGND VPWR VPWR _04445_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_24_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14732_ _06315_ _06316_ _06339_ _06340_ VGND VGND VPWR VPWR _06341_ sky130_fd_sc_hd__and4bb_2
X_11944_ net722 _02387_ VGND VGND VPWR VPWR _03300_ sky130_fd_sc_hd__or2_1
XFILLER_0_143_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14663_ _06262_ _06263_ _06161_ _06164_ VGND VGND VPWR VPWR _06265_ sky130_fd_sc_hd__a211o_1
X_11875_ _03207_ _03224_ VGND VGND VPWR VPWR _03226_ sky130_fd_sc_hd__xor2_1
X_13614_ net709 net272 VGND VGND VPWR VPWR _05121_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10826_ _02065_ _02066_ _02087_ _02088_ VGND VGND VPWR VPWR _02090_ sky130_fd_sc_hd__a2bb2oi_1
X_14594_ net382 net369 net559 net569 VGND VGND VPWR VPWR _06189_ sky130_fd_sc_hd__and4_1
XFILLER_0_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13545_ _05044_ _05045_ VGND VGND VPWR VPWR _05047_ sky130_fd_sc_hd__xnor2_2
X_10757_ _02019_ _02020_ _01740_ _01726_ VGND VGND VPWR VPWR _02021_ sky130_fd_sc_hd__a211o_1
XFILLER_0_109_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13476_ _04967_ _04968_ _04969_ VGND VGND VPWR VPWR _04972_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16264_ clknet_4_0_0_clk _00053_ net331 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_42_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10688_ _01948_ _01951_ VGND VGND VPWR VPWR _01952_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_113_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_33_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12427_ net612 net214 net205 net711 VGND VGND VPWR VPWR _03825_ sky130_fd_sc_hd__a22oi_2
X_15215_ net461 net568 net573 net451 VGND VGND VPWR VPWR _06868_ sky130_fd_sc_hd__a22o_1
X_16195_ _07876_ _07880_ _07883_ VGND VGND VPWR VPWR _07933_ sky130_fd_sc_hd__o21a_1
XFILLER_0_112_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12358_ _03742_ _03747_ _03748_ VGND VGND VPWR VPWR _03749_ sky130_fd_sc_hd__nand3_1
X_15146_ _06789_ _06790_ _06786_ VGND VGND VPWR VPWR _06793_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11309_ _02518_ _02521_ VGND VGND VPWR VPWR _02609_ sky130_fd_sc_hd__nor2_1
X_15077_ net516 net48 net625 VGND VGND VPWR VPWR _06718_ sky130_fd_sc_hd__and3_1
X_12289_ _03624_ _03602_ VGND VGND VPWR VPWR _03674_ sky130_fd_sc_hd__or2b_1
X_14028_ _05570_ _05571_ VGND VGND VPWR VPWR _05572_ sky130_fd_sc_hd__nor2_1
XFILLER_0_93_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_42_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15979_ _07682_ _07698_ VGND VGND VPWR VPWR _07699_ sky130_fd_sc_hd__and2_1
X_08520_ _06486_ _06671_ VGND VGND VPWR VPWR _06682_ sky130_fd_sc_hd__nor2_1
XFILLER_0_117_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08451_ _05752_ _05904_ _05915_ VGND VGND VPWR VPWR _05926_ sky130_fd_sc_hd__and3_4
XFILLER_0_147_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08382_ _05155_ _05144_ _05166_ VGND VGND VPWR VPWR _05177_ sky130_fd_sc_hd__or3_4
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09003_ _00231_ _00233_ VGND VGND VPWR VPWR _00321_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout501 net40 VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__buf_2
X_09905_ _01209_ _01211_ VGND VGND VPWR VPWR _01212_ sky130_fd_sc_hd__xor2_1
Xfanout512 net515 VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__clkbuf_2
Xfanout523 net39 VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__buf_2
Xfanout534 net38 VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__clkbuf_4
Xfanout545 net546 VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_67_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout556 net561 VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__clkbuf_4
X_09836_ _01084_ _01089_ VGND VGND VPWR VPWR _01144_ sky130_fd_sc_hd__and2b_1
Xfanout567 net568 VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__clkbuf_4
Xfanout578 net579 VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__clkbuf_4
Xfanout589 net598 VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__clkbuf_4
X_09767_ _00992_ _00999_ _01075_ VGND VGND VPWR VPWR _01076_ sky130_fd_sc_hd__a21o_1
X_08718_ _08026_ _08027_ _08028_ VGND VGND VPWR VPWR _08029_ sky130_fd_sc_hd__a21o_1
X_09698_ _00932_ _01007_ VGND VGND VPWR VPWR _01008_ sky130_fd_sc_hd__xor2_4
XFILLER_0_69_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08649_ net169 net547 _07959_ _07960_ VGND VGND VPWR VPWR _07961_ sky130_fd_sc_hd__a22o_1
X_11660_ _02989_ _02991_ VGND VGND VPWR VPWR _02992_ sky130_fd_sc_hd__xor2_2
XFILLER_0_37_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10611_ _01856_ _01871_ _01874_ VGND VGND VPWR VPWR _01875_ sky130_fd_sc_hd__nand3_1
XFILLER_0_126_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11591_ _02810_ _02813_ VGND VGND VPWR VPWR _02916_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13330_ _04811_ _04812_ VGND VGND VPWR VPWR _04813_ sky130_fd_sc_hd__xnor2_2
X_10542_ _01803_ _01805_ VGND VGND VPWR VPWR _01806_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13261_ _04737_ VGND VGND VPWR VPWR _00081_ sky130_fd_sc_hd__clkbuf_1
X_10473_ _01728_ _01729_ _01735_ VGND VGND VPWR VPWR _01737_ sky130_fd_sc_hd__and3_1
X_15000_ _06631_ _06632_ _06526_ _06528_ VGND VGND VPWR VPWR _06634_ sky130_fd_sc_hd__a211o_1
X_12212_ _03531_ _03589_ VGND VGND VPWR VPWR _03590_ sky130_fd_sc_hd__xor2_2
X_13192_ net737 net291 net282 net745 VGND VGND VPWR VPWR _04662_ sky130_fd_sc_hd__a22o_1
XFILLER_0_60_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12143_ _03389_ _03457_ VGND VGND VPWR VPWR _03516_ sky130_fd_sc_hd__or2_1
XFILLER_0_102_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12074_ _03423_ _03368_ _03343_ VGND VGND VPWR VPWR _03441_ sky130_fd_sc_hd__o21bai_2
X_15902_ net465 net660 VGND VGND VPWR VPWR _07615_ sky130_fd_sc_hd__nand2_1
X_11025_ _02190_ _02191_ _02193_ VGND VGND VPWR VPWR _02300_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_2_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15833_ _07474_ _07476_ VGND VGND VPWR VPWR _07540_ sky130_fd_sc_hd__or2b_1
X_15764_ _07348_ _07351_ _07349_ VGND VGND VPWR VPWR _07465_ sky130_fd_sc_hd__o21ba_1
X_12976_ net780 net788 net269 net259 VGND VGND VPWR VPWR _04427_ sky130_fd_sc_hd__and4_1
XFILLER_0_86_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14715_ net495 net584 VGND VGND VPWR VPWR _06323_ sky130_fd_sc_hd__nand2_1
X_11927_ _03280_ _03281_ VGND VGND VPWR VPWR _03282_ sky130_fd_sc_hd__or2_1
X_15695_ _07313_ _07315_ _07389_ VGND VGND VPWR VPWR _07391_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_129_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14646_ _06242_ _06246_ VGND VGND VPWR VPWR _06247_ sky130_fd_sc_hd__xnor2_1
X_11858_ _03147_ _03150_ _03206_ VGND VGND VPWR VPWR _03207_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_129_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_19 net375 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_10809_ net761 net353 net505 net767 VGND VGND VPWR VPWR _02073_ sky130_fd_sc_hd__and4_1
XFILLER_0_6_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14577_ _06167_ _06169_ _06170_ VGND VGND VPWR VPWR _06171_ sky130_fd_sc_hd__or3_1
X_11789_ _03129_ _03130_ _03131_ _03063_ VGND VGND VPWR VPWR _03132_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_138_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16316_ clknet_4_3_0_clk _00105_ net336 VGND VGND VPWR VPWR b_cos\[9\] sky130_fd_sc_hd__dfrtp_1
X_13528_ _04947_ _04950_ VGND VGND VPWR VPWR _05028_ sky130_fd_sc_hd__or2b_1
XFILLER_0_125_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16247_ clknet_4_5_0_clk _00036_ net334 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13459_ _04951_ _04952_ VGND VGND VPWR VPWR _04953_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_88_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput104 net104 VGND VGND VPWR VPWR Q[15] sky130_fd_sc_hd__clkbuf_4
Xoutput115 net115 VGND VGND VPWR VPWR Q[8] sky130_fd_sc_hd__clkbuf_4
X_16178_ _07606_ _07913_ VGND VGND VPWR VPWR _07914_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15129_ _06683_ _06680_ _06681_ VGND VGND VPWR VPWR _06774_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_121_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_50_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09621_ _00766_ _00931_ VGND VGND VPWR VPWR _00932_ sky130_fd_sc_hd__xor2_4
XFILLER_0_128_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09552_ _00845_ _00846_ _00862_ _00863_ VGND VGND VPWR VPWR _00864_ sky130_fd_sc_hd__o211ai_2
X_08503_ _05926_ _06003_ _06014_ VGND VGND VPWR VPWR _06497_ sky130_fd_sc_hd__or3_4
X_09483_ _00662_ _00667_ VGND VGND VPWR VPWR _00796_ sky130_fd_sc_hd__and2_1
XFILLER_0_66_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08434_ _05709_ _05730_ VGND VGND VPWR VPWR _05741_ sky130_fd_sc_hd__nand2_1
XFILLER_0_93_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08365_ _04502_ _04523_ _04513_ VGND VGND VPWR VPWR _04992_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_18_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08296_ net189 net576 net582 net179 VGND VGND VPWR VPWR _04240_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_34_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_42_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout320 net323 VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__clkbuf_4
Xfanout331 net333 VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__clkbuf_4
Xfanout342 net344 VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__clkbuf_4
Xfanout353 net355 VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__clkbuf_4
Xfanout364 net56 VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__clkbuf_8
Xfanout375 net55 VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__clkbuf_4
Xfanout386 net54 VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__clkbuf_4
Xfanout397 net403 VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__dlymetal6s2s_1
X_09819_ _01125_ _01126_ VGND VGND VPWR VPWR _01127_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12830_ _03830_ _03831_ _03841_ VGND VGND VPWR VPWR _04268_ sky130_fd_sc_hd__nand3_2
X_12761_ _04166_ _04188_ _04190_ _04191_ VGND VGND VPWR VPWR _04192_ sky130_fd_sc_hd__or4_4
XFILLER_0_96_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14500_ _06064_ _06063_ _06056_ VGND VGND VPWR VPWR _06086_ sky130_fd_sc_hd__a21o_1
X_11712_ net389 _02856_ _02938_ VGND VGND VPWR VPWR _03048_ sky130_fd_sc_hd__a21o_2
X_12692_ _04109_ _04106_ VGND VGND VPWR VPWR _04116_ sky130_fd_sc_hd__and2b_1
X_15480_ _07059_ _07079_ _07155_ VGND VGND VPWR VPWR _07156_ sky130_fd_sc_hd__a21o_1
XFILLER_0_37_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14431_ _06000_ _06001_ _06007_ VGND VGND VPWR VPWR _06010_ sky130_fd_sc_hd__a21o_1
X_11643_ _02970_ _02971_ _02962_ VGND VGND VPWR VPWR _02973_ sky130_fd_sc_hd__a21o_1
XFILLER_0_37_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14362_ _05880_ _05886_ _05933_ VGND VGND VPWR VPWR _05934_ sky130_fd_sc_hd__a21oi_2
X_11574_ a_cos\[7\] _02897_ _02383_ VGND VGND VPWR VPWR _02898_ sky130_fd_sc_hd__mux2_1
XFILLER_0_92_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput17 alpha[7] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_1
XFILLER_0_18_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16101_ _07829_ _07830_ _07763_ _07766_ VGND VGND VPWR VPWR _07831_ sky130_fd_sc_hd__o211ai_2
Xinput28 beta[17] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_1
Xinput39 cos[0] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__buf_2
X_13313_ _04792_ _04793_ VGND VGND VPWR VPWR _04794_ sky130_fd_sc_hd__nor2_1
XFILLER_0_107_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10525_ net410 net399 net778 net786 VGND VGND VPWR VPWR _01789_ sky130_fd_sc_hd__and4_1
X_14293_ _05853_ _05857_ VGND VGND VPWR VPWR _05858_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_80_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13244_ _04716_ _04717_ _04682_ VGND VGND VPWR VPWR _04719_ sky130_fd_sc_hd__a21o_1
X_16032_ _07620_ _07691_ _07747_ VGND VGND VPWR VPWR _07756_ sky130_fd_sc_hd__a21o_2
X_10456_ _01718_ _01719_ VGND VGND VPWR VPWR _01720_ sky130_fd_sc_hd__and2b_1
X_13175_ net780 net249 VGND VGND VPWR VPWR _04644_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10387_ net525 net743 net752 net440 VGND VGND VPWR VPWR _01651_ sky130_fd_sc_hd__a22oi_2
X_12126_ _03349_ _03497_ VGND VGND VPWR VPWR _03498_ sky130_fd_sc_hd__xnor2_1
X_12057_ _03422_ VGND VGND VPWR VPWR _03423_ sky130_fd_sc_hd__buf_2
XFILLER_0_74_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11008_ _02104_ _02280_ VGND VGND VPWR VPWR _02282_ sky130_fd_sc_hd__nand2_1
X_15816_ net491 net651 _07437_ _07436_ VGND VGND VPWR VPWR _07522_ sky130_fd_sc_hd__a31o_1
XFILLER_0_99_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15747_ _07369_ _07372_ VGND VGND VPWR VPWR _07447_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12959_ _04406_ _04407_ _04341_ VGND VGND VPWR VPWR _04409_ sky130_fd_sc_hd__a21o_1
X_15678_ net356 net632 _07369_ _07370_ VGND VGND VPWR VPWR _07372_ sky130_fd_sc_hd__nand4_1
X_14629_ _06215_ _06216_ _06226_ VGND VGND VPWR VPWR _06228_ sky130_fd_sc_hd__a21oi_2
X_08150_ net188 net179 net557 net564 VGND VGND VPWR VPWR _02648_ sky130_fd_sc_hd__and4_1
XFILLER_0_7_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08983_ _00209_ _00210_ VGND VGND VPWR VPWR _00301_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09604_ _00913_ _00914_ VGND VGND VPWR VPWR _00915_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_64_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09535_ _00766_ _00771_ VGND VGND VPWR VPWR _00847_ sky130_fd_sc_hd__or2_1
X_09466_ _00777_ _00758_ _00759_ VGND VGND VPWR VPWR _00779_ sky130_fd_sc_hd__and3_1
XFILLER_0_149_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08417_ _05470_ _05427_ VGND VGND VPWR VPWR _05557_ sky130_fd_sc_hd__or2b_1
XFILLER_0_93_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09397_ net297 net677 _00709_ _00710_ VGND VGND VPWR VPWR _00711_ sky130_fd_sc_hd__a22o_1
XFILLER_0_65_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08348_ _04774_ _04785_ _04796_ VGND VGND VPWR VPWR _04807_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_61_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08279_ _03312_ _03355_ _03377_ VGND VGND VPWR VPWR _04053_ sky130_fd_sc_hd__or3_1
XFILLER_0_117_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10310_ _01578_ _01579_ VGND VGND VPWR VPWR _01580_ sky130_fd_sc_hd__nor2_1
XFILLER_0_132_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11290_ _02472_ _02527_ _02587_ _02588_ VGND VGND VPWR VPWR _02589_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_30_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10241_ b_cos\[5\] a_sin\[5\] VGND VGND VPWR VPWR _01520_ sky130_fd_sc_hd__or2b_1
X_10172_ _01460_ _01461_ VGND VGND VPWR VPWR _01462_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14980_ net415 net654 VGND VGND VPWR VPWR _06612_ sky130_fd_sc_hd__nand2_1
Xfanout150 net151 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__clkbuf_4
Xfanout161 net871 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__clkbuf_4
Xfanout172 net76 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__clkbuf_4
X_13931_ net709 _00194_ VGND VGND VPWR VPWR _05466_ sky130_fd_sc_hd__or2_1
Xfanout183 net186 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__clkbuf_4
Xfanout194 net195 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13862_ _05389_ _05390_ VGND VGND VPWR VPWR _05391_ sky130_fd_sc_hd__nor2_1
X_15601_ _07284_ _07285_ _07286_ VGND VGND VPWR VPWR _07288_ sky130_fd_sc_hd__a21o_1
X_12813_ net773 net780 net294 net284 VGND VGND VPWR VPWR _04249_ sky130_fd_sc_hd__and4_1
X_13793_ _05313_ _05314_ _05294_ _05295_ VGND VGND VPWR VPWR _05316_ sky130_fd_sc_hd__a211o_1
XFILLER_0_29_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15532_ _07211_ _07212_ VGND VGND VPWR VPWR _07213_ sky130_fd_sc_hd__nor2_1
X_12744_ _04140_ _04172_ VGND VGND VPWR VPWR _04173_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_29_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15463_ _07036_ _07038_ VGND VGND VPWR VPWR _07138_ sky130_fd_sc_hd__nor2_1
XFILLER_0_127_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12675_ net757 net325 net843 net766 VGND VGND VPWR VPWR _04098_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_38_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14414_ _05989_ _05990_ VGND VGND VPWR VPWR _05991_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11626_ _02949_ _02950_ _02952_ VGND VGND VPWR VPWR _02955_ sky130_fd_sc_hd__nand3_2
X_15394_ net460 net451 net545 net555 VGND VGND VPWR VPWR _07062_ sky130_fd_sc_hd__nand4_2
XPHY_EDGE_ROW_7_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14345_ _05912_ _05913_ _05914_ VGND VGND VPWR VPWR _05916_ sky130_fd_sc_hd__nand3_2
XFILLER_0_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11557_ _02878_ _02879_ VGND VGND VPWR VPWR _02880_ sky130_fd_sc_hd__nand2_1
X_10508_ _01771_ _01752_ VGND VGND VPWR VPWR _01772_ sky130_fd_sc_hd__xor2_1
XFILLER_0_12_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14276_ _05837_ _05839_ VGND VGND VPWR VPWR _05840_ sky130_fd_sc_hd__xnor2_1
X_11488_ _02725_ _02708_ VGND VGND VPWR VPWR _02804_ sky130_fd_sc_hd__and2b_1
XFILLER_0_122_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16015_ _07662_ _07667_ VGND VGND VPWR VPWR _07738_ sky130_fd_sc_hd__and2b_1
XFILLER_0_150_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13227_ _04588_ _04590_ _04591_ VGND VGND VPWR VPWR _04701_ sky130_fd_sc_hd__o21bai_1
X_10439_ _01697_ _01701_ _01702_ VGND VGND VPWR VPWR _01703_ sky130_fd_sc_hd__nand3_1
XFILLER_0_21_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13158_ _04324_ _04417_ _04414_ VGND VGND VPWR VPWR _04626_ sky130_fd_sc_hd__a21oi_1
X_12109_ _03477_ _03478_ VGND VGND VPWR VPWR _03479_ sky130_fd_sc_hd__nor2_1
X_13089_ net737 net300 net291 net746 VGND VGND VPWR VPWR _04550_ sky130_fd_sc_hd__a22o_1
XFILLER_0_18_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09320_ _00543_ _00634_ VGND VGND VPWR VPWR _00635_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09251_ _00559_ _00561_ VGND VGND VPWR VPWR _00566_ sky130_fd_sc_hd__nor2_1
XFILLER_0_75_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08202_ _02626_ _02681_ VGND VGND VPWR VPWR _03214_ sky130_fd_sc_hd__or2b_1
XFILLER_0_141_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09182_ _00495_ _00497_ VGND VGND VPWR VPWR _00498_ sky130_fd_sc_hd__xor2_2
XFILLER_0_90_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08133_ _02430_ _02441_ _02386_ VGND VGND VPWR VPWR _02463_ sky130_fd_sc_hd__a21o_1
XFILLER_0_7_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08966_ _00196_ _00283_ _00284_ VGND VGND VPWR VPWR _00285_ sky130_fd_sc_hd__nand3_1
X_08897_ _00214_ _00215_ VGND VGND VPWR VPWR _00216_ sky130_fd_sc_hd__xor2_1
X_09518_ _00829_ VGND VGND VPWR VPWR _00830_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_149_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10790_ _01976_ _01978_ _01977_ VGND VGND VPWR VPWR _02054_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_137_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09449_ _00534_ _00681_ VGND VGND VPWR VPWR _00762_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12460_ _03859_ _03860_ VGND VGND VPWR VPWR _03861_ sky130_fd_sc_hd__nor2_1
XFILLER_0_35_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11411_ _02612_ _02618_ VGND VGND VPWR VPWR _02720_ sky130_fd_sc_hd__nand2_1
XFILLER_0_124_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12391_ _03781_ _03784_ VGND VGND VPWR VPWR _03785_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_62_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14130_ net227 net252 VGND VGND VPWR VPWR _05682_ sky130_fd_sc_hd__nand2_1
X_11342_ _02641_ _02642_ _02643_ VGND VGND VPWR VPWR _02645_ sky130_fd_sc_hd__a21o_1
XFILLER_0_50_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14061_ _05531_ _05534_ _05532_ VGND VGND VPWR VPWR _05607_ sky130_fd_sc_hd__o21ba_1
X_11273_ net517 net432 net803 VGND VGND VPWR VPWR _02570_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_120_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13012_ _04372_ _04374_ VGND VGND VPWR VPWR _04466_ sky130_fd_sc_hd__nand2_1
X_10224_ _01505_ VGND VGND VPWR VPWR _00040_ sky130_fd_sc_hd__clkbuf_1
X_10155_ _01447_ VGND VGND VPWR VPWR _00029_ sky130_fd_sc_hd__clkbuf_1
X_14963_ _06591_ _06592_ VGND VGND VPWR VPWR _06593_ sky130_fd_sc_hd__or2_1
X_10086_ a_cos\[1\] b_sin\[1\] VGND VGND VPWR VPWR _01388_ sky130_fd_sc_hd__nand2_1
X_13914_ _05421_ _05424_ VGND VGND VPWR VPWR _05447_ sky130_fd_sc_hd__or2_1
X_14894_ _06509_ _06516_ _06517_ VGND VGND VPWR VPWR _06518_ sky130_fd_sc_hd__nand3_2
XFILLER_0_89_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13845_ _05293_ _05364_ VGND VGND VPWR VPWR _05373_ sky130_fd_sc_hd__and2_1
XFILLER_0_69_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13776_ _05234_ _05240_ VGND VGND VPWR VPWR _05298_ sky130_fd_sc_hd__or2b_1
X_10988_ _02239_ _02258_ _02259_ VGND VGND VPWR VPWR _02260_ sky130_fd_sc_hd__and3_1
XFILLER_0_29_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15515_ net376 net365 net642 net634 VGND VGND VPWR VPWR _07195_ sky130_fd_sc_hd__nand4_2
X_12727_ _04137_ _04139_ _04136_ VGND VGND VPWR VPWR _04155_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_72_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15446_ net376 net365 net653 net644 VGND VGND VPWR VPWR _07120_ sky130_fd_sc_hd__nand4_2
XFILLER_0_5_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12658_ _04069_ net127 _04030_ _04078_ VGND VGND VPWR VPWR _04079_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_72_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11609_ _02932_ _02933_ _02934_ VGND VGND VPWR VPWR _02936_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_143_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15377_ _06957_ _07044_ VGND VGND VPWR VPWR _07045_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_4_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12589_ _03941_ _03950_ _03949_ VGND VGND VPWR VPWR _04003_ sky130_fd_sc_hd__nand3_2
XFILLER_0_111_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14328_ _05879_ _05888_ _05889_ VGND VGND VPWR VPWR _05897_ sky130_fd_sc_hd__nor3_1
Xmax_cap125 _06672_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__buf_1
X_14259_ net520 net560 net570 net435 VGND VGND VPWR VPWR _05821_ sky130_fd_sc_hd__a22o_1
XFILLER_0_111_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08820_ _00137_ _00138_ _00120_ VGND VGND VPWR VPWR _00140_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_29_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08751_ _07972_ _07974_ _07973_ VGND VGND VPWR VPWR _08062_ sky130_fd_sc_hd__o21bai_1
X_08682_ _07991_ _07992_ _07770_ VGND VGND VPWR VPWR _07994_ sky130_fd_sc_hd__a21o_1
XFILLER_0_48_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09303_ _00535_ _00615_ _00616_ VGND VGND VPWR VPWR _00618_ sky130_fd_sc_hd__and3_1
XFILLER_0_118_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_868 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09234_ _00546_ _00549_ VGND VGND VPWR VPWR _00550_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_146_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09165_ _00395_ _00410_ VGND VGND VPWR VPWR _00481_ sky130_fd_sc_hd__and2b_1
XFILLER_0_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08116_ net324 net240 net694 net531 VGND VGND VPWR VPWR _02278_ sky130_fd_sc_hd__and4_1
XFILLER_0_44_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09096_ _00334_ _00336_ VGND VGND VPWR VPWR _00413_ sky130_fd_sc_hd__nand2_1
XFILLER_0_141_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09998_ _00195_ net675 _01275_ VGND VGND VPWR VPWR _01303_ sky130_fd_sc_hd__or3_1
X_08949_ _00264_ _00265_ _00266_ VGND VGND VPWR VPWR _00268_ sky130_fd_sc_hd__a21o_1
X_11960_ net852 _00652_ VGND VGND VPWR VPWR _03318_ sky130_fd_sc_hd__nor2_1
X_10911_ _02166_ _02167_ _02176_ VGND VGND VPWR VPWR _02177_ sky130_fd_sc_hd__nor3b_2
X_11891_ net851 _00652_ VGND VGND VPWR VPWR _03243_ sky130_fd_sc_hd__nor2_1
X_13630_ _05138_ VGND VGND VPWR VPWR _05139_ sky130_fd_sc_hd__clkbuf_2
XPHY_EDGE_ROW_88_Left_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10842_ _02093_ VGND VGND VPWR VPWR _02106_ sky130_fd_sc_hd__inv_2
XFILLER_0_27_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13561_ net228 net165 _05061_ _05062_ VGND VGND VPWR VPWR _05064_ sky130_fd_sc_hd__nand4_1
XFILLER_0_67_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10773_ _01958_ _01960_ _01959_ VGND VGND VPWR VPWR _02037_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_26_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15300_ _06883_ _06903_ _06901_ VGND VGND VPWR VPWR _06960_ sky130_fd_sc_hd__a21o_1
XFILLER_0_94_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12512_ _03895_ _03890_ VGND VGND VPWR VPWR _03918_ sky130_fd_sc_hd__nor2_1
XFILLER_0_66_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16280_ clknet_4_7_0_clk _00069_ net338 VGND VGND VPWR VPWR a_cos\[11\] sky130_fd_sc_hd__dfrtp_1
X_13492_ _04985_ _04986_ _04987_ VGND VGND VPWR VPWR _04989_ sky130_fd_sc_hd__nand3_1
X_15231_ net487 net537 net546 net476 VGND VGND VPWR VPWR _06885_ sky130_fd_sc_hd__a22o_1
XFILLER_0_137_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12443_ _03830_ _03831_ _03841_ VGND VGND VPWR VPWR _03842_ sky130_fd_sc_hd__and3_1
XFILLER_0_125_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15162_ _06713_ _06722_ _06721_ VGND VGND VPWR VPWR _06810_ sky130_fd_sc_hd__a21bo_1
X_12374_ _03764_ _03765_ VGND VGND VPWR VPWR _03766_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14113_ _05661_ _05662_ VGND VGND VPWR VPWR _05663_ sky130_fd_sc_hd__xor2_1
X_11325_ _02624_ _02625_ VGND VGND VPWR VPWR _02627_ sky130_fd_sc_hd__xnor2_2
X_15093_ _06629_ net125 _06733_ _06734_ VGND VGND VPWR VPWR _06735_ sky130_fd_sc_hd__o211ai_4
XPHY_EDGE_ROW_97_Left_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14044_ a_sin\[14\] _05588_ _05291_ VGND VGND VPWR VPWR _05589_ sky130_fd_sc_hd__mux2_4
X_11256_ _02549_ _02551_ VGND VGND VPWR VPWR _02552_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10207_ _01490_ _01491_ VGND VGND VPWR VPWR _01492_ sky130_fd_sc_hd__xnor2_1
X_11187_ net835 net128 _02475_ _02476_ VGND VGND VPWR VPWR _02477_ sky130_fd_sc_hd__o211ai_4
X_10138_ _01424_ _01427_ _01425_ VGND VGND VPWR VPWR _01433_ sky130_fd_sc_hd__a21boi_1
X_15995_ _07714_ _07715_ VGND VGND VPWR VPWR _07717_ sky130_fd_sc_hd__xnor2_1
X_10069_ _01306_ _01308_ _01372_ VGND VGND VPWR VPWR _01373_ sky130_fd_sc_hd__o21ai_1
X_14946_ net568 _06572_ _06574_ VGND VGND VPWR VPWR _06575_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_82_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14877_ _06494_ _06498_ _06499_ VGND VGND VPWR VPWR _06500_ sky130_fd_sc_hd__and3_1
X_13828_ _05331_ _05332_ _05353_ VGND VGND VPWR VPWR _05355_ sky130_fd_sc_hd__nand3_2
XFILLER_0_106_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13759_ _05160_ _05183_ _05278_ net121 VGND VGND VPWR VPWR _05280_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_128_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15429_ _07098_ _07099_ _07082_ VGND VGND VPWR VPWR _07101_ sky130_fd_sc_hd__a21o_1
XFILLER_0_142_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09921_ _01226_ _01142_ _01224_ _01225_ VGND VGND VPWR VPWR _01228_ sky130_fd_sc_hd__a211oi_2
Xfanout705 net20 VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_1_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout716 net717 VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__buf_2
Xfanout727 net728 VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__clkbuf_4
X_09852_ _01074_ _01095_ _01072_ VGND VGND VPWR VPWR _01160_ sky130_fd_sc_hd__o21ai_1
Xfanout738 net739 VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__clkbuf_4
Xfanout749 net753 VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_147_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08803_ net292 net563 net571 net282 VGND VGND VPWR VPWR _00123_ sky130_fd_sc_hd__a22o_1
X_09783_ _01077_ _01091_ VGND VGND VPWR VPWR _01092_ sky130_fd_sc_hd__nor2_1
XFILLER_0_147_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08734_ net188 net177 net693 net530 VGND VGND VPWR VPWR _08045_ sky130_fd_sc_hd__nand4_1
XFILLER_0_56_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08665_ _03442_ _03463_ _03453_ VGND VGND VPWR VPWR _07977_ sky130_fd_sc_hd__o21bai_1
X_08596_ _07444_ _07466_ _07477_ _07499_ VGND VGND VPWR VPWR _07509_ sky130_fd_sc_hd__and4_1
XFILLER_0_49_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09217_ _00531_ _00532_ VGND VGND VPWR VPWR _00533_ sky130_fd_sc_hd__nor2_2
XFILLER_0_106_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09148_ _00463_ _00464_ VGND VGND VPWR VPWR _00465_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_133_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09079_ net273 net562 _00324_ _00323_ net552 VGND VGND VPWR VPWR _00396_ sky130_fd_sc_hd__a32o_2
XFILLER_0_20_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11110_ _02262_ _02264_ _02367_ _02368_ VGND VGND VPWR VPWR _02392_ sky130_fd_sc_hd__o211a_1
X_12090_ a_cos\[14\] _03458_ _02383_ VGND VGND VPWR VPWR _03459_ sky130_fd_sc_hd__mux2_1
XFILLER_0_102_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11041_ _02314_ _02315_ _02316_ VGND VGND VPWR VPWR _02317_ sky130_fd_sc_hd__a21o_1
X_14800_ _06413_ _06414_ _06412_ VGND VGND VPWR VPWR _06416_ sky130_fd_sc_hd__o21ai_1
X_15780_ _07463_ _07481_ VGND VGND VPWR VPWR _07483_ sky130_fd_sc_hd__or2_1
X_12992_ net755 net291 net284 net764 VGND VGND VPWR VPWR _04444_ sky130_fd_sc_hd__a22o_1
X_14731_ _06337_ _06338_ _06317_ _06318_ VGND VGND VPWR VPWR _06340_ sky130_fd_sc_hd__a211o_1
X_11943_ _03296_ _03298_ VGND VGND VPWR VPWR _03299_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14662_ _06161_ _06164_ _06262_ _06263_ VGND VGND VPWR VPWR _06264_ sky130_fd_sc_hd__o211ai_2
X_11874_ _03208_ _03223_ VGND VGND VPWR VPWR _03224_ sky130_fd_sc_hd__xnor2_1
X_13613_ _05118_ _05119_ VGND VGND VPWR VPWR _05120_ sky130_fd_sc_hd__nor2_1
XFILLER_0_67_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10825_ _02065_ _02066_ _02087_ _02088_ VGND VGND VPWR VPWR _02089_ sky130_fd_sc_hd__and4bb_2
X_14593_ net361 net578 VGND VGND VPWR VPWR _06188_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13544_ net754 _00192_ VGND VGND VPWR VPWR _05045_ sky130_fd_sc_hd__or2_1
XFILLER_0_82_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10756_ _02012_ _02011_ _02007_ VGND VGND VPWR VPWR _02020_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_124_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16263_ clknet_4_0_0_clk _00052_ net331 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dfrtp_1
X_13475_ _04967_ _04968_ _04969_ VGND VGND VPWR VPWR _04971_ sky130_fd_sc_hd__nand3_2
XFILLER_0_82_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10687_ _01949_ _01950_ VGND VGND VPWR VPWR _01951_ sky130_fd_sc_hd__nor2_1
XFILLER_0_63_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15214_ net460 net451 net573 VGND VGND VPWR VPWR _06866_ sky130_fd_sc_hd__and3_1
XFILLER_0_35_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12426_ net612 net711 net214 net205 VGND VGND VPWR VPWR _03824_ sky130_fd_sc_hd__and4_1
X_16194_ _07919_ _07930_ VGND VGND VPWR VPWR _07931_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_124_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15145_ _06786_ _06789_ _06790_ VGND VGND VPWR VPWR _06792_ sky130_fd_sc_hd__and3_1
X_12357_ _03744_ _03746_ _03743_ VGND VGND VPWR VPWR _03748_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_121_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11308_ _02507_ _02525_ _02607_ VGND VGND VPWR VPWR _02608_ sky130_fd_sc_hd__a21o_1
X_15076_ net516 net625 net48 VGND VGND VPWR VPWR _06717_ sky130_fd_sc_hd__a21oi_1
X_12288_ net465 net801 _03531_ _03529_ VGND VGND VPWR VPWR _03673_ sky130_fd_sc_hd__a31o_1
XFILLER_0_120_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14027_ _05476_ _05498_ _05474_ VGND VGND VPWR VPWR _05571_ sky130_fd_sc_hd__o21ai_1
X_11239_ net477 _02531_ _02532_ VGND VGND VPWR VPWR _02533_ sky130_fd_sc_hd__a21bo_1
X_15978_ _07685_ _07697_ VGND VGND VPWR VPWR _07698_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_117_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14929_ net461 net593 net604 net454 VGND VGND VPWR VPWR _06556_ sky130_fd_sc_hd__a22o_1
X_08450_ _05351_ _05340_ _05264_ VGND VGND VPWR VPWR _05915_ sky130_fd_sc_hd__a21o_1
XFILLER_0_89_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08381_ _05133_ _05122_ _05112_ _05024_ VGND VGND VPWR VPWR _05166_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_9_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09002_ _00239_ _00271_ _00272_ VGND VGND VPWR VPWR _00320_ sky130_fd_sc_hd__nor3_1
XFILLER_0_104_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09904_ _01210_ VGND VGND VPWR VPWR _01211_ sky130_fd_sc_hd__clkbuf_2
Xfanout502 net40 VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__clkbuf_4
Xfanout513 net515 VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__clkbuf_4
Xfanout524 net39 VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__clkbuf_4
Xfanout535 net537 VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__clkbuf_4
Xfanout546 net870 VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__clkbuf_4
Xfanout557 net561 VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__clkbuf_4
X_09835_ _01121_ _01141_ VGND VGND VPWR VPWR _01143_ sky130_fd_sc_hd__or2_1
Xfanout568 net34 VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__clkbuf_4
Xfanout579 net33 VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__buf_8
X_09766_ _00997_ _00998_ VGND VGND VPWR VPWR _01075_ sky130_fd_sc_hd__and2_1
X_08717_ net298 net563 VGND VGND VPWR VPWR _08028_ sky130_fd_sc_hd__and2_1
XFILLER_0_69_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09697_ net166 net619 _00834_ _00833_ VGND VGND VPWR VPWR _01007_ sky130_fd_sc_hd__a31o_2
Xrebuffer40 _03734_ VGND VGND VPWR VPWR net878 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_68_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08648_ net188 net177 net530 net539 VGND VGND VPWR VPWR _07960_ sky130_fd_sc_hd__nand4_1
XFILLER_0_139_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08579_ _07009_ _07314_ VGND VGND VPWR VPWR _07325_ sky130_fd_sc_hd__and2b_1
XFILLER_0_49_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10610_ _01873_ VGND VGND VPWR VPWR _01874_ sky130_fd_sc_hd__inv_2
X_11590_ _02913_ _02911_ _02912_ VGND VGND VPWR VPWR _02915_ sky130_fd_sc_hd__or3_1
XFILLER_0_92_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10541_ _01771_ _01804_ VGND VGND VPWR VPWR _01805_ sky130_fd_sc_hd__nand2_1
XFILLER_0_134_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13260_ a_sin\[4\] _04736_ _03521_ VGND VGND VPWR VPWR _04737_ sky130_fd_sc_hd__mux2_1
X_10472_ _01728_ _01729_ _01735_ VGND VGND VPWR VPWR _01736_ sky130_fd_sc_hd__a21oi_2
X_12211_ net465 net801 VGND VGND VPWR VPWR _03589_ sky130_fd_sc_hd__nand2_1
X_13191_ net737 net745 net291 VGND VGND VPWR VPWR _04661_ sky130_fd_sc_hd__and3_1
XFILLER_0_60_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12142_ _03460_ _03514_ VGND VGND VPWR VPWR _03515_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_130_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12073_ _03438_ _03439_ VGND VGND VPWR VPWR _03440_ sky130_fd_sc_hd__nor2_1
X_15901_ _07612_ _07613_ VGND VGND VPWR VPWR _07614_ sky130_fd_sc_hd__nor2_1
X_11024_ _02296_ _02297_ VGND VGND VPWR VPWR _02298_ sky130_fd_sc_hd__nand2_1
X_15832_ _07536_ _07537_ _07534_ net123 VGND VGND VPWR VPWR _07539_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_99_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15763_ _07363_ _07365_ VGND VGND VPWR VPWR _07464_ sky130_fd_sc_hd__nand2_1
X_12975_ net780 net268 VGND VGND VPWR VPWR _04426_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14714_ _06236_ _06238_ _06237_ VGND VGND VPWR VPWR _06321_ sky130_fd_sc_hd__o21ba_1
X_11926_ _03277_ _03278_ _03275_ net124 VGND VGND VPWR VPWR _03281_ sky130_fd_sc_hd__a211oi_2
X_15694_ _07311_ _07312_ VGND VGND VPWR VPWR _07389_ sky130_fd_sc_hd__or2_1
XFILLER_0_75_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14645_ _06243_ _06244_ VGND VGND VPWR VPWR _06246_ sky130_fd_sc_hd__nor2_1
X_11857_ _03151_ _03152_ VGND VGND VPWR VPWR _03206_ sky130_fd_sc_hd__or2_1
XFILLER_0_86_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10808_ net496 net776 VGND VGND VPWR VPWR _02072_ sky130_fd_sc_hd__nand2_1
X_14576_ net523 net683 net690 net438 VGND VGND VPWR VPWR _06170_ sky130_fd_sc_hd__a22oi_2
X_11788_ _03058_ _03059_ VGND VGND VPWR VPWR _03131_ sky130_fd_sc_hd__and2_1
XFILLER_0_28_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16315_ clknet_4_3_0_clk _00104_ net341 VGND VGND VPWR VPWR b_cos\[8\] sky130_fd_sc_hd__dfrtp_1
X_13527_ _04934_ _04954_ _05026_ VGND VGND VPWR VPWR _05027_ sky130_fd_sc_hd__a21oi_1
X_10739_ _01989_ _01990_ _02001_ VGND VGND VPWR VPWR _02003_ sky130_fd_sc_hd__and3_1
XFILLER_0_137_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16246_ clknet_4_5_0_clk _00035_ net334 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_125_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13458_ net763 _00192_ VGND VGND VPWR VPWR _04952_ sky130_fd_sc_hd__or2_1
XFILLER_0_3_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12409_ _03799_ _03804_ VGND VGND VPWR VPWR _03805_ sky130_fd_sc_hd__xnor2_1
X_16177_ _07605_ _07857_ VGND VGND VPWR VPWR _07913_ sky130_fd_sc_hd__nor2_1
X_13389_ _04875_ _04876_ VGND VGND VPWR VPWR _04877_ sky130_fd_sc_hd__and2b_1
Xoutput105 net105 VGND VGND VPWR VPWR Q[16] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput116 net116 VGND VGND VPWR VPWR Q[9] sky130_fd_sc_hd__clkbuf_4
X_15128_ _06768_ _06770_ _06771_ VGND VGND VPWR VPWR _06773_ sky130_fd_sc_hd__nand3_1
XFILLER_0_10_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15059_ _06599_ _06601_ VGND VGND VPWR VPWR _06698_ sky130_fd_sc_hd__nand2_1
XFILLER_0_128_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09620_ _00836_ _00930_ VGND VGND VPWR VPWR _00931_ sky130_fd_sc_hd__xor2_4
X_09551_ _00847_ _00848_ _00861_ VGND VGND VPWR VPWR _00863_ sky130_fd_sc_hd__nand3_1
X_08502_ _06421_ _06464_ _06475_ VGND VGND VPWR VPWR _06486_ sky130_fd_sc_hd__and3_1
X_09482_ _00793_ _00794_ VGND VGND VPWR VPWR _00795_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_144_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08433_ _05177_ _05698_ _05654_ _05687_ VGND VGND VPWR VPWR _05730_ sky130_fd_sc_hd__a211o_1
XFILLER_0_93_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08364_ _04861_ _04959_ _04970_ VGND VGND VPWR VPWR _04981_ sky130_fd_sc_hd__nand3_1
XFILLER_0_74_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08295_ net171 net592 VGND VGND VPWR VPWR _04229_ sky130_fd_sc_hd__nand2_1
XFILLER_0_144_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout310 net60 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__buf_4
Xfanout321 net322 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_100_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout332 net333 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__clkbuf_4
Xfanout343 net344 VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__buf_4
Xfanout354 net355 VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__clkbuf_4
Xfanout365 net375 VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__buf_4
Xfanout376 net386 VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__buf_4
X_09818_ net248 net676 VGND VGND VPWR VPWR _01126_ sky130_fd_sc_hd__nand2_1
Xfanout387 net388 VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__clkbuf_4
Xfanout398 net399 VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__buf_2
X_09749_ _01052_ _01057_ VGND VGND VPWR VPWR _01058_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_68_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12760_ _04120_ _04165_ net815 _04164_ VGND VGND VPWR VPWR _04191_ sky130_fd_sc_hd__o211a_1
XFILLER_0_69_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11711_ _02941_ _02944_ VGND VGND VPWR VPWR _03047_ sky130_fd_sc_hd__nand2_1
X_12691_ _04105_ _04112_ _04113_ _04114_ VGND VGND VPWR VPWR _04115_ sky130_fd_sc_hd__o211a_1
XFILLER_0_37_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_139_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14430_ _05954_ _05955_ _05949_ VGND VGND VPWR VPWR _06009_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_139_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11642_ _02962_ _02970_ _02971_ VGND VGND VPWR VPWR _02972_ sky130_fd_sc_hd__nand3_1
XFILLER_0_126_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14361_ net706 _05854_ _05887_ VGND VGND VPWR VPWR _05933_ sky130_fd_sc_hd__and3_1
XFILLER_0_119_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11573_ _02894_ _02896_ VGND VGND VPWR VPWR _02897_ sky130_fd_sc_hd__xnor2_1
Xinput18 alpha[8] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_1
X_16100_ _07804_ _07828_ VGND VGND VPWR VPWR _07830_ sky130_fd_sc_hd__nor2_1
X_13312_ _04790_ _04791_ _04787_ VGND VGND VPWR VPWR _04793_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_24_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput29 beta[18] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_2
X_10524_ net410 net778 net786 net399 VGND VGND VPWR VPWR _01788_ sky130_fd_sc_hd__a22oi_1
X_14292_ _05855_ _05856_ VGND VGND VPWR VPWR _05857_ sky130_fd_sc_hd__nand2_1
XFILLER_0_135_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16031_ _07753_ _07754_ VGND VGND VPWR VPWR _07755_ sky130_fd_sc_hd__or2_1
X_13243_ _04682_ _04716_ net820 VGND VGND VPWR VPWR _04718_ sky130_fd_sc_hd__nand3_1
X_10455_ net363 net777 _01716_ _01717_ VGND VGND VPWR VPWR _01719_ sky130_fd_sc_hd__a22o_1
XFILLER_0_149_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13174_ _04529_ _04640_ _04641_ VGND VGND VPWR VPWR _04642_ sky130_fd_sc_hd__a21o_1
X_10386_ net421 net760 VGND VGND VPWR VPWR _01650_ sky130_fd_sc_hd__nand2_1
XFILLER_0_102_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12125_ _03494_ _03495_ VGND VGND VPWR VPWR _03497_ sky130_fd_sc_hd__xor2_1
XFILLER_0_20_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12056_ _03343_ _03345_ VGND VGND VPWR VPWR _03422_ sky130_fd_sc_hd__or2_1
X_11007_ _02186_ _02280_ VGND VGND VPWR VPWR _02281_ sky130_fd_sc_hd__nand2_1
X_15815_ _07518_ _07519_ VGND VGND VPWR VPWR _07521_ sky130_fd_sc_hd__nor2_1
X_15746_ _07359_ _07361_ _07443_ VGND VGND VPWR VPWR _07446_ sky130_fd_sc_hd__nand3_1
X_12958_ _04341_ _04406_ _04407_ VGND VGND VPWR VPWR _04408_ sky130_fd_sc_hd__nand3_2
XFILLER_0_114_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11909_ _03260_ _03261_ VGND VGND VPWR VPWR _03262_ sky130_fd_sc_hd__nor2_1
X_15677_ net356 net632 _07369_ _07370_ VGND VGND VPWR VPWR _07371_ sky130_fd_sc_hd__a22o_1
XFILLER_0_59_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12889_ _04238_ _04331_ VGND VGND VPWR VPWR _04332_ sky130_fd_sc_hd__or2_1
XFILLER_0_74_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14628_ _06215_ _06216_ _06226_ VGND VGND VPWR VPWR _06227_ sky130_fd_sc_hd__and3_1
XFILLER_0_114_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14559_ net488 net707 VGND VGND VPWR VPWR _06151_ sky130_fd_sc_hd__nand2_1
XFILLER_0_126_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16229_ clknet_4_0_0_clk _00018_ net332 VGND VGND VPWR VPWR b_sin\[18\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_140_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08982_ _00216_ _00275_ _00276_ VGND VGND VPWR VPWR _00300_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_143_Right_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09603_ net272 net676 VGND VGND VPWR VPWR _00914_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09534_ _00748_ _00755_ VGND VGND VPWR VPWR _00846_ sky130_fd_sc_hd__and2_1
XFILLER_0_149_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09465_ _00758_ _00759_ _00777_ VGND VGND VPWR VPWR _00778_ sky130_fd_sc_hd__a21oi_1
X_08416_ _05394_ _05416_ VGND VGND VPWR VPWR _05546_ sky130_fd_sc_hd__or2b_1
X_09396_ net159 net305 net657 net667 VGND VGND VPWR VPWR _00710_ sky130_fd_sc_hd__nand4_2
XFILLER_0_58_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08347_ net324 net240 net540 net548 VGND VGND VPWR VPWR _04796_ sky130_fd_sc_hd__nand4_1
XFILLER_0_46_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08278_ _03355_ _03377_ _03312_ VGND VGND VPWR VPWR _04042_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_22_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10240_ _01519_ VGND VGND VPWR VPWR _00042_ sky130_fd_sc_hd__clkbuf_1
X_10171_ a_cos\[13\] b_sin\[13\] VGND VGND VPWR VPWR _01461_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_110_Right_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout140 net147 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__clkbuf_4
Xfanout151 net8 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__buf_2
Xfanout162 net163 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__clkbuf_4
X_13930_ _05461_ _05464_ VGND VGND VPWR VPWR _05465_ sky130_fd_sc_hd__xnor2_1
Xfanout173 net182 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__clkbuf_4
Xfanout184 net186 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__clkbuf_4
Xfanout195 net73 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__buf_4
X_13861_ net148 net295 _05386_ _05388_ VGND VGND VPWR VPWR _05390_ sky130_fd_sc_hd__and4_1
X_15600_ _07284_ _07285_ _07286_ VGND VGND VPWR VPWR _07287_ sky130_fd_sc_hd__nand3_2
X_12812_ net773 net294 net284 net780 VGND VGND VPWR VPWR _04248_ sky130_fd_sc_hd__a22oi_1
X_13792_ _05294_ _05295_ _05313_ _05314_ VGND VGND VPWR VPWR _05315_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_69_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15531_ net484 net474 net688 net697 VGND VGND VPWR VPWR _07212_ sky130_fd_sc_hd__and4_1
X_12743_ _04149_ _04148_ VGND VGND VPWR VPWR _04172_ sky130_fd_sc_hd__and2b_1
XFILLER_0_139_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15462_ _07080_ _07136_ VGND VGND VPWR VPWR _07137_ sky130_fd_sc_hd__xor2_2
X_12674_ net775 net221 VGND VGND VPWR VPWR _04096_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14413_ _05987_ _05988_ _05940_ VGND VGND VPWR VPWR _05990_ sky130_fd_sc_hd__a21o_1
XFILLER_0_127_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11625_ _02949_ _02950_ _02952_ VGND VGND VPWR VPWR _02954_ sky130_fd_sc_hd__a21o_1
X_15393_ net460 net545 net554 net451 VGND VGND VPWR VPWR _07061_ sky130_fd_sc_hd__a22o_1
XFILLER_0_108_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14344_ _05905_ _05911_ _05910_ VGND VGND VPWR VPWR _05914_ sky130_fd_sc_hd__a21o_1
XFILLER_0_8_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11556_ _02875_ _02876_ _02775_ _02853_ VGND VGND VPWR VPWR _02879_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_52_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_675 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10507_ net810 _01751_ VGND VGND VPWR VPWR _01771_ sky130_fd_sc_hd__nand2_1
XFILLER_0_150_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14275_ net391 net605 VGND VGND VPWR VPWR _05839_ sky130_fd_sc_hd__nand2_1
XFILLER_0_123_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11487_ _02705_ _02792_ _02802_ VGND VGND VPWR VPWR _02803_ sky130_fd_sc_hd__a21oi_2
X_16014_ _07734_ _07735_ VGND VGND VPWR VPWR _07736_ sky130_fd_sc_hd__xor2_2
XFILLER_0_33_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13226_ _04697_ _04699_ VGND VGND VPWR VPWR _04700_ sky130_fd_sc_hd__xor2_2
XFILLER_0_110_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10438_ _01699_ _01700_ _01698_ VGND VGND VPWR VPWR _01702_ sky130_fd_sc_hd__a21o_1
XFILLER_0_21_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13157_ _04516_ VGND VGND VPWR VPWR _04625_ sky130_fd_sc_hd__inv_2
XFILLER_0_0_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10369_ net421 net751 VGND VGND VPWR VPWR _01633_ sky130_fd_sc_hd__nand2_1
XFILLER_0_109_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12108_ _03410_ _03408_ VGND VGND VPWR VPWR _03478_ sky130_fd_sc_hd__and2b_1
X_13088_ net737 net746 net300 VGND VGND VPWR VPWR _04549_ sky130_fd_sc_hd__and3_1
X_12039_ net315 net456 net448 net426 VGND VGND VPWR VPWR _03403_ sky130_fd_sc_hd__a22oi_2
XPHY_EDGE_ROW_108_Left_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_149_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15729_ _07421_ _07419_ VGND VGND VPWR VPWR _07427_ sky130_fd_sc_hd__and2b_1
XFILLER_0_75_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09250_ _00565_ VGND VGND VPWR VPWR _00006_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08201_ _03181_ _03192_ VGND VGND VPWR VPWR _03203_ sky130_fd_sc_hd__or2b_1
XFILLER_0_118_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09181_ _00402_ _00403_ _00496_ VGND VGND VPWR VPWR _00497_ sky130_fd_sc_hd__o21a_1
XFILLER_0_7_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08132_ _02386_ _02430_ _02441_ VGND VGND VPWR VPWR _02452_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_117_Left_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08965_ _00281_ _00282_ _00181_ _00183_ VGND VGND VPWR VPWR _00284_ sky130_fd_sc_hd__o211ai_2
XPHY_EDGE_ROW_126_Left_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08896_ _08009_ _08103_ VGND VGND VPWR VPWR _00215_ sky130_fd_sc_hd__or2_1
XFILLER_0_75_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09517_ _00761_ _00762_ VGND VGND VPWR VPWR _00829_ sky130_fd_sc_hd__or2_1
XFILLER_0_94_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09448_ _00760_ VGND VGND VPWR VPWR _00761_ sky130_fd_sc_hd__buf_2
XFILLER_0_93_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_135_Left_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09379_ _00688_ _00691_ _00692_ VGND VGND VPWR VPWR _00693_ sky130_fd_sc_hd__nand3_1
XFILLER_0_46_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11410_ _02716_ _02718_ VGND VGND VPWR VPWR _02719_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_35_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12390_ _03782_ _03783_ VGND VGND VPWR VPWR _03784_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11341_ _02641_ _02642_ _02643_ VGND VGND VPWR VPWR _02644_ sky130_fd_sc_hd__nand3_1
X_14060_ _05598_ _05605_ VGND VGND VPWR VPWR _05606_ sky130_fd_sc_hd__xnor2_2
X_11272_ _02567_ _02568_ VGND VGND VPWR VPWR _02569_ sky130_fd_sc_hd__xor2_2
XFILLER_0_104_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13011_ _04378_ _04397_ _04398_ VGND VGND VPWR VPWR _04465_ sky130_fd_sc_hd__nand3_2
X_10223_ net109 _01504_ net136 VGND VGND VPWR VPWR _01505_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_144_Left_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10154_ net80 _01446_ net135 VGND VGND VPWR VPWR _01447_ sky130_fd_sc_hd__mux2_1
X_14962_ _06589_ _06590_ _06570_ VGND VGND VPWR VPWR _06592_ sky130_fd_sc_hd__a21oi_1
X_10085_ _01387_ VGND VGND VPWR VPWR _00019_ sky130_fd_sc_hd__clkbuf_1
X_13913_ _05441_ _05440_ VGND VGND VPWR VPWR _05446_ sky130_fd_sc_hd__and2b_1
XFILLER_0_89_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14893_ _06513_ _06514_ _06515_ VGND VGND VPWR VPWR _06517_ sky130_fd_sc_hd__a21o_1
X_13844_ _05365_ VGND VGND VPWR VPWR _05371_ sky130_fd_sc_hd__inv_2
XFILLER_0_71_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13775_ _05142_ _05239_ VGND VGND VPWR VPWR _05297_ sky130_fd_sc_hd__or2_1
X_10987_ _02254_ _02255_ _02257_ VGND VGND VPWR VPWR _02259_ sky130_fd_sc_hd__a21o_1
X_12726_ net805 net191 VGND VGND VPWR VPWR _04154_ sky130_fd_sc_hd__nand2_1
X_15514_ net365 net641 net634 net376 VGND VGND VPWR VPWR _07193_ sky130_fd_sc_hd__a22o_1
XFILLER_0_128_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15445_ net365 net653 net644 net376 VGND VGND VPWR VPWR _07119_ sky130_fd_sc_hd__a22o_1
XFILLER_0_128_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12657_ _04021_ _04029_ _04028_ VGND VGND VPWR VPWR _04078_ sky130_fd_sc_hd__a21o_1
XFILLER_0_143_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11608_ _02932_ _02933_ _02934_ VGND VGND VPWR VPWR _02935_ sky130_fd_sc_hd__and3_1
XFILLER_0_37_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15376_ _07040_ _07043_ VGND VGND VPWR VPWR _07044_ sky130_fd_sc_hd__xnor2_2
X_12588_ _03992_ _04000_ _04001_ VGND VGND VPWR VPWR _04002_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_142_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14327_ _05892_ _05894_ _05895_ VGND VGND VPWR VPWR _05896_ sky130_fd_sc_hd__nor3b_2
X_11539_ _02770_ _02857_ _02858_ VGND VGND VPWR VPWR _02860_ sky130_fd_sc_hd__nand3_1
XFILLER_0_123_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap126 _04544_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__buf_1
XFILLER_0_111_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14258_ net419 net577 VGND VGND VPWR VPWR _05820_ sky130_fd_sc_hd__and2_1
XFILLER_0_110_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13209_ _04678_ _04679_ _04659_ VGND VGND VPWR VPWR _04681_ sky130_fd_sc_hd__a21oi_1
X_14189_ net226 net247 _05744_ VGND VGND VPWR VPWR _05746_ sky130_fd_sc_hd__and3_1
XFILLER_0_29_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08750_ _08058_ _08059_ _08057_ VGND VGND VPWR VPWR _08061_ sky130_fd_sc_hd__o21ai_1
X_08681_ _07770_ _07991_ _07992_ VGND VGND VPWR VPWR _07993_ sky130_fd_sc_hd__nand3_2
XFILLER_0_136_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09302_ _00615_ _00616_ _00535_ VGND VGND VPWR VPWR _00617_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_119_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09233_ _00441_ _00547_ _00548_ VGND VGND VPWR VPWR _00549_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_145_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09164_ _00390_ _00466_ VGND VGND VPWR VPWR _00480_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08115_ net324 net693 net531 net240 VGND VGND VPWR VPWR _02267_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_9_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09095_ _00394_ _00411_ VGND VGND VPWR VPWR _00412_ sky130_fd_sc_hd__xor2_2
XFILLER_0_31_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09997_ _01272_ _01274_ VGND VGND VPWR VPWR _01302_ sky130_fd_sc_hd__or2_1
X_08948_ _00264_ _00265_ _00266_ VGND VGND VPWR VPWR _00267_ sky130_fd_sc_hd__nand3_1
XFILLER_0_99_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08879_ _00119_ _00177_ _00178_ VGND VGND VPWR VPWR _00198_ sky130_fd_sc_hd__nand3_1
X_10910_ _02174_ _02175_ VGND VGND VPWR VPWR _02176_ sky130_fd_sc_hd__nor2_1
X_11890_ _03238_ _03241_ VGND VGND VPWR VPWR _03242_ sky130_fd_sc_hd__xnor2_1
X_10841_ _01910_ _02103_ _02104_ VGND VGND VPWR VPWR _02105_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_67_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13560_ net228 net165 _05061_ _05062_ VGND VGND VPWR VPWR _05063_ sky130_fd_sc_hd__a22o_1
X_10772_ _01964_ _01969_ _01963_ VGND VGND VPWR VPWR _02036_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_137_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12511_ _03914_ _03915_ _03916_ VGND VGND VPWR VPWR _03917_ sky130_fd_sc_hd__nand3_4
XFILLER_0_82_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13491_ _04985_ _04986_ _04987_ VGND VGND VPWR VPWR _04988_ sky130_fd_sc_hd__a21o_1
XFILLER_0_94_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15230_ _06785_ _06793_ _06792_ VGND VGND VPWR VPWR _06884_ sky130_fd_sc_hd__a21o_1
X_12442_ _03832_ _03840_ VGND VGND VPWR VPWR _03841_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_124_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15161_ _06806_ _06807_ _06800_ VGND VGND VPWR VPWR _06809_ sky130_fd_sc_hd__a21o_1
XFILLER_0_140_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12373_ net738 net187 net177 net747 VGND VGND VPWR VPWR _03765_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_34_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14112_ net139 net271 VGND VGND VPWR VPWR _05662_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11324_ net784 _02385_ VGND VGND VPWR VPWR _02625_ sky130_fd_sc_hd__nor2_1
X_15092_ _06731_ _06732_ _06696_ VGND VGND VPWR VPWR _06734_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_120_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14043_ _05526_ _05587_ VGND VGND VPWR VPWR _05588_ sky130_fd_sc_hd__xor2_1
X_11255_ _02547_ _02548_ _02529_ VGND VGND VPWR VPWR _02551_ sky130_fd_sc_hd__a21oi_1
X_10206_ a_cos\[18\] b_sin\[18\] VGND VGND VPWR VPWR _01491_ sky130_fd_sc_hd__xnor2_1
X_11186_ _02472_ _02473_ _02437_ VGND VGND VPWR VPWR _02476_ sky130_fd_sc_hd__o21ai_2
X_10137_ _01430_ _01431_ VGND VGND VPWR VPWR _01432_ sky130_fd_sc_hd__and2b_1
X_15994_ _07637_ _07638_ VGND VGND VPWR VPWR _07715_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10068_ net262 net637 _01307_ VGND VGND VPWR VPWR _01372_ sky130_fd_sc_hd__nand3_1
X_14945_ net487 net568 net573 net476 VGND VGND VPWR VPWR _06574_ sky130_fd_sc_hd__a22o_1
XFILLER_0_89_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14876_ net360 net541 _06495_ _06496_ VGND VGND VPWR VPWR _06499_ sky130_fd_sc_hd__nand4_1
XFILLER_0_58_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13827_ _05331_ _05332_ _05353_ VGND VGND VPWR VPWR _05354_ sky130_fd_sc_hd__a21o_1
XFILLER_0_15_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13758_ _05251_ _05252_ _05277_ VGND VGND VPWR VPWR _05279_ sky130_fd_sc_hd__nor3_1
XFILLER_0_73_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12709_ _04102_ _04101_ _04093_ VGND VGND VPWR VPWR _04135_ sky130_fd_sc_hd__a21o_1
XFILLER_0_127_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13689_ _04420_ _04625_ _04627_ _05201_ _05202_ VGND VGND VPWR VPWR _05204_ sky130_fd_sc_hd__o2111a_4
XFILLER_0_72_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15428_ _07082_ _07098_ _07099_ VGND VGND VPWR VPWR _07100_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15359_ net415 net626 _01891_ VGND VGND VPWR VPWR _07025_ sky130_fd_sc_hd__and3_1
XFILLER_0_124_850 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09920_ _01224_ _01225_ _01226_ _01142_ VGND VGND VPWR VPWR _01227_ sky130_fd_sc_hd__o211a_1
XFILLER_0_1_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout706 net707 VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__buf_2
X_09851_ _01157_ _01158_ VGND VGND VPWR VPWR _01159_ sky130_fd_sc_hd__and2_1
Xfanout717 net2 VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__clkbuf_8
Xfanout728 net735 VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__clkbuf_2
Xfanout739 net744 VGND VGND VPWR VPWR net739 sky130_fd_sc_hd__clkbuf_4
X_08802_ net292 net283 net572 VGND VGND VPWR VPWR _00122_ sky130_fd_sc_hd__and3_1
X_09782_ _01083_ _01090_ VGND VGND VPWR VPWR _01091_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08733_ net188 net693 net530 net177 VGND VGND VPWR VPWR _08044_ sky130_fd_sc_hd__a22o_1
XFILLER_0_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08664_ _07973_ _07974_ _07972_ VGND VGND VPWR VPWR _07976_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_96_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08595_ _07412_ _07488_ net602 net704 VGND VGND VPWR VPWR _07499_ sky130_fd_sc_hd__and4b_1
XFILLER_0_49_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09216_ _00529_ _00530_ _00523_ VGND VGND VPWR VPWR _00532_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_146_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09147_ _00319_ _00376_ _00375_ VGND VGND VPWR VPWR _00464_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_122_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09078_ _00321_ _00340_ _00338_ VGND VGND VPWR VPWR _00395_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_32_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11040_ net750 net494 VGND VGND VPWR VPWR _02316_ sky130_fd_sc_hd__and2_1
X_12991_ net755 net764 net284 VGND VGND VPWR VPWR _04443_ sky130_fd_sc_hd__and3_1
XFILLER_0_99_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14730_ _06317_ _06318_ _06337_ _06338_ VGND VGND VPWR VPWR _06339_ sky130_fd_sc_hd__o211ai_2
X_11942_ _03216_ _03217_ _03297_ VGND VGND VPWR VPWR _03298_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_99_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14661_ _06252_ _06261_ _06260_ VGND VGND VPWR VPWR _06263_ sky130_fd_sc_hd__a21o_1
X_11873_ _03221_ _03222_ VGND VGND VPWR VPWR _03223_ sky130_fd_sc_hd__xnor2_1
X_13612_ net507 net609 net288 net279 VGND VGND VPWR VPWR _05119_ sky130_fd_sc_hd__and4_1
XFILLER_0_39_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10824_ _02085_ _02086_ _02067_ _02068_ VGND VGND VPWR VPWR _02088_ sky130_fd_sc_hd__a211o_1
X_14592_ _06002_ _06005_ _06004_ VGND VGND VPWR VPWR _06187_ sky130_fd_sc_hd__o21ba_1
X_13543_ _05041_ _05043_ VGND VGND VPWR VPWR _05044_ sky130_fd_sc_hd__xor2_2
X_10755_ _02012_ _02007_ _02011_ VGND VGND VPWR VPWR _02019_ sky130_fd_sc_hd__or3_1
XFILLER_0_137_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16262_ clknet_4_4_0_clk _00051_ net332 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dfrtp_1
X_13474_ _04868_ _04870_ _04869_ VGND VGND VPWR VPWR _04969_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_70_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10686_ net383 net751 net761 net372 VGND VGND VPWR VPWR _01950_ sky130_fd_sc_hd__a22oi_2
X_15213_ net468 net567 _06764_ _06763_ net554 VGND VGND VPWR VPWR _06865_ sky130_fd_sc_hd__a32o_2
X_12425_ net720 net197 VGND VGND VPWR VPWR _03823_ sky130_fd_sc_hd__nand2_1
X_16193_ _07924_ _07929_ VGND VGND VPWR VPWR _07930_ sky130_fd_sc_hd__xnor2_1
X_15144_ net357 net687 _06787_ _06788_ VGND VGND VPWR VPWR _06790_ sky130_fd_sc_hd__nand4_2
XFILLER_0_11_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12356_ _03743_ _03744_ _03746_ VGND VGND VPWR VPWR _03747_ sky130_fd_sc_hd__or3_1
XFILLER_0_23_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11307_ _02524_ _02508_ VGND VGND VPWR VPWR _02607_ sky130_fd_sc_hd__and2b_1
X_15075_ net431 net634 VGND VGND VPWR VPWR _06716_ sky130_fd_sc_hd__nand2_1
XFILLER_0_120_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12287_ _03664_ _03671_ VGND VGND VPWR VPWR _03672_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_121_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14026_ _05567_ _05569_ VGND VGND VPWR VPWR _05570_ sky130_fd_sc_hd__and2_1
X_11238_ net741 net486 net476 net750 VGND VGND VPWR VPWR _02532_ sky130_fd_sc_hd__a22o_1
X_11169_ net432 net869 VGND VGND VPWR VPWR _02457_ sky130_fd_sc_hd__nand2_1
X_15977_ _07611_ _07696_ VGND VGND VPWR VPWR _07697_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_26_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14928_ net470 net594 _06472_ _06471_ VGND VGND VPWR VPWR _06555_ sky130_fd_sc_hd__a31o_1
XFILLER_0_89_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14859_ _06476_ _06477_ _06478_ VGND VGND VPWR VPWR _06480_ sky130_fd_sc_hd__nand3_1
XFILLER_0_148_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08380_ _05068_ VGND VGND VPWR VPWR _05155_ sky130_fd_sc_hd__inv_2
XFILLER_0_92_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09001_ _00302_ _00318_ VGND VGND VPWR VPWR _00319_ sky130_fd_sc_hd__xor2_1
XFILLER_0_26_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09903_ _01152_ _01203_ VGND VGND VPWR VPWR _01210_ sky130_fd_sc_hd__or2b_1
Xfanout503 net40 VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__clkbuf_2
Xfanout514 net515 VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__buf_2
XFILLER_0_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout525 net39 VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__clkbuf_2
Xfanout536 net537 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__clkbuf_2
Xfanout547 net870 VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__clkbuf_4
X_09834_ _01121_ _01141_ VGND VGND VPWR VPWR _01142_ sky130_fd_sc_hd__nand2_2
Xfanout558 net561 VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__buf_4
Xfanout569 net34 VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__clkbuf_4
X_09765_ _01072_ _01073_ VGND VGND VPWR VPWR _01074_ sky130_fd_sc_hd__nand2_4
X_08716_ net160 net867 net544 net553 VGND VGND VPWR VPWR _08027_ sky130_fd_sc_hd__nand4_1
X_09696_ _00763_ _00933_ _00761_ VGND VGND VPWR VPWR _01006_ sky130_fd_sc_hd__a21oi_1
Xrebuffer30 _02463_ VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_96_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer41 _02811_ VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__dlymetal6s2s_1
X_08647_ net188 net530 net539 net177 VGND VGND VPWR VPWR _07959_ sky130_fd_sc_hd__a22o_1
XFILLER_0_96_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08578_ net872 _07270_ _07292_ _07303_ VGND VGND VPWR VPWR _07314_ sky130_fd_sc_hd__and4_1
XFILLER_0_77_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10540_ net381 net794 net810 net370 VGND VGND VPWR VPWR _01804_ sky130_fd_sc_hd__a22o_1
XFILLER_0_91_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10471_ _01625_ _01734_ VGND VGND VPWR VPWR _01735_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_32_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12210_ _03495_ _03534_ VGND VGND VPWR VPWR _03588_ sky130_fd_sc_hd__nor2_1
XFILLER_0_134_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13190_ _04571_ _04579_ _04577_ VGND VGND VPWR VPWR _04660_ sky130_fd_sc_hd__a21o_1
X_12141_ _03512_ _03513_ VGND VGND VPWR VPWR _03514_ sky130_fd_sc_hd__xor2_2
X_12072_ _03423_ _03437_ VGND VGND VPWR VPWR _03439_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15900_ net481 net471 net650 net641 VGND VGND VPWR VPWR _07613_ sky130_fd_sc_hd__and4_1
X_11023_ _02290_ _02295_ VGND VGND VPWR VPWR _02297_ sky130_fd_sc_hd__nand2_1
X_15831_ _07534_ net123 _07536_ _07537_ VGND VGND VPWR VPWR _07538_ sky130_fd_sc_hd__o211a_1
X_12974_ net783 net275 _04347_ _04346_ VGND VGND VPWR VPWR _04424_ sky130_fd_sc_hd__a31o_1
X_15762_ _07403_ _07405_ _07462_ VGND VGND VPWR VPWR _07463_ sky130_fd_sc_hd__o21ai_1
X_14713_ _06217_ _06225_ VGND VGND VPWR VPWR _06320_ sky130_fd_sc_hd__or2b_1
XFILLER_0_86_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11925_ _03275_ net124 _03277_ _03278_ VGND VGND VPWR VPWR _03280_ sky130_fd_sc_hd__o211a_1
X_15693_ _07385_ _07386_ _07383_ _07384_ VGND VGND VPWR VPWR _07388_ sky130_fd_sc_hd__o211a_1
X_14644_ net488 net604 net708 net478 VGND VGND VPWR VPWR _06244_ sky130_fd_sc_hd__a22oi_1
X_11856_ _03202_ _03130_ _03200_ _03201_ VGND VGND VPWR VPWR _03205_ sky130_fd_sc_hd__a211o_1
XFILLER_0_74_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10807_ _01991_ _01993_ _01992_ VGND VGND VPWR VPWR _02071_ sky130_fd_sc_hd__o21ba_1
X_14575_ net523 net438 net683 net690 VGND VGND VPWR VPWR _06169_ sky130_fd_sc_hd__and4_1
X_11787_ _03128_ _03112_ _03113_ VGND VGND VPWR VPWR _03130_ sky130_fd_sc_hd__nand3_2
XFILLER_0_12_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16314_ clknet_4_9_0_clk _00103_ net341 VGND VGND VPWR VPWR b_cos\[7\] sky130_fd_sc_hd__dfrtp_1
X_13526_ _04936_ _04953_ VGND VGND VPWR VPWR _05026_ sky130_fd_sc_hd__nor2_1
XFILLER_0_103_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10738_ _01989_ _01990_ _02001_ VGND VGND VPWR VPWR _02002_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_43_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13457_ _04947_ _04950_ VGND VGND VPWR VPWR _04951_ sky130_fd_sc_hd__xor2_2
X_16245_ clknet_4_4_0_clk _00034_ net337 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dfrtp_1
X_10669_ _01930_ _01931_ _01929_ VGND VGND VPWR VPWR _01933_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_124_Right_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12408_ _03803_ VGND VGND VPWR VPWR _03804_ sky130_fd_sc_hd__inv_2
XFILLER_0_88_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13388_ _04871_ _04873_ _04874_ VGND VGND VPWR VPWR _04876_ sky130_fd_sc_hd__a21o_1
X_16176_ _07909_ _07911_ VGND VGND VPWR VPWR _07912_ sky130_fd_sc_hd__nand2_1
Xoutput106 net106 VGND VGND VPWR VPWR Q[17] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput117 net117 VGND VGND VPWR VPWR done sky130_fd_sc_hd__buf_2
X_12339_ net756 net190 net180 net765 VGND VGND VPWR VPWR _03728_ sky130_fd_sc_hd__a22o_1
X_15127_ _06768_ _06770_ _06771_ VGND VGND VPWR VPWR _06772_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15058_ _06605_ _06624_ _06625_ VGND VGND VPWR VPWR _06697_ sky130_fd_sc_hd__nand3_2
X_14009_ _05530_ _05550_ VGND VGND VPWR VPWR _05551_ sky130_fd_sc_hd__xnor2_1
X_09550_ _00847_ _00848_ _00861_ VGND VGND VPWR VPWR _00862_ sky130_fd_sc_hd__a21o_1
X_08501_ _06234_ _06245_ _06399_ VGND VGND VPWR VPWR _06475_ sky130_fd_sc_hd__a21o_1
X_09481_ _00664_ _00666_ VGND VGND VPWR VPWR _00794_ sky130_fd_sc_hd__or2_1
XFILLER_0_144_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08432_ _04654_ _05199_ _05709_ VGND VGND VPWR VPWR _05719_ sky130_fd_sc_hd__nor3_1
XFILLER_0_53_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08363_ _04687_ _04850_ _04839_ VGND VGND VPWR VPWR _04970_ sky130_fd_sc_hd__a21o_1
X_08294_ _04185_ _04207_ VGND VGND VPWR VPWR _04218_ sky130_fd_sc_hd__xor2_1
XFILLER_0_73_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout300 net301 VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__clkbuf_4
Xfanout311 net312 VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__clkbuf_4
Xfanout322 net323 VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__buf_2
Xfanout333 net334 VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__buf_2
Xfanout344 net345 VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__buf_4
Xfanout355 net57 VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__clkbuf_8
Xfanout366 net375 VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__clkbuf_4
X_09817_ _01123_ _01124_ VGND VGND VPWR VPWR _01125_ sky130_fd_sc_hd__nor2_1
Xfanout377 net386 VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__clkbuf_4
Xfanout388 net390 VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__buf_2
Xfanout399 net400 VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__buf_2
X_09748_ _01055_ _01056_ VGND VGND VPWR VPWR _01057_ sky130_fd_sc_hd__xnor2_1
X_09679_ net290 net281 net646 net656 VGND VGND VPWR VPWR _00989_ sky130_fd_sc_hd__and4_1
XFILLER_0_68_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11710_ _03045_ VGND VGND VPWR VPWR _03046_ sky130_fd_sc_hd__dlymetal6s2s_1
X_12690_ _04058_ _04066_ _04065_ VGND VGND VPWR VPWR _04114_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11641_ _02967_ _02968_ _02969_ VGND VGND VPWR VPWR _02971_ sky130_fd_sc_hd__a21o_1
XFILLER_0_83_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14360_ net354 net707 VGND VGND VPWR VPWR _05932_ sky130_fd_sc_hd__nand2_1
X_11572_ _02698_ _02797_ _02895_ VGND VGND VPWR VPWR _02896_ sky130_fd_sc_hd__o21ba_1
X_13311_ _04787_ _04790_ _04791_ VGND VGND VPWR VPWR _04792_ sky130_fd_sc_hd__and3_1
XFILLER_0_80_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput19 alpha[9] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_1
X_10523_ _01767_ _01766_ _01759_ VGND VGND VPWR VPWR _01787_ sky130_fd_sc_hd__a21o_1
X_14291_ net380 net605 net706 net369 VGND VGND VPWR VPWR _05856_ sky130_fd_sc_hd__a22o_1
XFILLER_0_150_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13242_ _04714_ _04715_ _04683_ _04602_ VGND VGND VPWR VPWR _04717_ sky130_fd_sc_hd__a211o_1
X_16030_ net464 net641 _07750_ _07752_ VGND VGND VPWR VPWR _07754_ sky130_fd_sc_hd__and4_1
XFILLER_0_33_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10454_ net363 net777 _01716_ _01717_ VGND VGND VPWR VPWR _01718_ sky130_fd_sc_hd__and4_1
XFILLER_0_122_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13173_ net763 net772 net267 net260 VGND VGND VPWR VPWR _04641_ sky130_fd_sc_hd__and4_1
XFILLER_0_0_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10385_ _01635_ _01634_ _01633_ VGND VGND VPWR VPWR _01649_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_20_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12124_ _03359_ _03433_ net492 _03358_ VGND VGND VPWR VPWR _03495_ sky130_fd_sc_hd__a2bb2o_2
X_12055_ _03400_ _03418_ VGND VGND VPWR VPWR _03421_ sky130_fd_sc_hd__nor2_1
XFILLER_0_74_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11006_ _02101_ _02182_ _02183_ VGND VGND VPWR VPWR _02280_ sky130_fd_sc_hd__nand3_1
X_15814_ _07516_ _07517_ net491 net641 VGND VGND VPWR VPWR _07519_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_87_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15745_ _07359_ _07361_ _07443_ VGND VGND VPWR VPWR _07445_ sky130_fd_sc_hd__a21o_1
XFILLER_0_59_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12957_ _04403_ _04405_ _04302_ _04304_ VGND VGND VPWR VPWR _04407_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_59_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11908_ _03258_ _03259_ net492 net152 VGND VGND VPWR VPWR _03261_ sky130_fd_sc_hd__and4bb_1
X_15676_ net376 net365 net623 VGND VGND VPWR VPWR _07370_ sky130_fd_sc_hd__o21a_1
X_12888_ net788 net259 VGND VGND VPWR VPWR _04331_ sky130_fd_sc_hd__nand2_1
XFILLER_0_114_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14627_ _06217_ _06225_ VGND VGND VPWR VPWR _06226_ sky130_fd_sc_hd__xnor2_2
X_11839_ _03177_ _03185_ VGND VGND VPWR VPWR _03186_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14558_ _06020_ _06148_ _06149_ VGND VGND VPWR VPWR _06150_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_28_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13509_ _04880_ _04910_ _05007_ VGND VGND VPWR VPWR _05008_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_70_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14489_ _05851_ _05858_ _05859_ VGND VGND VPWR VPWR _06074_ sky130_fd_sc_hd__nand3_2
X_16228_ clknet_4_1_0_clk _00017_ net332 VGND VGND VPWR VPWR b_sin\[17\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_141_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16159_ _07847_ _07893_ VGND VGND VPWR VPWR _07894_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_39_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08981_ _00214_ _00215_ _00298_ VGND VGND VPWR VPWR _00299_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_139_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09602_ _00911_ _00912_ VGND VGND VPWR VPWR _00913_ sky130_fd_sc_hd__nor2_1
XFILLER_0_64_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09533_ _00753_ _00754_ VGND VGND VPWR VPWR _00845_ sky130_fd_sc_hd__and2_1
XFILLER_0_149_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09464_ _00774_ _00776_ VGND VGND VPWR VPWR _00777_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08415_ _05383_ _05503_ _05514_ _05524_ VGND VGND VPWR VPWR _05535_ sky130_fd_sc_hd__a211o_2
X_09395_ net159 net657 net667 net305 VGND VGND VPWR VPWR _00709_ sky130_fd_sc_hd__a22o_1
X_08346_ net324 net540 net548 net240 VGND VGND VPWR VPWR _04785_ sky130_fd_sc_hd__a22o_1
XFILLER_0_80_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08277_ net881 _04009_ _03040_ _03398_ VGND VGND VPWR VPWR _04031_ sky130_fd_sc_hd__o211a_1
XFILLER_0_144_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10170_ a_cos\[13\] b_sin\[13\] VGND VGND VPWR VPWR _01460_ sky130_fd_sc_hd__and2_1
Xfanout141 net147 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__clkbuf_4
Xfanout152 net153 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__clkbuf_4
Xfanout163 net871 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__clkbuf_4
Xfanout174 net182 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__buf_2
Xfanout185 net186 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__buf_4
Xfanout196 net199 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__clkbuf_4
X_13860_ net148 net295 _05386_ _05388_ VGND VGND VPWR VPWR _05389_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_69_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12811_ _03832_ _03840_ VGND VGND VPWR VPWR _04247_ sky130_fd_sc_hd__or2b_1
X_13791_ _05297_ _05298_ _05312_ VGND VGND VPWR VPWR _05314_ sky130_fd_sc_hd__nand3_1
XFILLER_0_69_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15530_ net484 net688 net697 net474 VGND VGND VPWR VPWR _07211_ sky130_fd_sc_hd__a22oi_1
X_12742_ net790 net805 net215 net206 VGND VGND VPWR VPWR _04171_ sky130_fd_sc_hd__and4_1
XFILLER_0_38_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12673_ _04050_ _04049_ _04048_ VGND VGND VPWR VPWR _04095_ sky130_fd_sc_hd__o21ai_1
X_15461_ _07133_ _07135_ VGND VGND VPWR VPWR _07136_ sky130_fd_sc_hd__xor2_2
XFILLER_0_38_843 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14412_ _05940_ _05987_ _05988_ VGND VGND VPWR VPWR _05989_ sky130_fd_sc_hd__nand3_2
X_11624_ _02862_ _02873_ _02874_ _02951_ VGND VGND VPWR VPWR _02952_ sky130_fd_sc_hd__a31o_1
X_15392_ _06981_ _06996_ _06997_ _07001_ VGND VGND VPWR VPWR _07060_ sky130_fd_sc_hd__a31o_1
XFILLER_0_25_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14343_ _05874_ _05875_ _05868_ VGND VGND VPWR VPWR _05913_ sky130_fd_sc_hd__a21bo_1
X_11555_ _02775_ _02853_ _02875_ _02876_ VGND VGND VPWR VPWR _02878_ sky130_fd_sc_hd__a211o_1
XFILLER_0_135_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10506_ _01756_ _01768_ _01769_ VGND VGND VPWR VPWR _01770_ sky130_fd_sc_hd__and3_1
XFILLER_0_135_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14274_ _05835_ _05836_ VGND VGND VPWR VPWR _05837_ sky130_fd_sc_hd__nor2_1
XFILLER_0_52_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11486_ _02791_ _02788_ VGND VGND VPWR VPWR _02802_ sky130_fd_sc_hd__and2b_1
XFILLER_0_100_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13225_ net313 net195 VGND VGND VPWR VPWR _04699_ sky130_fd_sc_hd__nand2_1
X_16013_ _07663_ _07666_ _07664_ VGND VGND VPWR VPWR _07735_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_123_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10437_ _01698_ _01699_ _01700_ VGND VGND VPWR VPWR _01701_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13156_ _04621_ _04623_ VGND VGND VPWR VPWR _04624_ sky130_fd_sc_hd__nor2_1
X_10368_ _01629_ _01630_ _01631_ VGND VGND VPWR VPWR _01632_ sky130_fd_sc_hd__or3_1
X_12107_ _03402_ _03407_ VGND VGND VPWR VPWR _03477_ sky130_fd_sc_hd__and2b_1
X_13087_ net754 net282 VGND VGND VPWR VPWR _04548_ sky130_fd_sc_hd__and2_1
X_10299_ _01558_ _01562_ _01566_ VGND VGND VPWR VPWR _01570_ sky130_fd_sc_hd__o21a_1
XFILLER_0_109_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12038_ _03350_ _03353_ _03351_ VGND VGND VPWR VPWR _03402_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_88_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13989_ _05479_ _05496_ VGND VGND VPWR VPWR _05529_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15728_ _07426_ VGND VGND VPWR VPWR _00106_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15659_ net467 net687 VGND VGND VPWR VPWR _07351_ sky130_fd_sc_hd__nand2_1
XFILLER_0_146_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08200_ _03160_ _03105_ VGND VGND VPWR VPWR _03192_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_118_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09180_ _00396_ _00401_ VGND VGND VPWR VPWR _00496_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08131_ _02408_ _02419_ _02397_ VGND VGND VPWR VPWR _02441_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_141_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08964_ _00181_ _00183_ _00281_ _00282_ VGND VGND VPWR VPWR _00283_ sky130_fd_sc_hd__a211o_1
X_08895_ _00199_ _00213_ VGND VGND VPWR VPWR _00214_ sky130_fd_sc_hd__xnor2_2
X_09516_ _00813_ _00811_ VGND VGND VPWR VPWR _00828_ sky130_fd_sc_hd__and2b_1
XFILLER_0_38_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09447_ _00534_ _00681_ _00682_ VGND VGND VPWR VPWR _00760_ sky130_fd_sc_hd__and3_1
XFILLER_0_136_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09378_ net166 net647 _00689_ _00690_ VGND VGND VPWR VPWR _00692_ sky130_fd_sc_hd__nand4_2
XFILLER_0_47_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08329_ _04295_ _04306_ VGND VGND VPWR VPWR _04600_ sky130_fd_sc_hd__and2b_1
XFILLER_0_145_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11340_ _02536_ _02538_ _02537_ VGND VGND VPWR VPWR _02643_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_104_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11271_ net317 net390 VGND VGND VPWR VPWR _02568_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13010_ _04462_ _04463_ VGND VGND VPWR VPWR _04464_ sky130_fd_sc_hd__or2_1
X_10222_ _01502_ _01503_ VGND VGND VPWR VPWR _01504_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10153_ _01444_ _01445_ VGND VGND VPWR VPWR _01446_ sky130_fd_sc_hd__xnor2_1
X_14961_ _06570_ _06589_ _06590_ VGND VGND VPWR VPWR _06591_ sky130_fd_sc_hd__and3_1
X_10084_ net79 _01386_ net137 VGND VGND VPWR VPWR _01387_ sky130_fd_sc_hd__mux2_1
X_13912_ _05445_ VGND VGND VPWR VPWR _00089_ sky130_fd_sc_hd__clkbuf_1
X_14892_ _06513_ _06514_ _06515_ VGND VGND VPWR VPWR _06516_ sky130_fd_sc_hd__nand3_1
X_13843_ _05370_ VGND VGND VPWR VPWR _00088_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_97_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13774_ _05219_ _05227_ VGND VGND VPWR VPWR _05295_ sky130_fd_sc_hd__and2_1
XFILLER_0_69_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10986_ _02254_ _02255_ _02257_ VGND VGND VPWR VPWR _02258_ sky130_fd_sc_hd__nand3_2
X_15513_ net387 net634 _07108_ _07191_ VGND VGND VPWR VPWR _07192_ sky130_fd_sc_hd__a31o_1
X_12725_ _04134_ _04135_ _04150_ VGND VGND VPWR VPWR _04153_ sky130_fd_sc_hd__and3_1
XFILLER_0_57_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15444_ _07016_ _07018_ _07017_ VGND VGND VPWR VPWR _07117_ sky130_fd_sc_hd__a21bo_1
X_12656_ _04074_ _04069_ _04076_ VGND VGND VPWR VPWR _04077_ sky130_fd_sc_hd__nor3_1
XFILLER_0_26_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11607_ _02770_ _02857_ _02858_ _02773_ VGND VGND VPWR VPWR _02934_ sky130_fd_sc_hd__a31o_1
XFILLER_0_5_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12587_ _03999_ _03993_ _03994_ VGND VGND VPWR VPWR _04001_ sky130_fd_sc_hd__nand3_1
X_15375_ _06882_ _06935_ _07041_ VGND VGND VPWR VPWR _07043_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_20_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_879 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14326_ _05855_ _05853_ _05856_ VGND VGND VPWR VPWR _05895_ sky130_fd_sc_hd__and3_1
XFILLER_0_80_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11538_ _02857_ _02858_ _02770_ VGND VGND VPWR VPWR _02859_ sky130_fd_sc_hd__a21o_1
XFILLER_0_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap127 _04077_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__buf_1
X_14257_ _05815_ _05817_ _05818_ VGND VGND VPWR VPWR _05819_ sky130_fd_sc_hd__or3_1
X_11469_ _02751_ _02783_ VGND VGND VPWR VPWR _02784_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_123_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13208_ _04659_ _04678_ _04679_ VGND VGND VPWR VPWR _04680_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14188_ net226 net247 _05744_ VGND VGND VPWR VPWR _05745_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_110_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13139_ _04602_ _04603_ _04495_ _04570_ VGND VGND VPWR VPWR _04605_ sky130_fd_sc_hd__o211a_1
X_08680_ _07989_ _07990_ _03734_ _03998_ VGND VGND VPWR VPWR _07992_ sky130_fd_sc_hd__a211o_1
XFILLER_0_45_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09301_ net194 net630 _00613_ _00614_ VGND VGND VPWR VPWR _00616_ sky130_fd_sc_hd__nand4_1
XFILLER_0_75_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09232_ _00454_ _00455_ VGND VGND VPWR VPWR _00548_ sky130_fd_sc_hd__nor2_1
XFILLER_0_61_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09163_ _00477_ _00473_ _00478_ VGND VGND VPWR VPWR _00479_ sky130_fd_sc_hd__o21a_1
XFILLER_0_134_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_870 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08114_ net224 net540 VGND VGND VPWR VPWR _02256_ sky130_fd_sc_hd__nand2_1
X_09094_ _00395_ _00410_ VGND VGND VPWR VPWR _00411_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_4_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09996_ _01287_ _01285_ VGND VGND VPWR VPWR _01301_ sky130_fd_sc_hd__and2b_1
XFILLER_0_110_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08947_ _00157_ _00165_ _00164_ VGND VGND VPWR VPWR _00266_ sky130_fd_sc_hd__a21bo_1
X_08878_ _08012_ _00118_ VGND VGND VPWR VPWR _00197_ sky130_fd_sc_hd__nor2_1
X_10840_ _02026_ _02031_ _02098_ _02099_ VGND VGND VPWR VPWR _02104_ sky130_fd_sc_hd__or4bb_1
XFILLER_0_79_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10771_ _01972_ _01973_ _01982_ VGND VGND VPWR VPWR _02035_ sky130_fd_sc_hd__nand3_1
XFILLER_0_94_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12510_ _03705_ _03698_ _03704_ VGND VGND VPWR VPWR _03916_ sky130_fd_sc_hd__a21o_1
X_13490_ _04893_ _04898_ _04899_ _04892_ VGND VGND VPWR VPWR _04987_ sky130_fd_sc_hd__a31o_1
XFILLER_0_66_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12441_ _03834_ _03839_ VGND VGND VPWR VPWR _03840_ sky130_fd_sc_hd__xnor2_2
X_12372_ net738 net747 net187 net177 VGND VGND VPWR VPWR _03764_ sky130_fd_sc_hd__and4_1
X_15160_ _06800_ _06806_ _06807_ VGND VGND VPWR VPWR _06808_ sky130_fd_sc_hd__nand3_1
XFILLER_0_22_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14111_ _05660_ VGND VGND VPWR VPWR _05661_ sky130_fd_sc_hd__clkbuf_2
X_11323_ _02621_ _02623_ VGND VGND VPWR VPWR _02624_ sky130_fd_sc_hd__xor2_2
XFILLER_0_133_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
X_15091_ _06696_ _06731_ _06732_ VGND VGND VPWR VPWR _06733_ sky130_fd_sc_hd__or3_4
X_14042_ _05527_ _05586_ VGND VGND VPWR VPWR _05587_ sky130_fd_sc_hd__xnor2_2
X_11254_ _02529_ _02547_ _02548_ VGND VGND VPWR VPWR _02549_ sky130_fd_sc_hd__and3_1
X_10205_ _01485_ _01487_ _01484_ VGND VGND VPWR VPWR _01490_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_120_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11185_ _02437_ _02472_ _02473_ VGND VGND VPWR VPWR _02475_ sky130_fd_sc_hd__or3_4
X_10136_ a_cos\[8\] b_sin\[8\] VGND VGND VPWR VPWR _01431_ sky130_fd_sc_hd__nand2_1
X_15993_ _07711_ _07713_ VGND VGND VPWR VPWR _07714_ sky130_fd_sc_hd__xnor2_1
X_10067_ _01211_ _01327_ _01203_ VGND VGND VPWR VPWR _01371_ sky130_fd_sc_hd__o21a_1
X_14944_ net487 net476 net574 VGND VGND VPWR VPWR _06572_ sky130_fd_sc_hd__and3_1
XFILLER_0_89_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14875_ net360 net541 _06495_ _06496_ VGND VGND VPWR VPWR _06498_ sky130_fd_sc_hd__a22o_1
XFILLER_0_15_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13826_ _05333_ _05352_ VGND VGND VPWR VPWR _05353_ sky130_fd_sc_hd__xor2_1
XFILLER_0_147_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13757_ _05251_ _05252_ _05277_ VGND VGND VPWR VPWR _05278_ sky130_fd_sc_hd__o21a_1
X_10969_ _02229_ _02238_ VGND VGND VPWR VPWR _02239_ sky130_fd_sc_hd__xor2_1
X_12708_ _04102_ _04093_ _04101_ VGND VGND VPWR VPWR _04134_ sky130_fd_sc_hd__nand3_1
XFILLER_0_128_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13688_ _04824_ _05198_ _05201_ _05202_ VGND VGND VPWR VPWR _05203_ sky130_fd_sc_hd__o211a_4
X_15427_ _07095_ _07097_ _07088_ VGND VGND VPWR VPWR _07099_ sky130_fd_sc_hd__a21o_1
X_12639_ _04055_ _04056_ _04057_ VGND VGND VPWR VPWR _04058_ sky130_fd_sc_hd__and3_2
XFILLER_0_127_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15358_ _07022_ _07019_ _07021_ VGND VGND VPWR VPWR _07024_ sky130_fd_sc_hd__nand3_1
XFILLER_0_14_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14309_ _05868_ _05874_ _05875_ VGND VGND VPWR VPWR _05876_ sky130_fd_sc_hd__nand3_1
XFILLER_0_40_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15289_ _02170_ VGND VGND VPWR VPWR _06949_ sky130_fd_sc_hd__buf_4
XFILLER_0_1_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09850_ _01074_ _01156_ VGND VGND VPWR VPWR _01158_ sky130_fd_sc_hd__or2_1
Xfanout707 net20 VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__buf_2
Xfanout718 net726 VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__buf_4
Xfanout729 net730 VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__clkbuf_4
X_08801_ _08042_ _08049_ _08048_ VGND VGND VPWR VPWR _00121_ sky130_fd_sc_hd__a21o_1
X_09781_ _01084_ _01089_ VGND VGND VPWR VPWR _01090_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_56_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08732_ _07967_ _07969_ _07968_ VGND VGND VPWR VPWR _08043_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_147_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08663_ _07972_ _07973_ _07974_ VGND VGND VPWR VPWR _07975_ sky130_fd_sc_hd__or3_1
XFILLER_0_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08594_ net241 net325 VGND VGND VPWR VPWR _07488_ sky130_fd_sc_hd__and2_4
XFILLER_0_72_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_138_Right_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09215_ _00523_ _00529_ _00530_ VGND VGND VPWR VPWR _00531_ sky130_fd_sc_hd__and3_1
X_09146_ _00412_ _00462_ VGND VGND VPWR VPWR _00463_ sky130_fd_sc_hd__xor2_2
XFILLER_0_44_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09077_ _00315_ _00316_ _00393_ VGND VGND VPWR VPWR _00394_ sky130_fd_sc_hd__a21o_1
XFILLER_0_20_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09979_ _01283_ _01284_ VGND VGND VPWR VPWR _01285_ sky130_fd_sc_hd__nor2_1
XFILLER_0_99_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12990_ _04368_ _04376_ _04375_ VGND VGND VPWR VPWR _04442_ sky130_fd_sc_hd__a21o_1
XFILLER_0_98_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11941_ _03209_ _03215_ VGND VGND VPWR VPWR _03297_ sky130_fd_sc_hd__and2b_1
X_14660_ _06252_ _06260_ _06261_ VGND VGND VPWR VPWR _06262_ sky130_fd_sc_hd__nand3_2
X_11872_ net731 _02387_ VGND VGND VPWR VPWR _03222_ sky130_fd_sc_hd__or2_1
XFILLER_0_79_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13611_ net508 net288 net279 net609 VGND VGND VPWR VPWR _05118_ sky130_fd_sc_hd__a22oi_2
X_10823_ _02067_ _02068_ _02085_ _02086_ VGND VGND VPWR VPWR _02087_ sky130_fd_sc_hd__o211ai_4
X_14591_ _06185_ _06017_ VGND VGND VPWR VPWR _06186_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_105_Right_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13542_ _04944_ _04946_ _05042_ VGND VGND VPWR VPWR _05043_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_94_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10754_ _02015_ _02016_ _01923_ _01926_ VGND VGND VPWR VPWR _02018_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_54_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16261_ clknet_4_4_0_clk _00050_ net335 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dfrtp_1
X_13473_ _04964_ _04965_ _04966_ VGND VGND VPWR VPWR _04968_ sky130_fd_sc_hd__nand3_1
X_10685_ net383 net372 net751 net761 VGND VGND VPWR VPWR _01949_ sky130_fd_sc_hd__and4_1
X_15212_ _06761_ _06782_ _06779_ VGND VGND VPWR VPWR _06864_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_109_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12424_ _03818_ _03819_ _03814_ VGND VGND VPWR VPWR _03821_ sky130_fd_sc_hd__a21o_1
X_16192_ _07925_ _07928_ VGND VGND VPWR VPWR _07929_ sky130_fd_sc_hd__xor2_1
XFILLER_0_23_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15143_ net357 net690 _06787_ _06788_ VGND VGND VPWR VPWR _06789_ sky130_fd_sc_hd__a22o_1
XFILLER_0_22_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12355_ net425 net329 net238 net510 VGND VGND VPWR VPWR _03746_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_23_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11306_ _02504_ _02595_ _02593_ VGND VGND VPWR VPWR _02606_ sky130_fd_sc_hd__a21bo_1
X_15074_ _06612_ _06613_ _06614_ VGND VGND VPWR VPWR _06714_ sky130_fd_sc_hd__nor3_1
X_12286_ _03666_ _03670_ VGND VGND VPWR VPWR _03671_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_31_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14025_ _05476_ _05566_ VGND VGND VPWR VPWR _05569_ sky130_fd_sc_hd__or2_1
X_11237_ net741 net750 net487 VGND VGND VPWR VPWR _02531_ sky130_fd_sc_hd__and3_1
X_11168_ _02348_ _02349_ _02350_ VGND VGND VPWR VPWR _02456_ sky130_fd_sc_hd__nor3_1
X_10119_ net93 _01416_ net138 VGND VGND VPWR VPWR _01417_ sky130_fd_sc_hd__mux2_1
X_15976_ _07690_ _07695_ VGND VGND VPWR VPWR _07696_ sky130_fd_sc_hd__xor2_1
X_11099_ _02275_ _02380_ VGND VGND VPWR VPWR _02381_ sky130_fd_sc_hd__xor2_1
X_14927_ _06466_ _06531_ _06532_ VGND VGND VPWR VPWR _06554_ sky130_fd_sc_hd__nand3_1
XFILLER_0_117_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14858_ _06476_ _06477_ _06478_ VGND VGND VPWR VPWR _06479_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_11_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13809_ _05229_ _05232_ VGND VGND VPWR VPWR _05334_ sky130_fd_sc_hd__nand2_1
XFILLER_0_147_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14789_ _06402_ _06403_ VGND VGND VPWR VPWR _06404_ sky130_fd_sc_hd__and2b_1
XFILLER_0_42_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09000_ _00303_ _00317_ VGND VGND VPWR VPWR _00318_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_73_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_20_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09902_ _01207_ _01208_ VGND VGND VPWR VPWR _01209_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout504 net506 VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__clkbuf_4
Xfanout515 net4 VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_67_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout526 net528 VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__clkbuf_4
X_09833_ _01122_ _01140_ VGND VGND VPWR VPWR _01141_ sky130_fd_sc_hd__xnor2_1
Xfanout537 net538 VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__buf_2
Xfanout548 net870 VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__buf_4
XFILLER_0_67_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout559 net561 VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__clkbuf_4
X_09764_ _00534_ _00681_ _01008_ VGND VGND VPWR VPWR _01073_ sky130_fd_sc_hd__or3_2
X_08715_ net160 net544 net553 net867 VGND VGND VPWR VPWR _08026_ sky130_fd_sc_hd__a22o_1
X_09695_ _00984_ _00985_ _01003_ VGND VGND VPWR VPWR _01005_ sky130_fd_sc_hd__or3_1
Xrebuffer20 _04738_ VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__buf_6
Xrebuffer31 _02366_ VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__clkbuf_1
Xrebuffer42 _02811_ VGND VGND VPWR VPWR net880 sky130_fd_sc_hd__dlymetal6s2s_1
X_08646_ _03518_ _03539_ _03528_ VGND VGND VPWR VPWR _07958_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_95_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08577_ net873 _06976_ _06944_ _06965_ VGND VGND VPWR VPWR _07303_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_37_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10470_ _01732_ _01733_ VGND VGND VPWR VPWR _01734_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09129_ _00442_ _00443_ _00444_ VGND VGND VPWR VPWR _00446_ sky130_fd_sc_hd__nand3_1
XFILLER_0_114_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12140_ _03448_ _03452_ _03449_ VGND VGND VPWR VPWR _03513_ sky130_fd_sc_hd__o21ba_1
X_12071_ _03423_ _03437_ VGND VGND VPWR VPWR _03438_ sky130_fd_sc_hd__and2_1
XFILLER_0_130_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11022_ _02290_ _02295_ VGND VGND VPWR VPWR _02296_ sky130_fd_sc_hd__or2_1
X_15830_ _07456_ _07445_ _07446_ VGND VGND VPWR VPWR _07537_ sky130_fd_sc_hd__nand3_1
X_15761_ _07406_ _07407_ VGND VGND VPWR VPWR _07462_ sky130_fd_sc_hd__or2_1
X_12973_ _04241_ _04410_ _04411_ VGND VGND VPWR VPWR _04423_ sky130_fd_sc_hd__nand3_1
X_14712_ _06218_ _06224_ VGND VGND VPWR VPWR _06319_ sky130_fd_sc_hd__or2b_1
X_11924_ _03199_ _03188_ _03189_ VGND VGND VPWR VPWR _03278_ sky130_fd_sc_hd__nand3_1
X_15692_ _07383_ _07384_ _07385_ _07386_ VGND VGND VPWR VPWR _07387_ sky130_fd_sc_hd__a211oi_1
X_14643_ net488 net478 net604 net708 VGND VGND VPWR VPWR _06243_ sky130_fd_sc_hd__and4_1
X_11855_ _03200_ _03201_ _03202_ _03130_ VGND VGND VPWR VPWR _03204_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_68_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10806_ _01974_ _01981_ VGND VGND VPWR VPWR _02070_ sky130_fd_sc_hd__or2b_1
X_14574_ net420 net700 VGND VGND VPWR VPWR _06167_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11786_ _03112_ _03113_ _03128_ VGND VGND VPWR VPWR _03129_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16313_ clknet_4_9_0_clk _00102_ net341 VGND VGND VPWR VPWR b_cos\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_138_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13525_ _04930_ _05015_ VGND VGND VPWR VPWR _05025_ sky130_fd_sc_hd__nor2_1
X_10737_ _01997_ _02000_ VGND VGND VPWR VPWR _02001_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16244_ clknet_4_7_0_clk _00033_ net337 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dfrtp_1
X_13456_ _04848_ _04851_ _04949_ VGND VGND VPWR VPWR _04950_ sky130_fd_sc_hd__a21o_1
XFILLER_0_113_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10668_ _01929_ _01930_ _01931_ VGND VGND VPWR VPWR _01932_ sky130_fd_sc_hd__or3_1
X_12407_ _03801_ _03802_ VGND VGND VPWR VPWR _03803_ sky130_fd_sc_hd__or2_1
XFILLER_0_51_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16175_ _07892_ _07890_ VGND VGND VPWR VPWR _07911_ sky130_fd_sc_hd__or2b_1
XFILLER_0_112_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13387_ _04871_ _04873_ _04874_ VGND VGND VPWR VPWR _04875_ sky130_fd_sc_hd__and3_1
X_10599_ _01860_ _01862_ VGND VGND VPWR VPWR _01863_ sky130_fd_sc_hd__or2b_1
Xoutput107 net107 VGND VGND VPWR VPWR Q[18] sky130_fd_sc_hd__clkbuf_4
X_15126_ net494 net537 VGND VGND VPWR VPWR _06771_ sky130_fd_sc_hd__and2_1
X_12338_ net774 net171 VGND VGND VPWR VPWR _03727_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15057_ _06694_ _06695_ VGND VGND VPWR VPWR _06696_ sky130_fd_sc_hd__or2_1
X_12269_ _03549_ _03607_ VGND VGND VPWR VPWR _03652_ sky130_fd_sc_hd__nor2_1
X_14008_ _05548_ _05549_ VGND VGND VPWR VPWR _05550_ sky130_fd_sc_hd__nand2_1
XFILLER_0_128_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15959_ _07675_ _07676_ VGND VGND VPWR VPWR _07677_ sky130_fd_sc_hd__xnor2_1
X_08500_ _06432_ _06453_ VGND VGND VPWR VPWR _06464_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09480_ _00787_ _00792_ VGND VGND VPWR VPWR _00793_ sky130_fd_sc_hd__xnor2_1
X_08431_ _05654_ _05687_ _05177_ _05698_ VGND VGND VPWR VPWR _05709_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_59_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08362_ _04905_ _04948_ VGND VGND VPWR VPWR _04959_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_86_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08293_ _02605_ _04196_ VGND VGND VPWR VPWR _04207_ sky130_fd_sc_hd__and2b_1
XFILLER_0_128_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout301 net61 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__clkbuf_4
Xfanout312 net319 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__buf_4
Xfanout323 net59 VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__buf_6
Xfanout334 net58 VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__clkbuf_4
Xfanout345 net58 VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__clkbuf_4
Xfanout356 net364 VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__clkbuf_4
Xfanout367 net375 VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__buf_4
X_09816_ net262 net253 net656 net666 VGND VGND VPWR VPWR _01124_ sky130_fd_sc_hd__and4_1
Xfanout378 net386 VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__clkbuf_4
Xfanout389 net390 VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_94_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09747_ net248 net686 VGND VGND VPWR VPWR _01056_ sky130_fd_sc_hd__nand2_1
X_09678_ net290 net646 net656 net281 VGND VGND VPWR VPWR _00988_ sky130_fd_sc_hd__a22oi_2
X_08629_ _07845_ _07856_ VGND VGND VPWR VPWR _07867_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11640_ _02967_ _02968_ _02969_ VGND VGND VPWR VPWR _02970_ sky130_fd_sc_hd__nand3_2
XFILLER_0_65_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11571_ _02703_ _02700_ _02796_ VGND VGND VPWR VPWR _02895_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_135_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13310_ net509 net168 _04788_ _04789_ VGND VGND VPWR VPWR _04791_ sky130_fd_sc_hd__nand4_1
XFILLER_0_92_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10522_ _01767_ _01759_ _01766_ VGND VGND VPWR VPWR _01786_ sky130_fd_sc_hd__nand3_1
X_14290_ net706 _05854_ VGND VGND VPWR VPWR _05855_ sky130_fd_sc_hd__nand2_1
XFILLER_0_107_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13241_ _04683_ _04602_ _04714_ net821 VGND VGND VPWR VPWR _04716_ sky130_fd_sc_hd__o211ai_2
X_10453_ net383 net761 net770 net372 VGND VGND VPWR VPWR _01717_ sky130_fd_sc_hd__a22o_1
XFILLER_0_33_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13172_ net772 net260 VGND VGND VPWR VPWR _04640_ sky130_fd_sc_hd__nand2_1
X_10384_ _01635_ _01633_ _01634_ VGND VGND VPWR VPWR _01648_ sky130_fd_sc_hd__or3_1
XFILLER_0_103_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12123_ _03492_ _03493_ VGND VGND VPWR VPWR _03494_ sky130_fd_sc_hd__or2_1
X_12054_ _03400_ _03418_ VGND VGND VPWR VPWR _03419_ sky130_fd_sc_hd__and2_1
X_11005_ _02189_ _02277_ VGND VGND VPWR VPWR _02279_ sky130_fd_sc_hd__xor2_2
XFILLER_0_74_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15813_ net491 net641 _07516_ _07517_ VGND VGND VPWR VPWR _07518_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_99_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15744_ _07428_ _07442_ VGND VGND VPWR VPWR _07443_ sky130_fd_sc_hd__xor2_1
X_12956_ _04302_ _04304_ _04403_ _04405_ VGND VGND VPWR VPWR _04406_ sky130_fd_sc_hd__a211o_1
X_11907_ net492 net152 _03258_ _03259_ VGND VGND VPWR VPWR _03260_ sky130_fd_sc_hd__o2bb2a_1
X_15675_ net376 net365 net623 VGND VGND VPWR VPWR _07369_ sky130_fd_sc_hd__nand3_2
XFILLER_0_23_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12887_ net789 net268 net259 net807 VGND VGND VPWR VPWR _04330_ sky130_fd_sc_hd__a22o_1
XFILLER_0_142_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14626_ _06218_ _06224_ VGND VGND VPWR VPWR _06225_ sky130_fd_sc_hd__xnor2_2
X_11838_ _03183_ _03184_ VGND VGND VPWR VPWR _03185_ sky130_fd_sc_hd__xor2_1
XFILLER_0_68_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14557_ _06013_ _06019_ VGND VGND VPWR VPWR _06149_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11769_ _03093_ _03108_ _03109_ VGND VGND VPWR VPWR _03110_ sky130_fd_sc_hd__nand3_2
XFILLER_0_43_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13508_ _04906_ _04909_ VGND VGND VPWR VPWR _05007_ sky130_fd_sc_hd__nor2_1
X_14488_ _05851_ _05859_ _05858_ VGND VGND VPWR VPWR _06073_ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16227_ clknet_4_2_0_clk _00016_ net332 VGND VGND VPWR VPWR b_sin\[16\] sky130_fd_sc_hd__dfrtp_2
XFILLER_0_2_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13439_ _04857_ _04841_ VGND VGND VPWR VPWR _04931_ sky130_fd_sc_hd__and2b_1
XFILLER_0_125_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16158_ _07890_ _07892_ VGND VGND VPWR VPWR _07893_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_140_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15109_ _06544_ _06545_ _06547_ _06645_ _06752_ VGND VGND VPWR VPWR _06753_ sky130_fd_sc_hd__a41o_1
XFILLER_0_140_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08980_ _00199_ _00213_ VGND VGND VPWR VPWR _00298_ sky130_fd_sc_hd__nand2_1
X_16089_ _07729_ _07732_ _07730_ VGND VGND VPWR VPWR _07818_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_121_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09601_ net290 net281 net656 net666 VGND VGND VPWR VPWR _00912_ sky130_fd_sc_hd__and4_1
XFILLER_0_3_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09532_ _00842_ _00843_ VGND VGND VPWR VPWR _00844_ sky130_fd_sc_hd__and2_1
XFILLER_0_148_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09463_ _00685_ _00697_ _00775_ VGND VGND VPWR VPWR _00776_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_149_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08414_ _04861_ _04959_ _04970_ VGND VGND VPWR VPWR _05524_ sky130_fd_sc_hd__and3_1
X_09394_ _00706_ _00707_ VGND VGND VPWR VPWR _00708_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_65_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08345_ net224 net558 VGND VGND VPWR VPWR _04774_ sky130_fd_sc_hd__and2_1
XFILLER_0_47_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08276_ _03040_ _03398_ net881 _04009_ VGND VGND VPWR VPWR _04020_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_73_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout142 net147 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__clkbuf_2
Xfanout153 net155 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__clkbuf_4
Xfanout164 net77 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__buf_4
Xfanout175 net182 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__buf_4
Xfanout186 net192 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__clkbuf_4
Xfanout197 net199 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__clkbuf_4
X_12810_ _03834_ _03839_ VGND VGND VPWR VPWR _04246_ sky130_fd_sc_hd__or2b_1
X_13790_ _05297_ _05298_ _05312_ VGND VGND VPWR VPWR _05313_ sky130_fd_sc_hd__a21o_1
X_12741_ _04156_ _04169_ VGND VGND VPWR VPWR _04170_ sky130_fd_sc_hd__xor2_1
X_15460_ _07003_ _07035_ _07134_ VGND VGND VPWR VPWR _07135_ sky130_fd_sc_hd__a21oi_2
X_12672_ _04050_ _04048_ _04049_ VGND VGND VPWR VPWR _04094_ sky130_fd_sc_hd__or3_1
XFILLER_0_127_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14411_ _05986_ _05985_ _05941_ _05930_ VGND VGND VPWR VPWR _05988_ sky130_fd_sc_hd__a211o_1
X_11623_ _02859_ _02860_ _02861_ VGND VGND VPWR VPWR _02951_ sky130_fd_sc_hd__and3_1
XFILLER_0_38_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15391_ _06974_ _06975_ _07058_ VGND VGND VPWR VPWR _07059_ sky130_fd_sc_hd__a21o_1
XFILLER_0_25_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14342_ _05905_ _05910_ _05911_ VGND VGND VPWR VPWR _05912_ sky130_fd_sc_hd__nand3_1
X_11554_ _02862_ _02863_ _02873_ _02874_ VGND VGND VPWR VPWR _02876_ sky130_fd_sc_hd__and4_1
XFILLER_0_64_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10505_ _01655_ _01654_ _01647_ VGND VGND VPWR VPWR _01769_ sky130_fd_sc_hd__a21o_1
XFILLER_0_150_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14273_ net408 net398 net586 net595 VGND VGND VPWR VPWR _05836_ sky130_fd_sc_hd__and4_1
XFILLER_0_107_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11485_ _02793_ _02795_ VGND VGND VPWR VPWR _02801_ sky130_fd_sc_hd__nor2_1
X_16012_ _07728_ _07733_ VGND VGND VPWR VPWR _07734_ sky130_fd_sc_hd__xnor2_2
X_13224_ net200 _04695_ _04696_ VGND VGND VPWR VPWR _04697_ sky130_fd_sc_hd__a21bo_1
X_10436_ net524 net616 net716 net439 VGND VGND VPWR VPWR _01700_ sky130_fd_sc_hd__a22o_1
XFILLER_0_150_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13155_ _04619_ _04620_ _04519_ VGND VGND VPWR VPWR _04623_ sky130_fd_sc_hd__a21oi_1
X_10367_ net524 net725 net734 net439 VGND VGND VPWR VPWR _01631_ sky130_fd_sc_hd__a22oi_2
X_12106_ _03473_ _03475_ VGND VGND VPWR VPWR _03476_ sky130_fd_sc_hd__xor2_1
X_13086_ _04466_ _04474_ _04473_ VGND VGND VPWR VPWR _04547_ sky130_fd_sc_hd__a21o_1
X_10298_ net135 _01567_ _01568_ _01569_ VGND VGND VPWR VPWR _00050_ sky130_fd_sc_hd__a31o_1
XFILLER_0_18_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12037_ _03348_ _03367_ _03364_ VGND VGND VPWR VPWR _03401_ sky130_fd_sc_hd__a21o_1
X_13988_ _05461_ _05464_ _05468_ VGND VGND VPWR VPWR _05528_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_87_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15727_ b_cos\[10\] _07425_ _06949_ VGND VGND VPWR VPWR _07426_ sky130_fd_sc_hd__mux2_1
XFILLER_0_34_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12939_ net150 net322 net238 net230 VGND VGND VPWR VPWR _04387_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_88_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15658_ _07348_ _07349_ VGND VGND VPWR VPWR _07350_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14609_ _06203_ _06204_ _06198_ VGND VGND VPWR VPWR _06206_ sky130_fd_sc_hd__a21o_1
XFILLER_0_141_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15589_ net484 net681 net687 net474 VGND VGND VPWR VPWR _07275_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_56_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08130_ _02397_ _02408_ _02419_ VGND VGND VPWR VPWR _02430_ sky130_fd_sc_hd__or3_4
XFILLER_0_114_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08963_ _00279_ _00280_ _00117_ _00197_ VGND VGND VPWR VPWR _00282_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08894_ _00211_ _00212_ VGND VGND VPWR VPWR _00213_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_3_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09515_ _00826_ _00824_ VGND VGND VPWR VPWR _00827_ sky130_fd_sc_hd__nor2_1
XFILLER_0_79_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09446_ _00714_ _00716_ _00757_ VGND VGND VPWR VPWR _00759_ sky130_fd_sc_hd__nand3_1
XFILLER_0_137_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09377_ net166 net646 _00689_ _00690_ VGND VGND VPWR VPWR _00691_ sky130_fd_sc_hd__a22o_1
XFILLER_0_148_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08328_ _03398_ _04567_ _04578_ VGND VGND VPWR VPWR _04589_ sky130_fd_sc_hd__nand3_1
XFILLER_0_62_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08259_ net160 net562 net572 net307 VGND VGND VPWR VPWR _03833_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_50_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11270_ net396 _02565_ _02566_ VGND VGND VPWR VPWR _02567_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_61_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10221_ b_cos\[2\] a_sin\[2\] VGND VGND VPWR VPWR _01503_ sky130_fd_sc_hd__xnor2_1
X_10152_ _01436_ _01439_ _01437_ VGND VGND VPWR VPWR _01445_ sky130_fd_sc_hd__a21boi_1
X_14960_ _06587_ _06588_ _06571_ VGND VGND VPWR VPWR _06590_ sky130_fd_sc_hd__a21o_1
X_10083_ a_cos\[0\] b_sin\[0\] VGND VGND VPWR VPWR _01386_ sky130_fd_sc_hd__xor2_1
X_13911_ a_sin\[12\] _05444_ _05291_ VGND VGND VPWR VPWR _05445_ sky130_fd_sc_hd__mux2_1
X_14891_ _06412_ _06414_ _06413_ VGND VGND VPWR VPWR _06515_ sky130_fd_sc_hd__o21bai_1
X_13842_ a_sin\[11\] _05369_ _05291_ VGND VGND VPWR VPWR _05370_ sky130_fd_sc_hd__mux2_1
XFILLER_0_97_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13773_ _05226_ _05225_ VGND VGND VPWR VPWR _05294_ sky130_fd_sc_hd__and2b_1
X_10985_ _02145_ _02153_ _02152_ VGND VGND VPWR VPWR _02257_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_85_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15512_ net404 net394 net625 VGND VGND VPWR VPWR _07191_ sky130_fd_sc_hd__and3_1
X_12724_ _04134_ _04135_ _04150_ VGND VGND VPWR VPWR _04151_ sky130_fd_sc_hd__nand3_1
XFILLER_0_29_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15443_ _07007_ _07010_ VGND VGND VPWR VPWR _07116_ sky130_fd_sc_hd__nand2_1
X_12655_ _04017_ _04068_ _04058_ _04067_ VGND VGND VPWR VPWR _04076_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_84_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11606_ _02770_ _02929_ _02930_ VGND VGND VPWR VPWR _02933_ sky130_fd_sc_hd__nand3_1
X_15374_ _06932_ _06934_ VGND VGND VPWR VPWR _07041_ sky130_fd_sc_hd__and2b_1
X_12586_ _03993_ _03994_ _03999_ VGND VGND VPWR VPWR _04000_ sky130_fd_sc_hd__a21o_1
XFILLER_0_65_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14325_ _05890_ _05891_ _05852_ _05861_ VGND VGND VPWR VPWR _05894_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_111_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11537_ net389 net869 _02854_ _02856_ VGND VGND VPWR VPWR _02858_ sky130_fd_sc_hd__nand4_1
X_14256_ net520 net550 net560 net436 VGND VGND VPWR VPWR _05818_ sky130_fd_sc_hd__a22oi_2
Xmax_cap128 _02413_ VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__buf_1
X_11468_ _02778_ _02782_ VGND VGND VPWR VPWR _02783_ sky130_fd_sc_hd__xor2_2
XFILLER_0_111_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13207_ _04675_ _04677_ _04660_ VGND VGND VPWR VPWR _04679_ sky130_fd_sc_hd__a21o_1
X_10419_ net383 net770 net777 net374 VGND VGND VPWR VPWR _01683_ sky130_fd_sc_hd__a22oi_2
X_14187_ _05683_ _05742_ _05743_ VGND VGND VPWR VPWR _05744_ sky130_fd_sc_hd__o21a_1
X_11399_ _02624_ _02625_ _02706_ VGND VGND VPWR VPWR _02707_ sky130_fd_sc_hd__a21o_1
X_13138_ _04495_ _04570_ _04602_ _04603_ VGND VGND VPWR VPWR _04604_ sky130_fd_sc_hd__a211oi_4
X_13069_ net772 net275 VGND VGND VPWR VPWR _04528_ sky130_fd_sc_hd__nand2_1
XFILLER_0_136_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_119_Right_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09300_ net194 net630 _00613_ _00614_ VGND VGND VPWR VPWR _00615_ sky130_fd_sc_hd__a22o_1
XFILLER_0_48_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09231_ _00454_ _00455_ VGND VGND VPWR VPWR _00547_ sky130_fd_sc_hd__nand2_1
XFILLER_0_61_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09162_ _00383_ _00467_ VGND VGND VPWR VPWR _00478_ sky130_fd_sc_hd__nand2_1
X_08113_ _02212_ _02223_ _02201_ VGND VGND VPWR VPWR _02245_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_43_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09093_ _00407_ _00409_ VGND VGND VPWR VPWR _00410_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_44_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_880 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_872 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09995_ _01299_ VGND VGND VPWR VPWR _01300_ sky130_fd_sc_hd__inv_2
X_08946_ _00262_ _00263_ _00255_ VGND VGND VPWR VPWR _00265_ sky130_fd_sc_hd__a21o_1
XFILLER_0_86_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08877_ _00195_ net702 VGND VGND VPWR VPWR _00196_ sky130_fd_sc_hd__nor2_1
XFILLER_0_98_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10770_ _01943_ _01955_ _01983_ _01984_ VGND VGND VPWR VPWR _02034_ sky130_fd_sc_hd__a211o_1
XFILLER_0_67_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09429_ _00660_ _00677_ _00741_ VGND VGND VPWR VPWR _00742_ sky130_fd_sc_hd__a21o_1
XFILLER_0_137_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12440_ _03835_ _03838_ VGND VGND VPWR VPWR _03839_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_57_Left_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12371_ net756 net171 VGND VGND VPWR VPWR _03763_ sky130_fd_sc_hd__nand2_1
XFILLER_0_133_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14110_ _05621_ net797 _01244_ VGND VGND VPWR VPWR _05660_ sky130_fd_sc_hd__and3b_1
XFILLER_0_62_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11322_ _02515_ _02516_ _02622_ VGND VGND VPWR VPWR _02623_ sky130_fd_sc_hd__o21a_1
X_15090_ _06729_ _06730_ _06624_ _06697_ VGND VGND VPWR VPWR _06732_ sky130_fd_sc_hd__o211a_1
XFILLER_0_120_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14041_ _05584_ _05585_ VGND VGND VPWR VPWR _05586_ sky130_fd_sc_hd__xnor2_2
X_11253_ _02545_ _02546_ _02530_ VGND VGND VPWR VPWR _02548_ sky130_fd_sc_hd__a21o_1
X_10204_ _01489_ VGND VGND VPWR VPWR _00036_ sky130_fd_sc_hd__clkbuf_1
X_11184_ _02470_ _02471_ _02360_ _02438_ VGND VGND VPWR VPWR _02473_ sky130_fd_sc_hd__o211a_1
XFILLER_0_101_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_66_Left_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10135_ a_cos\[8\] b_sin\[8\] VGND VGND VPWR VPWR _01430_ sky130_fd_sc_hd__nor2_1
X_15992_ _07712_ _07602_ VGND VGND VPWR VPWR _07713_ sky130_fd_sc_hd__nor2_1
X_10066_ _01325_ _01331_ _01329_ VGND VGND VPWR VPWR _01370_ sky130_fd_sc_hd__a21bo_1
X_14943_ _06493_ _06501_ _06500_ VGND VGND VPWR VPWR _06571_ sky130_fd_sc_hd__a21o_1
XFILLER_0_82_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14874_ net382 net371 net699 net532 VGND VGND VPWR VPWR _06496_ sky130_fd_sc_hd__nand4_2
XFILLER_0_106_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13825_ _05334_ _05350_ VGND VGND VPWR VPWR _05352_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13756_ _05255_ _05276_ VGND VGND VPWR VPWR _05277_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10968_ _02236_ _02237_ VGND VGND VPWR VPWR _02238_ sky130_fd_sc_hd__and2b_1
XFILLER_0_128_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12707_ _04121_ _04122_ _04115_ _04120_ VGND VGND VPWR VPWR _04133_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_75_Left_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13687_ _04734_ _04825_ _04826_ _05198_ VGND VGND VPWR VPWR _05202_ sky130_fd_sc_hd__a211o_1
XFILLER_0_122_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10899_ _02128_ _02129_ _02162_ _02163_ VGND VGND VPWR VPWR _02164_ sky130_fd_sc_hd__nand4_4
XFILLER_0_31_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15426_ _07088_ _07095_ _07097_ VGND VGND VPWR VPWR _07098_ sky130_fd_sc_hd__nand3_1
XFILLER_0_127_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12638_ _04001_ _04000_ _03992_ VGND VGND VPWR VPWR _04057_ sky130_fd_sc_hd__a21o_1
XFILLER_0_115_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15357_ _07019_ _07021_ _07022_ VGND VGND VPWR VPWR _07023_ sky130_fd_sc_hd__a21o_1
X_12569_ _03925_ _03927_ _03926_ VGND VGND VPWR VPWR _03981_ sky130_fd_sc_hd__o21a_1
XFILLER_0_25_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14308_ _05865_ _05867_ _05866_ VGND VGND VPWR VPWR _05875_ sky130_fd_sc_hd__a21o_1
XFILLER_0_103_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15288_ _06941_ _06947_ VGND VGND VPWR VPWR _06948_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_124_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14239_ _05475_ _05731_ _05723_ VGND VGND VPWR VPWR _05800_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_84_Left_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout708 net20 VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__buf_2
Xfanout719 net726 VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__buf_2
X_08800_ _08032_ _08034_ VGND VGND VPWR VPWR _00120_ sky130_fd_sc_hd__nand2_1
X_09780_ _01085_ _01088_ VGND VGND VPWR VPWR _01089_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_147_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08731_ _07960_ _07962_ VGND VGND VPWR VPWR _08042_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08662_ net323 net648 net659 net239 VGND VGND VPWR VPWR _07974_ sky130_fd_sc_hd__a22oi_2
X_08593_ net221 net703 _07390_ _07401_ VGND VGND VPWR VPWR _07477_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_93_Left_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09214_ _00527_ _00528_ _00524_ VGND VGND VPWR VPWR _00530_ sky130_fd_sc_hd__a21o_1
XFILLER_0_118_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09145_ _00460_ _00461_ VGND VGND VPWR VPWR _00462_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_8_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09076_ _00312_ _00314_ VGND VGND VPWR VPWR _00393_ sky130_fd_sc_hd__nor2_1
XFILLER_0_114_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09978_ _01219_ _01282_ _01280_ _01281_ VGND VGND VPWR VPWR _01284_ sky130_fd_sc_hd__a211oi_2
X_08929_ _00245_ _00246_ _00242_ VGND VGND VPWR VPWR _00248_ sky130_fd_sc_hd__a21o_1
XFILLER_0_99_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11940_ _03294_ _03295_ VGND VGND VPWR VPWR _03296_ sky130_fd_sc_hd__xor2_1
X_11871_ _03218_ _03220_ VGND VGND VPWR VPWR _03221_ sky130_fd_sc_hd__xor2_1
XFILLER_0_67_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13610_ _05058_ _05066_ _05065_ VGND VGND VPWR VPWR _05117_ sky130_fd_sc_hd__o21bai_1
X_10822_ _02069_ _02070_ _02084_ VGND VGND VPWR VPWR _02086_ sky130_fd_sc_hd__nand3_2
XFILLER_0_79_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14590_ net380 net369 net569 net578 VGND VGND VPWR VPWR _06185_ sky130_fd_sc_hd__and4_1
XFILLER_0_67_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13541_ _04938_ _04943_ VGND VGND VPWR VPWR _05042_ sky130_fd_sc_hd__nand2_1
XFILLER_0_149_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10753_ _01923_ _01926_ _02015_ _02016_ VGND VGND VPWR VPWR _02017_ sky130_fd_sc_hd__o211a_1
XFILLER_0_82_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16260_ clknet_4_0_0_clk _00049_ net331 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dfrtp_1
X_13472_ _04964_ _04965_ _04966_ VGND VGND VPWR VPWR _04967_ sky130_fd_sc_hd__a21o_1
X_10684_ net363 net770 VGND VGND VPWR VPWR _01948_ sky130_fd_sc_hd__nand2_1
XFILLER_0_82_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15211_ _06838_ _06839_ _06862_ VGND VGND VPWR VPWR _06863_ sky130_fd_sc_hd__a21o_1
X_12423_ _03814_ _03818_ _03819_ VGND VGND VPWR VPWR _03820_ sky130_fd_sc_hd__nand3_1
X_16191_ _07926_ _07927_ VGND VGND VPWR VPWR _07928_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_106_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15142_ net377 net366 net673 net682 VGND VGND VPWR VPWR _06788_ sky130_fd_sc_hd__nand4_2
X_12354_ net425 net510 net322 net238 VGND VGND VPWR VPWR _03744_ sky130_fd_sc_hd__and4_1
XFILLER_0_121_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11305_ _02604_ VGND VGND VPWR VPWR _00062_ sky130_fd_sc_hd__clkbuf_1
X_15073_ _06709_ _06712_ VGND VGND VPWR VPWR _06713_ sky130_fd_sc_hd__xnor2_1
X_12285_ _03592_ _03668_ VGND VGND VPWR VPWR _03670_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_31_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14024_ _05476_ _05566_ VGND VGND VPWR VPWR _05567_ sky130_fd_sc_hd__nand2_1
X_11236_ _02439_ _02447_ _02446_ VGND VGND VPWR VPWR _02530_ sky130_fd_sc_hd__a21o_1
X_11167_ _02450_ _02454_ VGND VGND VPWR VPWR _02455_ sky130_fd_sc_hd__xnor2_1
X_10118_ _01414_ _01415_ VGND VGND VPWR VPWR _01416_ sky130_fd_sc_hd__xnor2_1
X_15975_ _07620_ _07691_ _07693_ VGND VGND VPWR VPWR _07695_ sky130_fd_sc_hd__a21oi_1
X_11098_ _02378_ _02379_ VGND VGND VPWR VPWR _02380_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10049_ _01305_ _01320_ _01322_ VGND VGND VPWR VPWR _01353_ sky130_fd_sc_hd__a21bo_1
X_14926_ _06535_ VGND VGND VPWR VPWR _06553_ sky130_fd_sc_hd__inv_2
XFILLER_0_78_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14857_ net494 net567 VGND VGND VPWR VPWR _06478_ sky130_fd_sc_hd__and2_1
X_13808_ _05267_ _05269_ _05273_ VGND VGND VPWR VPWR _05333_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_58_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14788_ _06400_ _06401_ _06396_ VGND VGND VPWR VPWR _06403_ sky130_fd_sc_hd__a21o_1
XFILLER_0_9_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13739_ _05118_ _05121_ _05119_ VGND VGND VPWR VPWR _05258_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_46_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15409_ _07060_ _07078_ VGND VGND VPWR VPWR _07079_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_6_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09901_ _01205_ _01206_ net270 net643 VGND VGND VPWR VPWR _01208_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_10_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout505 net506 VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__clkbuf_4
Xfanout516 net518 VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__buf_6
X_09832_ _01138_ _01139_ VGND VGND VPWR VPWR _01140_ sky130_fd_sc_hd__nand2_1
Xfanout527 net528 VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__buf_2
Xfanout538 net543 VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__buf_4
Xfanout549 net870 VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__buf_2
X_09763_ _00761_ _01008_ VGND VGND VPWR VPWR _01072_ sky130_fd_sc_hd__nand2_4
X_08714_ _08023_ _08024_ VGND VGND VPWR VPWR _08025_ sky130_fd_sc_hd__xnor2_1
X_09694_ _00984_ _00985_ _01003_ VGND VGND VPWR VPWR _01004_ sky130_fd_sc_hd__o21ai_2
Xrebuffer10 _04715_ VGND VGND VPWR VPWR net821 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_69_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer21 _04704_ VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__clkbuf_1
Xrebuffer32 net241 VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__clkbuf_2
X_08645_ net169 net557 _03669_ _03658_ VGND VGND VPWR VPWR _07957_ sky130_fd_sc_hd__a31o_1
Xrebuffer43 _03998_ VGND VGND VPWR VPWR net881 sky130_fd_sc_hd__buf_6
XFILLER_0_83_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08576_ _07281_ _06954_ VGND VGND VPWR VPWR _07292_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09128_ _00442_ _00443_ _00444_ VGND VGND VPWR VPWR _00445_ sky130_fd_sc_hd__a21o_1
XFILLER_0_60_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09059_ _00319_ _00375_ _00376_ VGND VGND VPWR VPWR _00377_ sky130_fd_sc_hd__and3_1
XFILLER_0_130_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12070_ _03425_ _03436_ VGND VGND VPWR VPWR _03437_ sky130_fd_sc_hd__xnor2_1
X_11021_ _02293_ _02294_ VGND VGND VPWR VPWR _02295_ sky130_fd_sc_hd__xnor2_1
X_15760_ _07459_ _07384_ _07457_ _07458_ VGND VGND VPWR VPWR _07461_ sky130_fd_sc_hd__a211o_1
X_12972_ _04324_ _04417_ _04420_ VGND VGND VPWR VPWR _04422_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_99_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14711_ _06242_ _06246_ VGND VGND VPWR VPWR _06318_ sky130_fd_sc_hd__and2_1
X_11923_ _03197_ _03198_ VGND VGND VPWR VPWR _03277_ sky130_fd_sc_hd__nand2_1
X_15691_ _07271_ _07294_ _07295_ VGND VGND VPWR VPWR _07386_ sky130_fd_sc_hd__and3_1
XFILLER_0_87_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14642_ _06240_ _06241_ VGND VGND VPWR VPWR _06242_ sky130_fd_sc_hd__xor2_1
X_11854_ _03126_ _03124_ VGND VGND VPWR VPWR _03202_ sky130_fd_sc_hd__or2b_1
XFILLER_0_68_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10805_ _01975_ _01980_ VGND VGND VPWR VPWR _02069_ sky130_fd_sc_hd__or2b_1
X_14573_ _05995_ _05997_ _05996_ VGND VGND VPWR VPWR _06166_ sky130_fd_sc_hd__a21bo_1
X_11785_ _03124_ _03126_ VGND VGND VPWR VPWR _03128_ sky130_fd_sc_hd__xnor2_1
X_13524_ _05017_ _05019_ _05022_ VGND VGND VPWR VPWR _05023_ sky130_fd_sc_hd__o21ba_1
X_16312_ clknet_4_8_0_clk _00101_ net341 VGND VGND VPWR VPWR b_cos\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_82_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10736_ _01998_ _01999_ VGND VGND VPWR VPWR _02000_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_149_Left_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16243_ clknet_4_6_0_clk _00032_ net337 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dfrtp_1
X_13455_ _04842_ _04847_ VGND VGND VPWR VPWR _04949_ sky130_fd_sc_hd__and2_1
XFILLER_0_82_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10667_ net524 net513 net616 net439 VGND VGND VPWR VPWR _01931_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_3_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12406_ net788 net294 net284 net807 VGND VGND VPWR VPWR _03802_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_23_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16174_ _07888_ _07887_ VGND VGND VPWR VPWR _07909_ sky130_fd_sc_hd__or2b_1
X_13386_ _04770_ _04772_ _04771_ VGND VGND VPWR VPWR _04874_ sky130_fd_sc_hd__a21bo_1
X_10598_ _01836_ _01861_ VGND VGND VPWR VPWR _01862_ sky130_fd_sc_hd__xnor2_1
X_15125_ net350 net502 net698 net528 VGND VGND VPWR VPWR _06770_ sky130_fd_sc_hd__nand4_2
XFILLER_0_2_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12337_ net756 net765 net190 net180 VGND VGND VPWR VPWR _03726_ sky130_fd_sc_hd__nand4_1
Xoutput108 net108 VGND VGND VPWR VPWR Q[1] sky130_fd_sc_hd__buf_2
X_15056_ _06691_ _06692_ _06673_ VGND VGND VPWR VPWR _06695_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_10_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12268_ _03495_ _03590_ _03487_ VGND VGND VPWR VPWR _03651_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_120_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14007_ _05545_ _05547_ VGND VGND VPWR VPWR _05549_ sky130_fd_sc_hd__or2_1
X_11219_ net767 net776 net462 net453 VGND VGND VPWR VPWR _02511_ sky130_fd_sc_hd__and4_1
X_12199_ _03575_ _03576_ VGND VGND VPWR VPWR _03577_ sky130_fd_sc_hd__or2_1
Xoutput90 net90 VGND VGND VPWR VPWR D[2] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15958_ _02388_ net687 VGND VGND VPWR VPWR _07676_ sky130_fd_sc_hd__nor2_1
X_14909_ _06433_ _06452_ _06533_ _06534_ VGND VGND VPWR VPWR _06535_ sky130_fd_sc_hd__a211o_1
XFILLER_0_53_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15889_ _07583_ _07600_ VGND VGND VPWR VPWR _07601_ sky130_fd_sc_hd__xnor2_1
X_08430_ _05144_ _05166_ _05155_ VGND VGND VPWR VPWR _05698_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_144_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08361_ _04916_ _04927_ _04937_ VGND VGND VPWR VPWR _04948_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_129_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08292_ net171 net582 _02583_ _02594_ VGND VGND VPWR VPWR _04196_ sky130_fd_sc_hd__a22o_1
XFILLER_0_129_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout302 net310 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_111_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout313 net314 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_100_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout324 net330 VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__clkbuf_4
Xfanout335 net338 VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__clkbuf_4
Xfanout346 net355 VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__buf_4
X_09815_ net262 net656 net666 net253 VGND VGND VPWR VPWR _01123_ sky130_fd_sc_hd__a22oi_2
Xfanout357 net364 VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__buf_2
Xfanout368 net375 VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__buf_2
Xfanout379 net386 VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__buf_2
X_09746_ _01053_ _01054_ VGND VGND VPWR VPWR _01055_ sky130_fd_sc_hd__nor2_1
XFILLER_0_69_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09677_ _00929_ _00932_ VGND VGND VPWR VPWR _00987_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08628_ net274 net599 VGND VGND VPWR VPWR _07856_ sky130_fd_sc_hd__and2_1
XFILLER_0_139_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08559_ _06791_ _07096_ VGND VGND VPWR VPWR _07107_ sky130_fd_sc_hd__xnor2_1
X_11570_ _02892_ _02893_ VGND VGND VPWR VPWR _02894_ sky130_fd_sc_hd__nor2_1
XFILLER_0_91_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10521_ _01781_ _01782_ _01755_ VGND VGND VPWR VPWR _01785_ sky130_fd_sc_hd__a21o_1
XFILLER_0_135_755 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13240_ _04712_ _04713_ _04694_ VGND VGND VPWR VPWR _04715_ sky130_fd_sc_hd__a21o_1
XFILLER_0_122_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10452_ net383 net372 net761 net770 VGND VGND VPWR VPWR _01716_ sky130_fd_sc_hd__nand4_1
XFILLER_0_33_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13171_ _04548_ _04550_ _04549_ net292 VGND VGND VPWR VPWR _04639_ sky130_fd_sc_hd__a22o_1
XFILLER_0_60_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10383_ _01646_ _01610_ VGND VGND VPWR VPWR _01647_ sky130_fd_sc_hd__xnor2_1
X_12122_ net466 net152 _03489_ _03491_ VGND VGND VPWR VPWR _03493_ sky130_fd_sc_hd__and4_1
X_12053_ _03401_ _03417_ VGND VGND VPWR VPWR _03418_ sky130_fd_sc_hd__xnor2_1
X_11004_ _02275_ _02276_ VGND VGND VPWR VPWR _02277_ sky130_fd_sc_hd__and2_1
X_15812_ net346 net498 net631 net622 VGND VGND VPWR VPWR _07517_ sky130_fd_sc_hd__and4_1
X_12955_ _04401_ _04402_ _04366_ VGND VGND VPWR VPWR _04405_ sky130_fd_sc_hd__o21a_1
X_15743_ _07434_ _07441_ VGND VGND VPWR VPWR _07442_ sky130_fd_sc_hd__xnor2_1
X_11906_ net347 net501 net143 net802 VGND VGND VPWR VPWR _03259_ sky130_fd_sc_hd__and4_1
XFILLER_0_90_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12886_ _04249_ _04253_ VGND VGND VPWR VPWR _04329_ sky130_fd_sc_hd__or2_1
X_15674_ _07261_ _07263_ VGND VGND VPWR VPWR _07367_ sky130_fd_sc_hd__and2_1
X_14625_ _06219_ _06222_ VGND VGND VPWR VPWR _06224_ sky130_fd_sc_hd__xnor2_2
X_11837_ _03101_ _03103_ VGND VGND VPWR VPWR _03184_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14556_ _06021_ VGND VGND VPWR VPWR _06148_ sky130_fd_sc_hd__inv_2
X_11768_ _03106_ _03107_ _03099_ VGND VGND VPWR VPWR _03109_ sky130_fd_sc_hd__a21o_1
XFILLER_0_83_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13507_ _04979_ _05005_ VGND VGND VPWR VPWR _05006_ sky130_fd_sc_hd__xnor2_4
X_10719_ _01972_ _01973_ _01982_ VGND VGND VPWR VPWR _01983_ sky130_fd_sc_hd__and3_1
XFILLER_0_15_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14487_ _06070_ _06066_ _06071_ VGND VGND VPWR VPWR _06072_ sky130_fd_sc_hd__nor3_2
X_11699_ _03031_ _03032_ _03033_ VGND VGND VPWR VPWR _03034_ sky130_fd_sc_hd__nand3_2
XFILLER_0_24_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13438_ _04837_ _04919_ _04929_ VGND VGND VPWR VPWR _04930_ sky130_fd_sc_hd__a21oi_2
X_16226_ clknet_4_2_0_clk _00015_ net335 VGND VGND VPWR VPWR b_sin\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_3_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer1 _04707_ VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__clkbuf_1
X_16157_ _07806_ _07827_ _07891_ VGND VGND VPWR VPWR _07892_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_140_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13369_ _04852_ _04854_ VGND VGND VPWR VPWR _04855_ sky130_fd_sc_hd__xor2_2
XFILLER_0_23_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15108_ _06539_ _06542_ _06644_ VGND VGND VPWR VPWR _06752_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_139_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16088_ _07809_ _07816_ VGND VGND VPWR VPWR _07817_ sky130_fd_sc_hd__xnor2_1
X_15039_ net494 net487 net546 VGND VGND VPWR VPWR _06676_ sky130_fd_sc_hd__and3_1
XFILLER_0_3_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09600_ net286 net656 net666 net277 VGND VGND VPWR VPWR _00911_ sky130_fd_sc_hd__a22oi_2
X_09531_ _00761_ _00831_ _00841_ VGND VGND VPWR VPWR _00843_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09462_ _00681_ _00682_ _00684_ VGND VGND VPWR VPWR _00775_ sky130_fd_sc_hd__and3_1
XFILLER_0_149_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08413_ _04861_ _04970_ _04959_ VGND VGND VPWR VPWR _05514_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_93_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09393_ net272 net526 VGND VGND VPWR VPWR _00707_ sky130_fd_sc_hd__nand2_1
XFILLER_0_80_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08344_ _04436_ _04425_ _04415_ VGND VGND VPWR VPWR _04763_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_47_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08275_ _03734_ _03745_ _03976_ _03987_ VGND VGND VPWR VPWR _04009_ sky130_fd_sc_hd__a2bb2oi_1
XFILLER_0_46_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout143 net144 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__clkbuf_4
Xfanout154 net155 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__clkbuf_4
Xfanout165 net168 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__buf_4
Xfanout176 net182 VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__buf_2
Xfanout187 net192 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__clkbuf_4
Xfanout198 net199 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__dlymetal6s2s_1
X_09729_ _00942_ _00964_ VGND VGND VPWR VPWR _01039_ sky130_fd_sc_hd__nand2_1
X_12740_ _04153_ _04157_ VGND VGND VPWR VPWR _04169_ sky130_fd_sc_hd__nor2_1
XFILLER_0_139_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12671_ _04091_ _04092_ VGND VGND VPWR VPWR _04093_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_139_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14410_ _05930_ _05941_ _05985_ _05986_ VGND VGND VPWR VPWR _05987_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_77_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11622_ _02935_ _02936_ _02947_ _02948_ VGND VGND VPWR VPWR _02950_ sky130_fd_sc_hd__or4bb_1
X_15390_ _06971_ _06973_ VGND VGND VPWR VPWR _07058_ sky130_fd_sc_hd__nor2_1
XFILLER_0_53_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14341_ _05901_ _05903_ _05902_ VGND VGND VPWR VPWR _05911_ sky130_fd_sc_hd__a21o_1
X_11553_ _02862_ _02863_ _02873_ _02874_ VGND VGND VPWR VPWR _02875_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_53_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10504_ _01759_ _01766_ _01767_ VGND VGND VPWR VPWR _01768_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_80_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14272_ net408 net586 net595 net398 VGND VGND VPWR VPWR _05835_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_123_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11484_ _02799_ VGND VGND VPWR VPWR _00064_ sky130_fd_sc_hd__clkbuf_1
X_16011_ _07731_ _07732_ VGND VGND VPWR VPWR _07733_ sky130_fd_sc_hd__xnor2_2
X_13223_ net151 net209 net200 net229 VGND VGND VPWR VPWR _04696_ sky130_fd_sc_hd__a22o_1
XFILLER_0_123_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10435_ net524 net439 net615 net716 VGND VGND VPWR VPWR _01699_ sky130_fd_sc_hd__nand4_2
XFILLER_0_21_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13154_ _04519_ _04619_ _04620_ VGND VGND VPWR VPWR _04621_ sky130_fd_sc_hd__and3_1
X_10366_ net421 net742 VGND VGND VPWR VPWR _01630_ sky130_fd_sc_hd__nand2_1
X_12105_ _03403_ _03406_ _03404_ VGND VGND VPWR VPWR _03475_ sky130_fd_sc_hd__o21ba_1
X_13085_ _04455_ _04457_ VGND VGND VPWR VPWR _04546_ sky130_fd_sc_hd__nand2_1
X_10297_ net135 net101 VGND VGND VPWR VPWR _01569_ sky130_fd_sc_hd__and2b_1
X_12036_ _03336_ _03337_ _03399_ VGND VGND VPWR VPWR _03400_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_87_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13987_ _05513_ _05511_ VGND VGND VPWR VPWR _05527_ sky130_fd_sc_hd__and2b_1
X_15726_ _07340_ _07424_ VGND VGND VPWR VPWR _07425_ sky130_fd_sc_hd__xnor2_1
X_12938_ net229 net150 net321 net237 VGND VGND VPWR VPWR _04386_ sky130_fd_sc_hd__and4_1
XFILLER_0_125_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15657_ net484 net474 net672 net680 VGND VGND VPWR VPWR _07349_ sky130_fd_sc_hd__and4_1
X_12869_ _03871_ _03876_ _04309_ _04310_ VGND VGND VPWR VPWR _04311_ sky130_fd_sc_hd__a211o_2
XFILLER_0_133_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14608_ _06198_ _06203_ _06204_ VGND VGND VPWR VPWR _06205_ sky130_fd_sc_hd__nand3_1
XFILLER_0_145_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15588_ _07190_ _07199_ _07198_ VGND VGND VPWR VPWR _07274_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_7_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14539_ _06114_ _06123_ _06128_ _06121_ VGND VGND VPWR VPWR _06129_ sky130_fd_sc_hd__o211a_1
XFILLER_0_43_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16209_ b_cos\[18\] _07947_ _02170_ VGND VGND VPWR VPWR _07948_ sky130_fd_sc_hd__mux2_1
XFILLER_0_11_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08962_ _00117_ _00197_ _00279_ _00280_ VGND VGND VPWR VPWR _00281_ sky130_fd_sc_hd__o211a_4
X_08893_ net250 net599 VGND VGND VPWR VPWR _00212_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09514_ _00740_ _00814_ VGND VGND VPWR VPWR _00826_ sky130_fd_sc_hd__nor2_1
XFILLER_0_78_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09445_ _00714_ _00716_ _00757_ VGND VGND VPWR VPWR _00758_ sky130_fd_sc_hd__a21o_1
XFILLER_0_59_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09376_ net184 net174 net638 net630 VGND VGND VPWR VPWR _00690_ sky130_fd_sc_hd__nand4_2
XFILLER_0_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08327_ _03051_ _03062_ _03377_ _03388_ VGND VGND VPWR VPWR _04578_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_7_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08258_ net160 net307 net562 net572 VGND VGND VPWR VPWR _03822_ sky130_fd_sc_hd__and4_1
XFILLER_0_105_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_104_Left_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08189_ net163 net307 net592 net599 VGND VGND VPWR VPWR _03073_ sky130_fd_sc_hd__and4_1
XFILLER_0_104_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10220_ _01494_ _01498_ _01497_ VGND VGND VPWR VPWR _01502_ sky130_fd_sc_hd__a21oi_2
X_10151_ _01442_ _01443_ VGND VGND VPWR VPWR _01444_ sky130_fd_sc_hd__nor2_1
X_10082_ _00739_ _01383_ _01384_ _01385_ VGND VGND VPWR VPWR _00018_ sky130_fd_sc_hd__o31a_1
X_13910_ _05374_ _05443_ VGND VGND VPWR VPWR _05444_ sky130_fd_sc_hd__xnor2_1
X_14890_ _06511_ _06512_ _06510_ VGND VGND VPWR VPWR _06514_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_113_Left_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13841_ _05365_ _05368_ VGND VGND VPWR VPWR _05369_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13772_ _05287_ _05285_ VGND VGND VPWR VPWR _05293_ sky130_fd_sc_hd__and2b_1
X_10984_ _02252_ _02253_ _02244_ VGND VGND VPWR VPWR _02255_ sky130_fd_sc_hd__a21o_1
XFILLER_0_29_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15511_ _07120_ _07122_ VGND VGND VPWR VPWR _07190_ sky130_fd_sc_hd__nand2_1
X_12723_ _04140_ _04148_ _04149_ VGND VGND VPWR VPWR _04150_ sky130_fd_sc_hd__a21o_1
XFILLER_0_127_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12654_ _04072_ _04073_ VGND VGND VPWR VPWR _04074_ sky130_fd_sc_hd__or2_1
X_15442_ _07111_ _07112_ _07113_ VGND VGND VPWR VPWR _07115_ sky130_fd_sc_hd__nand3_1
XFILLER_0_37_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11605_ _02929_ _02930_ _02770_ VGND VGND VPWR VPWR _02932_ sky130_fd_sc_hd__a21o_1
XFILLER_0_25_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12585_ _03995_ _03996_ _03997_ VGND VGND VPWR VPWR _03999_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_53_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15373_ _06979_ _07039_ VGND VGND VPWR VPWR _07040_ sky130_fd_sc_hd__xor2_2
XFILLER_0_26_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_122_Left_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11536_ net389 net869 _02854_ _02856_ VGND VGND VPWR VPWR _02857_ sky130_fd_sc_hd__a22o_1
X_14324_ _05852_ _05861_ _05890_ _05891_ VGND VGND VPWR VPWR _05892_ sky130_fd_sc_hd__o211a_2
XFILLER_0_53_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14255_ net419 net569 VGND VGND VPWR VPWR _05817_ sky130_fd_sc_hd__nand2_1
Xmax_cap118 net861 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11467_ _02663_ _02780_ _02781_ VGND VGND VPWR VPWR _02782_ sky130_fd_sc_hd__a21oi_2
Xmax_cap129 _00217_ VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__buf_1
X_13206_ _04660_ _04675_ _04677_ VGND VGND VPWR VPWR _04678_ sky130_fd_sc_hd__nand3_1
X_10418_ net383 net372 net770 net777 VGND VGND VPWR VPWR _01682_ sky130_fd_sc_hd__and4_1
XFILLER_0_150_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14186_ net139 net261 net252 net148 VGND VGND VPWR VPWR _05743_ sky130_fd_sc_hd__a22o_1
XFILLER_0_104_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11398_ _02621_ _02623_ VGND VGND VPWR VPWR _02706_ sky130_fd_sc_hd__nor2_1
X_13137_ _04599_ _04601_ _04581_ VGND VGND VPWR VPWR _04603_ sky130_fd_sc_hd__a21oi_2
X_10349_ net363 net793 VGND VGND VPWR VPWR _01613_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13068_ net780 net259 VGND VGND VPWR VPWR _04527_ sky130_fd_sc_hd__nand2_1
X_12019_ _03307_ _03308_ VGND VGND VPWR VPWR _03382_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_131_Left_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15709_ _07403_ _07405_ VGND VGND VPWR VPWR _07406_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09230_ _00533_ _00545_ VGND VGND VPWR VPWR _00546_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_29_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09161_ _00383_ _00467_ VGND VGND VPWR VPWR _00477_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_140_Left_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08112_ _02201_ _02212_ _02223_ VGND VGND VPWR VPWR _02234_ sky130_fd_sc_hd__or3_1
XFILLER_0_44_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09092_ _00408_ net589 VGND VGND VPWR VPWR _00409_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09994_ _01289_ _01288_ VGND VGND VPWR VPWR _01299_ sky130_fd_sc_hd__and2b_1
X_08945_ _00255_ _00262_ _00263_ VGND VGND VPWR VPWR _00264_ sky130_fd_sc_hd__nand3_1
X_08876_ _00194_ VGND VGND VPWR VPWR _00195_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_99_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09428_ _00676_ _00661_ VGND VGND VPWR VPWR _00741_ sky130_fd_sc_hd__and2b_1
XFILLER_0_94_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09359_ _00581_ _00583_ _00672_ VGND VGND VPWR VPWR _00673_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_34_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12370_ _03716_ _03718_ _03717_ VGND VGND VPWR VPWR _03762_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_133_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11321_ _02509_ _02514_ VGND VGND VPWR VPWR _02622_ sky130_fd_sc_hd__nand2_1
XFILLER_0_132_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14040_ _05506_ _05510_ _05507_ VGND VGND VPWR VPWR _05585_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_132_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11252_ _02530_ _02545_ _02546_ VGND VGND VPWR VPWR _02547_ sky130_fd_sc_hd__nand3_1
X_10203_ net87 _01488_ net134 VGND VGND VPWR VPWR _01489_ sky130_fd_sc_hd__mux2_1
X_11183_ _02360_ _02438_ _02470_ _02471_ VGND VGND VPWR VPWR _02472_ sky130_fd_sc_hd__a211oi_4
X_10134_ _01429_ VGND VGND VPWR VPWR _00026_ sky130_fd_sc_hd__clkbuf_1
X_15991_ _07600_ _07583_ VGND VGND VPWR VPWR _07712_ sky130_fd_sc_hd__and2b_1
X_10065_ _01361_ _01368_ VGND VGND VPWR VPWR _01369_ sky130_fd_sc_hd__xnor2_1
X_14942_ _06482_ _06484_ VGND VGND VPWR VPWR _06570_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14873_ net382 net699 net532 net371 VGND VGND VPWR VPWR _06495_ sky130_fd_sc_hd__a22o_1
X_13824_ _05348_ _05349_ VGND VGND VPWR VPWR _05350_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13755_ _05257_ _05274_ VGND VGND VPWR VPWR _05276_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10967_ _02233_ _02235_ _02230_ VGND VGND VPWR VPWR _02237_ sky130_fd_sc_hd__a21o_1
X_12706_ _04081_ _04124_ _04123_ VGND VGND VPWR VPWR _04132_ sky130_fd_sc_hd__a21o_1
X_13686_ _05017_ _05018_ _05110_ _05200_ VGND VGND VPWR VPWR _05201_ sky130_fd_sc_hd__o31a_1
XFILLER_0_127_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10898_ _02160_ _02161_ _02052_ _02130_ VGND VGND VPWR VPWR _02163_ sky130_fd_sc_hd__o211ai_4
X_15425_ _07092_ _07093_ _07094_ VGND VGND VPWR VPWR _07097_ sky130_fd_sc_hd__a21o_1
XFILLER_0_25_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12637_ _03992_ _04001_ _04000_ VGND VGND VPWR VPWR _04056_ sky130_fd_sc_hd__nand3_1
XFILLER_0_66_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12568_ _03978_ _03970_ _03979_ VGND VGND VPWR VPWR _03980_ sky130_fd_sc_hd__nand3_1
X_15356_ net415 _06801_ _06920_ _01891_ VGND VGND VPWR VPWR _07022_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_136_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_842 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14307_ _05872_ _05873_ VGND VGND VPWR VPWR _05874_ sky130_fd_sc_hd__xnor2_1
X_11519_ net427 net512 net349 net500 VGND VGND VPWR VPWR _02838_ sky130_fd_sc_hd__nand4_1
X_12499_ _03903_ _03886_ VGND VGND VPWR VPWR _03904_ sky130_fd_sc_hd__xnor2_1
X_15287_ _06751_ _06942_ _06945_ _06946_ VGND VGND VPWR VPWR _06947_ sky130_fd_sc_hd__o211a_1
XFILLER_0_123_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14238_ _05791_ _05798_ VGND VGND VPWR VPWR _05799_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14169_ net797 net271 VGND VGND VPWR VPWR _05724_ sky130_fd_sc_hd__nand2_1
Xfanout709 net717 VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__buf_4
XFILLER_0_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08730_ _07966_ _07983_ _07984_ VGND VGND VPWR VPWR _08041_ sky130_fd_sc_hd__nand3_2
X_08661_ net323 net239 net648 net659 VGND VGND VPWR VPWR _07973_ sky130_fd_sc_hd__and4_1
X_08592_ net215 net703 _07433_ VGND VGND VPWR VPWR _07466_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09213_ _00524_ _00527_ _00528_ VGND VGND VPWR VPWR _00529_ sky130_fd_sc_hd__nand3_1
XFILLER_0_57_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09144_ _00341_ _00372_ _00371_ VGND VGND VPWR VPWR _00461_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_31_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09075_ _00302_ _00318_ _00391_ VGND VGND VPWR VPWR _00392_ sky130_fd_sc_hd__a21o_1
XFILLER_0_71_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09977_ _01280_ _01281_ _01219_ _01282_ VGND VGND VPWR VPWR _01283_ sky130_fd_sc_hd__o211a_1
X_08928_ _00242_ _00245_ _00246_ VGND VGND VPWR VPWR _00247_ sky130_fd_sc_hd__and3_1
XFILLER_0_99_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08859_ _00119_ _00177_ _00178_ VGND VGND VPWR VPWR _00179_ sky130_fd_sc_hd__and3_1
XFILLER_0_98_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11870_ _03144_ _03146_ _03219_ VGND VGND VPWR VPWR _03220_ sky130_fd_sc_hd__a21o_1
X_10821_ _02069_ _02070_ _02084_ VGND VGND VPWR VPWR _02085_ sky130_fd_sc_hd__a21o_2
XFILLER_0_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13540_ _05038_ _05040_ VGND VGND VPWR VPWR _05041_ sky130_fd_sc_hd__xnor2_2
X_10752_ _02006_ _02014_ _02013_ VGND VGND VPWR VPWR _02016_ sky130_fd_sc_hd__a21o_1
XFILLER_0_109_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13471_ net610 net297 VGND VGND VPWR VPWR _04966_ sky130_fd_sc_hd__and2_1
XFILLER_0_109_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10683_ _01705_ _01707_ _01706_ VGND VGND VPWR VPWR _01947_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_125_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12422_ _03816_ _03817_ _03815_ VGND VGND VPWR VPWR _03819_ sky130_fd_sc_hd__o21ai_1
X_15210_ _06834_ _06837_ VGND VGND VPWR VPWR _06862_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16190_ _02389_ net652 VGND VGND VPWR VPWR _07927_ sky130_fd_sc_hd__nor2_1
XFILLER_0_124_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12353_ net612 net223 VGND VGND VPWR VPWR _03743_ sky130_fd_sc_hd__nand2_1
X_15141_ net377 net673 net682 net366 VGND VGND VPWR VPWR _06787_ sky130_fd_sc_hd__a22o_1
XFILLER_0_105_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11304_ a_cos\[4\] _02603_ _02383_ VGND VGND VPWR VPWR _02604_ sky130_fd_sc_hd__mux2_1
X_15072_ net654 _06710_ _06711_ VGND VGND VPWR VPWR _06712_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_50_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12284_ _03667_ _03625_ _03599_ VGND VGND VPWR VPWR _03668_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14023_ _05554_ _05565_ VGND VGND VPWR VPWR _05566_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_121_878 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11235_ _02428_ _02431_ VGND VGND VPWR VPWR _02529_ sky130_fd_sc_hd__nand2_1
X_11166_ net407 _02451_ _02453_ VGND VGND VPWR VPWR _02454_ sky130_fd_sc_hd__a21bo_1
X_10117_ _01406_ _01409_ _01407_ VGND VGND VPWR VPWR _01415_ sky130_fd_sc_hd__o21ai_1
X_15974_ _07619_ _07692_ net491 VGND VGND VPWR VPWR _07693_ sky130_fd_sc_hd__o21a_1
X_11097_ _02375_ _02377_ _02271_ _02289_ VGND VGND VPWR VPWR _02379_ sky130_fd_sc_hd__o211ai_1
X_10048_ _01300_ _01347_ VGND VGND VPWR VPWR _01352_ sky130_fd_sc_hd__or2_1
X_14925_ _06544_ _06548_ _06542_ VGND VGND VPWR VPWR _06552_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_26_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14856_ net352 net502 net549 net556 VGND VGND VPWR VPWR _06477_ sky130_fd_sc_hd__nand4_1
XFILLER_0_89_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13807_ _05246_ _05249_ _05328_ _05330_ VGND VGND VPWR VPWR _05332_ sky130_fd_sc_hd__a211o_1
X_14787_ _06396_ _06400_ _06401_ VGND VGND VPWR VPWR _06402_ sky130_fd_sc_hd__and3_1
X_11999_ _03358_ _03359_ VGND VGND VPWR VPWR _03360_ sky130_fd_sc_hd__and2b_1
XFILLER_0_42_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13738_ _05256_ _05134_ VGND VGND VPWR VPWR _05257_ sky130_fd_sc_hd__nand2_1
XFILLER_0_42_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13669_ _05162_ _05180_ VGND VGND VPWR VPWR _05182_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15408_ _07076_ _07077_ VGND VGND VPWR VPWR _07078_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_26_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15339_ _07001_ _07002_ VGND VGND VPWR VPWR _07003_ sky130_fd_sc_hd__nor2_1
XFILLER_0_124_672 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09900_ net270 net637 _01205_ _01206_ VGND VGND VPWR VPWR _01207_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_1_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout506 net40 VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__buf_2
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout517 net518 VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__buf_4
X_09831_ _01136_ _01137_ VGND VGND VPWR VPWR _01139_ sky130_fd_sc_hd__or2_1
Xfanout528 net529 VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__clkbuf_4
Xfanout539 net543 VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__buf_2
X_09762_ _01051_ _01069_ VGND VGND VPWR VPWR _01071_ sky130_fd_sc_hd__or2_1
X_08713_ net274 net589 VGND VGND VPWR VPWR _08024_ sky130_fd_sc_hd__nand2_1
X_09693_ _01001_ _01002_ VGND VGND VPWR VPWR _01003_ sky130_fd_sc_hd__and2_1
XFILLER_0_20_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer11 _04719_ VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__clkbuf_1
X_08644_ _03593_ _03604_ _03701_ VGND VGND VPWR VPWR _07956_ sky130_fd_sc_hd__nand3_2
Xrebuffer22 _02484_ VGND VGND VPWR VPWR net833 sky130_fd_sc_hd__buf_1
Xrebuffer33 net843 VGND VGND VPWR VPWR net844 sky130_fd_sc_hd__buf_1
Xrebuffer44 net325 VGND VGND VPWR VPWR net882 sky130_fd_sc_hd__dlygate4sd1_1
X_08575_ _06878_ _06889_ VGND VGND VPWR VPWR _07281_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09127_ net194 net649 VGND VGND VPWR VPWR _00444_ sky130_fd_sc_hd__and2_1
XFILLER_0_45_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09058_ _00373_ _00374_ _00271_ _00320_ VGND VGND VPWR VPWR _00376_ sky130_fd_sc_hd__a211o_1
XFILLER_0_102_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11020_ net808 net444 VGND VGND VPWR VPWR _02294_ sky130_fd_sc_hd__nand2_1
X_12971_ net848 _00739_ _04421_ VGND VGND VPWR VPWR _00078_ sky130_fd_sc_hd__a21o_1
X_14710_ _06240_ _06241_ VGND VGND VPWR VPWR _06317_ sky130_fd_sc_hd__and2_1
X_11922_ _03274_ _03267_ _03269_ VGND VGND VPWR VPWR _03276_ sky130_fd_sc_hd__nor3_1
X_15690_ _07268_ _07269_ VGND VGND VPWR VPWR _07385_ sky130_fd_sc_hd__and2_1
XFILLER_0_68_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14641_ net495 net604 _06154_ _06153_ VGND VGND VPWR VPWR _06241_ sky130_fd_sc_hd__a31o_1
X_11853_ _03199_ _03188_ _03189_ VGND VGND VPWR VPWR _03201_ sky130_fd_sc_hd__and3_1
X_10804_ _01997_ _02000_ VGND VGND VPWR VPWR _02068_ sky130_fd_sc_hd__and2_1
X_14572_ _06001_ _06007_ _06000_ VGND VGND VPWR VPWR _06165_ sky130_fd_sc_hd__a21bo_1
X_11784_ _03125_ _03057_ _03043_ VGND VGND VPWR VPWR _03126_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_67_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16311_ clknet_4_8_0_clk _00100_ net343 VGND VGND VPWR VPWR b_cos\[4\] sky130_fd_sc_hd__dfrtp_1
X_13523_ _04928_ _05016_ VGND VGND VPWR VPWR _05022_ sky130_fd_sc_hd__and2_1
XFILLER_0_137_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10735_ net489 net792 net808 net478 VGND VGND VPWR VPWR _01999_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_138_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16242_ clknet_4_7_0_clk _00031_ net338 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dfrtp_1
X_13454_ _04944_ _04946_ VGND VGND VPWR VPWR _04947_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_42_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10666_ net524 net439 net513 net616 VGND VGND VPWR VPWR _01930_ sky130_fd_sc_hd__and4_1
XFILLER_0_36_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12405_ net788 net807 net294 net283 VGND VGND VPWR VPWR _03801_ sky130_fd_sc_hd__and4_1
X_13385_ _04868_ _04869_ _04870_ VGND VGND VPWR VPWR _04873_ sky130_fd_sc_hd__nand3_1
X_16173_ _07899_ _07905_ _07897_ VGND VGND VPWR VPWR _07908_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_140_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10597_ _01838_ _01837_ VGND VGND VPWR VPWR _01861_ sky130_fd_sc_hd__nor2_1
XFILLER_0_23_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15124_ net350 net698 net528 net502 VGND VGND VPWR VPWR _06768_ sky130_fd_sc_hd__a22o_1
X_12336_ _03721_ _03722_ _03706_ VGND VGND VPWR VPWR _03725_ sky130_fd_sc_hd__a21o_1
Xoutput109 net109 VGND VGND VPWR VPWR Q[2] sky130_fd_sc_hd__buf_2
XFILLER_0_105_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15055_ _06673_ _06691_ _06692_ VGND VGND VPWR VPWR _06694_ sky130_fd_sc_hd__and3_1
X_12267_ _03607_ _03649_ VGND VGND VPWR VPWR _03650_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_120_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14006_ _05545_ _05547_ VGND VGND VPWR VPWR _05548_ sky130_fd_sc_hd__nand2_1
X_11218_ net776 net453 VGND VGND VPWR VPWR _02510_ sky130_fd_sc_hd__nand2_1
X_12198_ _03570_ _03571_ _03574_ VGND VGND VPWR VPWR _03576_ sky130_fd_sc_hd__and3_1
Xoutput80 net80 VGND VGND VPWR VPWR D[10] sky130_fd_sc_hd__clkbuf_4
Xoutput91 net91 VGND VGND VPWR VPWR D[3] sky130_fd_sc_hd__clkbuf_4
X_11149_ _02414_ _02433_ _02434_ VGND VGND VPWR VPWR _02435_ sky130_fd_sc_hd__and3_1
X_15957_ _07670_ _07674_ VGND VGND VPWR VPWR _07675_ sky130_fd_sc_hd__xor2_1
X_14908_ _06531_ _06532_ _06466_ VGND VGND VPWR VPWR _06534_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_144_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15888_ _07598_ _07599_ VGND VGND VPWR VPWR _07600_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14839_ _06454_ _06456_ _06374_ _06379_ VGND VGND VPWR VPWR _06458_ sky130_fd_sc_hd__a211o_1
XFILLER_0_86_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08360_ net189 net179 net582 net592 VGND VGND VPWR VPWR _04937_ sky130_fd_sc_hd__and4_1
XFILLER_0_74_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08291_ net196 net564 _04174_ _04163_ VGND VGND VPWR VPWR _04185_ sky130_fd_sc_hd__a31o_1
XFILLER_0_144_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout303 net310 VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__clkbuf_2
Xfanout314 net319 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__clkbuf_2
Xfanout325 net326 VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__buf_8
Xfanout336 net338 VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__clkbuf_2
X_09814_ _01076_ _01094_ _01092_ VGND VGND VPWR VPWR _01122_ sky130_fd_sc_hd__a21o_1
Xfanout347 net355 VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__clkbuf_2
Xfanout358 net364 VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__clkbuf_4
Xfanout369 net370 VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__clkbuf_4
X_09745_ net263 net253 net666 net676 VGND VGND VPWR VPWR _01054_ sky130_fd_sc_hd__and4_1
X_09676_ _00766_ _00931_ VGND VGND VPWR VPWR _00986_ sky130_fd_sc_hd__or2_1
X_08627_ _07824_ _07835_ VGND VGND VPWR VPWR _07845_ sky130_fd_sc_hd__nor2_1
XFILLER_0_49_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08558_ _06813_ _06802_ VGND VGND VPWR VPWR _07096_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08489_ net328 net565 net575 net244 VGND VGND VPWR VPWR _06344_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_65_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10520_ _01743_ _01744_ _01783_ _01781_ VGND VGND VPWR VPWR _01784_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_91_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10451_ net393 net761 _01671_ _01670_ VGND VGND VPWR VPWR _01715_ sky130_fd_sc_hd__a31o_1
XFILLER_0_134_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13170_ _04547_ _04562_ _04563_ _04566_ VGND VGND VPWR VPWR _04638_ sky130_fd_sc_hd__a31o_1
X_10382_ _01609_ _01611_ VGND VGND VPWR VPWR _01646_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12121_ net465 net152 _03489_ _03491_ VGND VGND VPWR VPWR _03492_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_102_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12052_ _03415_ _03416_ VGND VGND VPWR VPWR _03417_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_130_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11003_ _02273_ _02274_ _02179_ _02182_ VGND VGND VPWR VPWR _02276_ sky130_fd_sc_hd__o211ai_1
X_15811_ net498 net631 net622 net346 VGND VGND VPWR VPWR _07516_ sky130_fd_sc_hd__a22oi_1
X_15742_ _07439_ _07440_ VGND VGND VPWR VPWR _07441_ sky130_fd_sc_hd__xor2_1
X_12954_ _04366_ _04401_ _04402_ VGND VGND VPWR VPWR _04403_ sky130_fd_sc_hd__nor3_2
XFILLER_0_59_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11905_ net501 net143 net802 net347 VGND VGND VPWR VPWR _03258_ sky130_fd_sc_hd__a22oi_1
X_15673_ _07363_ _07364_ _07344_ _07345_ VGND VGND VPWR VPWR _07366_ sky130_fd_sc_hd__a211o_1
X_12885_ _04237_ _04238_ VGND VGND VPWR VPWR _04328_ sky130_fd_sc_hd__nor2_1
X_14624_ _06220_ _06221_ VGND VGND VPWR VPWR _06222_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11836_ _03180_ _03182_ VGND VGND VPWR VPWR _03183_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_83_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14555_ _06143_ _06144_ _06145_ VGND VGND VPWR VPWR _06147_ sky130_fd_sc_hd__o21ai_1
X_11767_ _03099_ _03106_ _03107_ VGND VGND VPWR VPWR _03108_ sky130_fd_sc_hd__nand3_2
XFILLER_0_55_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13506_ _05002_ _05004_ VGND VGND VPWR VPWR _05005_ sky130_fd_sc_hd__xnor2_4
X_10718_ _01974_ _01981_ VGND VGND VPWR VPWR _01982_ sky130_fd_sc_hd__xnor2_2
X_14486_ _06050_ _06051_ _06065_ VGND VGND VPWR VPWR _06071_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_43_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11698_ _02963_ _02966_ _02965_ VGND VGND VPWR VPWR _03033_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_71_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16225_ clknet_4_6_0_clk _00014_ net335 VGND VGND VPWR VPWR b_sin\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_24_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13437_ _04918_ _04915_ VGND VGND VPWR VPWR _04929_ sky130_fd_sc_hd__and2b_1
XFILLER_0_82_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer2 _04707_ VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__clkbuf_1
X_10649_ _01721_ _01911_ _01912_ VGND VGND VPWR VPWR _01913_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_24_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16156_ _07808_ _07826_ VGND VGND VPWR VPWR _07891_ sky130_fd_sc_hd__and2_1
X_13368_ _04751_ _04753_ _04853_ VGND VGND VPWR VPWR _04854_ sky130_fd_sc_hd__o21a_1
XFILLER_0_140_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15107_ _06749_ _06750_ VGND VGND VPWR VPWR _06751_ sky130_fd_sc_hd__nand2_1
X_12319_ _03698_ _03704_ _03705_ VGND VGND VPWR VPWR _03706_ sky130_fd_sc_hd__a21bo_1
X_16087_ _07814_ _07815_ VGND VGND VPWR VPWR _07816_ sky130_fd_sc_hd__xnor2_1
X_13299_ _04769_ _04777_ _04778_ VGND VGND VPWR VPWR _04779_ sky130_fd_sc_hd__nand3_1
X_15038_ net476 net567 VGND VGND VPWR VPWR _06675_ sky130_fd_sc_hd__and2_1
XFILLER_0_48_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09530_ _00761_ _00831_ _00841_ VGND VGND VPWR VPWR _00842_ sky130_fd_sc_hd__or3_1
XFILLER_0_3_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09461_ _00763_ _00773_ VGND VGND VPWR VPWR _00774_ sky130_fd_sc_hd__xnor2_1
X_08412_ _05383_ _05481_ _05492_ VGND VGND VPWR VPWR _05503_ sky130_fd_sc_hd__nand3_2
X_09392_ _00704_ _00705_ VGND VGND VPWR VPWR _00706_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08343_ _04436_ _04415_ _04425_ VGND VGND VPWR VPWR _04752_ sky130_fd_sc_hd__or3_1
XFILLER_0_46_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08274_ _03734_ _03745_ _03976_ _03987_ VGND VGND VPWR VPWR _03998_ sky130_fd_sc_hd__and4bb_2
XFILLER_0_144_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_120_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout133 net134 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__clkbuf_4
Xfanout144 net147 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__buf_2
Xfanout155 net8 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__clkbuf_4
Xfanout166 net168 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__buf_2
Xfanout177 net182 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__clkbuf_4
Xfanout188 net192 VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__clkbuf_4
Xfanout199 net73 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09728_ _01036_ _01037_ VGND VGND VPWR VPWR _01038_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09659_ _00967_ _00969_ VGND VGND VPWR VPWR _00970_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_38_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12670_ net790 net198 VGND VGND VPWR VPWR _04092_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11621_ _02935_ _02936_ _02947_ _02948_ VGND VGND VPWR VPWR _02949_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_38_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14340_ _05908_ _05909_ VGND VGND VPWR VPWR _05910_ sky130_fd_sc_hd__xnor2_1
X_11552_ _02871_ _02872_ _02864_ VGND VGND VPWR VPWR _02874_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10503_ _01760_ _01765_ _01761_ VGND VGND VPWR VPWR _01767_ sky130_fd_sc_hd__nand3_1
X_14271_ _05825_ _05832_ _05831_ VGND VGND VPWR VPWR _05834_ sky130_fd_sc_hd__a21o_1
X_11483_ a_cos\[6\] _02798_ _02383_ VGND VGND VPWR VPWR _02799_ sky130_fd_sc_hd__mux2_1
XFILLER_0_135_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16010_ net442 net671 VGND VGND VPWR VPWR _07732_ sky130_fd_sc_hd__nand2_1
X_13222_ net229 net151 net209 VGND VGND VPWR VPWR _04695_ sky130_fd_sc_hd__and3_1
X_10434_ net421 net725 VGND VGND VPWR VPWR _01698_ sky130_fd_sc_hd__and2_1
XFILLER_0_21_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13153_ _04617_ _04618_ _04520_ VGND VGND VPWR VPWR _04620_ sky130_fd_sc_hd__a21o_1
X_10365_ net524 net439 net724 net733 VGND VGND VPWR VPWR _01629_ sky130_fd_sc_hd__and4_1
X_12104_ _03467_ _03472_ VGND VGND VPWR VPWR _03473_ sky130_fd_sc_hd__xnor2_1
X_13084_ _04464_ _04499_ _04500_ VGND VGND VPWR VPWR _04544_ sky130_fd_sc_hd__nor3_1
X_10296_ _01558_ _01562_ _01566_ VGND VGND VPWR VPWR _01568_ sky130_fd_sc_hd__or3_1
X_12035_ _03331_ _03335_ VGND VGND VPWR VPWR _03399_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13986_ _05516_ _05521_ _05525_ VGND VGND VPWR VPWR _05526_ sky130_fd_sc_hd__o21ba_4
XFILLER_0_88_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15725_ _07341_ _07422_ VGND VGND VPWR VPWR _07424_ sky130_fd_sc_hd__xnor2_1
X_12937_ net314 net225 VGND VGND VPWR VPWR _04385_ sky130_fd_sc_hd__nand2_1
XFILLER_0_88_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15656_ net484 net672 net681 net474 VGND VGND VPWR VPWR _07348_ sky130_fd_sc_hd__a22oi_1
X_12868_ _04307_ _04308_ _04243_ VGND VGND VPWR VPWR _04310_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_87_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14607_ _06200_ _06202_ _06199_ VGND VGND VPWR VPWR _06204_ sky130_fd_sc_hd__o21ai_1
X_11819_ _02999_ _03071_ _03069_ VGND VGND VPWR VPWR _03165_ sky130_fd_sc_hd__a21oi_1
X_15587_ _07215_ _07223_ _07224_ VGND VGND VPWR VPWR _07273_ sky130_fd_sc_hd__and3_1
XFILLER_0_139_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12799_ _03986_ _04038_ _04233_ VGND VGND VPWR VPWR _04234_ sky130_fd_sc_hd__o21a_1
XFILLER_0_126_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14538_ _06114_ _06123_ _06125_ _06126_ _06127_ VGND VGND VPWR VPWR _06128_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_141_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14469_ net409 net399 net595 net605 VGND VGND VPWR VPWR _06052_ sky130_fd_sc_hd__and4_1
XFILLER_0_126_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16208_ _07908_ _07946_ VGND VGND VPWR VPWR _07947_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_70_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16139_ _07790_ _07795_ _07871_ VGND VGND VPWR VPWR _07872_ sky130_fd_sc_hd__nor3_1
XFILLER_0_12_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08961_ _00277_ _00278_ _00177_ _00198_ VGND VGND VPWR VPWR _00280_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_11_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08892_ _00209_ _00210_ VGND VGND VPWR VPWR _00211_ sky130_fd_sc_hd__xor2_2
X_09513_ _00739_ _00823_ _00824_ _00825_ VGND VGND VPWR VPWR _00009_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_149_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09444_ _00743_ _00756_ VGND VGND VPWR VPWR _00757_ sky130_fd_sc_hd__xor2_1
XFILLER_0_148_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09375_ net174 net638 net630 net184 VGND VGND VPWR VPWR _00689_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08326_ _04327_ _04545_ _04556_ VGND VGND VPWR VPWR _04567_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_19_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08257_ net298 net580 VGND VGND VPWR VPWR _03811_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08188_ _03018_ _03029_ _02550_ _02713_ VGND VGND VPWR VPWR _03062_ sky130_fd_sc_hd__o211a_1
XFILLER_0_15_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10150_ a_cos\[10\] b_sin\[10\] VGND VGND VPWR VPWR _01443_ sky130_fd_sc_hd__nor2_1
XFILLER_0_100_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10081_ b_sin\[18\] _02181_ VGND VGND VPWR VPWR _01385_ sky130_fd_sc_hd__or2_1
X_13840_ _05205_ _05366_ _05367_ VGND VGND VPWR VPWR _05368_ sky130_fd_sc_hd__o21ai_1
X_13771_ _05292_ VGND VGND VPWR VPWR _00087_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_97_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10983_ _02244_ _02252_ _02253_ VGND VGND VPWR VPWR _02254_ sky130_fd_sc_hd__nand3_1
XFILLER_0_69_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15510_ _07185_ _07186_ _07187_ VGND VGND VPWR VPWR _07189_ sky130_fd_sc_hd__a21oi_1
X_12722_ _04142_ _04143_ _04147_ VGND VGND VPWR VPWR _04149_ sky130_fd_sc_hd__and3_1
XFILLER_0_85_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15441_ _07111_ _07112_ _07113_ VGND VGND VPWR VPWR _07114_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_133_Right_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12653_ net805 net871 _04070_ _04071_ VGND VGND VPWR VPWR _04073_ sky130_fd_sc_hd__a211oi_1
X_11604_ net389 _02854_ _02856_ VGND VGND VPWR VPWR _02930_ sky130_fd_sc_hd__nand3_1
XFILLER_0_26_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15372_ _07036_ _07038_ VGND VGND VPWR VPWR _07039_ sky130_fd_sc_hd__xor2_2
X_12584_ net739 net748 net327 net243 VGND VGND VPWR VPWR _03997_ sky130_fd_sc_hd__and4_1
XFILLER_0_25_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14323_ _05879_ _05889_ _05888_ VGND VGND VPWR VPWR _05891_ sky130_fd_sc_hd__o21ai_1
X_11535_ net406 net396 net803 VGND VGND VPWR VPWR _02856_ sky130_fd_sc_hd__o21a_1
XFILLER_0_123_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14254_ net521 net436 net550 net559 VGND VGND VPWR VPWR _05815_ sky130_fd_sc_hd__and4_1
X_11466_ _02675_ _02676_ VGND VGND VPWR VPWR _02781_ sky130_fd_sc_hd__nor2_1
Xmax_cap119 _05719_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__buf_1
XFILLER_0_80_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13205_ _04673_ _04674_ _04666_ VGND VGND VPWR VPWR _04677_ sky130_fd_sc_hd__a21o_1
XFILLER_0_123_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10417_ net363 net785 VGND VGND VPWR VPWR _01681_ sky130_fd_sc_hd__nand2_1
X_14185_ net139 net252 VGND VGND VPWR VPWR _05742_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11397_ _02610_ _02628_ _02704_ VGND VGND VPWR VPWR _02705_ sky130_fd_sc_hd__a21o_1
X_13136_ _04581_ _04599_ _04601_ VGND VGND VPWR VPWR _04602_ sky130_fd_sc_hd__and3_2
X_10348_ _01609_ _01610_ _01611_ VGND VGND VPWR VPWR _01612_ sky130_fd_sc_hd__o21ba_1
X_13067_ net291 _04443_ _04446_ _04444_ VGND VGND VPWR VPWR _04526_ sky130_fd_sc_hd__a22o_1
X_10279_ _01544_ _01547_ _01545_ VGND VGND VPWR VPWR _01553_ sky130_fd_sc_hd__a21bo_1
X_12018_ _03378_ _03380_ VGND VGND VPWR VPWR _03381_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_45_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13969_ _05506_ _05507_ VGND VGND VPWR VPWR _05508_ sky130_fd_sc_hd__nor2_1
X_15708_ _07309_ _07310_ _07404_ VGND VGND VPWR VPWR _07405_ sky130_fd_sc_hd__o21a_1
XFILLER_0_61_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15639_ _06941_ _07049_ _07144_ _07246_ VGND VGND VPWR VPWR _07330_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09160_ _00476_ VGND VGND VPWR VPWR _00005_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08111_ net324 net684 net693 net240 VGND VGND VPWR VPWR _02223_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_127_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09091_ _00193_ VGND VGND VPWR VPWR _00408_ sky130_fd_sc_hd__buf_4
XFILLER_0_142_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09993_ _01229_ _01240_ _01290_ VGND VGND VPWR VPWR _01298_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08944_ _00260_ _00261_ net827 _00256_ VGND VGND VPWR VPWR _00263_ sky130_fd_sc_hd__a211o_1
X_08875_ _00193_ VGND VGND VPWR VPWR _00194_ sky130_fd_sc_hd__buf_4
X_09427_ _00732_ _00734_ VGND VGND VPWR VPWR _00740_ sky130_fd_sc_hd__or2_2
X_09358_ _00575_ _00580_ VGND VGND VPWR VPWR _00672_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08309_ _04174_ _04371_ VGND VGND VPWR VPWR _04382_ sky130_fd_sc_hd__xnor2_1
X_09289_ _00511_ _00513_ _00512_ VGND VGND VPWR VPWR _00604_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_145_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11320_ _02619_ _02620_ VGND VGND VPWR VPWR _02621_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_133_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11251_ _02543_ _02544_ _02535_ VGND VGND VPWR VPWR _02546_ sky130_fd_sc_hd__a21o_1
XFILLER_0_120_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10202_ _01486_ _01487_ VGND VGND VPWR VPWR _01488_ sky130_fd_sc_hd__xnor2_1
X_11182_ _02468_ _02469_ _02449_ VGND VGND VPWR VPWR _02471_ sky130_fd_sc_hd__a21oi_2
X_10133_ net95 _01428_ net138 VGND VGND VPWR VPWR _01429_ sky130_fd_sc_hd__mux2_1
XFILLER_0_100_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15990_ _07709_ _07710_ VGND VGND VPWR VPWR _07711_ sky130_fd_sc_hd__nor2_1
X_10064_ _01363_ _01367_ VGND VGND VPWR VPWR _01368_ sky130_fd_sc_hd__xnor2_1
X_14941_ _06460_ _06568_ VGND VGND VPWR VPWR _06569_ sky130_fd_sc_hd__xor2_1
X_14872_ _06406_ _06408_ _06407_ VGND VGND VPWR VPWR _06494_ sky130_fd_sc_hd__o21bai_1
X_13823_ net727 _00408_ VGND VGND VPWR VPWR _05349_ sky130_fd_sc_hd__or2_1
XFILLER_0_98_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13754_ _05272_ _05273_ VGND VGND VPWR VPWR _05274_ sky130_fd_sc_hd__nand2_1
X_10966_ _02230_ _02233_ _02235_ VGND VGND VPWR VPWR _02236_ sky130_fd_sc_hd__and3_1
X_12705_ _04083_ _04126_ _04128_ VGND VGND VPWR VPWR _04131_ sky130_fd_sc_hd__nor3_1
X_13685_ _05025_ _05022_ _05109_ VGND VGND VPWR VPWR _05200_ sky130_fd_sc_hd__o21ai_1
X_10897_ _02052_ _02130_ _02160_ _02161_ VGND VGND VPWR VPWR _02162_ sky130_fd_sc_hd__a211o_2
XFILLER_0_66_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15424_ _07092_ _07093_ _07094_ VGND VGND VPWR VPWR _07095_ sky130_fd_sc_hd__nand3_1
X_12636_ _04045_ _04052_ _04054_ VGND VGND VPWR VPWR _04055_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_122_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15355_ _07016_ _07017_ _07018_ VGND VGND VPWR VPWR _07021_ sky130_fd_sc_hd__nand3_1
X_12567_ _03968_ _03969_ _03955_ _03967_ VGND VGND VPWR VPWR _03979_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_142_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14306_ net391 net586 VGND VGND VPWR VPWR _05873_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11518_ net427 net349 net500 net512 VGND VGND VPWR VPWR _02837_ sky130_fd_sc_hd__a22o_1
X_15286_ _06756_ _06853_ VGND VGND VPWR VPWR _06946_ sky130_fd_sc_hd__or2b_1
XFILLER_0_80_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12498_ _03885_ _03887_ VGND VGND VPWR VPWR _03903_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14237_ _05793_ _05797_ VGND VGND VPWR VPWR _05798_ sky130_fd_sc_hd__xnor2_1
X_11449_ _02759_ _02760_ _02752_ VGND VGND VPWR VPWR _02762_ sky130_fd_sc_hd__a21oi_1
X_14168_ _05474_ VGND VGND VPWR VPWR _05723_ sky130_fd_sc_hd__inv_2
X_13119_ net230 net150 net219 VGND VGND VPWR VPWR _04583_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14099_ _05647_ _05648_ VGND VGND VPWR VPWR _05649_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_147_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08660_ net220 net669 VGND VGND VPWR VPWR _07972_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08591_ _07379_ _07423_ _07444_ VGND VGND VPWR VPWR _07455_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_89_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09212_ net167 net667 _00525_ _00526_ VGND VGND VPWR VPWR _00528_ sky130_fd_sc_hd__nand4_2
XFILLER_0_146_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09143_ _00432_ _00459_ VGND VGND VPWR VPWR _00460_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_56_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09074_ _00317_ _00303_ VGND VGND VPWR VPWR _00391_ sky130_fd_sc_hd__and2b_1
XFILLER_0_112_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09976_ _01220_ _01200_ _01201_ VGND VGND VPWR VPWR _01282_ sky130_fd_sc_hd__nand3_1
X_08927_ net175 net684 _00243_ _00244_ VGND VGND VPWR VPWR _00246_ sky130_fd_sc_hd__nand4_1
XFILLER_0_99_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08858_ _00175_ _00176_ _08072_ net130 VGND VGND VPWR VPWR _00178_ sky130_fd_sc_hd__a211o_4
X_08789_ net250 net702 VGND VGND VPWR VPWR _08099_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10820_ _02077_ _02083_ VGND VGND VPWR VPWR _02084_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_9_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10751_ _02006_ _02013_ _02014_ VGND VGND VPWR VPWR _02015_ sky130_fd_sc_hd__nand3_2
XFILLER_0_55_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13470_ net423 net508 net158 net304 VGND VGND VPWR VPWR _04965_ sky130_fd_sc_hd__nand4_2
X_10682_ _01945_ _01718_ VGND VGND VPWR VPWR _01946_ sky130_fd_sc_hd__nor2_1
X_12421_ _03815_ _03816_ _03817_ VGND VGND VPWR VPWR _03818_ sky130_fd_sc_hd__or3_1
XFILLER_0_106_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15140_ _06709_ _06711_ _06710_ net654 VGND VGND VPWR VPWR _06786_ sky130_fd_sc_hd__a22o_1
X_12352_ _03708_ _03710_ _03709_ VGND VGND VPWR VPWR _03742_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_23_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11303_ _02601_ _02602_ VGND VGND VPWR VPWR _02603_ sky130_fd_sc_hd__xor2_1
X_15071_ net405 net654 net645 net415 VGND VGND VPWR VPWR _06711_ sky130_fd_sc_hd__a22o_1
XFILLER_0_105_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12283_ _03600_ VGND VGND VPWR VPWR _03667_ sky130_fd_sc_hd__inv_2
X_14022_ _05479_ _05564_ VGND VGND VPWR VPWR _05565_ sky130_fd_sc_hd__xor2_1
X_11234_ _02437_ _02472_ _02473_ VGND VGND VPWR VPWR _02527_ sky130_fd_sc_hd__nor3_1
XFILLER_0_120_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11165_ net234 net407 net155 net416 VGND VGND VPWR VPWR _02453_ sky130_fd_sc_hd__a22o_1
X_10116_ _01412_ _01413_ VGND VGND VPWR VPWR _01414_ sky130_fd_sc_hd__nand2_1
X_15973_ net491 net632 _07620_ VGND VGND VPWR VPWR _07692_ sky130_fd_sc_hd__a21oi_1
X_11096_ _02271_ _02289_ _02375_ _02377_ VGND VGND VPWR VPWR _02378_ sky130_fd_sc_hd__a211o_1
X_10047_ next_state _01349_ _01350_ _01351_ VGND VGND VPWR VPWR _00017_ sky130_fd_sc_hd__a31o_1
X_14924_ _06550_ VGND VGND VPWR VPWR _00097_ sky130_fd_sc_hd__clkbuf_1
X_14855_ net350 net549 net556 net502 VGND VGND VPWR VPWR _06476_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13806_ _05328_ _05330_ _05246_ _05249_ VGND VGND VPWR VPWR _05331_ sky130_fd_sc_hd__o211ai_2
X_14786_ net360 net549 _06397_ _06398_ VGND VGND VPWR VPWR _06401_ sky130_fd_sc_hd__nand4_1
X_11998_ net347 net501 net801 VGND VGND VPWR VPWR _03359_ sky130_fd_sc_hd__o21a_1
XFILLER_0_147_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13737_ _05131_ _05117_ VGND VGND VPWR VPWR _05256_ sky130_fd_sc_hd__or2b_1
XFILLER_0_128_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10949_ _02118_ _02119_ _02120_ VGND VGND VPWR VPWR _02217_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_45_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13668_ _05162_ _05180_ VGND VGND VPWR VPWR _05181_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15407_ _02385_ net573 VGND VGND VPWR VPWR _07077_ sky130_fd_sc_hd__nor2_1
X_12619_ _04034_ _04035_ _04026_ VGND VGND VPWR VPWR _04036_ sky130_fd_sc_hd__nor3b_4
X_13599_ _05027_ _05105_ VGND VGND VPWR VPWR _05106_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15338_ _06999_ _07000_ _06980_ VGND VGND VPWR VPWR _07002_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_124_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15269_ _06800_ _06807_ _06806_ VGND VGND VPWR VPWR _06927_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_111_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout507 net508 VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__clkbuf_4
X_09830_ _01136_ _01137_ VGND VGND VPWR VPWR _01138_ sky130_fd_sc_hd__nand2_1
Xfanout518 net39 VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__buf_6
Xfanout529 net534 VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__buf_4
XFILLER_0_10_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09761_ _01051_ _01069_ VGND VGND VPWR VPWR _01070_ sky130_fd_sc_hd__nand2_1
X_08712_ _08021_ _08022_ VGND VGND VPWR VPWR _08023_ sky130_fd_sc_hd__nor2_1
X_09692_ _00986_ _00987_ _01000_ VGND VGND VPWR VPWR _01002_ sky130_fd_sc_hd__nand3_1
Xrebuffer12 net246 VGND VGND VPWR VPWR net823 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_83_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer23 net875 VGND VGND VPWR VPWR net872 sky130_fd_sc_hd__dlygate4sd1_1
X_08643_ _07952_ _07953_ _07781_ _07791_ VGND VGND VPWR VPWR _07955_ sky130_fd_sc_hd__a211o_1
Xrebuffer34 net844 VGND VGND VPWR VPWR net845 sky130_fd_sc_hd__buf_1
XFILLER_0_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08574_ _07216_ _07249_ _06922_ _07259_ VGND VGND VPWR VPWR _07270_ sky130_fd_sc_hd__o211a_1
XFILLER_0_77_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09126_ net209 net200 net639 net629 VGND VGND VPWR VPWR _00443_ sky130_fd_sc_hd__nand4_1
XFILLER_0_44_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09057_ _00271_ _00320_ _00373_ _00374_ VGND VGND VPWR VPWR _00375_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_114_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09959_ net251 net662 VGND VGND VPWR VPWR _01265_ sky130_fd_sc_hd__nand2_1
X_12970_ _02181_ _04419_ _04420_ VGND VGND VPWR VPWR _04421_ sky130_fd_sc_hd__and3_1
X_11921_ _03267_ _03269_ _03274_ VGND VGND VPWR VPWR _03275_ sky130_fd_sc_hd__o21a_1
X_14640_ _06236_ _06239_ VGND VGND VPWR VPWR _06240_ sky130_fd_sc_hd__xnor2_1
X_11852_ _03188_ _03189_ _03199_ VGND VGND VPWR VPWR _03200_ sky130_fd_sc_hd__a21oi_1
X_10803_ _01995_ _01996_ VGND VGND VPWR VPWR _02067_ sky130_fd_sc_hd__and2_1
X_14571_ _06162_ _06163_ VGND VGND VPWR VPWR _06164_ sky130_fd_sc_hd__and2_1
XFILLER_0_68_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11783_ _03043_ _03044_ VGND VGND VPWR VPWR _03125_ sky130_fd_sc_hd__nor2_2
X_16310_ clknet_4_11_0_clk _00099_ net343 VGND VGND VPWR VPWR b_cos\[3\] sky130_fd_sc_hd__dfrtp_1
X_13522_ _05021_ VGND VGND VPWR VPWR _00084_ sky130_fd_sc_hd__clkbuf_1
X_10734_ net489 net478 net792 net808 VGND VGND VPWR VPWR _01998_ sky130_fd_sc_hd__and4_1
XFILLER_0_82_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16241_ clknet_4_7_0_clk _00030_ net337 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dfrtp_1
X_13453_ _04945_ VGND VGND VPWR VPWR _04946_ sky130_fd_sc_hd__inv_2
X_10665_ net421 net716 VGND VGND VPWR VPWR _01929_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12404_ _03797_ _03798_ VGND VGND VPWR VPWR _03799_ sky130_fd_sc_hd__xor2_1
X_16172_ _00652_ _07906_ _07907_ VGND VGND VPWR VPWR _00113_ sky130_fd_sc_hd__a21oi_1
X_13384_ _04868_ _04869_ _04870_ VGND VGND VPWR VPWR _04871_ sky130_fd_sc_hd__a21o_1
XFILLER_0_51_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10596_ _01857_ _01859_ VGND VGND VPWR VPWR _01860_ sky130_fd_sc_hd__nor2_1
XFILLER_0_112_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15123_ _06765_ _06766_ VGND VGND VPWR VPWR _06767_ sky130_fd_sc_hd__xor2_1
X_12335_ _03706_ _03721_ _03722_ VGND VGND VPWR VPWR _03724_ sky130_fd_sc_hd__nand3_4
XFILLER_0_133_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15054_ _06689_ _06690_ _06674_ VGND VGND VPWR VPWR _06692_ sky130_fd_sc_hd__a21o_1
X_12266_ _03464_ _03591_ _03594_ VGND VGND VPWR VPWR _03649_ sky130_fd_sc_hd__a21oi_1
X_14005_ net609 _00194_ VGND VGND VPWR VPWR _05547_ sky130_fd_sc_hd__or2_1
X_11217_ _02416_ _02418_ _02417_ net490 VGND VGND VPWR VPWR _02509_ sky130_fd_sc_hd__a22o_1
X_12197_ _03570_ _03571_ _03574_ VGND VGND VPWR VPWR _03575_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_120_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput81 net81 VGND VGND VPWR VPWR D[11] sky130_fd_sc_hd__clkbuf_4
Xoutput92 net92 VGND VGND VPWR VPWR D[4] sky130_fd_sc_hd__clkbuf_4
X_11148_ _02431_ _02432_ _02415_ VGND VGND VPWR VPWR _02434_ sky130_fd_sc_hd__a21o_1
XFILLER_0_128_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11079_ _02244_ _02253_ _02252_ VGND VGND VPWR VPWR _02359_ sky130_fd_sc_hd__a21bo_1
X_15956_ _07671_ _07673_ VGND VGND VPWR VPWR _07674_ sky130_fd_sc_hd__nor2_1
X_14907_ _06466_ _06531_ _06532_ VGND VGND VPWR VPWR _06533_ sky130_fd_sc_hd__and3_1
XFILLER_0_78_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15887_ _02388_ net697 VGND VGND VPWR VPWR _07599_ sky130_fd_sc_hd__or2_1
X_14838_ _06374_ _06379_ _06454_ _06456_ VGND VGND VPWR VPWR _06457_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_129_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14769_ net350 net559 net567 net504 VGND VGND VPWR VPWR _06382_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_86_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08290_ _04152_ _04163_ VGND VGND VPWR VPWR _04174_ sky130_fd_sc_hd__nor2_1
XFILLER_0_58_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout304 net310 VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__clkbuf_4
Xfanout315 net316 VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__clkbuf_4
Xfanout326 net327 VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__buf_8
X_09813_ _01064_ _01065_ _01120_ VGND VGND VPWR VPWR _01121_ sky130_fd_sc_hd__o21ai_1
Xfanout337 net338 VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout348 net355 VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__clkbuf_4
Xfanout359 net364 VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__clkbuf_2
X_09744_ net263 net666 net676 net253 VGND VGND VPWR VPWR _01053_ sky130_fd_sc_hd__a22oi_2
X_09675_ _00915_ _00922_ VGND VGND VPWR VPWR _00985_ sky130_fd_sc_hd__and2_1
X_08626_ net293 net283 net581 net590 VGND VGND VPWR VPWR _07835_ sky130_fd_sc_hd__and4_1
XFILLER_0_68_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08557_ net222 net601 _07063_ _07074_ VGND VGND VPWR VPWR _07085_ sky130_fd_sc_hd__and4_1
XFILLER_0_37_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08488_ net222 net583 VGND VGND VPWR VPWR _06333_ sky130_fd_sc_hd__nand2_1
XFILLER_0_64_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_99_Left_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10450_ _01710_ _01712_ _01711_ VGND VGND VPWR VPWR _01714_ sky130_fd_sc_hd__a21o_1
XFILLER_0_45_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09109_ _00422_ _00423_ _00424_ VGND VGND VPWR VPWR _00426_ sky130_fd_sc_hd__a21o_1
XFILLER_0_150_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10381_ _01638_ _01643_ _01644_ VGND VGND VPWR VPWR _01645_ sky130_fd_sc_hd__nand3_2
X_12120_ _03490_ VGND VGND VPWR VPWR _03491_ sky130_fd_sc_hd__inv_2
X_12051_ net613 _02388_ VGND VGND VPWR VPWR _03416_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11002_ _02179_ _02182_ _02273_ _02274_ VGND VGND VPWR VPWR _02275_ sky130_fd_sc_hd__a211o_1
X_15810_ _07513_ _07514_ VGND VGND VPWR VPWR _07515_ sky130_fd_sc_hd__xnor2_2
X_15741_ _07354_ _07356_ VGND VGND VPWR VPWR _07440_ sky130_fd_sc_hd__nand2_1
X_12953_ _04399_ _04400_ _04298_ _04367_ VGND VGND VPWR VPWR _04402_ sky130_fd_sc_hd__o211a_1
X_11904_ _03254_ _03255_ VGND VGND VPWR VPWR _03256_ sky130_fd_sc_hd__xnor2_1
X_15672_ _07344_ _07345_ _07363_ _07364_ VGND VGND VPWR VPWR _07365_ sky130_fd_sc_hd__o211ai_2
X_12884_ _03845_ _03869_ _04304_ _04305_ VGND VGND VPWR VPWR _04326_ sky130_fd_sc_hd__o211a_1
XFILLER_0_87_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14623_ net382 net549 net559 net371 VGND VGND VPWR VPWR _06221_ sky130_fd_sc_hd__a22oi_2
X_11835_ net232 net492 VGND VGND VPWR VPWR _03182_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14554_ _05987_ _05989_ _06045_ _06044_ VGND VGND VPWR VPWR _06145_ sky130_fd_sc_hd__a211o_1
X_11766_ _03102_ _03103_ _03104_ VGND VGND VPWR VPWR _03107_ sky130_fd_sc_hd__a21o_1
XFILLER_0_56_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13505_ _04891_ _04904_ _04902_ VGND VGND VPWR VPWR _05004_ sky130_fd_sc_hd__a21o_1
X_10717_ _01975_ _01980_ VGND VGND VPWR VPWR _01981_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_71_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14485_ _06067_ _06068_ VGND VGND VPWR VPWR _06070_ sky130_fd_sc_hd__xnor2_1
X_11697_ _03027_ _03028_ _03030_ VGND VGND VPWR VPWR _03032_ sky130_fd_sc_hd__nand3_1
XFILLER_0_126_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16224_ clknet_4_6_0_clk _00013_ net335 VGND VGND VPWR VPWR b_sin\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_125_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13436_ _04920_ _04922_ VGND VGND VPWR VPWR _04928_ sky130_fd_sc_hd__nor2_1
X_10648_ _01715_ _01720_ VGND VGND VPWR VPWR _01912_ sky130_fd_sc_hd__and2_1
Xrebuffer3 _04160_ VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__clkbuf_1
X_16155_ _07887_ _07888_ VGND VGND VPWR VPWR _07890_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13367_ _04745_ _04750_ VGND VGND VPWR VPWR _04853_ sky130_fd_sc_hd__nand2_1
X_10579_ _01829_ _01830_ _01842_ VGND VGND VPWR VPWR _01843_ sky130_fd_sc_hd__and3_1
X_15106_ _06746_ _06747_ _06642_ VGND VGND VPWR VPWR _06750_ sky130_fd_sc_hd__o21ai_1
X_12318_ _03697_ _03692_ _03693_ VGND VGND VPWR VPWR _03705_ sky130_fd_sc_hd__nand3_1
X_16086_ net442 net660 VGND VGND VPWR VPWR _07815_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13298_ _04773_ _04775_ _04776_ VGND VGND VPWR VPWR _04778_ sky130_fd_sc_hd__a21o_1
XFILLER_0_48_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15037_ _06596_ _06603_ _06602_ VGND VGND VPWR VPWR _06674_ sky130_fd_sc_hd__a21o_1
X_12249_ _03545_ _03566_ _03630_ VGND VGND VPWR VPWR _03631_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_139_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_147_Right_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15939_ _07579_ _07645_ VGND VGND VPWR VPWR _07655_ sky130_fd_sc_hd__and2_1
X_09460_ _00764_ _00772_ VGND VGND VPWR VPWR _00773_ sky130_fd_sc_hd__xnor2_1
X_08411_ _05209_ _05372_ _05362_ VGND VGND VPWR VPWR _05492_ sky130_fd_sc_hd__a21o_1
XFILLER_0_149_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09391_ net289 net280 net689 net701 VGND VGND VPWR VPWR _00705_ sky130_fd_sc_hd__and4_1
XFILLER_0_148_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08342_ _04720_ _04731_ VGND VGND VPWR VPWR _04741_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_80_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08273_ _03954_ _03965_ _03756_ _03767_ VGND VGND VPWR VPWR _03987_ sky130_fd_sc_hd__a211o_1
XFILLER_0_74_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout134 net135 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__clkbuf_4
Xfanout145 net147 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__buf_1
Xfanout156 net871 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__clkbuf_2
Xfanout167 net168 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__buf_4
Xfanout178 net182 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__buf_2
Xfanout189 net191 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_114_Right_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09727_ _01013_ _01014_ _01034_ _01035_ VGND VGND VPWR VPWR _01037_ sky130_fd_sc_hd__nand4_2
X_09658_ _00872_ _00891_ _00968_ VGND VGND VPWR VPWR _00969_ sky130_fd_sc_hd__a21oi_2
X_08609_ _07042_ _07607_ _06212_ _07618_ _07640_ VGND VGND VPWR VPWR _07651_ sky130_fd_sc_hd__a2111o_1
X_09589_ _00828_ _00900_ VGND VGND VPWR VPWR _00901_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_65_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11620_ _02945_ _02946_ _02937_ VGND VGND VPWR VPWR _02948_ sky130_fd_sc_hd__a21o_1
XFILLER_0_38_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11551_ _02864_ _02871_ _02872_ VGND VGND VPWR VPWR _02873_ sky130_fd_sc_hd__nand3_1
XFILLER_0_9_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10502_ _01760_ _01761_ _01765_ VGND VGND VPWR VPWR _01766_ sky130_fd_sc_hd__a21o_1
X_14270_ _05825_ _05831_ _05832_ VGND VGND VPWR VPWR _05833_ sky130_fd_sc_hd__nand3_1
X_11482_ _02701_ _02797_ VGND VGND VPWR VPWR _02798_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_150_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13221_ _04684_ _04693_ VGND VGND VPWR VPWR _04694_ sky130_fd_sc_hd__xor2_1
X_10433_ _01663_ _01664_ _01662_ VGND VGND VPWR VPWR _01697_ sky130_fd_sc_hd__o21bai_1
X_13152_ _04520_ _04617_ _04618_ VGND VGND VPWR VPWR _04619_ sky130_fd_sc_hd__nand3_1
X_10364_ _01618_ _01624_ _01627_ VGND VGND VPWR VPWR _01628_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_20_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12103_ _03470_ _03471_ VGND VGND VPWR VPWR _03472_ sky130_fd_sc_hd__xnor2_1
X_13083_ _04541_ _04542_ VGND VGND VPWR VPWR _04543_ sky130_fd_sc_hd__xor2_1
XFILLER_0_103_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10295_ _01558_ _01562_ _01566_ VGND VGND VPWR VPWR _01567_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_130_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12034_ _03384_ _03381_ VGND VGND VPWR VPWR _03397_ sky130_fd_sc_hd__and2b_1
Xfanout690 net692 VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__clkbuf_4
X_13985_ _05446_ _05515_ VGND VGND VPWR VPWR _05525_ sky130_fd_sc_hd__and2_1
X_12936_ _04379_ _04383_ VGND VGND VPWR VPWR _04384_ sky130_fd_sc_hd__xnor2_1
X_15724_ _07419_ _07421_ VGND VGND VPWR VPWR _07422_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_34_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12867_ _04243_ _04307_ _04308_ VGND VGND VPWR VPWR _04309_ sky130_fd_sc_hd__and3_2
XFILLER_0_87_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15655_ _07257_ _07265_ _07264_ VGND VGND VPWR VPWR _07347_ sky130_fd_sc_hd__a21o_1
XFILLER_0_96_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14606_ _06199_ _06200_ _06202_ VGND VGND VPWR VPWR _06203_ sky130_fd_sc_hd__or3_1
X_11818_ _03161_ _03163_ VGND VGND VPWR VPWR _03164_ sky130_fd_sc_hd__xnor2_1
X_15586_ _07223_ VGND VGND VPWR VPWR _07272_ sky130_fd_sc_hd__inv_2
XFILLER_0_29_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12798_ _03936_ _03985_ VGND VGND VPWR VPWR _04233_ sky130_fd_sc_hd__or2_1
XFILLER_0_141_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14537_ _06119_ _06117_ _06118_ VGND VGND VPWR VPWR _06127_ sky130_fd_sc_hd__and3_1
X_11749_ _03088_ VGND VGND VPWR VPWR _00067_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_55_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14468_ _05848_ _05847_ _05840_ VGND VGND VPWR VPWR _06051_ sky130_fd_sc_hd__a21o_1
XFILLER_0_114_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13419_ _04906_ _04909_ VGND VGND VPWR VPWR _04910_ sky130_fd_sc_hd__xor2_2
X_16207_ _07931_ _07945_ VGND VGND VPWR VPWR _07946_ sky130_fd_sc_hd__xnor2_1
X_14399_ _05973_ _05972_ _05929_ _05916_ VGND VGND VPWR VPWR _05975_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_24_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16138_ _07866_ _07870_ VGND VGND VPWR VPWR _07871_ sky130_fd_sc_hd__xor2_1
XFILLER_0_51_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08960_ _00177_ _00198_ _00277_ _00278_ VGND VGND VPWR VPWR _00279_ sky130_fd_sc_hd__a211o_1
X_16069_ _07794_ _07795_ VGND VGND VPWR VPWR _07796_ sky130_fd_sc_hd__or2_1
X_08891_ _08008_ _08102_ _08101_ VGND VGND VPWR VPWR _00210_ sky130_fd_sc_hd__a21bo_1
X_09512_ b_sin\[9\] _00739_ VGND VGND VPWR VPWR _00825_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09443_ _00748_ _00755_ VGND VGND VPWR VPWR _00756_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_19_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09374_ net194 net630 _00614_ _00687_ VGND VGND VPWR VPWR _00688_ sky130_fd_sc_hd__a31o_1
XFILLER_0_93_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08325_ _04502_ _04534_ _04349_ _04338_ VGND VGND VPWR VPWR _04556_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_35_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08256_ _03236_ _03257_ _03246_ VGND VGND VPWR VPWR _03800_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_61_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08187_ _02550_ _02713_ _03018_ _03029_ VGND VGND VPWR VPWR _03051_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_43_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_18_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10080_ _01352_ _01349_ _01382_ VGND VGND VPWR VPWR _01384_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_97_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13770_ a_sin\[10\] _05290_ _05291_ VGND VGND VPWR VPWR _05292_ sky130_fd_sc_hd__mux2_1
X_10982_ _02249_ _02250_ _02251_ VGND VGND VPWR VPWR _02253_ sky130_fd_sc_hd__a21o_1
X_12721_ _04142_ _04143_ _04147_ VGND VGND VPWR VPWR _04148_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_27_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15440_ _07022_ _07019_ _07021_ _07025_ VGND VGND VPWR VPWR _07113_ sky130_fd_sc_hd__a31o_1
X_12652_ _04070_ _04071_ net805 net162 VGND VGND VPWR VPWR _04072_ sky130_fd_sc_hd__o211a_1
XFILLER_0_37_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11603_ net389 net803 _02854_ _02856_ VGND VGND VPWR VPWR _02929_ sky130_fd_sc_hd__a22o_1
X_15371_ _06904_ _06931_ _07037_ VGND VGND VPWR VPWR _07038_ sky130_fd_sc_hd__a21oi_2
X_12583_ net739 net327 net243 net748 VGND VGND VPWR VPWR _03996_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_65_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_880 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14322_ _05879_ _05888_ _05889_ VGND VGND VPWR VPWR _05890_ sky130_fd_sc_hd__or3_1
XFILLER_0_108_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11534_ net406 net396 net803 VGND VGND VPWR VPWR _02854_ sky130_fd_sc_hd__nand3_2
XFILLER_0_53_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_850 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14253_ next_state _05812_ _05813_ _05814_ VGND VGND VPWR VPWR _00095_ sky130_fd_sc_hd__a31o_1
XFILLER_0_105_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11465_ _02675_ _02676_ VGND VGND VPWR VPWR _02780_ sky130_fd_sc_hd__nand2_1
XFILLER_0_123_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13204_ _04666_ _04673_ _04674_ VGND VGND VPWR VPWR _04675_ sky130_fd_sc_hd__nand3_2
XFILLER_0_61_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10416_ _01639_ _01642_ _01640_ VGND VGND VPWR VPWR _01680_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_36_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14184_ net140 net270 _05661_ _05621_ VGND VGND VPWR VPWR _05740_ sky130_fd_sc_hd__a31o_1
X_11396_ _02627_ _02611_ VGND VGND VPWR VPWR _02704_ sky130_fd_sc_hd__and2b_1
X_13135_ _04596_ _04597_ _04598_ VGND VGND VPWR VPWR _04601_ sky130_fd_sc_hd__a21o_1
XFILLER_0_103_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10347_ net413 net401 net760 net769 VGND VGND VPWR VPWR _01611_ sky130_fd_sc_hd__and4_1
X_13066_ _04442_ _04457_ _04459_ _04462_ VGND VGND VPWR VPWR _04525_ sky130_fd_sc_hd__a31o_1
X_10278_ _01550_ _01551_ VGND VGND VPWR VPWR _01552_ sky130_fd_sc_hd__or2_1
X_12017_ _03284_ _03305_ _03379_ VGND VGND VPWR VPWR _03380_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_136_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmax_cap1 net862 VGND VGND VPWR VPWR net861 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_45_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13968_ _05502_ _05504_ _05505_ VGND VGND VPWR VPWR _05507_ sky130_fd_sc_hd__and3_1
XFILLER_0_88_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15707_ _07302_ _07308_ VGND VGND VPWR VPWR _07404_ sky130_fd_sc_hd__nand2_1
X_12919_ _04362_ _04363_ _04342_ _04343_ VGND VGND VPWR VPWR _04365_ sky130_fd_sc_hd__a211o_1
X_13899_ _05407_ _05408_ _05430_ _05431_ VGND VGND VPWR VPWR _05432_ sky130_fd_sc_hd__a22o_1
XFILLER_0_61_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15638_ _07327_ _07328_ VGND VGND VPWR VPWR _07329_ sky130_fd_sc_hd__or2b_1
XFILLER_0_28_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15569_ _07025_ _07185_ _07186_ VGND VGND VPWR VPWR _07253_ sky130_fd_sc_hd__and3_2
XFILLER_0_145_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08110_ net324 net240 net684 net693 VGND VGND VPWR VPWR _02212_ sky130_fd_sc_hd__and4_1
XFILLER_0_126_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09090_ _00404_ _00406_ VGND VGND VPWR VPWR _00407_ sky130_fd_sc_hd__xor2_4
XFILLER_0_43_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_872 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09992_ _01236_ _01295_ VGND VGND VPWR VPWR _01297_ sky130_fd_sc_hd__or2_1
X_08943_ net828 _00256_ _00260_ _00261_ VGND VGND VPWR VPWR _00262_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_86_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
X_08874_ _00192_ VGND VGND VPWR VPWR _00193_ sky130_fd_sc_hd__buf_4
XFILLER_0_79_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09426_ net863 VGND VGND VPWR VPWR _00739_ sky130_fd_sc_hd__buf_4
XFILLER_0_19_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09357_ _00668_ _00670_ VGND VGND VPWR VPWR _00671_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_136_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08308_ net196 net564 VGND VGND VPWR VPWR _04371_ sky130_fd_sc_hd__nand2_1
XFILLER_0_117_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09288_ _00599_ _00600_ _00601_ VGND VGND VPWR VPWR _00603_ sky130_fd_sc_hd__nand3_1
XFILLER_0_62_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08239_ _02942_ _02964_ _02953_ VGND VGND VPWR VPWR _03615_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_62_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11250_ _02535_ _02543_ _02544_ VGND VGND VPWR VPWR _02545_ sky130_fd_sc_hd__nand3_2
X_10201_ _01478_ _01479_ _01480_ VGND VGND VPWR VPWR _01487_ sky130_fd_sc_hd__o21ai_1
X_11181_ _02449_ _02468_ _02469_ VGND VGND VPWR VPWR _02470_ sky130_fd_sc_hd__and3_2
X_10132_ _01426_ _01427_ VGND VGND VPWR VPWR _01428_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_101_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10063_ _01364_ _01366_ VGND VGND VPWR VPWR _01367_ sky130_fd_sc_hd__xnor2_1
X_14940_ _06566_ _06567_ VGND VGND VPWR VPWR _06568_ sky130_fd_sc_hd__or2b_1
X_14871_ _06398_ _06401_ VGND VGND VPWR VPWR _06493_ sky130_fd_sc_hd__nand2_1
XFILLER_0_98_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13822_ _05344_ _05347_ VGND VGND VPWR VPWR _05348_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_106_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13753_ _05270_ _05271_ VGND VGND VPWR VPWR _05273_ sky130_fd_sc_hd__or2_1
XFILLER_0_58_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10965_ net864 net362 _02231_ _02232_ VGND VGND VPWR VPWR _02235_ sky130_fd_sc_hd__nand4_1
X_12704_ _04083_ _04126_ _04128_ VGND VGND VPWR VPWR _04129_ sky130_fd_sc_hd__o21a_1
XFILLER_0_85_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13684_ _04823_ _04924_ _05017_ _05110_ VGND VGND VPWR VPWR _05198_ sky130_fd_sc_hd__or4_4
X_10896_ _02157_ _02158_ _02140_ VGND VGND VPWR VPWR _02161_ sky130_fd_sc_hd__a21oi_2
X_12635_ _04051_ _04046_ _04047_ VGND VGND VPWR VPWR _04054_ sky130_fd_sc_hd__nand3_1
X_15423_ _06988_ _06990_ _06989_ VGND VGND VPWR VPWR _07094_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_109_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15354_ _07016_ _07017_ _07018_ VGND VGND VPWR VPWR _07019_ sky130_fd_sc_hd__a21o_1
X_12566_ _03975_ _03977_ VGND VGND VPWR VPWR _03978_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14305_ _05869_ _05870_ VGND VGND VPWR VPWR _05872_ sky130_fd_sc_hd__nor2_1
X_11517_ _02834_ _02835_ VGND VGND VPWR VPWR _02836_ sky130_fd_sc_hd__xnor2_1
X_15285_ _06749_ _06943_ VGND VGND VPWR VPWR _06945_ sky130_fd_sc_hd__or2_1
X_12497_ _03774_ _03775_ _03808_ _03809_ VGND VGND VPWR VPWR _03902_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_124_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14236_ _05794_ _05796_ VGND VGND VPWR VPWR _05797_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_111_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11448_ _02752_ _02759_ _02760_ VGND VGND VPWR VPWR _02761_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14167_ _05706_ _05707_ VGND VGND VPWR VPWR _05722_ sky130_fd_sc_hd__and2b_1
XFILLER_0_1_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11379_ _02526_ _02590_ _02589_ VGND VGND VPWR VPWR _02686_ sky130_fd_sc_hd__a21boi_1
X_13118_ net313 net203 VGND VGND VPWR VPWR _04582_ sky130_fd_sc_hd__and2_1
X_14098_ _05578_ _05583_ _05580_ VGND VGND VPWR VPWR _05648_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_147_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13049_ _04504_ _04505_ _04440_ VGND VGND VPWR VPWR _04507_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_147_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_53_Left_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08590_ net215 net703 _07433_ VGND VGND VPWR VPWR _07444_ sky130_fd_sc_hd__nand3_1
XFILLER_0_48_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09211_ net167 net667 _00525_ _00526_ VGND VGND VPWR VPWR _00527_ sky130_fd_sc_hd__a22o_1
XFILLER_0_29_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09142_ _00457_ _00458_ VGND VGND VPWR VPWR _00459_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_62_Left_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09073_ _00299_ _00380_ _00379_ VGND VGND VPWR VPWR _00390_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_44_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout3 _02159_ VGND VGND VPWR VPWR net863 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09975_ _01257_ _01279_ VGND VGND VPWR VPWR _01281_ sky130_fd_sc_hd__and2_1
X_08926_ net175 net684 _00243_ _00244_ VGND VGND VPWR VPWR _00245_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_71_Left_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08857_ _08072_ net130 _00175_ _00176_ VGND VGND VPWR VPWR _00177_ sky130_fd_sc_hd__o211ai_4
X_08788_ net589 _08007_ _08097_ VGND VGND VPWR VPWR _08098_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_98_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10750_ _01985_ _01986_ _02004_ _02005_ VGND VGND VPWR VPWR _02014_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_95_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09409_ _00700_ _00722_ VGND VGND VPWR VPWR _00723_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_82_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_80_Left_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10681_ net383 net372 net761 net770 VGND VGND VPWR VPWR _01945_ sky130_fd_sc_hd__and4_1
XFILLER_0_48_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12420_ net313 net322 net238 net425 VGND VGND VPWR VPWR _03817_ sky130_fd_sc_hd__a22oi_2
X_12351_ _03715_ _03720_ _03714_ VGND VGND VPWR VPWR _03741_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_105_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11302_ _02493_ _02498_ _02492_ VGND VGND VPWR VPWR _02602_ sky130_fd_sc_hd__a21bo_1
X_15070_ net415 net405 net645 VGND VGND VPWR VPWR _06710_ sky130_fd_sc_hd__and3_1
X_12282_ _03665_ _03596_ _03343_ VGND VGND VPWR VPWR _03666_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_22_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14021_ _05560_ _05563_ VGND VGND VPWR VPWR _05564_ sky130_fd_sc_hd__xnor2_1
X_11233_ _02507_ _02525_ VGND VGND VPWR VPWR _02526_ sky130_fd_sc_hd__xor2_1
X_11164_ net234 net416 net154 VGND VGND VPWR VPWR _02451_ sky130_fd_sc_hd__and3_1
XFILLER_0_101_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10115_ a_cos\[5\] b_sin\[5\] VGND VGND VPWR VPWR _01413_ sky130_fd_sc_hd__nand2_1
X_15972_ net491 net623 VGND VGND VPWR VPWR _07691_ sky130_fd_sc_hd__nand2_1
X_11095_ _02373_ _02374_ _02199_ VGND VGND VPWR VPWR _02377_ sky130_fd_sc_hd__a21oi_1
X_14923_ b_cos\[1\] _06549_ _05291_ VGND VGND VPWR VPWR _06550_ sky130_fd_sc_hd__mux2_1
X_10046_ b_sin\[17\] net863 VGND VGND VPWR VPWR _01351_ sky130_fd_sc_hd__and2_1
X_14854_ _06472_ _06473_ VGND VGND VPWR VPWR _06474_ sky130_fd_sc_hd__xnor2_1
X_13805_ _05327_ _05315_ _05316_ VGND VGND VPWR VPWR _05330_ sky130_fd_sc_hd__and3_2
X_14785_ net360 net549 _06397_ _06398_ VGND VGND VPWR VPWR _06400_ sky130_fd_sc_hd__a22o_1
X_11997_ net347 net501 net801 VGND VGND VPWR VPWR _03358_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_119_Left_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13736_ _05176_ _05178_ _05254_ VGND VGND VPWR VPWR _05255_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_85_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10948_ _02211_ _02213_ _02214_ VGND VGND VPWR VPWR _02216_ sky130_fd_sc_hd__nand3_1
XFILLER_0_46_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10879_ net514 net412 net401 net616 VGND VGND VPWR VPWR _02143_ sky130_fd_sc_hd__a22oi_2
X_13667_ _05163_ _05179_ VGND VGND VPWR VPWR _05180_ sky130_fd_sc_hd__xor2_1
XFILLER_0_128_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15406_ _07072_ _07075_ VGND VGND VPWR VPWR _07076_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_5_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12618_ _04032_ _04033_ _04021_ _04030_ VGND VGND VPWR VPWR _04035_ sky130_fd_sc_hd__o211a_1
X_13598_ _05102_ _05104_ VGND VGND VPWR VPWR _05105_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_108_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12549_ _03956_ _03958_ VGND VGND VPWR VPWR _03959_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_54_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15337_ _06980_ _06999_ _07000_ VGND VGND VPWR VPWR _07001_ sky130_fd_sc_hd__and3_1
XFILLER_0_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_1 _00834_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_77_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15268_ _06924_ _06925_ VGND VGND VPWR VPWR _06926_ sky130_fd_sc_hd__or2_1
XFILLER_0_111_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14219_ _05765_ _05762_ VGND VGND VPWR VPWR _05778_ sky130_fd_sc_hd__and2b_1
XFILLER_0_112_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15199_ _06740_ _06742_ _06849_ _06850_ VGND VGND VPWR VPWR _06851_ sky130_fd_sc_hd__o211a_1
XFILLER_0_10_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout508 net515 VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__buf_4
Xfanout519 net521 VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__buf_2
X_09760_ _01067_ _01068_ VGND VGND VPWR VPWR _01069_ sky130_fd_sc_hd__and2_1
X_08711_ net293 net283 net572 net581 VGND VGND VPWR VPWR _08022_ sky130_fd_sc_hd__and4_1
X_09691_ _00986_ _00987_ _01000_ VGND VGND VPWR VPWR _01001_ sky130_fd_sc_hd__a21o_1
XFILLER_0_83_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08642_ _07781_ _07791_ _07952_ _07953_ VGND VGND VPWR VPWR _07954_ sky130_fd_sc_hd__o211ai_4
Xrebuffer13 net330 VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__buf_1
Xrebuffer24 _02364_ VGND VGND VPWR VPWR net835 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer35 net845 VGND VGND VPWR VPWR net846 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_83_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08573_ net877 _06911_ _06900_ VGND VGND VPWR VPWR _07259_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_76_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09125_ net200 net639 net629 net209 VGND VGND VPWR VPWR _00442_ sky130_fd_sc_hd__a22o_1
XFILLER_0_60_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09056_ _00371_ _00372_ _00341_ VGND VGND VPWR VPWR _00374_ sky130_fd_sc_hd__a21o_1
XFILLER_0_102_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09958_ _01262_ _01263_ VGND VGND VPWR VPWR _01264_ sky130_fd_sc_hd__nor2_1
X_08909_ _00225_ _00226_ _00227_ VGND VGND VPWR VPWR _00228_ sky130_fd_sc_hd__a21o_1
X_09889_ _01193_ _01195_ VGND VGND VPWR VPWR _01196_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_99_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11920_ _03270_ _03273_ VGND VGND VPWR VPWR _03274_ sky130_fd_sc_hd__xnor2_1
X_11851_ _03197_ _03198_ VGND VGND VPWR VPWR _03199_ sky130_fd_sc_hd__xor2_1
XFILLER_0_68_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10802_ _02063_ _02064_ _01972_ _02035_ VGND VGND VPWR VPWR _02066_ sky130_fd_sc_hd__o211a_1
XFILLER_0_67_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14570_ _06150_ _06160_ VGND VGND VPWR VPWR _06163_ sky130_fd_sc_hd__xnor2_1
X_11782_ _03046_ _03123_ VGND VGND VPWR VPWR _03124_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_94_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13521_ a_sin\[7\] _05020_ _03521_ VGND VGND VPWR VPWR _05021_ sky130_fd_sc_hd__mux2_1
X_10733_ _01995_ _01996_ VGND VGND VPWR VPWR _01997_ sky130_fd_sc_hd__xor2_1
XFILLER_0_67_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13452_ _04843_ _04846_ _04844_ VGND VGND VPWR VPWR _04945_ sky130_fd_sc_hd__o21ba_1
X_16240_ clknet_4_13_0_clk _00029_ net337 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_137_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10664_ _01698_ _01700_ _01699_ VGND VGND VPWR VPWR _01928_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_35_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12403_ net788 net299 _03784_ _03782_ VGND VGND VPWR VPWR _03798_ sky130_fd_sc_hd__a31o_1
XFILLER_0_36_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13383_ net710 net301 VGND VGND VPWR VPWR _04870_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16171_ net854 _02181_ VGND VGND VPWR VPWR _07907_ sky130_fd_sc_hd__nor2_1
X_10595_ _01857_ _01858_ net418 net795 VGND VGND VPWR VPWR _01859_ sky130_fd_sc_hd__and4b_1
XFILLER_0_23_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12334_ _03714_ _03715_ _03720_ VGND VGND VPWR VPWR _03722_ sky130_fd_sc_hd__a21o_1
X_15122_ net468 net567 VGND VGND VPWR VPWR _06766_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15053_ _06674_ _06689_ _06690_ VGND VGND VPWR VPWR _06691_ sky130_fd_sc_hd__nand3_1
X_12265_ _03639_ _03644_ _03636_ VGND VGND VPWR VPWR _03648_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_128_Right_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14004_ _05541_ _05544_ VGND VGND VPWR VPWR _05545_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_120_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11216_ _02415_ _02431_ _02432_ _02435_ VGND VGND VPWR VPWR _02508_ sky130_fd_sc_hd__a31o_1
X_12196_ _03573_ _03484_ VGND VGND VPWR VPWR _03574_ sky130_fd_sc_hd__or2_1
Xoutput82 net82 VGND VGND VPWR VPWR D[12] sky130_fd_sc_hd__clkbuf_4
Xoutput93 net93 VGND VGND VPWR VPWR D[5] sky130_fd_sc_hd__clkbuf_4
X_11147_ _02415_ _02431_ _02432_ VGND VGND VPWR VPWR _02433_ sky130_fd_sc_hd__nand3_1
X_15955_ _07592_ _07591_ VGND VGND VPWR VPWR _07673_ sky130_fd_sc_hd__and2b_1
X_11078_ _02355_ _02356_ _02347_ VGND VGND VPWR VPWR _02358_ sky130_fd_sc_hd__a21o_1
X_10029_ _01324_ _01253_ _01333_ VGND VGND VPWR VPWR _01334_ sky130_fd_sc_hd__nor3_1
X_14906_ _06528_ _06529_ _06428_ _06430_ VGND VGND VPWR VPWR _06532_ sky130_fd_sc_hd__o211ai_2
X_15886_ _07593_ _07597_ VGND VGND VPWR VPWR _07598_ sky130_fd_sc_hd__xnor2_1
X_14837_ net708 _06455_ VGND VGND VPWR VPWR _06456_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14768_ net495 net574 VGND VGND VPWR VPWR _06381_ sky130_fd_sc_hd__nand2_1
X_13719_ _05235_ net798 _00834_ VGND VGND VPWR VPWR _05236_ sky130_fd_sc_hd__and3b_1
XFILLER_0_74_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14699_ net360 net559 VGND VGND VPWR VPWR _06305_ sky130_fd_sc_hd__nand2_1
XFILLER_0_116_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout305 net310 VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout316 net319 VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__buf_4
Xfanout327 net328 VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__buf_8
X_09812_ _01060_ _01063_ VGND VGND VPWR VPWR _01120_ sky130_fd_sc_hd__or2_1
Xfanout338 net58 VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__clkbuf_4
Xfanout349 net355 VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__buf_2
X_09743_ _00988_ _00991_ _00989_ VGND VGND VPWR VPWR _01052_ sky130_fd_sc_hd__o21ba_1
X_09674_ _00921_ _00920_ VGND VGND VPWR VPWR _00984_ sky130_fd_sc_hd__and2b_1
XFILLER_0_118_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08625_ net293 net581 net590 net283 VGND VGND VPWR VPWR _07824_ sky130_fd_sc_hd__a22oi_1
X_08556_ net326 net583 net591 net242 VGND VGND VPWR VPWR _07074_ sky130_fd_sc_hd__a22o_1
XFILLER_0_76_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08487_ net224 net575 _05860_ _05849_ VGND VGND VPWR VPWR _06322_ sky130_fd_sc_hd__a22o_1
XFILLER_0_147_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09108_ _00422_ _00423_ _00424_ VGND VGND VPWR VPWR _00425_ sky130_fd_sc_hd__nand3_1
X_10380_ _01632_ _01637_ _01636_ VGND VGND VPWR VPWR _01644_ sky130_fd_sc_hd__a21o_1
XFILLER_0_33_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09039_ _00355_ _00356_ VGND VGND VPWR VPWR _00357_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_60_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12050_ _03411_ _03414_ VGND VGND VPWR VPWR _03415_ sky130_fd_sc_hd__xor2_1
X_11001_ _02271_ _02272_ _02174_ VGND VGND VPWR VPWR _02274_ sky130_fd_sc_hd__a21oi_1
X_15740_ _07437_ _07438_ VGND VGND VPWR VPWR _07439_ sky130_fd_sc_hd__xnor2_1
X_12952_ _04298_ _04367_ _04399_ _04400_ VGND VGND VPWR VPWR _04401_ sky130_fd_sc_hd__a211oi_4
X_11903_ net426 net465 VGND VGND VPWR VPWR _03255_ sky130_fd_sc_hd__nand2_1
X_15671_ _07361_ _07362_ _07347_ VGND VGND VPWR VPWR _07364_ sky130_fd_sc_hd__a21o_1
X_12883_ _03873_ _04311_ _04312_ VGND VGND VPWR VPWR _04325_ sky130_fd_sc_hd__nand3b_2
X_14622_ net382 net371 net549 net559 VGND VGND VPWR VPWR _06220_ sky130_fd_sc_hd__and4_1
X_11834_ _03178_ _03179_ VGND VGND VPWR VPWR _03180_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14553_ _06082_ _06048_ _06083_ _06046_ VGND VGND VPWR VPWR _06144_ sky130_fd_sc_hd__a2bb2o_1
X_11765_ _03102_ _03103_ _03104_ VGND VGND VPWR VPWR _03106_ sky130_fd_sc_hd__nand3_2
XFILLER_0_67_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13504_ _04990_ _05001_ VGND VGND VPWR VPWR _05002_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_82_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10716_ _01976_ _01979_ VGND VGND VPWR VPWR _01980_ sky130_fd_sc_hd__xnor2_2
X_14484_ net391 net706 _06053_ _06052_ VGND VGND VPWR VPWR _06068_ sky130_fd_sc_hd__a31oi_2
X_11696_ _03027_ _03028_ _03030_ VGND VGND VPWR VPWR _03031_ sky130_fd_sc_hd__a21o_1
X_16223_ clknet_4_3_0_clk _00012_ net336 VGND VGND VPWR VPWR b_sin\[12\] sky130_fd_sc_hd__dfrtp_1
X_13435_ _04926_ VGND VGND VPWR VPWR _00083_ sky130_fd_sc_hd__clkbuf_1
X_10647_ _01722_ VGND VGND VPWR VPWR _01911_ sky130_fd_sc_hd__inv_2
XFILLER_0_24_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer4 _04160_ VGND VGND VPWR VPWR net815 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_106_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13366_ _04848_ _04851_ VGND VGND VPWR VPWR _04852_ sky130_fd_sc_hd__xnor2_2
X_16154_ _07803_ _07830_ VGND VGND VPWR VPWR _07888_ sky130_fd_sc_hd__nor2_1
XFILLER_0_23_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10578_ _01833_ _01840_ _01841_ VGND VGND VPWR VPWR _01842_ sky130_fd_sc_hd__a21o_1
XFILLER_0_23_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15105_ _06642_ _06746_ _06747_ VGND VGND VPWR VPWR _06749_ sky130_fd_sc_hd__or3_4
X_12317_ _03699_ _03703_ VGND VGND VPWR VPWR _03704_ sky130_fd_sc_hd__xnor2_2
X_13297_ _04773_ _04775_ _04776_ VGND VGND VPWR VPWR _04777_ sky130_fd_sc_hd__nand3_1
X_16085_ _07811_ _07812_ VGND VGND VPWR VPWR _07814_ sky130_fd_sc_hd__nor2_1
X_15036_ _06585_ _06587_ VGND VGND VPWR VPWR _06673_ sky130_fd_sc_hd__nand2_1
X_12248_ _03547_ _03565_ VGND VGND VPWR VPWR _03630_ sky130_fd_sc_hd__and2_1
X_12179_ _03553_ _03554_ VGND VGND VPWR VPWR _03555_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_48_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15938_ _07654_ VGND VGND VPWR VPWR _00109_ sky130_fd_sc_hd__clkbuf_1
X_15869_ _07572_ _07573_ VGND VGND VPWR VPWR _07579_ sky130_fd_sc_hd__and2_1
XFILLER_0_149_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08410_ _05427_ _05470_ VGND VGND VPWR VPWR _05481_ sky130_fd_sc_hd__xnor2_1
X_09390_ net289 net689 net696 net280 VGND VGND VPWR VPWR _00704_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08341_ net196 net575 VGND VGND VPWR VPWR _04731_ sky130_fd_sc_hd__nand2_1
XFILLER_0_80_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08272_ _03756_ _03767_ _03954_ _03965_ VGND VGND VPWR VPWR _03976_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_117_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout135 state VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__buf_4
Xfanout146 net147 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__clkbuf_2
Xfanout157 net871 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__buf_2
Xfanout168 net76 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_129_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout179 net181 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__clkbuf_4
X_09726_ _01013_ _01014_ _01034_ _01035_ VGND VGND VPWR VPWR _01036_ sky130_fd_sc_hd__a22o_1
X_09657_ _00874_ _00888_ _00889_ VGND VGND VPWR VPWR _00968_ sky130_fd_sc_hd__and3_1
XFILLER_0_96_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08608_ _05741_ _06639_ _06628_ _07629_ VGND VGND VPWR VPWR _07640_ sky130_fd_sc_hd__a31o_1
X_09588_ _00898_ _00899_ VGND VGND VPWR VPWR _00900_ sky130_fd_sc_hd__xnor2_2
X_08539_ net197 net703 _06726_ _06715_ VGND VGND VPWR VPWR _06889_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_77_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11550_ _02869_ _02870_ _02865_ VGND VGND VPWR VPWR _02872_ sky130_fd_sc_hd__a21o_1
XFILLER_0_108_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10501_ _01762_ _01763_ _01764_ VGND VGND VPWR VPWR _01765_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_108_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11481_ _02703_ _02796_ VGND VGND VPWR VPWR _02797_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_80_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13220_ _04691_ _04692_ VGND VGND VPWR VPWR _04693_ sky130_fd_sc_hd__and2b_1
X_10432_ _01678_ _01688_ _01679_ VGND VGND VPWR VPWR _01696_ sky130_fd_sc_hd__nand3_2
XFILLER_0_61_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13151_ _04615_ _04616_ _04508_ _04521_ VGND VGND VPWR VPWR _04618_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_103_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10363_ _01625_ _01626_ VGND VGND VPWR VPWR _01627_ sky130_fd_sc_hd__or2_1
XFILLER_0_60_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12102_ net426 net441 VGND VGND VPWR VPWR _03471_ sky130_fd_sc_hd__nand2_1
X_13082_ _04333_ _04431_ _04432_ _04329_ VGND VGND VPWR VPWR _04542_ sky130_fd_sc_hd__and4b_1
X_10294_ _01564_ _01565_ VGND VGND VPWR VPWR _01566_ sky130_fd_sc_hd__nor2_1
X_12033_ _03389_ _03393_ _03386_ VGND VGND VPWR VPWR _03396_ sky130_fd_sc_hd__o21bai_1
Xfanout680 net681 VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__clkbuf_4
Xfanout691 net692 VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__dlymetal6s2s_1
X_13984_ _05523_ VGND VGND VPWR VPWR _00090_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15723_ _07252_ _07321_ _07420_ VGND VGND VPWR VPWR _07421_ sky130_fd_sc_hd__a21oi_1
X_12935_ _04380_ _04381_ VGND VGND VPWR VPWR _04383_ sky130_fd_sc_hd__nor2_1
X_15654_ _07279_ _07287_ _07288_ VGND VGND VPWR VPWR _07345_ sky130_fd_sc_hd__and3_1
X_12866_ _04304_ _04305_ _03845_ _03869_ VGND VGND VPWR VPWR _04308_ sky130_fd_sc_hd__a211o_1
X_14605_ net516 net674 net683 net431 VGND VGND VPWR VPWR _06202_ sky130_fd_sc_hd__a22oi_2
X_11817_ _03000_ _03016_ _03162_ VGND VGND VPWR VPWR _03163_ sky130_fd_sc_hd__a21o_1
X_15585_ _07268_ _07269_ VGND VGND VPWR VPWR _07271_ sky130_fd_sc_hd__xor2_1
X_12797_ _04126_ _04230_ _04227_ _04231_ VGND VGND VPWR VPWR _04232_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_145_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14536_ net606 net707 _01891_ VGND VGND VPWR VPWR _06126_ sky130_fd_sc_hd__nand3_1
X_11748_ a_cos\[9\] _03087_ _02383_ VGND VGND VPWR VPWR _03088_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14467_ _05848_ _05840_ _05847_ VGND VGND VPWR VPWR _06050_ sky130_fd_sc_hd__nand3_1
XFILLER_0_24_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11679_ _02915_ _02918_ VGND VGND VPWR VPWR _03012_ sky130_fd_sc_hd__and2_1
X_16206_ _07934_ _07944_ VGND VGND VPWR VPWR _07945_ sky130_fd_sc_hd__xnor2_1
X_13418_ _04795_ _04907_ _04908_ VGND VGND VPWR VPWR _04909_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_141_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14398_ _05916_ _05929_ _05972_ _05973_ VGND VGND VPWR VPWR _05974_ sky130_fd_sc_hd__a211o_1
X_16137_ _07810_ _07868_ _07869_ VGND VGND VPWR VPWR _07870_ sky130_fd_sc_hd__o21ai_1
X_13349_ _04729_ _04822_ VGND VGND VPWR VPWR _04833_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16068_ net464 net631 _07793_ VGND VGND VPWR VPWR _07795_ sky130_fd_sc_hd__and3_1
X_15019_ net454 net593 VGND VGND VPWR VPWR _06654_ sky130_fd_sc_hd__nand2_1
X_08890_ _00206_ _00208_ VGND VGND VPWR VPWR _00209_ sky130_fd_sc_hd__xnor2_2
X_09511_ _00819_ _00822_ _00815_ VGND VGND VPWR VPWR _00824_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_79_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09442_ _00753_ _00754_ VGND VGND VPWR VPWR _00755_ sky130_fd_sc_hd__xor2_1
XFILLER_0_149_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09373_ net209 net200 net621 VGND VGND VPWR VPWR _00687_ sky130_fd_sc_hd__and3_1
XFILLER_0_148_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08324_ _04338_ _04349_ _04534_ _04502_ VGND VGND VPWR VPWR _04545_ sky130_fd_sc_hd__o211a_1
XFILLER_0_46_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08255_ _02920_ _02996_ VGND VGND VPWR VPWR _03789_ sky130_fd_sc_hd__or2b_1
XFILLER_0_7_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08186_ _02550_ _02713_ _03018_ _03029_ VGND VGND VPWR VPWR _03040_ sky130_fd_sc_hd__a211o_1
XFILLER_0_6_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09709_ net263 net676 net686 net255 VGND VGND VPWR VPWR _01019_ sky130_fd_sc_hd__a22oi_2
X_10981_ _02249_ _02250_ _02251_ VGND VGND VPWR VPWR _02252_ sky130_fd_sc_hd__nand3_1
XFILLER_0_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12720_ _04144_ _04145_ _04146_ VGND VGND VPWR VPWR _04147_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_97_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12651_ _04059_ _04063_ VGND VGND VPWR VPWR _04071_ sky130_fd_sc_hd__and2_1
XFILLER_0_37_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11602_ _02906_ _02927_ VGND VGND VPWR VPWR _02928_ sky130_fd_sc_hd__xor2_2
X_12582_ net757 net221 VGND VGND VPWR VPWR _03995_ sky130_fd_sc_hd__nand2_1
X_15370_ _06929_ _06930_ VGND VGND VPWR VPWR _07037_ sky130_fd_sc_hd__and2b_1
XFILLER_0_65_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14321_ _05876_ _05878_ _05877_ VGND VGND VPWR VPWR _05889_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_135_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11533_ _02761_ _02762_ _02775_ _02776_ VGND VGND VPWR VPWR _02853_ sky130_fd_sc_hd__or4bb_1
XFILLER_0_52_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14252_ a_sin\[18\] net863 VGND VGND VPWR VPWR _05814_ sky130_fd_sc_hd__and2_1
X_11464_ _02763_ _02777_ VGND VGND VPWR VPWR _02778_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_150_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13203_ _04670_ _04671_ _04672_ VGND VGND VPWR VPWR _04674_ sky130_fd_sc_hd__a21o_1
X_10415_ _01675_ _01677_ _01676_ VGND VGND VPWR VPWR _01679_ sky130_fd_sc_hd__a21o_1
X_14183_ _05480_ _05667_ _05738_ VGND VGND VPWR VPWR _05739_ sky130_fd_sc_hd__a21o_1
X_11395_ _02688_ _02606_ VGND VGND VPWR VPWR _02703_ sky130_fd_sc_hd__or2b_1
XFILLER_0_104_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13134_ _04596_ _04597_ _04598_ VGND VGND VPWR VPWR _04599_ sky130_fd_sc_hd__nand3_1
X_10346_ net393 net777 VGND VGND VPWR VPWR _01610_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13065_ _04401_ _04403_ _04501_ _04503_ VGND VGND VPWR VPWR _04524_ sky130_fd_sc_hd__o211a_1
X_10277_ b_cos\[10\] a_sin\[10\] VGND VGND VPWR VPWR _01551_ sky130_fd_sc_hd__and2b_1
X_12016_ _03286_ _03302_ _03303_ VGND VGND VPWR VPWR _03379_ sky130_fd_sc_hd__and3_1
XFILLER_0_136_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13967_ _05502_ _05504_ _05505_ VGND VGND VPWR VPWR _05506_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_100_Left_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15706_ _07399_ _07402_ VGND VGND VPWR VPWR _07403_ sky130_fd_sc_hd__xnor2_1
X_12918_ _04342_ _04343_ _04362_ _04363_ VGND VGND VPWR VPWR _04364_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_48_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13898_ _05410_ _05429_ VGND VGND VPWR VPWR _05431_ sky130_fd_sc_hd__or2_1
XFILLER_0_88_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15637_ _07250_ _07326_ VGND VGND VPWR VPWR _07328_ sky130_fd_sc_hd__nand2_1
X_12849_ _04286_ _04287_ _04288_ VGND VGND VPWR VPWR _04289_ sky130_fd_sc_hd__or3_1
XFILLER_0_131_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15568_ _07159_ _07180_ _07251_ VGND VGND VPWR VPWR _07252_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_84_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14519_ _06066_ _06071_ _06070_ VGND VGND VPWR VPWR _06107_ sky130_fd_sc_hd__o21a_1
XFILLER_0_4_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15499_ _07175_ _07176_ VGND VGND VPWR VPWR _07177_ sky130_fd_sc_hd__nand2_1
XFILLER_0_127_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09991_ _01112_ _01114_ _01233_ _01295_ VGND VGND VPWR VPWR _01296_ sky130_fd_sc_hd__a211o_1
XFILLER_0_110_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08942_ _00258_ _00259_ _00257_ VGND VGND VPWR VPWR _00261_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_110_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08873_ net68 VGND VGND VPWR VPWR _00192_ sky130_fd_sc_hd__inv_2
XFILLER_0_98_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09425_ _00738_ VGND VGND VPWR VPWR _00008_ sky130_fd_sc_hd__clkbuf_1
X_09356_ _00669_ VGND VGND VPWR VPWR _00670_ sky130_fd_sc_hd__inv_2
XFILLER_0_75_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08307_ _02365_ _02299_ _02354_ VGND VGND VPWR VPWR _04360_ sky130_fd_sc_hd__nand3_1
XFILLER_0_129_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09287_ _00599_ _00600_ _00601_ VGND VGND VPWR VPWR _00602_ sky130_fd_sc_hd__a21o_1
XFILLER_0_90_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08238_ _03572_ _03583_ _03420_ VGND VGND VPWR VPWR _03604_ sky130_fd_sc_hd__a21o_1
XFILLER_0_34_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08169_ _02833_ _02844_ VGND VGND VPWR VPWR _02855_ sky130_fd_sc_hd__nor2_1
X_10200_ _01484_ _01485_ VGND VGND VPWR VPWR _01486_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11180_ _02465_ _02466_ _02467_ VGND VGND VPWR VPWR _02469_ sky130_fd_sc_hd__a21o_1
XFILLER_0_101_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10131_ _01418_ _01421_ _01419_ VGND VGND VPWR VPWR _01427_ sky130_fd_sc_hd__o21ai_1
X_10062_ _01331_ _01365_ VGND VGND VPWR VPWR _01366_ sky130_fd_sc_hd__xnor2_1
X_14870_ _06405_ _06424_ _06425_ VGND VGND VPWR VPWR _06492_ sky130_fd_sc_hd__nand3_2
X_13821_ _05345_ _05346_ VGND VGND VPWR VPWR _05347_ sky130_fd_sc_hd__nor2_1
XFILLER_0_106_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13752_ _05270_ _05271_ VGND VGND VPWR VPWR _05272_ sky130_fd_sc_hd__nand2_1
XFILLER_0_98_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10964_ net864 net362 _02231_ _02232_ VGND VGND VPWR VPWR _02233_ sky130_fd_sc_hd__a22o_1
X_12703_ _04038_ _04127_ VGND VGND VPWR VPWR _04128_ sky130_fd_sc_hd__nand2_1
X_13683_ _05195_ _05196_ VGND VGND VPWR VPWR _05197_ sky130_fd_sc_hd__or2_1
X_10895_ _02140_ _02157_ _02158_ VGND VGND VPWR VPWR _02160_ sky130_fd_sc_hd__and3_1
X_15422_ _07089_ _07090_ _07091_ VGND VGND VPWR VPWR _07093_ sky130_fd_sc_hd__nand3_1
XFILLER_0_128_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12634_ _04046_ _04047_ _04051_ VGND VGND VPWR VPWR _04052_ sky130_fd_sc_hd__a21o_1
XFILLER_0_53_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15353_ net387 net644 VGND VGND VPWR VPWR _07018_ sky130_fd_sc_hd__and2_1
X_12565_ _03971_ _03972_ _03974_ VGND VGND VPWR VPWR _03977_ sky130_fd_sc_hd__and3_1
XFILLER_0_53_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14304_ net408 net398 net570 net577 VGND VGND VPWR VPWR _05870_ sky130_fd_sc_hd__and4_1
XFILLER_0_124_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11516_ net731 net469 VGND VGND VPWR VPWR _02835_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15284_ _06853_ _06756_ VGND VGND VPWR VPWR _06943_ sky130_fd_sc_hd__and2b_1
X_12496_ _03883_ _03898_ _03900_ VGND VGND VPWR VPWR _03901_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_22_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14235_ net227 _00195_ VGND VGND VPWR VPWR _05796_ sky130_fd_sc_hd__nor2_1
XFILLER_0_123_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11447_ _02756_ _02758_ _02753_ VGND VGND VPWR VPWR _02760_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14166_ _05710_ _05708_ VGND VGND VPWR VPWR _05721_ sky130_fd_sc_hd__and2b_1
X_11378_ _02629_ _02684_ VGND VGND VPWR VPWR _02685_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13117_ _04571_ _04580_ VGND VGND VPWR VPWR _04581_ sky130_fd_sc_hd__xor2_1
X_10329_ b_cos\[17\] a_sin\[17\] VGND VGND VPWR VPWR _01596_ sky130_fd_sc_hd__or2b_1
X_14097_ _05643_ _05646_ VGND VGND VPWR VPWR _05647_ sky130_fd_sc_hd__xnor2_2
X_13048_ _04440_ _04504_ _04505_ VGND VGND VPWR VPWR _04506_ sky130_fd_sc_hd__and3_2
XFILLER_0_56_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14999_ _06526_ _06528_ _06631_ _06632_ VGND VGND VPWR VPWR _06633_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_49_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09210_ net184 net173 net649 net659 VGND VGND VPWR VPWR _00526_ sky130_fd_sc_hd__nand4_2
XFILLER_0_8_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09141_ _00352_ _00368_ _00367_ VGND VGND VPWR VPWR _00458_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_71_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09072_ _00389_ VGND VGND VPWR VPWR _00004_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_71_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout4 net733 VGND VGND VPWR VPWR net864 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_13_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09974_ _01257_ _01279_ VGND VGND VPWR VPWR _01280_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08925_ net195 net185 net668 net678 VGND VGND VPWR VPWR _00244_ sky130_fd_sc_hd__nand4_2
X_08856_ _00173_ _00174_ _00141_ VGND VGND VPWR VPWR _00176_ sky130_fd_sc_hd__o21ai_2
X_08787_ net268 net589 net599 net259 VGND VGND VPWR VPWR _08097_ sky130_fd_sc_hd__a22o_1
XFILLER_0_95_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09408_ _00720_ _00721_ VGND VGND VPWR VPWR _00722_ sky130_fd_sc_hd__nand2_1
X_10680_ _01941_ _01942_ _01927_ VGND VGND VPWR VPWR _01944_ sky130_fd_sc_hd__a21o_1
XFILLER_0_109_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09339_ next_state _00651_ _00653_ VGND VGND VPWR VPWR _00007_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_109_Right_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12350_ _03724_ _03725_ _03739_ VGND VGND VPWR VPWR _03740_ sky130_fd_sc_hd__nand3_1
XFILLER_0_62_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11301_ _02501_ _02600_ VGND VGND VPWR VPWR _02601_ sky130_fd_sc_hd__xor2_1
XFILLER_0_62_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12281_ _03345_ VGND VGND VPWR VPWR _03665_ sky130_fd_sc_hd__inv_2
XFILLER_0_132_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14020_ net295 _05561_ _05562_ VGND VGND VPWR VPWR _05563_ sky130_fd_sc_hd__a21oi_1
X_11232_ _02508_ _02524_ VGND VGND VPWR VPWR _02525_ sky130_fd_sc_hd__xnor2_1
X_11163_ net317 net397 VGND VGND VPWR VPWR _02450_ sky130_fd_sc_hd__and2_1
XFILLER_0_101_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10114_ a_cos\[5\] b_sin\[5\] VGND VGND VPWR VPWR _01412_ sky130_fd_sc_hd__or2_1
X_15971_ _07688_ _07689_ VGND VGND VPWR VPWR _07690_ sky130_fd_sc_hd__xnor2_1
X_11094_ _02199_ _02373_ _02374_ VGND VGND VPWR VPWR _02375_ sky130_fd_sc_hd__and3_1
X_10045_ _01348_ _01296_ _01297_ _01298_ VGND VGND VPWR VPWR _01350_ sky130_fd_sc_hd__nand4_1
X_14922_ _06544_ _06548_ VGND VGND VPWR VPWR _06549_ sky130_fd_sc_hd__xor2_1
X_14853_ net470 net594 VGND VGND VPWR VPWR _06473_ sky130_fd_sc_hd__nand2_1
X_13804_ _05315_ _05316_ _05327_ VGND VGND VPWR VPWR _05328_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_86_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14784_ net382 net371 net532 net541 VGND VGND VPWR VPWR _06398_ sky130_fd_sc_hd__nand4_2
X_11996_ net492 net143 VGND VGND VPWR VPWR _03357_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13735_ _05173_ _05175_ VGND VGND VPWR VPWR _05254_ sky130_fd_sc_hd__or2b_1
XFILLER_0_86_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10947_ _02211_ _02213_ _02214_ VGND VGND VPWR VPWR _02215_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13666_ _05176_ _05178_ VGND VGND VPWR VPWR _05179_ sky130_fd_sc_hd__xnor2_1
X_10878_ net514 net412 net401 net616 VGND VGND VPWR VPWR _02142_ sky130_fd_sc_hd__and4_1
XFILLER_0_26_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15405_ _06968_ _06970_ _07073_ VGND VGND VPWR VPWR _07075_ sky130_fd_sc_hd__a21o_1
X_12617_ _04021_ _04030_ _04032_ _04033_ VGND VGND VPWR VPWR _04034_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_66_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13597_ _04955_ _05009_ _05103_ VGND VGND VPWR VPWR _05104_ sky130_fd_sc_hd__a21oi_1
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_115_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15336_ _06996_ _06997_ _06981_ VGND VGND VPWR VPWR _07000_ sky130_fd_sc_hd__a21o_1
X_12548_ _03891_ _03957_ VGND VGND VPWR VPWR _03958_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_108_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_124_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15267_ _06918_ _06919_ _06923_ VGND VGND VPWR VPWR _06925_ sky130_fd_sc_hd__a21oi_1
X_12479_ _03776_ _03881_ VGND VGND VPWR VPWR _03882_ sky130_fd_sc_hd__xnor2_1
XANTENNA_2 _02159_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14218_ _05760_ _05761_ VGND VGND VPWR VPWR _05777_ sky130_fd_sc_hd__and2b_1
XFILLER_0_123_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15198_ _06847_ _06848_ _06759_ VGND VGND VPWR VPWR _06850_ sky130_fd_sc_hd__a21o_1
X_14149_ _05675_ _05701_ VGND VGND VPWR VPWR _05703_ sky130_fd_sc_hd__and2_1
XFILLER_0_6_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout509 net515 VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__clkbuf_4
X_08710_ net293 net572 net581 net283 VGND VGND VPWR VPWR _08021_ sky130_fd_sc_hd__a22oi_1
X_09690_ _00992_ _00999_ VGND VGND VPWR VPWR _01000_ sky130_fd_sc_hd__xnor2_1
X_08641_ _07802_ _07813_ _07951_ VGND VGND VPWR VPWR _07953_ sky130_fd_sc_hd__nand3_2
Xrebuffer14 net875 VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__clkbuf_1
Xrebuffer25 _04595_ VGND VGND VPWR VPWR net836 sky130_fd_sc_hd__clkbuf_1
Xrebuffer36 _05882_ VGND VGND VPWR VPWR net874 sky130_fd_sc_hd__clkbuf_1
X_08572_ _07227_ _07205_ _07238_ VGND VGND VPWR VPWR _07249_ sky130_fd_sc_hd__and3_1
XFILLER_0_77_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09124_ _00433_ _00440_ VGND VGND VPWR VPWR _00441_ sky130_fd_sc_hd__xor2_2
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09055_ _00341_ _00371_ _00372_ VGND VGND VPWR VPWR _00373_ sky130_fd_sc_hd__nand3_1
XFILLER_0_5_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09957_ net262 net253 net652 net643 VGND VGND VPWR VPWR _01263_ sky130_fd_sc_hd__and4_1
X_08908_ net867 net538 VGND VGND VPWR VPWR _00227_ sky130_fd_sc_hd__and2_1
X_09888_ _01129_ _01194_ VGND VGND VPWR VPWR _01195_ sky130_fd_sc_hd__nor2_1
X_08839_ net236 net639 net629 net320 VGND VGND VPWR VPWR _00159_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_99_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11850_ _03125_ _03123_ _03043_ VGND VGND VPWR VPWR _03198_ sky130_fd_sc_hd__a21o_1
XFILLER_0_68_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10801_ _01972_ _02035_ _02063_ _02064_ VGND VGND VPWR VPWR _02065_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_94_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11781_ _03114_ _03122_ VGND VGND VPWR VPWR _03123_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_67_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13520_ _05017_ _05019_ VGND VGND VPWR VPWR _05020_ sky130_fd_sc_hd__xor2_1
X_10732_ net496 net793 _01917_ _01916_ VGND VGND VPWR VPWR _01996_ sky130_fd_sc_hd__a31o_1
XFILLER_0_27_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13451_ _04938_ _04943_ VGND VGND VPWR VPWR _04944_ sky130_fd_sc_hd__xor2_2
XFILLER_0_138_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10663_ _01704_ _01709_ _01703_ VGND VGND VPWR VPWR _01927_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_36_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12402_ _03793_ _03796_ VGND VGND VPWR VPWR _03797_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_125_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16170_ _07899_ _07905_ VGND VGND VPWR VPWR _07906_ sky130_fd_sc_hd__xnor2_1
X_13382_ net508 net610 net159 net305 VGND VGND VPWR VPWR _04869_ sky130_fd_sc_hd__nand4_2
X_10594_ net519 net779 net787 net434 VGND VGND VPWR VPWR _01858_ sky130_fd_sc_hd__a22o_1
X_15121_ net554 _06763_ _06764_ VGND VGND VPWR VPWR _06765_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_2_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12333_ _03714_ _03715_ _03720_ VGND VGND VPWR VPWR _03721_ sky130_fd_sc_hd__nand3_2
XFILLER_0_51_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15052_ _06687_ _06688_ _06679_ VGND VGND VPWR VPWR _06690_ sky130_fd_sc_hd__a21o_1
XFILLER_0_120_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12264_ _00652_ _03645_ _03646_ VGND VGND VPWR VPWR _00075_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_50_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14003_ _05542_ _05543_ VGND VGND VPWR VPWR _05544_ sky130_fd_sc_hd__nor2_1
XFILLER_0_121_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11215_ _02404_ _02405_ _02505_ VGND VGND VPWR VPWR _02507_ sky130_fd_sc_hd__a21o_1
X_12195_ _03482_ _03466_ VGND VGND VPWR VPWR _03573_ sky130_fd_sc_hd__and2b_1
Xoutput83 net83 VGND VGND VPWR VPWR D[13] sky130_fd_sc_hd__clkbuf_4
X_11146_ _02428_ _02429_ _02421_ VGND VGND VPWR VPWR _02432_ sky130_fd_sc_hd__a21o_1
Xoutput94 net94 VGND VGND VPWR VPWR D[6] sky130_fd_sc_hd__clkbuf_4
X_15954_ _07584_ _07590_ VGND VGND VPWR VPWR _07671_ sky130_fd_sc_hd__and2b_1
X_11077_ _02347_ _02355_ _02356_ VGND VGND VPWR VPWR _02357_ sky130_fd_sc_hd__nand3_2
X_10028_ _01074_ _01332_ VGND VGND VPWR VPWR _01333_ sky130_fd_sc_hd__xor2_1
X_14905_ _06428_ _06430_ _06528_ _06529_ VGND VGND VPWR VPWR _06531_ sky130_fd_sc_hd__a211o_1
X_15885_ _07594_ _07595_ VGND VGND VPWR VPWR _07597_ sky130_fd_sc_hd__nor2_1
XFILLER_0_144_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14836_ net461 net451 net604 VGND VGND VPWR VPWR _06455_ sky130_fd_sc_hd__and3_1
XFILLER_0_144_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14767_ _06378_ _06379_ VGND VGND VPWR VPWR _06380_ sky130_fd_sc_hd__nor2_1
X_11979_ _03336_ _03337_ VGND VGND VPWR VPWR _03338_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_74_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13718_ net798 net183 net173 VGND VGND VPWR VPWR _05235_ sky130_fd_sc_hd__and3_1
X_14698_ _06207_ _06209_ _06208_ VGND VGND VPWR VPWR _06304_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_73_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13649_ _05157_ _05158_ _05154_ _05156_ VGND VGND VPWR VPWR _05160_ sky130_fd_sc_hd__a211o_1
XFILLER_0_54_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15319_ _06905_ _06913_ _06912_ VGND VGND VPWR VPWR _06981_ sky130_fd_sc_hd__a21o_1
XFILLER_0_124_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16299_ clknet_4_2_0_clk _00088_ net335 VGND VGND VPWR VPWR a_sin\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_2_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout306 net310 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__clkbuf_2
Xfanout317 net318 VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__clkbuf_4
X_09811_ _01108_ _01106_ VGND VGND VPWR VPWR _01119_ sky130_fd_sc_hd__and2b_1
Xfanout328 net329 VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__buf_8
Xfanout339 net345 VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__clkbuf_4
X_09742_ _01030_ _01031_ _01050_ VGND VGND VPWR VPWR _01051_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_94_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09673_ _00972_ _00970_ VGND VGND VPWR VPWR _00983_ sky130_fd_sc_hd__and2b_1
XFILLER_0_118_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08624_ _03615_ _03690_ VGND VGND VPWR VPWR _07813_ sky130_fd_sc_hd__or2b_1
X_08555_ _07052_ VGND VGND VPWR VPWR _07063_ sky130_fd_sc_hd__inv_2
XFILLER_0_49_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08486_ _05860_ _05838_ _05849_ VGND VGND VPWR VPWR _06311_ sky130_fd_sc_hd__nand3_1
XFILLER_0_37_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_138_Left_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09107_ _00328_ _00330_ _00329_ VGND VGND VPWR VPWR _00424_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_72_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09038_ net193 net658 VGND VGND VPWR VPWR _00356_ sky130_fd_sc_hd__nand2_1
X_11000_ _02174_ _02271_ _02272_ VGND VGND VPWR VPWR _02273_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_147_Left_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12951_ _04397_ _04398_ _04378_ VGND VGND VPWR VPWR _04400_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_99_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11902_ _03252_ _03253_ VGND VGND VPWR VPWR _03254_ sky130_fd_sc_hd__nor2_1
X_15670_ _07347_ _07361_ _07362_ VGND VGND VPWR VPWR _07363_ sky130_fd_sc_hd__nand3_1
X_12882_ _04315_ _04314_ VGND VGND VPWR VPWR _04324_ sky130_fd_sc_hd__nor2_1
XFILLER_0_99_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14621_ net360 net569 VGND VGND VPWR VPWR _06219_ sky130_fd_sc_hd__nand2_1
X_11833_ net347 net498 net153 net144 VGND VGND VPWR VPWR _03179_ sky130_fd_sc_hd__and4_1
X_14552_ _06048_ _06084_ _06142_ VGND VGND VPWR VPWR _06143_ sky130_fd_sc_hd__a21oi_1
X_11764_ _03027_ _03030_ _03028_ VGND VGND VPWR VPWR _03104_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_95_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13503_ _04991_ _05000_ VGND VGND VPWR VPWR _05001_ sky130_fd_sc_hd__xor2_4
XFILLER_0_55_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10715_ _01977_ _01978_ VGND VGND VPWR VPWR _01979_ sky130_fd_sc_hd__nor2_1
X_14483_ net381 net706 VGND VGND VPWR VPWR _06067_ sky130_fd_sc_hd__nand2_1
X_11695_ net427 net493 VGND VGND VPWR VPWR _03030_ sky130_fd_sc_hd__and2_1
X_16222_ clknet_4_3_0_clk _00011_ net336 VGND VGND VPWR VPWR b_sin\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_125_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13434_ a_sin\[6\] _04925_ _03521_ VGND VGND VPWR VPWR _04926_ sky130_fd_sc_hd__mux2_1
XFILLER_0_82_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10646_ _01905_ _01908_ _01909_ VGND VGND VPWR VPWR _01910_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_36_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer5 net815 VGND VGND VPWR VPWR net816 sky130_fd_sc_hd__clkbuf_1
X_16153_ _07861_ _07886_ VGND VGND VPWR VPWR _07887_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_51_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13365_ _04849_ VGND VGND VPWR VPWR _04851_ sky130_fd_sc_hd__inv_2
XFILLER_0_24_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10577_ _01834_ _01835_ _01839_ VGND VGND VPWR VPWR _01841_ sky130_fd_sc_hd__and3_1
XFILLER_0_51_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15104_ _06744_ _06745_ _06648_ VGND VGND VPWR VPWR _06747_ sky130_fd_sc_hd__a21oi_1
X_12316_ _03700_ _03702_ VGND VGND VPWR VPWR _03703_ sky130_fd_sc_hd__nor2_1
X_16084_ net455 net447 net650 net641 VGND VGND VPWR VPWR _07812_ sky130_fd_sc_hd__and4_1
X_13296_ _04667_ _04669_ _04668_ VGND VGND VPWR VPWR _04776_ sky130_fd_sc_hd__a21bo_1
X_15035_ _06593_ _06629_ _06630_ VGND VGND VPWR VPWR _06672_ sky130_fd_sc_hd__nor3_1
X_12247_ _03627_ _03628_ VGND VGND VPWR VPWR _03629_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_121_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12178_ net315 net441 VGND VGND VPWR VPWR _03554_ sky130_fd_sc_hd__nand2_1
X_11129_ _02329_ _02364_ _02366_ VGND VGND VPWR VPWR _02413_ sky130_fd_sc_hd__nor3_1
X_15937_ b_cos\[13\] _07653_ _06949_ VGND VGND VPWR VPWR _07654_ sky130_fd_sc_hd__mux2_1
X_15868_ _00652_ _07577_ _07578_ VGND VGND VPWR VPWR _00108_ sky130_fd_sc_hd__a21oi_1
X_14819_ _06435_ _06436_ VGND VGND VPWR VPWR _06437_ sky130_fd_sc_hd__nor2_1
X_15799_ _07503_ VGND VGND VPWR VPWR _00107_ sky130_fd_sc_hd__clkbuf_1
X_08340_ _04698_ _04709_ VGND VGND VPWR VPWR _04720_ sky130_fd_sc_hd__nor2_1
XFILLER_0_86_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08271_ _03778_ _03789_ _03943_ VGND VGND VPWR VPWR _03965_ sky130_fd_sc_hd__nand3_2
XFILLER_0_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout136 net138 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__clkbuf_4
Xfanout147 net9 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__buf_8
Xfanout158 net871 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__clkbuf_4
Xfanout169 net172 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__buf_2
X_09725_ _01016_ _01033_ VGND VGND VPWR VPWR _01035_ sky130_fd_sc_hd__or2_1
X_09656_ _00965_ _00966_ VGND VGND VPWR VPWR _00967_ sky130_fd_sc_hd__nor2_1
XFILLER_0_69_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08607_ _06190_ _06223_ _07031_ _07020_ VGND VGND VPWR VPWR _07629_ sky130_fd_sc_hd__o31a_1
X_09587_ _00804_ _00805_ _00809_ _00810_ _00742_ VGND VGND VPWR VPWR _00899_ sky130_fd_sc_hd__a32o_1
XFILLER_0_38_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08538_ net190 net703 VGND VGND VPWR VPWR _06878_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08469_ _05535_ _05622_ _05611_ VGND VGND VPWR VPWR _06124_ sky130_fd_sc_hd__a21o_1
XFILLER_0_92_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10500_ net525 net440 net752 net760 VGND VGND VPWR VPWR _01764_ sky130_fd_sc_hd__nand4_1
X_11480_ _02793_ _02795_ VGND VGND VPWR VPWR _02796_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_61_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10431_ _01691_ _01693_ _01694_ VGND VGND VPWR VPWR _01695_ sky130_fd_sc_hd__nand3_4
XFILLER_0_123_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13150_ _04508_ _04521_ _04615_ _04616_ VGND VGND VPWR VPWR _04617_ sky130_fd_sc_hd__a211o_1
XFILLER_0_60_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10362_ net353 net793 net810 net505 VGND VGND VPWR VPWR _01626_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_20_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12101_ _03468_ _03469_ VGND VGND VPWR VPWR _03470_ sky130_fd_sc_hd__nor2_1
X_13081_ _04525_ _04540_ VGND VGND VPWR VPWR _04541_ sky130_fd_sc_hd__xnor2_1
X_10293_ b_cos\[12\] a_sin\[12\] VGND VGND VPWR VPWR _01565_ sky130_fd_sc_hd__and2b_1
X_12032_ _03395_ VGND VGND VPWR VPWR _00071_ sky130_fd_sc_hd__clkbuf_1
Xfanout670 net24 VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__buf_6
Xfanout681 net23 VGND VGND VPWR VPWR net681 sky130_fd_sc_hd__clkbuf_4
Xfanout692 net22 VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__buf_6
X_13983_ a_sin\[13\] _05522_ _05291_ VGND VGND VPWR VPWR _05523_ sky130_fd_sc_hd__mux2_1
X_15722_ _07319_ _07320_ VGND VGND VPWR VPWR _07420_ sky130_fd_sc_hd__and2b_1
X_12934_ net425 net211 net202 net509 VGND VGND VPWR VPWR _04381_ sky130_fd_sc_hd__a22oi_2
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15653_ _07287_ VGND VGND VPWR VPWR _07344_ sky130_fd_sc_hd__inv_2
X_12865_ _03845_ _03869_ _04304_ _04305_ VGND VGND VPWR VPWR _04307_ sky130_fd_sc_hd__o211ai_1
X_14604_ net516 net431 net674 net683 VGND VGND VPWR VPWR _06200_ sky130_fd_sc_hd__and4_1
XFILLER_0_56_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11816_ _03015_ _03001_ VGND VGND VPWR VPWR _03162_ sky130_fd_sc_hd__and2b_1
XFILLER_0_28_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15584_ _07188_ _07203_ VGND VGND VPWR VPWR _07269_ sky130_fd_sc_hd__or2b_1
X_12796_ _04084_ _03986_ _04128_ VGND VGND VPWR VPWR _04231_ sky130_fd_sc_hd__nor3_1
XFILLER_0_83_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14535_ _06119_ _06117_ _06118_ VGND VGND VPWR VPWR _06125_ sky130_fd_sc_hd__a21oi_1
X_11747_ _03079_ _03086_ VGND VGND VPWR VPWR _03087_ sky130_fd_sc_hd__xor2_1
XFILLER_0_126_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14466_ _05938_ _05936_ _05896_ _05892_ VGND VGND VPWR VPWR _06049_ sky130_fd_sc_hd__a211o_1
X_11678_ _03009_ _03010_ VGND VGND VPWR VPWR _03011_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_126_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16205_ _07935_ _07942_ VGND VGND VPWR VPWR _07944_ sky130_fd_sc_hd__xnor2_1
X_13417_ _04808_ _04809_ VGND VGND VPWR VPWR _04908_ sky130_fd_sc_hd__nor2_1
XFILLER_0_126_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10629_ _01886_ _01888_ _01889_ _01892_ VGND VGND VPWR VPWR _01893_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14397_ _05960_ _05971_ _05961_ VGND VGND VPWR VPWR _05973_ sky130_fd_sc_hd__and3_1
XFILLER_0_52_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16136_ net447 net643 net633 net455 VGND VGND VPWR VPWR _07869_ sky130_fd_sc_hd__a22o_1
XFILLER_0_12_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13348_ next_state _04830_ _04831_ _04832_ VGND VGND VPWR VPWR _00082_ sky130_fd_sc_hd__a31o_1
XFILLER_0_122_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16067_ net464 net631 _07793_ VGND VGND VPWR VPWR _07794_ sky130_fd_sc_hd__a21oi_1
X_13279_ _04754_ _04756_ VGND VGND VPWR VPWR _04757_ sky130_fd_sc_hd__xor2_1
XFILLER_0_121_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15018_ net568 _06572_ _06576_ _06574_ VGND VGND VPWR VPWR _06653_ sky130_fd_sc_hd__a22o_1
XFILLER_0_75_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09510_ _00815_ _00819_ _00822_ VGND VGND VPWR VPWR _00823_ sky130_fd_sc_hd__and3_1
XFILLER_0_149_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09441_ _00710_ _00712_ VGND VGND VPWR VPWR _00754_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09372_ _00626_ _00628_ VGND VGND VPWR VPWR _00686_ sky130_fd_sc_hd__and2_1
XFILLER_0_46_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08323_ _04502_ _04513_ _04523_ VGND VGND VPWR VPWR _04534_ sky130_fd_sc_hd__nand3_1
X_08254_ _02931_ _02986_ VGND VGND VPWR VPWR _03778_ sky130_fd_sc_hd__or2b_1
XFILLER_0_61_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08185_ _02899_ _02909_ _03007_ VGND VGND VPWR VPWR _03029_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_144_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09708_ _00911_ _00914_ _00912_ VGND VGND VPWR VPWR _01018_ sky130_fd_sc_hd__o21ba_1
X_10980_ _02146_ _02148_ _02147_ VGND VGND VPWR VPWR _02251_ sky130_fd_sc_hd__o21bai_1
X_09639_ _00948_ _00949_ VGND VGND VPWR VPWR _00950_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12650_ _04060_ _04062_ VGND VGND VPWR VPWR _04070_ sky130_fd_sc_hd__and2_1
XFILLER_0_78_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11601_ _02907_ _02926_ VGND VGND VPWR VPWR _02927_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_108_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12581_ _03947_ _03946_ _03945_ VGND VGND VPWR VPWR _03994_ sky130_fd_sc_hd__a21o_1
XFILLER_0_65_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14320_ _05855_ _05887_ VGND VGND VPWR VPWR _05888_ sky130_fd_sc_hd__xor2_1
XFILLER_0_25_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11532_ _02850_ _02851_ VGND VGND VPWR VPWR _02852_ sky130_fd_sc_hd__nand2_2
XFILLER_0_52_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14251_ _05769_ _05773_ _05811_ VGND VGND VPWR VPWR _05813_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_108_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11463_ _02775_ _02776_ VGND VGND VPWR VPWR _02777_ sky130_fd_sc_hd__and2_1
X_13202_ _04670_ _04671_ _04672_ VGND VGND VPWR VPWR _04673_ sky130_fd_sc_hd__nand3_2
X_10414_ _01675_ _01676_ _01677_ VGND VGND VPWR VPWR _01678_ sky130_fd_sc_hd__nand3_4
X_14182_ _05659_ _05668_ VGND VGND VPWR VPWR _05738_ sky130_fd_sc_hd__and2_1
X_11394_ _02700_ _02698_ VGND VGND VPWR VPWR _02701_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13133_ _04482_ _04490_ _04489_ VGND VGND VPWR VPWR _04598_ sky130_fd_sc_hd__a21bo_1
X_10345_ net412 net760 net769 net401 VGND VGND VPWR VPWR _01609_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_29_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13064_ _04335_ _04439_ VGND VGND VPWR VPWR _04522_ sky130_fd_sc_hd__nor2_1
X_10276_ a_sin\[10\] b_cos\[10\] VGND VGND VPWR VPWR _01550_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12015_ _03375_ _03376_ VGND VGND VPWR VPWR _03378_ sky130_fd_sc_hd__nor2_1
XFILLER_0_45_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13966_ _05408_ _05433_ VGND VGND VPWR VPWR _05505_ sky130_fd_sc_hd__nand2_1
X_12917_ _04359_ _04361_ _04344_ VGND VGND VPWR VPWR _04363_ sky130_fd_sc_hd__a21o_1
X_15705_ _07400_ VGND VGND VPWR VPWR _07402_ sky130_fd_sc_hd__inv_2
X_13897_ _05410_ _05429_ VGND VGND VPWR VPWR _05430_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12848_ net229 net322 net238 net314 VGND VGND VPWR VPWR _04288_ sky130_fd_sc_hd__a22oi_2
X_15636_ _07250_ _07326_ VGND VGND VPWR VPWR _07327_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15567_ _07160_ _07179_ VGND VGND VPWR VPWR _07251_ sky130_fd_sc_hd__or2b_1
X_12779_ _04204_ _07488_ net806 net796 VGND VGND VPWR VPWR _04212_ sky130_fd_sc_hd__and4b_1
XFILLER_0_56_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14518_ _06098_ _06104_ _06105_ VGND VGND VPWR VPWR _06106_ sky130_fd_sc_hd__nand3_1
XFILLER_0_127_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15498_ _07170_ _07171_ _07174_ VGND VGND VPWR VPWR _07176_ sky130_fd_sc_hd__nand3_1
XFILLER_0_83_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14449_ net354 net504 net597 net607 VGND VGND VPWR VPWR _06030_ sky130_fd_sc_hd__and4_1
XFILLER_0_114_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16119_ net464 net622 VGND VGND VPWR VPWR _07850_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09990_ _01232_ _01291_ VGND VGND VPWR VPWR _01295_ sky130_fd_sc_hd__or2_1
X_08941_ _00257_ _00258_ _00259_ VGND VGND VPWR VPWR _00260_ sky130_fd_sc_hd__or3_1
XFILLER_0_110_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08872_ _00185_ _00186_ VGND VGND VPWR VPWR _00191_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09424_ b_sin\[8\] _00737_ _00475_ VGND VGND VPWR VPWR _00738_ sky130_fd_sc_hd__mux2_1
XFILLER_0_94_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09355_ _00576_ _00579_ _00577_ VGND VGND VPWR VPWR _00669_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_75_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08306_ _02550_ _02561_ _02702_ VGND VGND VPWR VPWR _04349_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_75_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09286_ net297 net686 VGND VGND VPWR VPWR _00601_ sky130_fd_sc_hd__and2_1
XFILLER_0_74_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08237_ _03420_ _03572_ _03583_ VGND VGND VPWR VPWR _03593_ sky130_fd_sc_hd__nand3_4
XFILLER_0_62_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08168_ net213 net694 net530 net204 VGND VGND VPWR VPWR _02844_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_70_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10130_ _01424_ _01425_ VGND VGND VPWR VPWR _01426_ sky130_fd_sc_hd__nand2_1
XFILLER_0_100_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10061_ _01073_ _01332_ _01324_ VGND VGND VPWR VPWR _01365_ sky130_fd_sc_hd__a21oi_1
X_13820_ _05266_ _05265_ VGND VGND VPWR VPWR _05346_ sky130_fd_sc_hd__and2b_1
XFILLER_0_97_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13751_ net736 _00193_ VGND VGND VPWR VPWR _05271_ sky130_fd_sc_hd__or2_1
X_10963_ net715 net724 net384 net373 VGND VGND VPWR VPWR _02232_ sky130_fd_sc_hd__nand4_2
XFILLER_0_85_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12702_ _03984_ _04037_ _04034_ _04036_ VGND VGND VPWR VPWR _04127_ sky130_fd_sc_hd__a211o_1
X_13682_ _05114_ _05194_ VGND VGND VPWR VPWR _05196_ sky130_fd_sc_hd__and2_1
X_10894_ _02154_ _02155_ _02156_ VGND VGND VPWR VPWR _02158_ sky130_fd_sc_hd__a21o_1
X_15421_ _07089_ _07090_ _07091_ VGND VGND VPWR VPWR _07092_ sky130_fd_sc_hd__a21o_1
XFILLER_0_128_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12633_ _04048_ _04049_ _04050_ VGND VGND VPWR VPWR _04051_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_109_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15352_ net404 net394 net634 net626 VGND VGND VPWR VPWR _07017_ sky130_fd_sc_hd__nand4_1
X_12564_ _03971_ _03972_ _03974_ VGND VGND VPWR VPWR _03975_ sky130_fd_sc_hd__a21oi_1
X_14303_ net408 net570 net577 net398 VGND VGND VPWR VPWR _05869_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_142_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11515_ _02831_ _02832_ VGND VGND VPWR VPWR _02834_ sky130_fd_sc_hd__nor2_1
X_15283_ _06753_ _06854_ VGND VGND VPWR VPWR _06942_ sky130_fd_sc_hd__nand2_1
X_12495_ _03896_ _03897_ VGND VGND VPWR VPWR _03900_ sky130_fd_sc_hd__and2b_1
XFILLER_0_53_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14234_ _05750_ _05751_ _05749_ VGND VGND VPWR VPWR _05794_ sky130_fd_sc_hd__o21a_1
X_11446_ _02753_ _02756_ _02758_ VGND VGND VPWR VPWR _02759_ sky130_fd_sc_hd__nand3_1
XFILLER_0_21_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14165_ _05657_ _05655_ _05711_ VGND VGND VPWR VPWR _05720_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_22_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11377_ _02682_ _02683_ VGND VGND VPWR VPWR _02684_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_150_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13116_ _04577_ _04579_ VGND VGND VPWR VPWR _04580_ sky130_fd_sc_hd__and2b_1
X_10328_ net133 _01593_ _01594_ _01595_ VGND VGND VPWR VPWR _00054_ sky130_fd_sc_hd__a31o_1
X_14096_ _05645_ _05552_ VGND VGND VPWR VPWR _05646_ sky130_fd_sc_hd__nand2_2
X_13047_ _04501_ _04503_ _04401_ _04403_ VGND VGND VPWR VPWR _04505_ sky130_fd_sc_hd__a211o_1
X_10259_ _01534_ _01535_ VGND VGND VPWR VPWR _01536_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_89_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14998_ _06629_ _06630_ _06593_ VGND VGND VPWR VPWR _06632_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_89_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13949_ _05482_ _05483_ _05484_ VGND VGND VPWR VPWR _05486_ sky130_fd_sc_hd__nor3_1
XFILLER_0_88_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15619_ _07306_ _07307_ VGND VGND VPWR VPWR _07308_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_118_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09140_ _00441_ _00456_ VGND VGND VPWR VPWR _00457_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_84_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09071_ b_sin\[4\] _00388_ _02181_ VGND VGND VPWR VPWR _00389_ sky130_fd_sc_hd__mux2_1
XFILLER_0_112_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout5 net483 VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_141_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09973_ _01259_ _01278_ VGND VGND VPWR VPWR _01279_ sky130_fd_sc_hd__xnor2_1
X_08924_ net195 net668 net678 net185 VGND VGND VPWR VPWR _00243_ sky130_fd_sc_hd__a22o_1
XFILLER_0_0_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08855_ _00141_ _00173_ _00174_ VGND VGND VPWR VPWR _00175_ sky130_fd_sc_hd__or3_4
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08786_ net274 net589 _08023_ _08022_ VGND VGND VPWR VPWR _08096_ sky130_fd_sc_hd__a31o_1
XFILLER_0_79_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09407_ _00718_ _00719_ _00701_ _00702_ VGND VGND VPWR VPWR _00721_ sky130_fd_sc_hd__a211o_1
XFILLER_0_149_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09338_ net850 _00652_ VGND VGND VPWR VPWR _00653_ sky130_fd_sc_hd__nor2_1
XFILLER_0_62_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09269_ _00581_ _00583_ VGND VGND VPWR VPWR _00584_ sky130_fd_sc_hd__xnor2_4
X_11300_ _02598_ _02599_ VGND VGND VPWR VPWR _02600_ sky130_fd_sc_hd__and2_1
XFILLER_0_132_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12280_ _03662_ _03663_ VGND VGND VPWR VPWR _03664_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11231_ _02522_ _02523_ VGND VGND VPWR VPWR _02524_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_121_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11162_ _02439_ _02448_ VGND VGND VPWR VPWR _02449_ sky130_fd_sc_hd__xor2_1
X_10113_ _01411_ VGND VGND VPWR VPWR _00023_ sky130_fd_sc_hd__clkbuf_1
X_15970_ net464 net650 VGND VGND VPWR VPWR _07689_ sky130_fd_sc_hd__nand2_1
X_11093_ _02371_ _02372_ _02266_ _02269_ VGND VGND VPWR VPWR _02374_ sky130_fd_sc_hd__o211ai_2
X_10044_ _01296_ _01297_ _01298_ _01348_ VGND VGND VPWR VPWR _01349_ sky130_fd_sc_hd__a31o_1
X_14921_ _06545_ _06547_ VGND VGND VPWR VPWR _06548_ sky130_fd_sc_hd__and2_1
X_14852_ _06470_ _06471_ VGND VGND VPWR VPWR _06472_ sky130_fd_sc_hd__nor2_1
X_13803_ _05325_ _05326_ VGND VGND VPWR VPWR _05327_ sky130_fd_sc_hd__nor2_1
X_14783_ net382 net532 net541 net371 VGND VGND VPWR VPWR _06397_ sky130_fd_sc_hd__a22o_1
X_11995_ _03259_ _03261_ VGND VGND VPWR VPWR _03356_ sky130_fd_sc_hd__nor2_1
XFILLER_0_98_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13734_ _05250_ _05156_ _05248_ _05249_ VGND VGND VPWR VPWR _05252_ sky130_fd_sc_hd__o211a_1
X_10946_ net759 net496 VGND VGND VPWR VPWR _02214_ sky130_fd_sc_hd__and2_1
X_13665_ net745 _00193_ VGND VGND VPWR VPWR _05178_ sky130_fd_sc_hd__or2_1
X_10877_ net393 net715 VGND VGND VPWR VPWR _02141_ sky130_fd_sc_hd__nand2_1
XFILLER_0_42_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12616_ _03970_ _03979_ _03978_ VGND VGND VPWR VPWR _04033_ sky130_fd_sc_hd__a21oi_2
X_15404_ _06961_ _06967_ VGND VGND VPWR VPWR _07073_ sky130_fd_sc_hd__and2_1
XFILLER_0_66_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13596_ _05006_ _05008_ VGND VGND VPWR VPWR _05103_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15335_ _06981_ _06996_ _06997_ VGND VGND VPWR VPWR _06999_ sky130_fd_sc_hd__nand3_1
XFILLER_0_14_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12547_ _03893_ _03892_ VGND VGND VPWR VPWR _03957_ sky130_fd_sc_hd__nor2_1
XFILLER_0_53_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15266_ _06918_ _06919_ _06923_ VGND VGND VPWR VPWR _06924_ sky130_fd_sc_hd__and3_1
X_12478_ _03779_ _03777_ VGND VGND VPWR VPWR _03881_ sky130_fd_sc_hd__nor2_1
XANTENNA_3 _05712_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14217_ net856 next_state _05776_ VGND VGND VPWR VPWR _00094_ sky130_fd_sc_hd__o21a_1
X_11429_ _02736_ _02737_ _02738_ VGND VGND VPWR VPWR _02740_ sky130_fd_sc_hd__nand3_1
X_15197_ _06759_ _06847_ _06848_ VGND VGND VPWR VPWR _06849_ sky130_fd_sc_hd__nand3_1
XFILLER_0_111_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14148_ _05675_ _05701_ VGND VGND VPWR VPWR _05702_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14079_ _05562_ _05618_ VGND VGND VPWR VPWR _05627_ sky130_fd_sc_hd__or2_1
XFILLER_0_83_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08640_ _07802_ _07813_ _07951_ VGND VGND VPWR VPWR _07952_ sky130_fd_sc_hd__a21o_2
XFILLER_0_83_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer15 _04020_ VGND VGND VPWR VPWR net826 sky130_fd_sc_hd__buf_1
Xrebuffer26 _06562_ VGND VGND VPWR VPWR net873 sky130_fd_sc_hd__dlymetal6s2s_1
X_08571_ _07194_ _07118_ _07172_ VGND VGND VPWR VPWR _07238_ sky130_fd_sc_hd__nand3_1
Xrebuffer37 _06987_ VGND VGND VPWR VPWR net875 sky130_fd_sc_hd__dlymetal6s4s_1
XFILLER_0_49_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09123_ _00434_ _00439_ VGND VGND VPWR VPWR _00440_ sky130_fd_sc_hd__xor2_2
XFILLER_0_44_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09054_ _00369_ _00370_ _00342_ _00269_ VGND VGND VPWR VPWR _00372_ sky130_fd_sc_hd__a211o_1
XFILLER_0_25_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09956_ net253 net652 net643 net262 VGND VGND VPWR VPWR _01262_ sky130_fd_sc_hd__a22oi_2
X_08907_ net169 net160 net693 net529 VGND VGND VPWR VPWR _00226_ sky130_fd_sc_hd__nand4_1
X_09887_ _01131_ _01130_ VGND VGND VPWR VPWR _01194_ sky130_fd_sc_hd__and2b_1
X_08838_ net220 net648 VGND VGND VPWR VPWR _00158_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_142_Right_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08769_ _07991_ _07993_ _08078_ _08079_ VGND VGND VPWR VPWR _08080_ sky130_fd_sc_hd__a211o_1
XFILLER_0_67_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10800_ _02052_ _02053_ _02062_ VGND VGND VPWR VPWR _02064_ sky130_fd_sc_hd__a21oi_1
X_11780_ _03120_ _03121_ VGND VGND VPWR VPWR _03122_ sky130_fd_sc_hd__nor2_1
XFILLER_0_68_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10731_ _01991_ _01994_ VGND VGND VPWR VPWR _01995_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_94_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13450_ _04941_ _04942_ VGND VGND VPWR VPWR _04943_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_36_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10662_ _01924_ _01925_ VGND VGND VPWR VPWR _01926_ sky130_fd_sc_hd__and2_1
X_12401_ _03794_ _03795_ VGND VGND VPWR VPWR _03796_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13381_ net508 net159 net305 net610 VGND VGND VPWR VPWR _04868_ sky130_fd_sc_hd__a22o_1
XFILLER_0_51_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10593_ net519 net434 net779 net787 VGND VGND VPWR VPWR _01857_ sky130_fd_sc_hd__and4_1
XFILLER_0_35_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15120_ net487 net546 net554 net476 VGND VGND VPWR VPWR _06764_ sky130_fd_sc_hd__a22o_1
X_12332_ _03716_ _03719_ VGND VGND VPWR VPWR _03720_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_23_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15051_ _06679_ _06687_ _06688_ VGND VGND VPWR VPWR _06689_ sky130_fd_sc_hd__nand3_1
X_12263_ net849 _00652_ VGND VGND VPWR VPWR _03646_ sky130_fd_sc_hd__nor2_1
X_14002_ _05460_ _05458_ VGND VGND VPWR VPWR _05543_ sky130_fd_sc_hd__and2b_1
X_11214_ net792 net445 _02406_ VGND VGND VPWR VPWR _02505_ sky130_fd_sc_hd__and3_1
X_12194_ _03502_ _03505_ _03568_ _03569_ VGND VGND VPWR VPWR _03571_ sky130_fd_sc_hd__a211o_1
X_11145_ _02421_ _02428_ _02429_ VGND VGND VPWR VPWR _02431_ sky130_fd_sc_hd__nand3_2
Xoutput84 net84 VGND VGND VPWR VPWR D[14] sky130_fd_sc_hd__clkbuf_4
Xoutput95 net95 VGND VGND VPWR VPWR D[7] sky130_fd_sc_hd__clkbuf_4
X_11076_ _02351_ _02352_ _02353_ VGND VGND VPWR VPWR _02356_ sky130_fd_sc_hd__a21o_1
X_15953_ _07668_ _07669_ VGND VGND VPWR VPWR _07670_ sky130_fd_sc_hd__xor2_1
X_10027_ _01325_ _01331_ VGND VGND VPWR VPWR _01332_ sky130_fd_sc_hd__xnor2_1
X_14904_ _06526_ _06527_ _06491_ VGND VGND VPWR VPWR _06529_ sky130_fd_sc_hd__o21a_1
X_15884_ _07552_ _07551_ VGND VGND VPWR VPWR _07595_ sky130_fd_sc_hd__and2b_1
X_14835_ net461 net604 net708 net451 VGND VGND VPWR VPWR _06454_ sky130_fd_sc_hd__a22o_1
X_14766_ _06375_ _06376_ VGND VGND VPWR VPWR _06379_ sky130_fd_sc_hd__and2_1
X_11978_ net713 _02388_ VGND VGND VPWR VPWR _03337_ sky130_fd_sc_hd__or2_1
XFILLER_0_129_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13717_ _05143_ _05147_ _05145_ VGND VGND VPWR VPWR _05234_ sky130_fd_sc_hd__o21ba_1
X_10929_ _02190_ _02194_ VGND VGND VPWR VPWR _02195_ sky130_fd_sc_hd__xnor2_1
X_14697_ _06219_ _06221_ _06220_ VGND VGND VPWR VPWR _06303_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_73_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13648_ _05154_ _05156_ _05157_ _05158_ VGND VGND VPWR VPWR _05159_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_39_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13579_ net508 net297 _05082_ _05083_ VGND VGND VPWR VPWR _05084_ sky130_fd_sc_hd__a22o_1
XFILLER_0_5_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15318_ _06896_ _06898_ VGND VGND VPWR VPWR _06980_ sky130_fd_sc_hd__nand2_1
X_16298_ clknet_4_3_0_clk _00087_ net335 VGND VGND VPWR VPWR a_sin\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_41_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15249_ _06788_ _06790_ VGND VGND VPWR VPWR _06905_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout307 net309 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__clkbuf_4
X_09810_ _01049_ _01109_ _01110_ _01115_ VGND VGND VPWR VPWR _01118_ sky130_fd_sc_hd__o2bb2ai_1
Xfanout318 net319 VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_10_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout329 net330 VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__buf_8
XFILLER_0_94_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09741_ _01026_ _01029_ VGND VGND VPWR VPWR _01050_ sky130_fd_sc_hd__or2_1
XFILLER_0_94_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09672_ _00974_ _00978_ _00981_ VGND VGND VPWR VPWR _00982_ sky130_fd_sc_hd__o21bai_1
X_08623_ _03626_ _03680_ VGND VGND VPWR VPWR _07802_ sky130_fd_sc_hd__or2b_1
XFILLER_0_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08554_ net328 net244 net583 net591 VGND VGND VPWR VPWR _07052_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_59_Left_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08485_ _06278_ _06289_ VGND VGND VPWR VPWR _06300_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_65_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09106_ _00419_ _00420_ _00421_ VGND VGND VPWR VPWR _00423_ sky130_fd_sc_hd__nand3_1
XFILLER_0_150_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09037_ _00353_ _00354_ VGND VGND VPWR VPWR _00355_ sky130_fd_sc_hd__nor2_1
XFILLER_0_143_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09939_ _01243_ _01244_ net624 VGND VGND VPWR VPWR _01245_ sky130_fd_sc_hd__and3b_1
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
X_12950_ _04378_ _04397_ _04398_ VGND VGND VPWR VPWR _04399_ sky130_fd_sc_hd__and3_1
X_11901_ net231 net315 net482 net472 VGND VGND VPWR VPWR _03253_ sky130_fd_sc_hd__and4_1
X_12881_ _03933_ _04039_ _04318_ _04322_ VGND VGND VPWR VPWR _04323_ sky130_fd_sc_hd__o31a_1
X_14620_ _06175_ _06177_ _06176_ VGND VGND VPWR VPWR _06218_ sky130_fd_sc_hd__o21ba_1
X_11832_ net498 net153 net144 net347 VGND VGND VPWR VPWR _03178_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_114_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14551_ _06134_ _06136_ _06140_ _06141_ VGND VGND VPWR VPWR _06142_ sky130_fd_sc_hd__a31o_1
X_11763_ net316 net492 _03100_ _03101_ VGND VGND VPWR VPWR _03103_ sky130_fd_sc_hd__nand4_2
X_13502_ _04998_ _04999_ VGND VGND VPWR VPWR _05000_ sky130_fd_sc_hd__nand2_2
XFILLER_0_55_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10714_ net384 net742 net751 net373 VGND VGND VPWR VPWR _01978_ sky130_fd_sc_hd__a22oi_1
X_14482_ _06050_ _06051_ _06065_ VGND VGND VPWR VPWR _06066_ sky130_fd_sc_hd__and3_2
X_11694_ net232 net316 net349 net501 VGND VGND VPWR VPWR _03028_ sky130_fd_sc_hd__nand4_1
XFILLER_0_71_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13433_ _04834_ _04924_ VGND VGND VPWR VPWR _04925_ sky130_fd_sc_hd__xnor2_1
X_16221_ clknet_4_7_0_clk _00010_ net337 VGND VGND VPWR VPWR b_sin\[10\] sky130_fd_sc_hd__dfrtp_1
X_10645_ _01781_ _01783_ _01744_ _01743_ VGND VGND VPWR VPWR _01909_ sky130_fd_sc_hd__a211o_1
XFILLER_0_51_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16152_ _07863_ _07885_ VGND VGND VPWR VPWR _07886_ sky130_fd_sc_hd__xor2_1
XFILLER_0_141_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13364_ _04746_ _04749_ _04747_ VGND VGND VPWR VPWR _04849_ sky130_fd_sc_hd__o21ba_1
Xrebuffer6 net876 VGND VGND VPWR VPWR net817 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10576_ _01834_ _01835_ _01839_ VGND VGND VPWR VPWR _01840_ sky130_fd_sc_hd__a21o_1
X_12315_ net730 net214 net205 net738 VGND VGND VPWR VPWR _03702_ sky130_fd_sc_hd__a22oi_2
X_15103_ _06648_ _06744_ _06745_ VGND VGND VPWR VPWR _06746_ sky130_fd_sc_hd__and3_1
X_16083_ net447 net650 _07810_ VGND VGND VPWR VPWR _07811_ sky130_fd_sc_hd__a21boi_1
X_13295_ _04770_ _04771_ _04772_ VGND VGND VPWR VPWR _04775_ sky130_fd_sc_hd__nand3_1
X_15034_ _06668_ _06669_ VGND VGND VPWR VPWR _06670_ sky130_fd_sc_hd__xor2_1
X_12246_ _03542_ _03569_ VGND VGND VPWR VPWR _03628_ sky130_fd_sc_hd__nor2_1
XFILLER_0_121_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12177_ _03551_ _03552_ VGND VGND VPWR VPWR _03553_ sky130_fd_sc_hd__nor2_1
X_11128_ _02410_ _02411_ VGND VGND VPWR VPWR _02412_ sky130_fd_sc_hd__xor2_1
XFILLER_0_3_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11059_ net724 net362 _02334_ _02335_ VGND VGND VPWR VPWR _02337_ sky130_fd_sc_hd__nand4_1
X_15936_ _07647_ _07652_ VGND VGND VPWR VPWR _07653_ sky130_fd_sc_hd__xnor2_1
X_15867_ net853 _00652_ VGND VGND VPWR VPWR _07578_ sky130_fd_sc_hd__nor2_1
X_14818_ _06433_ _06434_ _06368_ VGND VGND VPWR VPWR _06436_ sky130_fd_sc_hd__a21oi_1
X_15798_ b_cos\[11\] _07502_ _06949_ VGND VGND VPWR VPWR _07503_ sky130_fd_sc_hd__mux2_1
XFILLER_0_129_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14749_ _06346_ VGND VGND VPWR VPWR _06360_ sky130_fd_sc_hd__inv_2
XFILLER_0_129_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08270_ _03778_ _03789_ _03943_ VGND VGND VPWR VPWR _03954_ sky130_fd_sc_hd__a21o_2
XFILLER_0_73_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout137 net138 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__buf_2
Xfanout148 net149 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__buf_2
Xfanout159 net871 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__clkbuf_4
X_09724_ _01016_ _01033_ VGND VGND VPWR VPWR _01034_ sky130_fd_sc_hd__nand2_1
X_09655_ _00963_ _00964_ _00905_ _00906_ VGND VGND VPWR VPWR _00966_ sky130_fd_sc_hd__a211oi_1
X_08606_ _06639_ _06628_ _05741_ VGND VGND VPWR VPWR _07618_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_145_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09586_ _00895_ _00897_ VGND VGND VPWR VPWR _00898_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_49_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08537_ _06693_ _06704_ _06857_ VGND VGND VPWR VPWR _06867_ sky130_fd_sc_hd__and3_1
XFILLER_0_65_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08468_ _06047_ _06091_ _06102_ VGND VGND VPWR VPWR _06113_ sky130_fd_sc_hd__nor3_1
XFILLER_0_148_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08399_ _05264_ _05340_ _05351_ VGND VGND VPWR VPWR _05362_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_150_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10430_ _01690_ _01689_ _01661_ _01658_ VGND VGND VPWR VPWR _01694_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_45_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10361_ net353 net505 net793 net810 VGND VGND VPWR VPWR _01625_ sky130_fd_sc_hd__and4_1
X_12100_ net231 net315 net457 net449 VGND VGND VPWR VPWR _03469_ sky130_fd_sc_hd__and4_1
X_13080_ _04538_ _04539_ VGND VGND VPWR VPWR _04540_ sky130_fd_sc_hd__xor2_1
XFILLER_0_103_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10292_ a_sin\[12\] b_cos\[12\] VGND VGND VPWR VPWR _01564_ sky130_fd_sc_hd__and2b_1
X_12031_ a_cos\[13\] _03394_ _02383_ VGND VGND VPWR VPWR _03395_ sky130_fd_sc_hd__mux2_1
XFILLER_0_130_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout660 net662 VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__clkbuf_4
Xfanout671 net675 VGND VGND VPWR VPWR net671 sky130_fd_sc_hd__clkbuf_4
Xfanout682 net683 VGND VGND VPWR VPWR net682 sky130_fd_sc_hd__clkbuf_4
Xfanout693 net695 VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__buf_4
X_13982_ _05516_ _05521_ VGND VGND VPWR VPWR _05522_ sky130_fd_sc_hd__xor2_1
X_15721_ _07416_ _07418_ VGND VGND VPWR VPWR _07419_ sky130_fd_sc_hd__xnor2_1
X_12933_ net425 net509 net211 net202 VGND VGND VPWR VPWR _04380_ sky130_fd_sc_hd__and4_1
XFILLER_0_34_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15652_ _07299_ _07318_ VGND VGND VPWR VPWR _07343_ sky130_fd_sc_hd__nand2_1
X_12864_ _04266_ _04267_ _04302_ _04303_ VGND VGND VPWR VPWR _04305_ sky130_fd_sc_hd__a22o_1
XFILLER_0_96_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14603_ net420 net691 VGND VGND VPWR VPWR _06199_ sky130_fd_sc_hd__nand2_1
X_11815_ _03158_ _03159_ VGND VGND VPWR VPWR _03161_ sky130_fd_sc_hd__or2b_1
X_12795_ _04128_ VGND VGND VPWR VPWR _04230_ sky130_fd_sc_hd__inv_2
X_15583_ _07256_ _07267_ VGND VGND VPWR VPWR _07268_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_139_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14534_ _06121_ _06122_ VGND VGND VPWR VPWR _06123_ sky130_fd_sc_hd__nand2_1
X_11746_ _02498_ _03081_ _03082_ _03085_ VGND VGND VPWR VPWR _03086_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_71_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14465_ _05939_ _05991_ _06046_ VGND VGND VPWR VPWR _06048_ sky130_fd_sc_hd__a21oi_1
X_11677_ _02910_ _02912_ VGND VGND VPWR VPWR _03010_ sky130_fd_sc_hd__nor2_1
X_16204_ _07936_ _07941_ VGND VGND VPWR VPWR _07942_ sky130_fd_sc_hd__xnor2_1
X_13416_ _04808_ _04809_ VGND VGND VPWR VPWR _04907_ sky130_fd_sc_hd__nand2_1
X_10628_ _01883_ _01891_ net795 net809 VGND VGND VPWR VPWR _01892_ sky130_fd_sc_hd__and4b_1
XFILLER_0_24_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14396_ _05960_ _05961_ _05971_ VGND VGND VPWR VPWR _05972_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_107_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13347_ a_sin\[5\] net863 VGND VGND VPWR VPWR _04832_ sky130_fd_sc_hd__and2_1
X_16135_ net447 net633 VGND VGND VPWR VPWR _07868_ sky130_fd_sc_hd__nand2_1
XFILLER_0_141_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10559_ net410 net786 net794 net399 VGND VGND VPWR VPWR _01823_ sky130_fd_sc_hd__a22o_1
X_13278_ _04646_ _04647_ _04755_ VGND VGND VPWR VPWR _04756_ sky130_fd_sc_hd__o21a_1
X_16066_ _07790_ _07792_ VGND VGND VPWR VPWR _07793_ sky130_fd_sc_hd__nor2b_2
XFILLER_0_11_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15017_ _06571_ _06587_ _06588_ _06591_ VGND VGND VPWR VPWR _06652_ sky130_fd_sc_hd__a31o_1
X_12229_ _03549_ _03607_ _03608_ VGND VGND VPWR VPWR _03609_ sky130_fd_sc_hd__o21ai_1
X_15919_ _07602_ _07603_ _07633_ VGND VGND VPWR VPWR _07634_ sky130_fd_sc_hd__o21ai_1
X_09440_ _00751_ _00752_ VGND VGND VPWR VPWR _00753_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_87_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09371_ _00683_ _00684_ VGND VGND VPWR VPWR _00685_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_24_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08322_ _04360_ _04491_ _04480_ VGND VGND VPWR VPWR _04523_ sky130_fd_sc_hd__a21o_1
XFILLER_0_59_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08253_ _03301_ _03333_ VGND VGND VPWR VPWR _03767_ sky130_fd_sc_hd__and2_1
XFILLER_0_6_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08184_ _02899_ _02909_ _03007_ VGND VGND VPWR VPWR _03018_ sky130_fd_sc_hd__and3_1
XFILLER_0_112_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09707_ _00924_ _00926_ VGND VGND VPWR VPWR _01017_ sky130_fd_sc_hd__and2_1
XFILLER_0_69_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09638_ net248 net529 VGND VGND VPWR VPWR _00949_ sky130_fd_sc_hd__nand2_1
X_09569_ _00875_ _00880_ VGND VGND VPWR VPWR _00881_ sky130_fd_sc_hd__xnor2_1
X_11600_ _02924_ _02925_ VGND VGND VPWR VPWR _02926_ sky130_fd_sc_hd__xnor2_2
X_12580_ _03945_ _03947_ _03946_ VGND VGND VPWR VPWR _03993_ sky130_fd_sc_hd__nand3_1
XFILLER_0_136_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11531_ _02848_ _02849_ _02829_ VGND VGND VPWR VPWR _02851_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_872 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14250_ _05769_ _05773_ _05811_ VGND VGND VPWR VPWR _05812_ sky130_fd_sc_hd__or3_1
XFILLER_0_108_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_842 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11462_ _02771_ _02772_ _02774_ VGND VGND VPWR VPWR _02776_ sky130_fd_sc_hd__a21o_1
XFILLER_0_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13201_ _04555_ _04553_ _04554_ VGND VGND VPWR VPWR _04672_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_123_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10413_ _01668_ _01674_ _01673_ VGND VGND VPWR VPWR _01677_ sky130_fd_sc_hd__a21o_1
X_14181_ _05693_ _05695_ _05736_ VGND VGND VPWR VPWR _05737_ sky130_fd_sc_hd__o21ai_1
X_11393_ _02598_ _02689_ VGND VGND VPWR VPWR _02700_ sky130_fd_sc_hd__or2_1
XFILLER_0_33_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13132_ _04594_ _04595_ _04586_ VGND VGND VPWR VPWR _04597_ sky130_fd_sc_hd__a21o_1
X_10344_ _01608_ VGND VGND VPWR VPWR _00057_ sky130_fd_sc_hd__clkbuf_1
X_13063_ _04339_ _04508_ _04509_ VGND VGND VPWR VPWR _04521_ sky130_fd_sc_hd__nand3_1
XFILLER_0_29_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10275_ _01549_ VGND VGND VPWR VPWR _00047_ sky130_fd_sc_hd__clkbuf_1
X_12014_ _03281_ _03374_ _03372_ _03373_ VGND VGND VPWR VPWR _03376_ sky130_fd_sc_hd__o211a_1
Xfanout490 net42 VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__buf_4
X_13965_ _05501_ _05472_ _05473_ VGND VGND VPWR VPWR _05504_ sky130_fd_sc_hd__nand3_1
X_15704_ _07304_ _07307_ _07305_ VGND VGND VPWR VPWR _07400_ sky130_fd_sc_hd__o21ba_1
X_12916_ _04344_ _04359_ _04361_ VGND VGND VPWR VPWR _04362_ sky130_fd_sc_hd__nand3_2
X_13896_ _05411_ _05428_ VGND VGND VPWR VPWR _05429_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15635_ _07322_ _07324_ VGND VGND VPWR VPWR _07326_ sky130_fd_sc_hd__xnor2_1
X_12847_ net229 net313 net322 net238 VGND VGND VPWR VPWR _04287_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_14_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15566_ _07242_ _07244_ VGND VGND VPWR VPWR _07250_ sky130_fd_sc_hd__or2_1
X_12778_ net806 net222 _04202_ _04203_ VGND VGND VPWR VPWR _04211_ sky130_fd_sc_hd__a22o_1
XFILLER_0_145_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14517_ _06085_ _06086_ _06103_ VGND VGND VPWR VPWR _06105_ sky130_fd_sc_hd__a21o_1
XFILLER_0_126_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11729_ _03065_ _03064_ _03017_ VGND VGND VPWR VPWR _03067_ sky130_fd_sc_hd__a21bo_1
X_15497_ _07170_ _07171_ _07174_ VGND VGND VPWR VPWR _07175_ sky130_fd_sc_hd__a21o_1
X_14448_ _05969_ _05968_ VGND VGND VPWR VPWR _06029_ sky130_fd_sc_hd__or2b_1
XFILLER_0_4_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14379_ net391 net569 VGND VGND VPWR VPWR _05953_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16118_ _07756_ _07796_ _07747_ VGND VGND VPWR VPWR _07849_ sky130_fd_sc_hd__o21bai_1
XPHY_EDGE_ROW_23_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08940_ net320 net68 net620 VGND VGND VPWR VPWR _00259_ sky130_fd_sc_hd__and3_1
X_16049_ _07773_ _07774_ VGND VGND VPWR VPWR _07775_ sky130_fd_sc_hd__xor2_2
XFILLER_0_20_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08871_ _00190_ VGND VGND VPWR VPWR _00002_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_79_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09423_ _00655_ _00736_ VGND VGND VPWR VPWR _00737_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_32_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09354_ _00662_ _00667_ VGND VGND VPWR VPWR _00668_ sky130_fd_sc_hd__xor2_2
XFILLER_0_47_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08305_ _02550_ _02561_ _02702_ VGND VGND VPWR VPWR _04338_ sky130_fd_sc_hd__and3_1
XFILLER_0_136_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09285_ net159 net305 net670 net676 VGND VGND VPWR VPWR _00600_ sky130_fd_sc_hd__nand4_2
XFILLER_0_142_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08236_ _03496_ _03507_ _03561_ VGND VGND VPWR VPWR _03583_ sky130_fd_sc_hd__a21o_1
XFILLER_0_16_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08167_ net213 net204 net694 net530 VGND VGND VPWR VPWR _02833_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_41_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10060_ _01335_ _01338_ VGND VGND VPWR VPWR _01364_ sky130_fd_sc_hd__or2_1
X_13750_ _05267_ _05269_ VGND VGND VPWR VPWR _05270_ sky130_fd_sc_hd__xnor2_1
X_10962_ net715 net384 net373 net724 VGND VGND VPWR VPWR _02231_ sky130_fd_sc_hd__a22o_1
XFILLER_0_58_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12701_ _04084_ _04085_ _04125_ VGND VGND VPWR VPWR _04126_ sky130_fd_sc_hd__and3_1
XFILLER_0_57_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13681_ _05114_ _05194_ VGND VGND VPWR VPWR _05195_ sky130_fd_sc_hd__nor2_1
X_10893_ _02154_ _02155_ _02156_ VGND VGND VPWR VPWR _02157_ sky130_fd_sc_hd__nand3_4
XFILLER_0_85_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15420_ net493 net688 VGND VGND VPWR VPWR _07091_ sky130_fd_sc_hd__and2_1
X_12632_ net748 net757 net327 net243 VGND VGND VPWR VPWR _04050_ sky130_fd_sc_hd__and4_1
XFILLER_0_127_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12563_ _03883_ _03973_ VGND VGND VPWR VPWR _03974_ sky130_fd_sc_hd__or2_1
X_15351_ net394 net634 net625 net404 VGND VGND VPWR VPWR _07016_ sky130_fd_sc_hd__a22o_1
XFILLER_0_136_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14302_ _05865_ _05866_ _05867_ VGND VGND VPWR VPWR _05868_ sky130_fd_sc_hd__nand3_1
X_11514_ net714 net723 net485 net474 VGND VGND VPWR VPWR _02832_ sky130_fd_sc_hd__and4_1
XFILLER_0_108_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12494_ _03896_ _03897_ VGND VGND VPWR VPWR _03898_ sky130_fd_sc_hd__xnor2_1
X_15282_ _06851_ _06940_ VGND VGND VPWR VPWR _06941_ sky130_fd_sc_hd__xor2_1
XFILLER_0_123_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11445_ net428 net359 _02754_ _02755_ VGND VGND VPWR VPWR _02758_ sky130_fd_sc_hd__nand4_2
XFILLER_0_150_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14233_ _05737_ _05758_ _05792_ VGND VGND VPWR VPWR _05793_ sky130_fd_sc_hd__a21o_1
XFILLER_0_124_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14164_ _05593_ _05716_ VGND VGND VPWR VPWR _05718_ sky130_fd_sc_hd__or2_1
X_11376_ _02552_ _02586_ _02585_ VGND VGND VPWR VPWR _02683_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13115_ _04575_ _04576_ _04572_ VGND VGND VPWR VPWR _04579_ sky130_fd_sc_hd__a21o_1
X_10327_ net134 net105 VGND VGND VPWR VPWR _01595_ sky130_fd_sc_hd__and2b_1
X_14095_ _05550_ _05530_ VGND VGND VPWR VPWR _05645_ sky130_fd_sc_hd__or2b_1
X_13046_ _04401_ _04403_ _04501_ _04503_ VGND VGND VPWR VPWR _04504_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_147_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10258_ _01526_ _01529_ _01527_ VGND VGND VPWR VPWR _01535_ sky130_fd_sc_hd__a21bo_1
X_10189_ net85 _01476_ net135 VGND VGND VPWR VPWR _01477_ sky130_fd_sc_hd__mux2_1
XFILLER_0_88_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14997_ _06593_ _06629_ _06630_ VGND VGND VPWR VPWR _06631_ sky130_fd_sc_hd__or3_4
XFILLER_0_88_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13948_ _05482_ _05483_ _05484_ VGND VGND VPWR VPWR _05485_ sky130_fd_sc_hd__o21a_1
XFILLER_0_48_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13879_ _05344_ _05347_ _05409_ VGND VGND VPWR VPWR _05410_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_119_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15618_ net442 net545 VGND VGND VPWR VPWR _07307_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15549_ _07207_ _07208_ _07230_ _07231_ VGND VGND VPWR VPWR _07232_ sky130_fd_sc_hd__a22o_1
X_09070_ _00386_ _00387_ VGND VGND VPWR VPWR _00388_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_114_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout6 net473 VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_97_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09972_ _01261_ _01277_ VGND VGND VPWR VPWR _01278_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_123_Right_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08923_ net658 _00153_ _00156_ _00154_ VGND VGND VPWR VPWR _00242_ sky130_fd_sc_hd__a22o_1
XFILLER_0_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08854_ _00171_ _00172_ _08068_ _00142_ VGND VGND VPWR VPWR _00174_ sky130_fd_sc_hd__o211a_1
X_08785_ _08017_ _08076_ _08077_ VGND VGND VPWR VPWR _08095_ sky130_fd_sc_hd__nand3_1
XFILLER_0_46_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09406_ _00701_ _00702_ _00718_ _00719_ VGND VGND VPWR VPWR _00720_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_137_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09337_ _02170_ VGND VGND VPWR VPWR _00652_ sky130_fd_sc_hd__buf_4
XFILLER_0_8_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09268_ _00582_ VGND VGND VPWR VPWR _00583_ sky130_fd_sc_hd__inv_2
XFILLER_0_117_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08219_ _03051_ _03062_ _03377_ _03388_ VGND VGND VPWR VPWR _03398_ sky130_fd_sc_hd__or4_4
XFILLER_0_7_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09199_ _00511_ _00512_ _00513_ VGND VGND VPWR VPWR _00515_ sky130_fd_sc_hd__nand3_1
XFILLER_0_120_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11230_ net792 _02385_ VGND VGND VPWR VPWR _02523_ sky130_fd_sc_hd__nor2_1
XFILLER_0_15_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11161_ _02446_ _02447_ VGND VGND VPWR VPWR _02448_ sky130_fd_sc_hd__and2b_1
X_10112_ net92 _01410_ net137 VGND VGND VPWR VPWR _01411_ sky130_fd_sc_hd__mux2_1
X_11092_ _02266_ _02269_ _02371_ _02372_ VGND VGND VPWR VPWR _02373_ sky130_fd_sc_hd__a211o_2
X_10043_ _01300_ _01347_ VGND VGND VPWR VPWR _01348_ sky130_fd_sc_hd__xnor2_1
X_14920_ _06147_ _06357_ _06546_ _06358_ VGND VGND VPWR VPWR _06547_ sky130_fd_sc_hd__a211o_1
Xhold40 a_cos\[11\] VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__dlygate4sd3_1
X_14851_ net488 net478 net574 net585 VGND VGND VPWR VPWR _06471_ sky130_fd_sc_hd__and4_1
X_13802_ _05323_ _05324_ VGND VGND VPWR VPWR _05326_ sky130_fd_sc_hd__and2_1
X_14782_ _06293_ _06295_ _06294_ VGND VGND VPWR VPWR _06396_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_86_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11994_ _03352_ _03353_ VGND VGND VPWR VPWR _03354_ sky130_fd_sc_hd__xnor2_1
X_13733_ _05248_ _05249_ _05250_ _05156_ VGND VGND VPWR VPWR _05251_ sky130_fd_sc_hd__a211oi_1
X_10945_ net742 net749 net351 net502 VGND VGND VPWR VPWR _02213_ sky130_fd_sc_hd__nand4_1
X_13664_ _05173_ _05175_ VGND VGND VPWR VPWR _05176_ sky130_fd_sc_hd__xor2_1
X_10876_ _02131_ _02139_ VGND VGND VPWR VPWR _02140_ sky130_fd_sc_hd__xor2_2
XFILLER_0_54_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15403_ _07069_ _07071_ VGND VGND VPWR VPWR _07072_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_128_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12615_ _03978_ _03970_ _03979_ VGND VGND VPWR VPWR _04032_ sky130_fd_sc_hd__and3_1
XFILLER_0_109_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13595_ _05049_ _05100_ VGND VGND VPWR VPWR _05102_ sky130_fd_sc_hd__xnor2_2
X_15334_ _06994_ _06995_ _06986_ VGND VGND VPWR VPWR _06997_ sky130_fd_sc_hd__a21o_1
XFILLER_0_124_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12546_ _03937_ _03940_ _03938_ VGND VGND VPWR VPWR _03956_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_108_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15265_ _01891_ _06920_ _06921_ _06801_ net415 VGND VGND VPWR VPWR _06923_ sky130_fd_sc_hd__o32ai_4
X_12477_ net791 net805 net162 net309 VGND VGND VPWR VPWR _03880_ sky130_fd_sc_hd__and4_1
XANTENNA_4 net876 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14216_ _05773_ _05775_ _00652_ VGND VGND VPWR VPWR _05776_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_111_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11428_ _02736_ _02737_ _02738_ VGND VGND VPWR VPWR _02739_ sky130_fd_sc_hd__a21o_1
X_15196_ _06843_ _06845_ _06735_ _06738_ VGND VGND VPWR VPWR _06848_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_21_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11359_ net396 net154 net146 net406 VGND VGND VPWR VPWR _02664_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14147_ _05678_ _05700_ VGND VGND VPWR VPWR _05701_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14078_ _05624_ _05625_ VGND VGND VPWR VPWR _05626_ sky130_fd_sc_hd__xor2_1
X_13029_ net150 net141 net322 net237 VGND VGND VPWR VPWR _04485_ sky130_fd_sc_hd__and4_2
Xrebuffer16 _00160_ VGND VGND VPWR VPWR net827 sky130_fd_sc_hd__clkbuf_1
X_08570_ net215 net206 net601 net703 VGND VGND VPWR VPWR _07227_ sky130_fd_sc_hd__and4_1
Xrebuffer27 net692 VGND VGND VPWR VPWR net838 sky130_fd_sc_hd__buf_2
Xrebuffer38 _07488_ VGND VGND VPWR VPWR net876 sky130_fd_sc_hd__buf_2
XFILLER_0_16_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09122_ _00437_ _00438_ VGND VGND VPWR VPWR _00439_ sky130_fd_sc_hd__xor2_2
XFILLER_0_17_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09053_ _00342_ _00269_ _00369_ _00370_ VGND VGND VPWR VPWR _00371_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_89_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09955_ _01181_ _01212_ _01260_ VGND VGND VPWR VPWR _01261_ sky130_fd_sc_hd__a21o_1
X_08906_ net169 net693 net529 net160 VGND VGND VPWR VPWR _00225_ sky130_fd_sc_hd__a22o_1
X_09886_ _01191_ _01192_ VGND VGND VPWR VPWR _01193_ sky130_fd_sc_hd__xor2_1
XFILLER_0_99_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08837_ _00155_ _00156_ VGND VGND VPWR VPWR _00157_ sky130_fd_sc_hd__xnor2_2
X_08768_ _08076_ _08077_ _08017_ VGND VGND VPWR VPWR _08079_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_68_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08699_ _08006_ _08008_ _07835_ _07878_ VGND VGND VPWR VPWR _08010_ sky130_fd_sc_hd__a211o_1
XFILLER_0_67_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10730_ _01992_ _01993_ VGND VGND VPWR VPWR _01994_ sky130_fd_sc_hd__nor2_1
XFILLER_0_138_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10661_ _01913_ _01922_ VGND VGND VPWR VPWR _01925_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12400_ net765 net162 net309 net772 VGND VGND VPWR VPWR _03795_ sky130_fd_sc_hd__a22oi_2
X_13380_ _04865_ _04866_ VGND VGND VPWR VPWR _04867_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_91_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10592_ _01845_ _01855_ VGND VGND VPWR VPWR _01856_ sky130_fd_sc_hd__or2_1
XFILLER_0_36_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12331_ _03717_ _03718_ VGND VGND VPWR VPWR _03719_ sky130_fd_sc_hd__nor2_1
XFILLER_0_63_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15050_ _06684_ _06685_ _06686_ VGND VGND VPWR VPWR _06688_ sky130_fd_sc_hd__a21o_1
X_12262_ _03639_ _03644_ VGND VGND VPWR VPWR _03645_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_105_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14001_ _05452_ _05457_ VGND VGND VPWR VPWR _05542_ sky130_fd_sc_hd__and2b_1
X_11213_ _02410_ _02411_ _02503_ VGND VGND VPWR VPWR _02504_ sky130_fd_sc_hd__a21o_1
X_12193_ _03568_ _03569_ _03502_ _03505_ VGND VGND VPWR VPWR _03570_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_120_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11144_ _02425_ _02426_ _02427_ VGND VGND VPWR VPWR _02429_ sky130_fd_sc_hd__a21o_1
Xoutput85 net85 VGND VGND VPWR VPWR D[15] sky130_fd_sc_hd__clkbuf_4
Xoutput96 net96 VGND VGND VPWR VPWR D[8] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11075_ _02351_ _02352_ _02353_ VGND VGND VPWR VPWR _02355_ sky130_fd_sc_hd__nand3_1
X_15952_ _07586_ _07589_ _07587_ VGND VGND VPWR VPWR _07669_ sky130_fd_sc_hd__o21ba_1
X_10026_ _01329_ _01330_ VGND VGND VPWR VPWR _01331_ sky130_fd_sc_hd__and2_1
X_14903_ _06491_ _06526_ _06527_ VGND VGND VPWR VPWR _06528_ sky130_fd_sc_hd__nor3_2
X_15883_ _07545_ _07550_ VGND VGND VPWR VPWR _07594_ sky130_fd_sc_hd__and2b_1
X_14834_ _06368_ _06433_ _06434_ VGND VGND VPWR VPWR _06452_ sky130_fd_sc_hd__nand3_1
XFILLER_0_59_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14765_ _06375_ _06376_ VGND VGND VPWR VPWR _06378_ sky130_fd_sc_hd__nor2_1
XFILLER_0_98_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11977_ _03331_ _03335_ VGND VGND VPWR VPWR _03336_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13716_ _05229_ _05230_ _05211_ _05212_ VGND VGND VPWR VPWR _05233_ sky130_fd_sc_hd__a211o_1
XFILLER_0_58_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10928_ _02191_ _02193_ VGND VGND VPWR VPWR _02194_ sky130_fd_sc_hd__nand2_1
X_14696_ _06298_ _06299_ _06283_ VGND VGND VPWR VPWR _06302_ sky130_fd_sc_hd__a21o_1
XFILLER_0_74_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13647_ _05072_ _05094_ _05095_ VGND VGND VPWR VPWR _05158_ sky130_fd_sc_hd__nand3_1
X_10859_ _02072_ _02074_ _02073_ VGND VGND VPWR VPWR _02123_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_144_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13578_ net312 net423 net158 net304 VGND VGND VPWR VPWR _05083_ sky130_fd_sc_hd__nand4_2
XFILLER_0_14_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15317_ _06959_ _06978_ VGND VGND VPWR VPWR _06979_ sky130_fd_sc_hd__xor2_2
X_12529_ net748 net216 net207 net756 VGND VGND VPWR VPWR _03937_ sky130_fd_sc_hd__a22oi_2
X_16297_ clknet_4_3_0_clk _00086_ net336 VGND VGND VPWR VPWR a_sin\[9\] sky130_fd_sc_hd__dfrtp_1
X_15248_ _06883_ _06903_ VGND VGND VPWR VPWR _06904_ sky130_fd_sc_hd__xor2_2
XFILLER_0_75_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15179_ _06827_ _06828_ VGND VGND VPWR VPWR _06829_ sky130_fd_sc_hd__or2_1
XFILLER_0_1_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout308 net309 VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__clkbuf_4
Xfanout319 net6 VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__buf_6
X_09740_ _01044_ _01043_ VGND VGND VPWR VPWR _01049_ sky130_fd_sc_hd__nor2b_2
.ends
