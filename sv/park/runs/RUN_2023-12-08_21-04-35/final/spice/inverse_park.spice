* NGSPICE file created from inverse_park.ext - technology: sky130A

.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A a_113_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_113_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X1 a_80_21# C1 a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X2 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_300_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.26 ps=1.45 w=0.65 l=0.15
X6 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_80_21# A1 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 a_472_297# B1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X9 a_80_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=0.59
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=0.59
.ends

.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
X0 VPWR B a_59_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 X a_59_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.475 pd=2.95 as=0.167 ps=1.39 w=1 l=0.15
X2 VGND B a_145_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_59_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X4 X a_59_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.112 ps=1.04 w=0.65 l=0.15
X5 a_145_75# A a_59_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=2.89
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=2.89
.ends

.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X2 a_193_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y A a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X4 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 a_109_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.97
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.97
.ends

.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
X0 a_377_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.365 ps=1.73 w=1 l=0.15
X1 a_47_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.3 ps=2.6 w=1 l=0.15
X2 a_129_47# B a_47_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_285_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 Y a_47_47# a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_129_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0683 ps=0.86 w=0.65 l=0.15
X6 VPWR A a_47_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.365 pd=1.73 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_47_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.165 ps=1.33 w=1 l=0.15
X8 Y B a_377_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
X0 Y C a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 a_281_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X6 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X10 a_281_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_297# B a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
X0 X a_35_297# a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.26 ps=2.52 w=1 l=0.15
X1 X B a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.25 pd=1.42 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_117_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 VPWR B a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.25 ps=1.42 w=0.65 l=0.15
X7 a_285_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A a_117_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_109_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
X0 a_27_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_560_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X2 VGND B a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0991 ps=0.955 w=0.65 l=0.15
X3 Y B a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_297# a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_474_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X7 VGND A a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# B a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X12 a_474_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_560_47# a_27_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X14 VPWR A a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X15 Y a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X16 VPWR a_27_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X17 a_560_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.35 as=0.265 ps=2.53 w=1 l=0.15
X1 a_209_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.172 ps=1.35 w=1 l=0.15
X2 a_303_47# A2 a_209_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.104 ps=0.97 w=0.65 l=0.15
X3 a_209_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.112 ps=0.995 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.172 ps=1.83 w=0.65 l=0.15
X5 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.107 ps=0.98 w=0.65 l=0.15
X6 a_80_21# A1 a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X7 VPWR A2 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.16 ps=1.32 w=1 l=0.15
X8 a_80_21# B1 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X9 a_209_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_206_369# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.146 ps=1.34 w=0.42 l=0.15
X1 a_206_369# A2_N a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 VGND B2 a_489_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_585_369# B2 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0672 ps=0.74 w=0.42 l=0.15
X4 a_489_47# a_206_369# a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_489_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VPWR A2_N a_206_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.209 pd=1.35 as=0.129 ps=1.18 w=0.42 l=0.15
X7 a_76_199# a_206_369# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.74 as=0.209 ps=1.35 w=0.42 l=0.15
X8 a_205_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0662 pd=0.735 as=0.0986 ps=0.98 w=0.42 l=0.15
X9 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.26 ps=2.52 w=1 l=0.15
X10 VPWR B1 a_585_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0986 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_397_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR B1_N a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X2 Y A2 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VGND A2 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND A1 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_28_297# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X6 Y a_28_297# a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VPWR a_28_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_397_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X9 a_229_47# a_28_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y a_28_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X11 a_229_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_229_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A1 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.091 ps=0.93 w=0.65 l=0.15
X1 Y B1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.175 ps=1.35 w=1 l=0.15
X4 a_29_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y A2 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND A1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 a_112_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X8 a_112_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.14 ps=1.28 w=1 l=0.15
X9 a_29_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X11 a_29_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
X0 VGND A a_68_297# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_68_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_68_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR A a_150_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 X a_68_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.34 pd=2.68 as=0.146 ps=1.34 w=1 l=0.15
X5 a_150_297# B a_68_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 a_81_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.257 ps=1.44 w=0.65 l=0.15
X1 a_299_297# B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_299_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 a_384_47# A1 a_81_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_286_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X2 a_286_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X3 Y A2 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 VGND A1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X6 VGND A2 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X7 a_487_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# B1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR A1 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_27_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X13 a_487_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X14 a_286_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_388_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.127 pd=1.25 as=0.153 ps=1.3 w=1 l=0.15
X1 a_105_352# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_297_47# a_105_352# Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A1 a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.127 ps=1.25 w=1 l=0.15
X5 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X6 VPWR B1_N a_105_352# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.178 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 Y a_105_352# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.178 ps=1.4 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.172 ps=1.83 w=0.65 l=0.15
X2 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X3 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X5 a_326_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.127 ps=1.04 w=0.65 l=0.15
X6 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.635 pd=3.27 as=0.195 ps=1.39 w=1 l=0.15
X7 Y C1 a_326_47# VNB sky130_fd_pr__nfet_01v8 ad=0.393 pd=2.51 as=0.0683 ps=0.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_199_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_113_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.147 ps=1.29 w=1 l=0.15
X2 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X3 VPWR A1 a_113_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.29 as=0.14 ps=1.28 w=1 l=0.15
X4 a_113_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A2 a_199_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0959 ps=0.945 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VPWR C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 a_181_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VGND C a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.132 pd=1.14 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 a_27_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X6 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.132 ps=1.14 w=0.65 l=0.15
X7 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
X0 VPWR B a_207_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.228 pd=1.74 as=0.0609 ps=0.71 w=0.42 l=0.15
X1 X a_207_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.228 ps=1.74 w=1 l=0.15
X2 a_297_47# a_27_413# a_207_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0504 pd=0.66 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_207_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.99 w=0.65 l=0.15
X4 a_207_413# a_27_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0609 pd=0.71 as=0.0714 ps=0.76 w=0.42 l=0.15
X5 VPWR A_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0714 pd=0.76 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VGND B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.99 as=0.0504 ps=0.66 w=0.42 l=0.15
X7 a_27_413# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.05
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.05
.ends

.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X3 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X4 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X5 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.301 ps=2.66 w=1 l=0.15
X7 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X8 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X10 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X12 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X13 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X14 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X15 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X16 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X17 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X18 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X20 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X21 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X22 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.209 ps=2.02 w=0.65 l=0.15
X23 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X24 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X25 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X26 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X27 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.42 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0703 pd=0.755 as=0.111 ps=1.37 w=0.42 l=0.15
X6 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.14 ps=1.28 w=1 l=0.15
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0703 ps=0.755 w=0.42 l=0.15
X8 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.165 ps=1.33 w=1 l=0.15
X9 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 Y A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.174 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.182 pd=1.92 as=0.174 ps=1.39 w=0.7 l=0.15
X2 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X3 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.16 ps=1.32 w=1 l=0.15
X1 a_27_297# B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X2 VGND A2 a_373_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.114 ps=1 w=0.65 l=0.15
X3 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X4 a_27_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.253 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.253 ps=2.52 w=1 l=0.15
X6 a_373_47# A1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.96 w=0.65 l=0.15
X8 a_109_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
X0 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.157 ps=1.17 w=0.42 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.157 pd=1.17 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X6 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X21 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.149 ps=1.33 w=1 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.149 pd=1.33 as=0.166 ps=1.8 w=0.64 l=0.15
X3 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X4 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
X0 VPWR a_75_212# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 a_75_212# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 a_75_212# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND a_75_212# X VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.745 as=0.111 ps=1.37 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.162 ps=1.33 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
X0 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_161_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X2 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_161_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A a_161_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_161_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_467_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_467_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_109_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A2 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_109_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
X0 a_27_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y A a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y A a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_445_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X12 a_445_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_445_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X17 a_445_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X23 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
X0 VGND C a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 a_277_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_47# B a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.135 ps=1.27 w=1 l=0.15
X8 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_277_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_197_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0798 pd=0.8 as=0.0609 ps=0.71 w=0.42 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.312 ps=1.68 w=1 l=0.15
X3 a_303_47# C a_197_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0798 ps=0.8 w=0.42 l=0.15
X4 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.68 as=0.0588 ps=0.7 w=0.42 l=0.15
X6 VGND D a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.196 pd=1.33 as=0.0693 ps=0.75 w=0.42 l=0.15
X7 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X8 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.196 ps=1.33 w=0.65 l=0.15
X9 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
X0 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X1 a_471_47# B a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.42 pd=2.84 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_47# C a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=1.67 w=1 l=0.15
X8 a_277_47# B a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X9 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.335 pd=1.67 as=0.135 ps=1.27 w=1 l=0.15
X10 Y A a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_277_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X13 a_471_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_470_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_470_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_470_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.106 ps=0.975 w=0.65 l=0.15
X6 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X8 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X10 a_470_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.162 ps=1.33 w=1 l=0.15
X11 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 VPWR B a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X13 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X16 X a_112_47# a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 a_470_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X18 X B a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
X0 VPWR a_505_21# a_535_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_505_21# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.0693 ps=0.75 w=0.42 l=0.15
X2 a_218_374# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0767 pd=0.785 as=0.158 ps=1.39 w=0.42 l=0.15
X3 VGND a_505_21# a_439_47# VNB sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.11 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 a_76_199# A0 a_218_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.193 pd=1.34 as=0.0767 ps=0.785 w=0.42 l=0.15
X5 a_505_21# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.145 ps=1.11 w=0.42 l=0.15
X6 a_439_47# A0 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0997 ps=0.895 w=0.42 l=0.15
X7 a_535_374# A1 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.193 ps=1.34 w=0.42 l=0.15
X8 a_76_199# A1 a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0997 pd=0.895 as=0.0693 ps=0.75 w=0.42 l=0.15
X9 a_218_47# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.113 ps=1.04 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.158 pd=1.39 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.04 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_382_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X1 a_297_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X2 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.327 pd=1.65 as=0.28 ps=2.56 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.327 ps=1.65 w=1 l=0.15
X6 a_382_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.195 ps=1.39 w=1 l=0.15
X7 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_222_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X1 VPWR A1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.105 ps=1.21 w=1 l=0.15
X2 VGND a_79_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_222_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.186 ps=1.41 w=0.42 l=0.15
X4 VGND A2 a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_448_47# a_222_93# a_79_199# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_79_199# a_222_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.3 ps=2.6 w=1 l=0.15
X7 a_544_297# A2 a_79_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X8 a_448_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.186 pd=1.41 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
X0 VPWR D a_343_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.46 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_223_47# B_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.5 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 a_515_93# a_223_47# a_429_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 a_223_47# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.134 pd=1.48 as=0.0588 ps=0.7 w=0.42 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.168 ps=1.64 w=0.42 l=0.15
X5 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.168 ps=1.64 w=0.42 l=0.15
X6 X a_343_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.172 ps=1.46 w=1 l=0.15
X7 a_429_93# a_27_47# a_343_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.118 ps=1.4 w=0.42 l=0.15
X8 VGND D a_615_93# VNB sky130_fd_pr__nfet_01v8 ad=0.126 pd=1.11 as=0.0777 ps=0.79 w=0.42 l=0.15
X9 a_343_93# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X10 a_343_93# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.122 ps=1.42 w=0.42 l=0.15
X11 a_615_93# C a_515_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X12 X a_343_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.82 as=0.126 ps=1.11 w=0.65 l=0.15
X13 VPWR a_223_47# a_343_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X7 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.38 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X11 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X18 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.117 ps=1.01 w=0.65 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.41 pd=1.82 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.175 ps=1.35 w=1 l=0.15
X4 a_277_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.41 ps=1.82 w=1 l=0.15
X10 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.18 ps=1.36 w=1 l=0.15
X11 a_277_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.114 ps=1 w=0.65 l=0.15
X13 Y A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.0975 ps=0.95 w=0.65 l=0.15
X14 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4b_1 A_N B C D VGND VNB VPB VPWR Y
X0 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.192 ps=1.38 w=1 l=0.15
X1 a_232_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.118 ps=1.04 w=0.65 l=0.15
X2 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.192 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A_N a_41_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR a_41_93# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.195 ps=1.39 w=1 l=0.15
X5 a_316_47# C a_232_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y a_41_93# a_423_47# VNB sky130_fd_pr__nfet_01v8 ad=0.228 pd=2 as=0.127 ps=1.04 w=0.65 l=0.15
X7 a_423_47# B a_316_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.125 ps=1.03 w=0.65 l=0.15
X8 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X9 VGND A_N a_41_93# VNB sky130_fd_pr__nfet_01v8 ad=0.118 pd=1.04 as=0.111 ps=1.37 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 Y B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X1 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.135 ps=1.27 w=1 l=0.15
X3 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_381_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_109_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VGND A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0683 ps=0.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_298_297# a_27_413# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.265 ps=2.53 w=1 l=0.15
X1 a_215_297# a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.136 ps=1.1 w=0.65 l=0.15
X2 a_298_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.258 ps=1.45 w=0.65 l=0.15
X4 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X6 a_382_47# A1 a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.136 pd=1.1 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VPWR A1 a_298_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND A2 a_382_47# VNB sky130_fd_pr__nfet_01v8 ad=0.258 pd=1.45 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32a_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_429_297# A2 a_345_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND A2 a_345_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_345_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.14 ps=1.08 w=0.65 l=0.15
X5 a_345_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.305 ps=1.61 w=1 l=0.15
X6 a_629_297# B2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR B1 a_629_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.33 pd=2.66 as=0.19 ps=1.38 w=1 l=0.15
X8 a_79_21# B2 a_345_47# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_345_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.214 pd=1.96 as=0.123 ps=1.03 w=0.65 l=0.15
X10 a_79_21# A3 a_429_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X11 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X12 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_345_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.198 ps=1.26 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 Y a_61_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.183 ps=1.24 w=0.65 l=0.15
X1 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_217_297# a_61_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_479_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X4 a_217_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X5 Y a_61_47# a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 VPWR A1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_61_47# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VGND A2 a_637_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_61_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A1 a_479_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0683 ps=0.86 w=0.65 l=0.15
X11 VGND B1_N a_61_47# VNB sky130_fd_pr__nfet_01v8 ad=0.183 pd=1.24 as=0.126 ps=1.44 w=0.42 l=0.15
X12 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X13 a_637_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VGND A2 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR A1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_37_297# B1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_485_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_292_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VPWR A2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X8 a_485_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X11 a_37_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 Y A1 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X13 Y C1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_292_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X15 a_292_297# B1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
X0 a_558_47# a_381_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X1 VGND X a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_841_47# a_664_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VPWR A a_62_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A a_62_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_558_47# a_381_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X6 X a_62_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR X a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_841_47# a_664_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X9 X a_62_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X10 VPWR a_558_47# a_664_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND a_558_47# a_664_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
X0 VGND A a_311_413# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 VPWR A a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0598 ps=0.705 w=0.42 l=0.15
X2 a_393_413# a_205_93# a_311_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.122 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND C_N a_27_410# VNB sky130_fd_pr__nfet_01v8 ad=0.0619 pd=0.715 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR C_N a_27_410# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.123 pd=1.32 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_311_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X6 VGND a_27_410# a_311_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0598 ps=0.705 w=0.42 l=0.15
X7 a_561_297# B a_489_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0598 pd=0.705 as=0.0441 ps=0.63 w=0.42 l=0.15
X8 a_205_93# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0619 ps=0.715 w=0.42 l=0.15
X9 a_205_93# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.123 ps=1.32 w=0.42 l=0.15
X10 a_489_297# a_27_410# a_393_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.122 ps=1.33 w=0.42 l=0.15
X11 a_311_413# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X12 a_311_413# a_205_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0598 pd=0.705 as=0.109 ps=1.36 w=0.42 l=0.15
X13 X a_311_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.102 ps=0.99 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
X0 a_109_93# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_215_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 VGND a_109_93# a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND A a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 VPWR A a_369_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_369_297# B a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_215_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X7 a_297_297# a_109_93# a_215_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_109_93# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 X a_215_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.1 ps=0.985 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
D0 VNB DIODE sky130_fd_pr__diode_pw2nd_05v5 pj=2.64e+06 area=4.347e+11
.ends

.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 X a_79_204# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A1 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_473_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.195 ps=1.39 w=1 l=0.15
X3 X a_79_204# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X4 VGND C1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.104 ps=0.97 w=0.65 l=0.15
X5 a_79_204# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0926 ps=0.935 w=0.65 l=0.15
X6 VPWR a_79_204# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X7 a_473_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X8 a_473_297# B1 a_727_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.16 ps=1.32 w=1 l=0.15
X9 X a_79_204# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X10 VGND B1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.127 ps=1.04 w=0.65 l=0.15
X11 a_79_204# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.109 ps=0.985 w=0.65 l=0.15
X12 VGND a_79_204# X VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.0959 ps=0.945 w=0.65 l=0.15
X13 a_1123_47# A1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_555_297# B1 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X15 VPWR A2 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X16 VGND A2 a_1123_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.091 ps=0.93 w=0.65 l=0.15
X17 a_951_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.14 ps=1.08 w=0.65 l=0.15
X18 VPWR a_79_204# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_79_204# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X20 a_79_204# A1 a_951_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 a_79_204# C1 a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 a_727_297# C1 a_79_204# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X23 X a_79_204# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
X0 X a_299_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X1 VPWR a_193_47# a_299_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 VGND a_193_47# a_299_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X6 X a_299_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
X0 X a_29_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.148 ps=1.34 w=1 l=0.15
X1 a_111_297# C a_29_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_29_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.102 ps=0.99 w=0.65 l=0.15
X3 a_183_297# B a_111_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 VPWR A a_183_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X5 a_29_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VGND C a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_806_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_47# B1 a_1314_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=2.09 as=0.104 ps=0.97 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X17 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.0943 ps=0.94 w=0.65 l=0.15
X19 Y C1 a_978_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_27_47# B1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 a_806_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.675 pd=3.35 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.091 ps=0.93 w=0.65 l=0.15
X27 a_978_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.091 ps=0.93 w=0.65 l=0.15
X28 a_1314_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X31 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
X0 a_297_47# a_27_47# a_193_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_369_47# B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0441 ps=0.63 w=0.42 l=0.15
X2 VPWR D a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.0662 ps=0.735 w=0.42 l=0.15
X3 X a_193_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.103 ps=1 w=0.65 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND D a_469_47# VNB sky130_fd_pr__nfet_01v8 ad=0.103 pd=1 as=0.0609 ps=0.71 w=0.42 l=0.15
X6 X a_193_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR B a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.128 pd=1.03 as=0.0987 ps=0.89 w=0.42 l=0.15
X8 a_193_413# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.128 ps=1.03 w=0.42 l=0.15
X9 a_193_413# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0987 pd=0.89 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 a_469_47# C a_369_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.0735 ps=0.77 w=0.42 l=0.15
X11 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VGND A1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
X1 a_510_47# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.143 ps=1.09 w=0.65 l=0.15
X2 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.175 ps=1.35 w=1 l=0.15
X3 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.22 ps=1.44 w=1 l=0.15
X4 a_79_21# A2 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.22 pd=1.44 as=0.162 ps=1.33 w=1 l=0.15
X5 a_297_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X6 a_79_21# C1 a_510_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.114 ps=1 w=0.65 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X8 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
X9 a_215_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.106 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.272 ps=2.56 w=1 l=0.15
X15 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X17 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X19 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X24 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.257 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X30 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X38 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0683 ps=0.86 w=0.65 l=0.15
X1 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=2.1 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A1 a_114_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
X3 a_114_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.185 ps=1.87 w=0.65 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.28 ps=2.56 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X10 a_285_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.091 ps=0.93 w=0.65 l=0.15
X11 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X6 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X11 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
X0 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.165 ps=1.33 w=1 l=0.15
X2 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_193_47# C a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_277_47# B a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X1 X a_80_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 VGND a_80_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=0.99 as=0.091 ps=0.93 w=0.65 l=0.15
X3 a_386_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.157 ps=1.32 w=1 l=0.15
X4 X a_80_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_80_199# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.162 pd=1.15 as=0.111 ps=0.99 w=0.65 l=0.15
X6 a_386_297# B1 a_80_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_458_47# A1 a_80_199# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.162 ps=1.15 w=0.65 l=0.15
X8 VPWR A1 a_386_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X9 VGND A2 a_458_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.123 ps=1.03 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
X0 VPWR a_29_311# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_29_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.151 ps=1.35 w=1 l=0.15
X2 VPWR A a_29_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND a_29_311# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_184_53# B a_112_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X5 VPWR C a_29_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.151 pd=1.35 as=0.0744 ps=0.815 w=0.42 l=0.15
X6 X a_29_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.13 ps=1.11 w=0.65 l=0.15
X7 a_112_53# A a_29_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_29_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 VGND C a_184_53# VNB sky130_fd_pr__nfet_01v8 ad=0.13 pd=1.11 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
X0 a_109_93# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_209_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X2 a_109_93# A_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_296_53# a_109_93# a_209_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.108 ps=1.36 w=0.42 l=0.15
X4 VPWR C a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0744 ps=0.815 w=0.42 l=0.15
X5 a_368_53# B a_296_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_209_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.122 ps=1.08 w=0.65 l=0.15
X7 a_209_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VPWR a_109_93# a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.108 ps=1.36 w=0.42 l=0.15
X9 VGND C a_368_53# VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.08 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_75_199# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.135 ps=1.07 w=0.65 l=0.15
X1 a_208_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.112 ps=0.995 w=0.65 l=0.15
X2 a_315_47# A2 a_208_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.17 as=0.125 ps=1.03 w=0.65 l=0.15
X3 VGND B1 a_75_199# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.07 as=0.106 ps=0.975 w=0.65 l=0.15
X4 a_75_199# A1 a_315_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.17 w=0.65 l=0.15
X5 a_75_199# C1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.207 ps=1.41 w=1 l=0.15
X6 a_544_297# B1 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.207 pd=1.41 as=0.162 ps=1.33 w=1 l=0.15
X7 VPWR a_75_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.285 ps=2.57 w=1 l=0.15
X8 a_201_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.142 ps=1.28 w=1 l=0.15
X9 VPWR A2 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.165 ps=1.33 w=1 l=0.15
X10 a_201_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.305 ps=1.61 w=1 l=0.15
X11 VGND a_75_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X4 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X5 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X6 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X8 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.301 ps=2.66 w=1 l=0.15
X9 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X10 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X11 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X12 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X13 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X14 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X15 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X16 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X17 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X18 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X19 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X20 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X21 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X22 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X23 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X24 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.209 ps=2.02 w=0.65 l=0.15
X25 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X26 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X27 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X28 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X29 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_56_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A2 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_139_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.266 ps=2.12 w=0.65 l=0.15
X4 a_311_297# B1 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X5 Y C1 a_311_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X7 Y A1 a_139_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
X0 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X5 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X7 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.26 ps=1.45 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.4 ps=1.8 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.205 pd=1.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.135 ps=1.27 w=1 l=0.15
X5 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_109_297# C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y A3 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_449_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 Y A3 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y B1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_449_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.263 ps=2.57 w=1 l=0.15
X8 Y B1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_31_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_297# A2 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.261 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 a_31_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 a_31_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_31_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_449_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X20 VGND A2 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 VGND A2 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VGND A3 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.223 pd=1.34 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_31_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.223 ps=1.34 w=0.65 l=0.15
X25 a_27_297# A2 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND A3 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 a_31_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X28 a_449_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 a_31_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 a_31_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 a_27_47# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.368 pd=1.74 as=0.14 ps=1.28 w=1 l=0.15
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.231 pd=2.01 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VPWR A1 a_373_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X4 a_182_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.165 ps=1.82 w=0.65 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.195 ps=1.39 w=1 l=0.15
X6 a_182_47# B1 a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X8 a_373_297# A2 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.368 ps=1.74 w=1 l=0.15
X9 a_110_47# C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X10 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X11 VGND A1 a_182_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2bb2ai_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
X0 a_113_297# A2_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_113_47# A2_N a_113_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR B1 a_730_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A2_N a_113_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 a_730_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_471_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_471_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y B2 a_730_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_113_297# A2_N a_113_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_113_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X10 VGND A1_N a_113_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND B2 a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR a_113_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X13 a_113_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X14 Y a_113_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.4 ps=1.8 w=1 l=0.15
X15 a_730_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.153 ps=1.3 w=1 l=0.15
X16 Y a_113_297# a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.176 ps=1.84 w=0.65 l=0.15
X17 a_471_47# a_113_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR A1_N a_113_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.135 ps=1.27 w=1 l=0.15
X19 VGND B1 a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0991 ps=0.955 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22o_4 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 a_484_297# B2 a_96_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND B2 a_566_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_96_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR a_96_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_96_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_96_21# B1 a_484_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR a_96_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_96_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X8 VGND a_96_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_484_297# B1 a_96_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_484_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A2 a_918_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_96_21# B2 a_484_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 a_96_21# B1 a_566_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_484_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VPWR A1 a_484_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 a_96_21# A1 a_918_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VPWR A2 a_484_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.175 ps=1.35 w=1 l=0.15
X18 a_566_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X19 a_918_47# A1 a_96_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_566_47# B1 a_96_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_918_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X22 X a_96_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X23 VGND a_96_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311a_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.305 ps=1.61 w=1 l=0.15
X1 a_467_47# C1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_467_47# B1 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND A1 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.135 ps=1.27 w=1 l=0.15
X6 a_79_21# C1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_717_47# B1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VGND A3 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.27 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_1147_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR A1 a_1147_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_1147_297# A2 a_875_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X18 a_79_21# A3 a_875_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X19 a_875_297# A3 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 a_875_297# A2 a_1147_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 a_717_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.201 ps=1.27 w=0.65 l=0.15
X23 a_717_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_717_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X26 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X3 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X4 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X5 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=2.61 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X8 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X9 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X12 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X14 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X15 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X16 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X17 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X18 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X19 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X20 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X21 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X23 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X24 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X25 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X28 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X29 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X30 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X31 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X32 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
X33 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
X0 VPWR A a_49_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VGND a_285_47# a_391_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.5
X2 X a_391_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VGND A a_49_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR a_285_47# a_391_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.5
X5 a_285_47# a_49_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X6 a_285_47# a_49_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X7 X a_391_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 a_103_199# B1 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.107 ps=0.98 w=0.65 l=0.15
X1 VPWR a_103_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.36 ps=2.72 w=1 l=0.15
X2 a_337_297# A2 a_253_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_103_199# A3 a_337_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.165 ps=1.33 w=1 l=0.15
X4 a_253_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.195 ps=1.39 w=1 l=0.15
X5 VPWR B1 a_103_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.345 pd=2.69 as=0.213 ps=1.42 w=1 l=0.15
X6 VGND a_103_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.234 ps=2.02 w=0.65 l=0.15
X7 a_253_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X8 a_253_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X9 VGND A2 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 a_79_21# A1 a_348_47# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.133 ps=1.06 w=0.65 l=0.15
X1 a_79_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X2 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.2 pd=1.26 as=0.091 ps=0.93 w=0.65 l=0.15
X3 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 a_79_21# C1 a_585_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X5 VPWR A2 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.26 ps=2.52 w=1 l=0.15
X6 a_299_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.195 ps=1.39 w=1 l=0.15
X7 a_585_297# B1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X8 a_348_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.2 ps=1.26 w=0.65 l=0.15
X9 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.115 ps=1 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
X0 VPWR a_219_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.295 pd=2.59 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.202 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.17 pd=1.34 as=0.105 ps=1.21 w=1 l=0.15
X3 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.111 ps=0.99 w=0.65 l=0.15
X5 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X6 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=0.99 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_219_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND a_219_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.17 ps=1.34 w=1 l=0.15
X11 VGND a_219_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.214 pd=1.96 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.202 ps=1.4 w=0.65 l=0.15
X13 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
X0 a_27_47# C a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# C a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_445_47# B a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_445_47# B a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y A a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X14 Y A a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_803_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X17 a_803_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_445_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 a_803_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X23 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X24 a_445_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_803_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X30 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X31 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
X0 X a_61_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.167 ps=1.39 w=1 l=0.15
X1 VPWR a_61_75# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.195 ps=1.39 w=1 l=0.15
X2 VPWR B a_61_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 VGND B a_147_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 X a_61_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.112 ps=1.04 w=0.65 l=0.15
X5 VGND a_61_75# X VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.127 ps=1.04 w=0.65 l=0.15
X6 a_61_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X7 a_147_75# A a_61_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
X0 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X5 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X17 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X21 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X23 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X36 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X39 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31a_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_926_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND A1 a_496_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_926_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A3 a_496_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X4 VGND a_102_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A2 a_496_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_926_297# A2 a_672_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_102_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X8 a_496_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 X a_102_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0975 ps=0.95 w=0.65 l=0.15
X10 a_102_21# B1 a_496_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X11 VPWR a_102_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 X a_102_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 X a_102_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.15 ps=1.3 w=1 l=0.15
X14 VPWR a_102_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X15 a_672_297# A3 a_102_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 a_496_47# B1 a_102_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_102_21# A3 a_672_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X18 VGND a_102_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_102_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X20 a_496_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR B1 a_102_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.145 ps=1.29 w=1 l=0.15
X22 a_496_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 a_672_297# A2 a_926_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_300_297# a_27_413# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X3 Y a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.102 ps=0.99 w=0.65 l=0.15
X4 VPWR A1 a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 a_384_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.143 ps=1.09 w=0.65 l=0.15
X6 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.111 ps=1.37 w=0.42 l=0.15
X7 a_300_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 a_281_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X1 a_281_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X6 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X7 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X9 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.127 ps=1.04 w=0.65 l=0.15
X10 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.198 ps=1.26 w=0.65 l=0.15
X11 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.127 ps=1.04 w=0.65 l=0.15
X12 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y A3 a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.195 ps=1.39 w=1 l=0.15
X15 a_27_297# A2 a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 Y A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.109 ps=0.985 w=0.65 l=0.15
X4 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_949_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 Y C1 a_949_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.15 ps=1.3 w=1 l=0.15
X10 a_781_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_27_297# B1 a_781_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_781_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_1301_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.15 ps=1.3 w=1 l=0.15
X16 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 Y C1 a_781_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.14 ps=1.28 w=1 l=0.15
X18 a_109_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_109_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_109_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.091 ps=0.93 w=0.65 l=0.15
X27 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X28 a_27_297# B1 a_1301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X29 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0894 ps=0.925 w=0.65 l=0.15
X30 a_109_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X31 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
X0 VPWR A a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_218_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.156 ps=1.16 w=0.42 l=0.15
X2 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.156 pd=1.16 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_300_297# a_27_53# a_218_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_218_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 VPWR a_218_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_218_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X7 VGND a_218_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 VGND A a_218_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_39_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=1 w=0.65 l=0.15
X2 VPWR a_39_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_39_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.156 ps=1.36 w=1 l=0.15
X4 VGND a_39_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.156 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VGND A a_39_297# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=1 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_39_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y A1 a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.119 ps=1.01 w=0.65 l=0.15
X1 a_181_47# A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.0683 ps=0.86 w=0.65 l=0.15
X2 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.106 ps=0.975 w=0.65 l=0.15
X3 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.162 ps=1.33 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.153 ps=1.3 w=1 l=0.15
X6 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
X0 VPWR S a_591_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.0672 ps=0.85 w=0.64 l=0.15
X1 a_591_369# A0 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.85 as=0.131 ps=1.05 w=0.64 l=0.15
X2 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.178 pd=1.41 as=0.135 ps=1.27 w=1 l=0.15
X3 a_79_21# A1 a_306_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.131 pd=1.05 as=0.229 ps=1.36 w=0.64 l=0.15
X4 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND S a_578_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0578 ps=0.695 w=0.42 l=0.15
X6 a_306_369# a_257_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.229 pd=1.36 as=0.178 ps=1.41 w=0.64 l=0.15
X7 a_79_21# A0 a_288_47# VNB sky130_fd_pr__nfet_01v8 ad=0.173 pd=1.25 as=0.0683 ps=0.745 w=0.42 l=0.15
X8 a_288_47# a_257_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.745 as=0.097 ps=0.975 w=0.42 l=0.15
X9 a_257_199# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 a_578_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.173 ps=1.25 w=0.42 l=0.15
X11 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X12 a_257_199# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.173 pd=1.82 as=0.0864 ps=0.91 w=0.64 l=0.15
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
X0 Y a_53_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.192 ps=1.38 w=1 l=0.15
X1 a_232_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.192 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A_N a_53_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A_N a_53_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_316_47# B a_232_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y a_53_93# a_316_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.125 ps=1.03 w=0.65 l=0.15
X7 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
X0 a_109_53# A_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_215_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.1 w=0.65 l=0.15
X2 a_109_53# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND C a_373_53# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.1 as=0.0536 ps=0.675 w=0.42 l=0.15
X4 VGND a_215_311# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR C a_215_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.0744 ps=0.815 w=0.42 l=0.15
X6 VPWR a_215_311# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_215_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X8 a_301_53# a_109_53# a_215_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_215_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 a_373_53# B a_301_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X11 VPWR a_109_53# a_215_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
X0 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR A a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_109_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 VPWR A a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VGND A a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 a_109_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.135 ps=1.27 w=1 l=0.15
X24 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_109_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X29 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 a_109_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X31 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
X0 VPWR A a_304_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X1 a_304_297# B a_220_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND C a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X3 a_220_297# C a_114_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X4 a_32_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_32_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X11 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X13 a_114_297# D a_32_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.26 ps=2.52 w=1 l=0.15
X14 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR A2 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 a_277_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X2 a_79_21# B1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X3 a_277_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_361_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_277_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.127 ps=1.04 w=0.65 l=0.15
X9 a_79_21# A1 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_93_21# A1 a_346_47# VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.146 ps=1.1 w=0.65 l=0.15
X1 a_93_21# B1 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.185 ps=1.37 w=1 l=0.15
X2 a_584_47# B1 a_93_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.143 ps=1.09 w=0.65 l=0.15
X3 VPWR a_93_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.243 pd=1.49 as=0.33 ps=2.66 w=1 l=0.15
X4 VGND B2 a_584_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 a_256_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.167 ps=1.16 w=0.65 l=0.15
X6 a_250_297# B2 a_93_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 VGND a_93_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.167 pd=1.16 as=0.214 ps=1.96 w=0.65 l=0.15
X8 a_250_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.243 ps=1.49 w=1 l=0.15
X9 VPWR A2 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.225 pd=1.45 as=0.165 ps=1.33 w=1 l=0.15
X10 a_250_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.225 ps=1.45 w=1 l=0.15
X11 a_346_47# A2 a_256_47# VNB sky130_fd_pr__nfet_01v8 ad=0.146 pd=1.1 as=0.0975 ps=0.95 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
X0 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.107 ps=0.98 w=0.65 l=0.15
X1 VGND D a_304_47# VNB sky130_fd_pr__nfet_01v8 ad=0.175 pd=1.26 as=0.0693 ps=0.75 w=0.42 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.28 ps=1.62 w=1 l=0.15
X3 a_198_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0798 pd=0.8 as=0.0619 ps=0.715 w=0.42 l=0.15
X4 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0777 ps=0.79 w=0.42 l=0.15
X5 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.165 ps=1.33 w=1 l=0.15
X6 a_304_47# C a_198_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0798 ps=0.8 w=0.42 l=0.15
X7 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0746 pd=0.775 as=0.109 ps=1.36 w=0.42 l=0.15
X8 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=1.62 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.175 ps=1.26 w=0.65 l=0.15
X10 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0746 ps=0.775 w=0.42 l=0.15
X11 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0619 pd=0.715 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.135 ps=1.27 w=1 l=0.15
X3 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X17 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_803_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_803_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 VGND A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X30 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X31 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X7 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X11 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X12 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X14 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X15 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X16 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.155 ps=1.31 w=1 l=0.15
X20 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
X0 VGND a_91_199# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.221 ps=1.98 w=0.65 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A a_245_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.135 ps=1.27 w=1 l=0.15
X3 a_91_199# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_245_297# B a_161_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_91_199# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.146 ps=1.34 w=0.42 l=0.15
X7 a_161_297# a_91_199# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.32 ps=2.64 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_223_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 Y A1 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X3 a_223_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X4 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 VGND A2 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_223_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X7 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.123 ps=1.03 w=0.65 l=0.15
X8 VPWR A2 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 a_658_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.201 ps=1.27 w=0.65 l=0.15
X10 VPWR A1 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_223_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 a_658_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 Y a_27_47# a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_223_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X15 VPWR A2 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.155 ps=1.31 w=1 l=0.15
X16 VPWR A1 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 a_658_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VGND B1_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.27 ps=2.13 w=0.65 l=0.15
X19 a_223_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X20 a_658_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 VGND A2 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.27 as=0.091 ps=0.93 w=0.65 l=0.15
X23 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X24 Y A1 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X25 Y a_27_47# a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111ai_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
X0 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_298_47# C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VGND A1 a_497_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X3 a_664_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.33 pd=2.66 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND A2 a_497_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_298_47# B1 a_497_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.176 ps=1.84 w=0.65 l=0.15
X7 a_497_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 Y D1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.224 ps=1.99 w=0.65 l=0.15
X9 a_497_47# B1 a_298_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 Y A2 a_664_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.295 ps=2.59 w=1 l=0.15
X12 a_27_47# C1 a_298_47# VNB sky130_fd_pr__nfet_01v8 ad=0.192 pd=1.89 as=0.091 ps=0.93 w=0.65 l=0.15
X13 VPWR D1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X14 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X15 a_27_47# D1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X16 a_497_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.214 pd=1.96 as=0.091 ps=0.93 w=0.65 l=0.15
X17 Y D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X18 VPWR A1 a_664_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X19 a_664_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 VPWR a_82_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.186 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X1 a_646_47# B2 a_82_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_574_369# a_313_47# a_82_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0976 pd=0.945 as=0.166 ps=1.8 w=0.64 l=0.15
X3 a_574_369# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X4 VGND a_82_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.09 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR B2 a_574_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.0976 ps=0.945 w=0.64 l=0.15
X6 X a_82_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.172 ps=1.83 w=0.65 l=0.15
X7 X a_82_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.265 ps=2.53 w=1 l=0.15
X8 a_313_47# A2_N a_313_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.17 pd=1.81 as=0.0672 ps=0.85 w=0.64 l=0.15
X9 a_313_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.12 ps=1.09 w=0.42 l=0.15
X10 a_313_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.85 as=0.186 ps=1.43 w=0.64 l=0.15
X11 VGND A2_N a_313_47# VNB sky130_fd_pr__nfet_01v8 ad=0.142 pd=1.1 as=0.0567 ps=0.69 w=0.42 l=0.15
X12 a_82_21# a_313_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.142 ps=1.1 w=0.42 l=0.15
X13 VGND B1 a_646_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311ai_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
X0 a_39_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR A1 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X4 a_125_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0943 ps=0.94 w=0.65 l=0.15
X5 a_125_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_125_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_1163_47# B1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_39_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_1163_47# B1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A3 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND A3 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_39_297# A2 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_125_47# B1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X17 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 a_125_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X19 VGND A2 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_125_47# B1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VGND A2 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y C1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y C1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_461_297# A2 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 Y A3 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X26 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 Y A3 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 a_125_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 VPWR A1 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X31 a_461_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 a_461_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X33 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 a_125_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X35 a_1163_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X36 a_1163_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X37 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X38 a_39_297# A2 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X39 a_461_297# A2 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
X0 VPWR a_315_380# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_315_380# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X2 a_315_380# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND C_N a_27_410# VNB sky130_fd_pr__nfet_01v8 ad=0.0619 pd=0.715 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR C_N a_27_410# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.123 pd=1.32 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VPWR A a_583_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_27_410# a_315_380# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X7 a_583_297# B a_499_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_315_380# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_397_297# a_205_93# a_315_380# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.258 ps=2.52 w=1 l=0.15
X10 X a_315_380# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X11 X a_315_380# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_499_297# a_27_410# a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.18 ps=1.36 w=1 l=0.15
X13 VPWR a_315_380# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 a_205_93# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0619 ps=0.715 w=0.42 l=0.15
X15 a_205_93# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.4 as=0.123 ps=1.32 w=0.42 l=0.15
X16 VGND a_315_380# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND a_315_380# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_315_380# a_205_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.169 ps=1.82 w=0.65 l=0.15
X19 X a_315_380# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_226_47# A2_N a_226_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_489_413# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_226_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.167 ps=1.43 w=0.42 l=0.15
X3 VPWR B2 a_489_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_489_413# a_226_47# a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_76_199# a_226_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.139 ps=1.08 w=0.42 l=0.15
X6 VGND B1 a_556_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_556_47# B2 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VGND A2_N a_226_47# VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.08 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_226_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.12 ps=1.09 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.43 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.09 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_4 A B C VGND VNB VPB VPWR Y
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_449_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 Y C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_449_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X10 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X15 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
X0 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X1 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND B a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 a_78_199# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 VPWR A1 a_493_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X2 a_493_297# A2 a_78_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.235 ps=1.47 w=1 l=0.15
X3 VPWR a_78_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.373 pd=1.75 as=0.28 ps=2.56 w=1 l=0.15
X4 VGND A2 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X5 a_78_199# B2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.235 pd=1.47 as=0.117 ps=1.24 w=1 l=0.15
X6 a_215_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_215_47# B2 a_78_199# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_292_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.117 pd=1.24 as=0.373 ps=1.75 w=1 l=0.15
X9 VGND a_78_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_4 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_1021_47# A1 a_205_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 X a_205_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 VPWR a_205_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_205_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VGND A2 a_1021_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND a_42_47# a_205_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_861_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.101 ps=0.96 w=0.65 l=0.15
X7 a_205_21# A1 a_861_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0747 ps=0.88 w=0.65 l=0.15
X8 X a_205_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 a_603_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND B1_N a_42_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.25 ps=2.07 w=0.65 l=0.15
X11 VPWR A2 a_603_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_603_297# a_42_47# a_205_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 VPWR a_205_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.14 ps=1.28 w=1 l=0.15
X14 a_205_21# a_42_47# a_603_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND a_205_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.263 pd=1.46 as=0.091 ps=0.93 w=0.65 l=0.15
X16 VPWR B1_N a_42_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X17 VGND a_205_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VPWR A1 a_603_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 a_603_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 a_205_21# a_42_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.263 ps=1.46 w=0.65 l=0.15
X21 X a_205_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
X0 a_408_47# B a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_408_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y a_27_47# a_408_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.176 pd=1.39 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND C a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X6 a_218_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.12 ps=1.04 w=0.65 l=0.15
X7 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_218_47# B a_408_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X11 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.176 ps=1.39 w=1 l=0.15
X12 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.04 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
X0 VPWR a_30_53# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.315 pd=2.63 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND a_30_53# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_30_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X3 a_112_297# C a_30_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_30_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 VGND A a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 a_30_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 VGND C a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_184_297# B a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X9 VPWR A a_184_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_33_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND A1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_33_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_797_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_797_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y B2 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR B1 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_33_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 a_33_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_33_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_33_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_797_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.16 ps=1.32 w=1 l=0.15
X17 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR B1 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND A2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_33_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 a_797_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.135 ps=1.27 w=1 l=0.15
X24 Y B2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 Y B2 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 Y B1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.104 ps=0.97 w=0.65 l=0.15
X27 Y B2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 Y B1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_33_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.29 ps=2.58 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X8 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X11 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=1.37 as=0.0588 ps=0.7 w=0.42 l=0.15
X18 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X20 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X21 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X22 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X23 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X25 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X26 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X27 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X28 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X29 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X30 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X31 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X32 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X33 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X34 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X35 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X36 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X37 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X38 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X39 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0578 ps=0.695 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
X0 VPWR A a_94_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.198 pd=1.39 as=0.305 ps=2.61 w=1 l=0.15
X1 a_294_47# B a_185_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.128 ps=1.04 w=0.65 l=0.15
X2 a_185_47# A a_94_47# VNB sky130_fd_pr__nfet_01v8 ad=0.128 pd=1.04 as=0.198 ps=1.91 w=0.65 l=0.15
X3 VPWR a_94_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND C a_294_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 a_94_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.198 ps=1.39 w=1 l=0.15
X6 X a_94_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X7 X a_94_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 VPWR C a_94_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X9 X a_94_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X10 VGND a_94_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X11 VPWR a_94_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND a_94_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 X a_94_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_240_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_51_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A1 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_51_297# B2 a_245_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.412 pd=1.83 as=0.105 ps=1.21 w=1 l=0.15
X4 a_149_47# C1 a_51_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.201 ps=1.92 w=0.65 l=0.15
X5 a_240_47# B1 a_149_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0991 ps=0.955 w=0.65 l=0.15
X6 VPWR A1 a_512_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X7 X a_51_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.165 ps=1.33 w=1 l=0.15
X8 a_149_47# B2 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_245_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X10 VPWR C1 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.34 ps=2.68 w=1 l=0.15
X11 a_512_297# A2 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.412 ps=1.83 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VGND A1 a_474_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.104 ps=0.97 w=0.65 l=0.15
X1 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 VPWR A1 a_1122_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.252 pd=1.5 as=0.14 ps=1.28 w=1 l=0.15
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.192 pd=1.89 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.252 ps=1.5 w=1 l=0.15
X8 a_950_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X9 a_557_47# B1 a_474_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X10 a_474_47# B1 a_748_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X11 VGND A2 a_474_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_79_21# C1 a_557_47# VNB sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.1 as=0.0683 ps=0.86 w=0.65 l=0.15
X15 a_474_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X16 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.14 ps=1.28 w=1 l=0.15
X17 a_748_47# C1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.145 ps=1.1 w=0.65 l=0.15
X18 a_474_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
X19 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.195 ps=1.39 w=1 l=0.15
X20 a_79_21# A2 a_950_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X21 a_1122_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X23 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.385 pd=1.77 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X9 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.385 ps=1.77 w=1 l=0.15
X14 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X21 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X31 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
X0 Y a_74_47# a_265_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 VPWR B_N a_74_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.39 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_265_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.157 ps=1.39 w=1 l=0.15
X3 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X4 VGND B_N a_74_47# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND a_74_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 VGND A2 a_660_47# VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.0829 ps=0.905 w=0.65 l=0.15
X1 VGND C1 a_85_193# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.101 ps=0.96 w=0.65 l=0.15
X2 a_414_297# C1 a_334_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.125 ps=1.25 w=1 l=0.15
X3 VGND a_85_193# X VNB sky130_fd_pr__nfet_01v8 ad=0.275 pd=1.5 as=0.214 ps=1.96 w=0.65 l=0.15
X4 a_334_297# D1 a_85_193# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.125 pd=1.25 as=0.385 ps=2.77 w=1 l=0.15
X5 a_516_297# B1 a_414_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=1.56 as=0.18 ps=1.36 w=1 l=0.15
X6 a_516_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.135 ps=1.27 w=1 l=0.15
X7 a_660_47# A1 a_85_193# VNB sky130_fd_pr__nfet_01v8 ad=0.0829 pd=0.905 as=0.185 ps=1.22 w=0.65 l=0.15
X8 a_85_193# D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.275 ps=1.5 w=0.65 l=0.15
X9 VPWR A1 a_516_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=1.56 w=1 l=0.15
X10 a_85_193# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.22 as=0.117 ps=1.01 w=0.65 l=0.15
X11 VPWR a_85_193# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.29 ps=2.58 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
X0 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.14 ps=1.28 w=1 l=0.15
X1 a_235_47# C1 a_163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.0683 ps=0.86 w=0.65 l=0.15
X2 a_343_47# B1 a_235_47# VNB sky130_fd_pr__nfet_01v8 ad=0.132 pd=1.05 as=0.127 ps=1.04 w=0.65 l=0.15
X3 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.203 pd=1.4 as=0.195 ps=1.39 w=1 l=0.15
X4 a_454_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.203 ps=1.4 w=1 l=0.15
X5 Y D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X6 VPWR A1 a_454_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.195 ps=1.39 w=1 l=0.15
X7 a_163_47# D1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X8 VGND A2 a_343_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.132 ps=1.05 w=0.65 l=0.15
X9 a_343_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.127 ps=1.04 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3b_4 A B C_N VGND VNB VPB VPWR Y
X0 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VPWR A a_197_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_555_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_197_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_197_297# B a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X8 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X12 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y a_27_47# a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y a_27_47# a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X16 a_555_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_555_297# B a_197_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 a_197_297# B a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_555_297# B a_197_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 VPWR A a_197_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X23 a_197_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X25 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.221 pd=1.98 as=0.198 ps=1.26 w=0.65 l=0.15
X1 Y A3 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.393 pd=1.78 as=0.135 ps=1.27 w=1 l=0.15
X2 a_193_297# A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.393 ps=1.78 w=1 l=0.15
X5 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2oi_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR Y
X0 a_109_47# A2_N a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 a_397_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR B2 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A2_N a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.283 pd=1.52 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_397_297# a_109_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.34 ps=2.68 w=1 l=0.15
X5 a_481_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.283 ps=1.52 w=0.65 l=0.15
X7 VGND B1 a_481_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_109_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X9 a_109_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
X0 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_27_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_277_297# B a_205_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VPWR A a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X5 a_205_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X6 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X7 VGND C a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0693 ps=0.75 w=0.42 l=0.15
X8 a_109_297# D a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X9 VGND A a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 a_676_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.213 ps=1.42 w=1 l=0.15
X1 a_512_47# B1 a_409_47# VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.119 ps=1.01 w=0.65 l=0.15
X2 a_306_47# D1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.198 ps=1.91 w=0.65 l=0.15
X3 VGND A2 a_512_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.198 ps=1.26 w=0.65 l=0.15
X4 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.218 ps=1.43 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.305 ps=1.61 w=1 l=0.15
X6 VPWR A1 a_676_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.105 ps=1.21 w=1 l=0.15
X7 a_512_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_409_47# C1 a_306_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.119 ps=1.01 w=0.65 l=0.15
X9 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.382 pd=1.76 as=0.26 ps=2.52 w=1 l=0.15
X10 a_79_21# D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.218 pd=1.43 as=0.382 ps=1.76 w=1 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
X0 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0894 ps=0.925 w=0.65 l=0.15
X1 a_191_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.13 ps=1.26 w=1 l=0.15
X2 VPWR A a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.119 ps=1.01 w=0.65 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_297_297# B a_191_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X6 a_109_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.13 pd=1.26 as=0.26 ps=2.52 w=1 l=0.15
X7 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4bb_2 A_N B_N C D VGND VNB VPB VPWR X
X0 a_174_21# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X1 a_174_21# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.74 as=0.331 ps=1.71 w=0.42 l=0.15
X2 a_476_47# a_27_47# a_174_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VPWR a_174_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.331 pd=1.71 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_174_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.141 ps=1.33 w=1 l=0.15
X5 a_548_47# a_505_280# a_476_47# VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X7 X a_174_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X8 VPWR D a_174_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0924 pd=0.86 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 VGND D a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0924 pd=0.86 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 VPWR a_505_280# a_174_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0672 ps=0.74 w=0.42 l=0.15
X11 a_505_280# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0924 ps=0.86 w=0.42 l=0.15
X12 VGND a_174_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_505_280# B_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0924 ps=0.86 w=0.42 l=0.15
X14 a_639_47# C a_548_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.064 ps=0.725 w=0.42 l=0.15
X15 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_4 A B C D VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_188_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.0796 ps=0.895 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND D a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.141 ps=1.09 w=0.65 l=0.15
X5 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.215 ps=1.43 w=1 l=0.15
X6 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X7 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.106 ps=0.975 w=0.65 l=0.15
X10 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.155 ps=1.31 w=1 l=0.15
X12 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X14 a_285_47# C a_188_47# VNB sky130_fd_pr__nfet_01v8 ad=0.141 pd=1.09 as=0.109 ps=0.985 w=0.65 l=0.15
X15 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0796 pd=0.895 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.28 ps=2.56 w=1 l=0.15
X1 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X4 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.177 ps=1.36 w=1 l=0.15
X7 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.105 ps=1.21 w=1 l=0.15
X9 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X1 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0926 ps=0.935 w=0.65 l=0.15
X2 VPWR A1 a_307_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.105 ps=1.21 w=1 l=0.15
X3 a_307_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.233 ps=1.47 w=1 l=0.15
X4 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.233 pd=1.47 as=0.112 ps=1.23 w=1 l=0.15
X6 a_109_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.112 pd=1.23 as=0.26 ps=2.52 w=1 l=0.15
X7 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311oi_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
X0 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.159 ps=1.14 w=0.65 l=0.15
X3 a_1139_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.245 pd=1.49 as=0.135 ps=1.27 w=1 l=0.15
X4 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A3 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_109_297# B1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_1139_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X13 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_109_297# B1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X16 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VPWR A3 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 a_1139_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 Y C1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_1139_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.159 pd=1.14 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X32 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y C1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.245 ps=1.49 w=1 l=0.15
X35 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X36 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X38 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X39 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
X0 VGND A_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X1 Y a_27_93# a_206_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_206_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR a_27_93# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X5 VPWR A_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32ai_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 a_1224_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 VPWR A1 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.183 ps=1.37 w=1 l=0.15
X2 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_806_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.205 ps=1.28 w=0.65 l=0.15
X8 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.205 pd=1.28 as=0.14 ps=1.08 w=0.65 l=0.15
X10 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_806_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A3 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y A3 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X19 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.119 ps=1.01 w=0.65 l=0.15
X22 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0926 ps=0.935 w=0.65 l=0.15
X24 a_806_297# A2 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X25 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.142 ps=1.28 w=1 l=0.15
X28 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_1224_297# A2 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 a_1224_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.183 pd=1.37 as=0.135 ps=1.27 w=1 l=0.15
X32 a_806_297# A2 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 VPWR A1 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X35 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X36 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X37 a_1224_297# A2 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X38 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X39 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4b_2 A_N B C D VGND VNB VPB VPWR Y
X0 Y a_27_47# a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 a_465_47# B a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND D a_655_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.117 ps=1.01 w=0.65 l=0.15
X3 a_215_47# B a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_655_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_655_47# C a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.37 pd=1.74 as=0.135 ps=1.27 w=1 l=0.15
X8 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_465_47# C a_655_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X10 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=2.8 as=0.135 ps=1.27 w=1 l=0.15
X13 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.18 ps=1.36 w=1 l=0.15
X14 a_215_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X16 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.37 ps=1.74 w=1 l=0.15
X17 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor4_2 A B C D VGND VNB VPB VPWR Y
X0 a_281_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_475_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y D a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND D Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X9 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X12 a_475_297# C a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_281_297# C a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X14 a_27_297# B a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X15 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2111o_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 VPWR a_86_235# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X1 VGND C1 a_86_235# VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.02 as=0.091 ps=0.93 w=0.65 l=0.15
X2 X a_86_235# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 a_86_235# D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.291 ps=1.54 w=0.65 l=0.15
X4 X a_86_235# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X5 a_715_47# A1 a_86_235# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.109 ps=0.985 w=0.65 l=0.15
X6 VGND A2 a_715_47# VNB sky130_fd_pr__nfet_01v8 ad=0.221 pd=1.98 as=0.127 ps=1.04 w=0.65 l=0.15
X7 a_499_297# C1 a_427_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X8 VGND a_86_235# X VNB sky130_fd_pr__nfet_01v8 ad=0.291 pd=1.54 as=0.091 ps=0.93 w=0.65 l=0.15
X9 a_86_235# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.122 ps=1.02 w=0.65 l=0.15
X10 a_607_297# B1 a_499_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X11 a_427_297# D1 a_86_235# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.41 ps=2.82 w=1 l=0.15
X12 VPWR A1 a_607_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X13 a_607_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.195 ps=1.39 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
X0 a_281_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND a_531_21# Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR C_N a_531_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X7 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X9 a_281_297# a_531_21# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X10 Y a_531_21# a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X11 VGND C_N a_531_21# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X12 a_27_297# B a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X13 Y a_531_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor4_4 A B C D VGND VNB VPB VPWR Y
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_807_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y D a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X9 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X13 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 a_807_297# C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 VGND D Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 VGND D Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_807_297# C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X22 a_449_297# C a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_449_297# C a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X26 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_807_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X28 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 Y D a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o221ai_4 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
X0 a_471_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_471_47# B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_471_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A1 a_1241_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.295 pd=2.59 as=0.135 ps=1.27 w=1 l=0.15
X5 a_471_47# B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_471_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_1241_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.175 ps=1.35 w=1 l=0.15
X10 a_27_47# B2 a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B1 a_553_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A2 a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_553_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X14 a_27_47# B2 a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND A2 a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND A1 a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X19 a_27_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_1241_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VPWR B1 a_553_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.135 ps=1.27 w=1 l=0.15
X22 VPWR A1 a_1241_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 Y B2 a_553_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 a_1241_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X26 a_553_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_471_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 Y A2 a_1241_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 a_553_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 a_27_47# B1 a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X31 VGND A1 a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X32 Y B2 a_553_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 a_1241_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 a_27_47# B1 a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X35 a_553_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 Y A2 a_1241_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X38 a_471_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 a_471_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_475_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A1 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X9 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.27 pd=1.48 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X12 a_475_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 Y A2 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X14 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.27 ps=1.48 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.16 ps=1.32 w=1 l=0.15
X1 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.4 ps=1.8 w=1 l=0.15
X2 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0894 ps=0.925 w=0.65 l=0.15
X3 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_470_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.138 ps=1.27 w=1 l=0.15
X6 a_384_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 a_384_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.104 ps=0.97 w=0.65 l=0.15
X8 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_2 A1 A2 B1_N VGND VNB VPB VPWR X
X0 VGND B1_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VGND A2 a_478_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.106 ps=0.975 w=0.65 l=0.15
X2 a_478_47# a_27_93# a_174_21# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_478_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 X a_174_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X5 VPWR a_174_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_174_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X7 VPWR A1 a_574_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.105 ps=1.21 w=1 l=0.15
X8 VGND a_174_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR B1_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X10 a_574_297# A2 a_174_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X11 a_174_21# a_27_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.395 ps=1.79 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
X0 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND a_215_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR a_215_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_109_93# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X4 a_215_297# a_109_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.165 ps=1.82 w=0.65 l=0.15
X5 VGND C a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X6 VGND A a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X8 a_215_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_109_93# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X10 VPWR A a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND a_215_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_487_297# B a_403_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_403_297# C a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X14 VPWR a_215_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X15 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X16 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_297_297# a_109_93# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
X0 a_204_297# A1 a_396_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.16 ps=1.32 w=1 l=0.15
X1 VPWR a_396_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_396_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR S a_314_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_204_297# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.162 ps=1.33 w=1 l=0.15
X5 a_396_47# A0 a_314_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.26 ps=2.52 w=1 l=0.15
X6 a_206_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.109 ps=0.985 w=0.65 l=0.15
X7 X a_396_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_396_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_396_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_490_47# A1 a_396_47# VNB sky130_fd_pr__nfet_01v8 ad=0.275 pd=1.5 as=0.104 ps=0.97 w=0.65 l=0.15
X11 VGND S a_490_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.275 ps=1.5 w=0.65 l=0.15
X12 VGND a_396_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_396_47# A0 a_206_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.26 ps=1.45 w=0.65 l=0.15
X14 VGND a_396_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR S a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X16 X a_396_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND S a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32oi_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.338 pd=1.67 as=0.135 ps=1.27 w=1 l=0.15
X5 a_1249_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_1249_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.252 pd=1.5 as=0.338 ps=1.67 w=1 l=0.15
X12 a_803_47# A2 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X16 a_803_47# A2 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X20 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X21 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_1249_47# A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.133 ps=1.06 w=0.65 l=0.15
X23 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 a_1249_47# A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.252 ps=1.5 w=1 l=0.15
X28 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X30 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X32 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X35 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 VGND A3 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X37 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VGND A3 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
X0 X a_80_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_475_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X2 X a_80_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_762_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.31 ps=1.62 w=1 l=0.15
X5 a_475_47# B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VGND A2 a_475_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 X a_80_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X10 a_80_21# A2 a_762_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_80_21# B1 a_475_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X12 a_80_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.15 ps=1.3 w=1 l=0.15
X13 a_475_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.117 ps=1.01 w=0.65 l=0.15
X14 X a_80_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 VPWR A1 a_934_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X16 a_934_297# A2 a_80_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 VPWR B1 a_80_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=1.62 as=0.14 ps=1.28 w=1 l=0.15
X18 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND A1 a_475_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.117 ps=1.01 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.166 pd=1.63 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.345 pd=2.69 as=0.14 ps=1.28 w=1 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X6 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.305 ps=2.61 w=1 l=0.15
X7 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.139 ps=1.5 w=0.42 l=0.15
X8 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt inverse_park D[0] D[10] D[11] D[12] D[13] D[14] D[15] D[16] D[17] D[18] D[1]
+ D[2] D[3] D[4] D[5] D[6] D[7] D[8] D[9] Q[0] Q[10] Q[11] Q[12] Q[13] Q[14] Q[15]
+ Q[16] Q[17] Q[18] Q[1] Q[2] Q[3] Q[4] Q[5] Q[6] Q[7] Q[8] Q[9] VGND VPWR alpha[0]
+ alpha[10] alpha[11] alpha[12] alpha[13] alpha[14] alpha[15] alpha[16] alpha[17]
+ alpha[18] alpha[1] alpha[2] alpha[3] alpha[4] alpha[5] alpha[6] alpha[7] alpha[8]
+ alpha[9] beta[0] beta[10] beta[11] beta[12] beta[13] beta[14] beta[15] beta[16]
+ beta[17] beta[18] beta[1] beta[2] beta[3] beta[4] beta[5] beta[6] beta[7] beta[8]
+ beta[9] clk cos[0] cos[10] cos[11] cos[12] cos[13] cos[14] cos[15] cos[16] cos[17]
+ cos[18] cos[1] cos[2] cos[3] cos[4] cos[5] cos[6] cos[7] cos[8] cos[9] done rstb
+ sin[0] sin[10] sin[11] sin[12] sin[13] sin[14] sin[15] sin[16] sin[17] sin[18] sin[1]
+ sin[2] sin[3] sin[4] sin[5] sin[6] sin[7] sin[8] sin[9] start
X_09671_ net530 net441 VGND VGND VPWR VPWR _00944_ sky130_fd_sc_hd__nand2_1
X_08622_ _07162_ _07173_ _07325_ _07369_ VGND VGND VPWR VPWR _07379_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_6_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08553_ _06366_ _06421_ VGND VGND VPWR VPWR _06628_ sky130_fd_sc_hd__and2_1
XFILLER_0_77_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08484_ _05785_ _05850_ _05860_ VGND VGND VPWR VPWR _05871_ sky130_fd_sc_hd__nand3_1
XFILLER_0_147_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09105_ _00383_ _00384_ VGND VGND VPWR VPWR _00385_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_150_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_143_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09036_ _00237_ _00268_ net950 VGND VGND VPWR VPWR _00316_ sky130_fd_sc_hd__nor3_2
XFILLER_0_103_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09938_ _01205_ _01206_ VGND VGND VPWR VPWR _01207_ sky130_fd_sc_hd__xor2_1
X_09869_ net680 _00192_ VGND VGND VPWR VPWR _01139_ sky130_fd_sc_hd__nor2_1
XFILLER_0_99_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11900_ _03205_ _03210_ VGND VGND VPWR VPWR _03211_ sky130_fd_sc_hd__xnor2_2
X_12880_ net170 net744 _04195_ _04194_ VGND VGND VPWR VPWR _04281_ sky130_fd_sc_hd__a31o_1
X_11831_ net720 net443 _03134_ _03135_ VGND VGND VPWR VPWR _03136_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_67_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14550_ _05977_ _05978_ _05976_ VGND VGND VPWR VPWR _06099_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_67_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11762_ _03037_ _03060_ VGND VGND VPWR VPWR _03061_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_138_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13501_ _04866_ _04884_ VGND VGND VPWR VPWR _04957_ sky130_fd_sc_hd__and2_1
X_10713_ _01930_ _01937_ _01931_ VGND VGND VPWR VPWR _01939_ sky130_fd_sc_hd__nor3_2
X_14481_ _06022_ VGND VGND VPWR VPWR _06023_ sky130_fd_sc_hd__inv_2
X_11693_ _02904_ _02921_ VGND VGND VPWR VPWR _02986_ sky130_fd_sc_hd__and2_1
XFILLER_0_82_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16220_ _07837_ _07918_ VGND VGND VPWR VPWR _07919_ sky130_fd_sc_hd__xor2_1
XFILLER_0_126_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13432_ net766 _04881_ VGND VGND VPWR VPWR _04882_ sky130_fd_sc_hd__nor2_1
X_10644_ _01863_ _01868_ _01869_ VGND VGND VPWR VPWR _01870_ sky130_fd_sc_hd__nand3_1
XFILLER_0_130_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16151_ _07652_ _07843_ VGND VGND VPWR VPWR _07844_ sky130_fd_sc_hd__xnor2_1
X_10575_ net320 net434 VGND VGND VPWR VPWR _01801_ sky130_fd_sc_hd__nand2_1
X_13363_ _04704_ _04705_ _04703_ VGND VGND VPWR VPWR _04808_ sky130_fd_sc_hd__o21ai_2
Xrebuffer7 _04415_ VGND VGND VPWR VPWR net813 sky130_fd_sc_hd__buf_1
X_15102_ _06492_ _06594_ VGND VGND VPWR VPWR _06703_ sky130_fd_sc_hd__or2_1
X_12314_ _03559_ _03601_ VGND VGND VPWR VPWR _03660_ sky130_fd_sc_hd__nor2_1
XFILLER_0_121_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16082_ _07723_ _07724_ _07768_ VGND VGND VPWR VPWR _07769_ sky130_fd_sc_hd__a21o_1
XFILLER_0_133_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13294_ _04729_ _04730_ _04619_ _04699_ VGND VGND VPWR VPWR _04733_ sky130_fd_sc_hd__o211ai_2
X_15033_ _06539_ _06542_ _06540_ VGND VGND VPWR VPWR _06629_ sky130_fd_sc_hd__o21bai_1
X_12245_ _03584_ _03585_ VGND VGND VPWR VPWR _03586_ sky130_fd_sc_hd__xnor2_1
X_12176_ _03350_ _03509_ VGND VGND VPWR VPWR _03511_ sky130_fd_sc_hd__or2_1
X_11127_ _02269_ _02271_ _02368_ _02369_ VGND VGND VPWR VPWR _02370_ sky130_fd_sc_hd__o211ai_1
X_15935_ _07609_ _07610_ VGND VGND VPWR VPWR _07611_ sky130_fd_sc_hd__xnor2_1
X_11058_ _02198_ _02292_ _02293_ VGND VGND VPWR VPWR _02294_ sky130_fd_sc_hd__a21oi_1
X_10009_ _01254_ _01276_ VGND VGND VPWR VPWR _01277_ sky130_fd_sc_hd__xnor2_1
X_15866_ _07448_ _07449_ VGND VGND VPWR VPWR _07536_ sky130_fd_sc_hd__nand2_1
XFILLER_0_149_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14817_ _06353_ _06372_ _06387_ VGND VGND VPWR VPWR _06393_ sky130_fd_sc_hd__and3_1
XFILLER_0_99_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15797_ _07454_ _07452_ VGND VGND VPWR VPWR _07460_ sky130_fd_sc_hd__and2b_1
XFILLER_0_147_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14748_ _06314_ _06315_ _06310_ VGND VGND VPWR VPWR _06317_ sky130_fd_sc_hd__a21o_1
XFILLER_0_59_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14679_ _06239_ _06240_ VGND VGND VPWR VPWR _06241_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_144_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16349_ clknet_4_13_0_clk _00062_ net344 VGND VGND VPWR VPWR D_cos\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_131_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout138 net140 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__clkbuf_4
Xfanout149 net154 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__buf_1
X_09723_ _00980_ _00994_ VGND VGND VPWR VPWR _00995_ sky130_fd_sc_hd__xnor2_1
X_09654_ _00923_ _00926_ VGND VGND VPWR VPWR _00927_ sky130_fd_sc_hd__xnor2_1
X_08605_ _06190_ _06179_ _06069_ VGND VGND VPWR VPWR _07194_ sky130_fd_sc_hd__a21o_1
X_09585_ _00766_ _00775_ _00764_ VGND VGND VPWR VPWR _00859_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_49_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08536_ _06355_ _06432_ VGND VGND VPWR VPWR _06443_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08467_ _05405_ _05568_ _05558_ VGND VGND VPWR VPWR _05688_ sky130_fd_sc_hd__a21o_1
XFILLER_0_64_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08398_ net587 net360 _02321_ _02332_ VGND VGND VPWR VPWR _04938_ sky130_fd_sc_hd__a22o_1
XFILLER_0_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10360_ D_sin\[15\] Q_cos\[15\] VGND VGND VPWR VPWR _01591_ sky130_fd_sc_hd__and2b_1
XFILLER_0_131_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09019_ net583 net454 VGND VGND VPWR VPWR _00299_ sky130_fd_sc_hd__nand2_1
X_10291_ D_sin\[6\] Q_cos\[6\] VGND VGND VPWR VPWR _01531_ sky130_fd_sc_hd__or2b_1
X_12030_ _03267_ _03276_ _03351_ VGND VGND VPWR VPWR _03352_ sky130_fd_sc_hd__a21o_1
XFILLER_0_103_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout650 net653 VGND VGND VPWR VPWR net650 sky130_fd_sc_hd__clkbuf_4
Xfanout661 net25 VGND VGND VPWR VPWR net661 sky130_fd_sc_hd__buf_8
Xfanout672 net674 VGND VGND VPWR VPWR net672 sky130_fd_sc_hd__buf_2
X_13981_ _05479_ VGND VGND VPWR VPWR _00089_ sky130_fd_sc_hd__clkbuf_1
Xfanout683 net688 VGND VGND VPWR VPWR net683 sky130_fd_sc_hd__clkbuf_2
Xfanout694 net21 VGND VGND VPWR VPWR net694 sky130_fd_sc_hd__buf_6
X_15720_ _07312_ _07311_ VGND VGND VPWR VPWR _07376_ sky130_fd_sc_hd__and2b_1
X_12932_ _04337_ VGND VGND VPWR VPWR _00077_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_34_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15651_ net290 net674 net680 net281 VGND VGND VPWR VPWR _07301_ sky130_fd_sc_hd__a22oi_2
X_12863_ _04260_ _04261_ VGND VGND VPWR VPWR _04263_ sky130_fd_sc_hd__nor2_1
X_14602_ _06138_ _06154_ _06155_ VGND VGND VPWR VPWR _06156_ sky130_fd_sc_hd__nand3_4
X_11814_ _03109_ _03115_ _03117_ VGND VGND VPWR VPWR _03118_ sky130_fd_sc_hd__nand3_2
X_15582_ net182 net172 net639 net872 VGND VGND VPWR VPWR _07226_ sky130_fd_sc_hd__and4_1
X_12794_ _04177_ _04178_ _04183_ VGND VGND VPWR VPWR _04187_ sky130_fd_sc_hd__a21o_1
X_14533_ net188 net178 net535 net541 VGND VGND VPWR VPWR _06081_ sky130_fd_sc_hd__nand4_2
X_11745_ net712 net468 _02951_ _02950_ VGND VGND VPWR VPWR _03043_ sky130_fd_sc_hd__a31o_1
XFILLER_0_83_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14464_ _05996_ _06004_ VGND VGND VPWR VPWR _06005_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_78_Left_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11676_ _02945_ _02967_ VGND VGND VPWR VPWR _02968_ sky130_fd_sc_hd__xor2_2
XFILLER_0_36_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16203_ _07896_ _07899_ VGND VGND VPWR VPWR _07901_ sky130_fd_sc_hd__xor2_1
XFILLER_0_24_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13415_ _04788_ _04804_ VGND VGND VPWR VPWR _04864_ sky130_fd_sc_hd__and2_1
X_10627_ _01849_ _01848_ _01825_ _01762_ VGND VGND VPWR VPWR _01853_ sky130_fd_sc_hd__a211o_1
X_14395_ net196 net559 _05853_ _05854_ VGND VGND VPWR VPWR _05929_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_107_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16134_ Q_sin\[15\] _07826_ _00186_ VGND VGND VPWR VPWR _07827_ sky130_fd_sc_hd__mux2_1
X_13346_ net722 net295 net284 net730 VGND VGND VPWR VPWR _04789_ sky130_fd_sc_hd__a22oi_2
X_10558_ _01781_ _01782_ _01763_ _01764_ VGND VGND VPWR VPWR _01784_ sky130_fd_sc_hd__a211o_1
XFILLER_0_24_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16065_ _07730_ _07731_ _07751_ VGND VGND VPWR VPWR _07752_ sky130_fd_sc_hd__o21ai_1
X_13277_ _04712_ _04713_ VGND VGND VPWR VPWR _04714_ sky130_fd_sc_hd__xor2_1
X_10489_ net709 net438 VGND VGND VPWR VPWR _01715_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15016_ net159 net541 net548 net308 VGND VGND VPWR VPWR _06610_ sky130_fd_sc_hd__a22o_1
X_12228_ _03500_ _03558_ _03565_ VGND VGND VPWR VPWR _03567_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_87_Left_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12159_ _03475_ _03491_ VGND VGND VPWR VPWR _03492_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15918_ _07508_ _07512_ _07509_ VGND VGND VPWR VPWR _07592_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_79_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15849_ _07424_ _07429_ VGND VGND VPWR VPWR _07517_ sky130_fd_sc_hd__and2b_1
XFILLER_0_149_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09370_ _00643_ _00646_ VGND VGND VPWR VPWR _00647_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08321_ _03550_ _03572_ _03561_ VGND VGND VPWR VPWR _04097_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_24_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_96_Left_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08252_ _03312_ _03322_ _03333_ VGND VGND VPWR VPWR _03344_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_7_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08183_ _02572_ _02583_ net699 net497 VGND VGND VPWR VPWR _02594_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_61_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_12_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_12_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_131_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09706_ _00910_ _00917_ VGND VGND VPWR VPWR _00978_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09637_ _00908_ _00909_ VGND VGND VPWR VPWR _00910_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_139_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09568_ _00752_ _00755_ _00753_ VGND VGND VPWR VPWR _00842_ sky130_fd_sc_hd__o21ba_1
X_08519_ _06234_ _06245_ VGND VGND VPWR VPWR _06256_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_38_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09499_ _00768_ _00773_ VGND VGND VPWR VPWR _00774_ sky130_fd_sc_hd__xor2_1
X_11530_ _02741_ _02758_ VGND VGND VPWR VPWR _02808_ sky130_fd_sc_hd__nor2_1
XFILLER_0_92_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_884 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_137_Right_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11461_ _02730_ _02732_ VGND VGND VPWR VPWR _02733_ sky130_fd_sc_hd__xor2_2
XFILLER_0_34_843 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13200_ _04563_ _04628_ _04629_ VGND VGND VPWR VPWR _04630_ sky130_fd_sc_hd__nand3_2
XFILLER_0_150_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10412_ _01636_ _01637_ net787 net498 VGND VGND VPWR VPWR _01638_ sky130_fd_sc_hd__and4bb_1
X_11392_ net319 net376 net367 net426 VGND VGND VPWR VPWR _02658_ sky130_fd_sc_hd__a22o_1
X_14180_ net288 net279 net793 VGND VGND VPWR VPWR _05695_ sky130_fd_sc_hd__and3_1
XFILLER_0_60_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13131_ net800 net250 _04444_ _04443_ VGND VGND VPWR VPWR _04554_ sky130_fd_sc_hd__a31oi_2
X_10343_ Q_cos\[13\] D_sin\[13\] VGND VGND VPWR VPWR _01576_ sky130_fd_sc_hd__and2b_1
XFILLER_0_21_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10274_ _01513_ _01516_ VGND VGND VPWR VPWR _01517_ sky130_fd_sc_hd__nor2_1
X_13062_ _04476_ _04477_ _04457_ VGND VGND VPWR VPWR _04479_ sky130_fd_sc_hd__a21oi_1
X_12013_ _03331_ _03332_ VGND VGND VPWR VPWR _03334_ sky130_fd_sc_hd__xor2_1
Xfanout480 net482 VGND VGND VPWR VPWR net480 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_136_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout491 net492 VGND VGND VPWR VPWR net491 sky130_fd_sc_hd__clkbuf_4
X_13964_ net711 _04881_ VGND VGND VPWR VPWR _05462_ sky130_fd_sc_hd__or2_1
XFILLER_0_88_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15703_ _07278_ _07357_ VGND VGND VPWR VPWR _07359_ sky130_fd_sc_hd__xnor2_1
X_12915_ _04316_ _04318_ _04255_ _04230_ VGND VGND VPWR VPWR _04320_ sky130_fd_sc_hd__a211o_1
X_13895_ _05360_ _05361_ _05385_ VGND VGND VPWR VPWR _05387_ sky130_fd_sc_hd__nand3_1
X_15634_ _07225_ _07229_ _07226_ VGND VGND VPWR VPWR _07283_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12846_ _04167_ _04242_ _04243_ VGND VGND VPWR VPWR _04244_ sky130_fd_sc_hd__and3_1
XFILLER_0_75_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15565_ _07204_ _07207_ VGND VGND VPWR VPWR _07208_ sky130_fd_sc_hd__xor2_2
X_12777_ _04135_ _04113_ _04114_ _04136_ VGND VGND VPWR VPWR _04168_ sky130_fd_sc_hd__nand4b_1
XFILLER_0_139_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14516_ _06060_ _06061_ VGND VGND VPWR VPWR _06062_ sky130_fd_sc_hd__nor2_1
XFILLER_0_127_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11728_ _03021_ _03022_ _03023_ VGND VGND VPWR VPWR _03024_ sky130_fd_sc_hd__nand3_1
XFILLER_0_28_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15496_ _07124_ _07131_ _07132_ VGND VGND VPWR VPWR _07133_ sky130_fd_sc_hd__nand3_2
XFILLER_0_9_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14447_ net210 net200 net687 net693 VGND VGND VPWR VPWR _05986_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_104_Right_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11659_ net612 net486 net475 net703 VGND VGND VPWR VPWR _02949_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_142_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14378_ _05907_ _05908_ _05909_ VGND VGND VPWR VPWR _05910_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_3_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16117_ _07806_ _07807_ VGND VGND VPWR VPWR _07808_ sky130_fd_sc_hd__or2_1
X_13329_ _04768_ _04769_ VGND VGND VPWR VPWR _04770_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_110_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16048_ _07666_ _07671_ VGND VGND VPWR VPWR _07733_ sky130_fd_sc_hd__and2b_1
X_08870_ net675 net384 VGND VGND VPWR VPWR _00152_ sky130_fd_sc_hd__and2_1
XFILLER_0_86_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09422_ _00696_ _00697_ VGND VGND VPWR VPWR _00698_ sky130_fd_sc_hd__nor2_1
XFILLER_0_126_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09353_ _00625_ _00628_ _00629_ VGND VGND VPWR VPWR _00630_ sky130_fd_sc_hd__nand3_1
X_08304_ net602 net469 _03899_ VGND VGND VPWR VPWR _03910_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_142_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09284_ _00559_ _00561_ VGND VGND VPWR VPWR _00562_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08235_ net677 net526 net437 net686 VGND VGND VPWR VPWR _03160_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_90_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08166_ net577 net352 net504 net587 VGND VGND VPWR VPWR _02408_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_70_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08999_ _00177_ _00179_ _00278_ _00279_ VGND VGND VPWR VPWR _00280_ sky130_fd_sc_hd__a211o_1
XFILLER_0_98_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10961_ _01856_ _01950_ _01955_ _01958_ _02186_ VGND VGND VPWR VPWR _02189_ sky130_fd_sc_hd__o32a_2
XFILLER_0_97_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12700_ net328 net429 net517 net243 VGND VGND VPWR VPWR _04083_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_85_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13680_ net230 net316 net158 net307 VGND VGND VPWR VPWR _05152_ sky130_fd_sc_hd__and4_1
X_10892_ net786 net802 net418 net411 VGND VGND VPWR VPWR _02118_ sky130_fd_sc_hd__and4_1
X_12631_ _03949_ _03951_ _04005_ _04006_ VGND VGND VPWR VPWR _04007_ sky130_fd_sc_hd__a211o_1
XFILLER_0_109_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15350_ _06816_ _06880_ _06877_ VGND VGND VPWR VPWR _06974_ sky130_fd_sc_hd__a21oi_1
X_12562_ _03924_ _03929_ _03930_ VGND VGND VPWR VPWR _03931_ sky130_fd_sc_hd__nand3_1
XFILLER_0_136_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14301_ _05761_ VGND VGND VPWR VPWR _05826_ sky130_fd_sc_hd__inv_2
X_11513_ _02628_ _02690_ _02689_ VGND VGND VPWR VPWR _02791_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_108_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15281_ _06795_ _06815_ _06897_ VGND VGND VPWR VPWR _06898_ sky130_fd_sc_hd__a21bo_1
X_12493_ _03854_ _03845_ VGND VGND VPWR VPWR _03856_ sky130_fd_sc_hd__or2_1
XFILLER_0_80_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14232_ _05745_ _05746_ VGND VGND VPWR VPWR _05751_ sky130_fd_sc_hd__and2b_1
XFILLER_0_135_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11444_ _02625_ _02610_ VGND VGND VPWR VPWR _02715_ sky130_fd_sc_hd__and2b_1
XFILLER_0_40_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14163_ _05675_ _05676_ VGND VGND VPWR VPWR _05678_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11375_ net713 net498 VGND VGND VPWR VPWR _02640_ sky130_fd_sc_hd__and2_1
XFILLER_0_104_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13114_ _04529_ _04530_ VGND VGND VPWR VPWR _04536_ sky130_fd_sc_hd__nand2_1
X_10326_ net915 VGND VGND VPWR VPWR _01561_ sky130_fd_sc_hd__inv_2
X_14094_ _05526_ _05599_ _05602_ VGND VGND VPWR VPWR _05603_ sky130_fd_sc_hd__a21oi_1
X_13045_ net750 net293 net283 net758 VGND VGND VPWR VPWR _04461_ sky130_fd_sc_hd__a22o_1
X_10257_ _01498_ _01500_ _01501_ VGND VGND VPWR VPWR _01502_ sky130_fd_sc_hd__and3_1
X_10188_ _01441_ _01442_ VGND VGND VPWR VPWR _01443_ sky130_fd_sc_hd__xnor2_2
X_14996_ net266 net592 net601 net259 VGND VGND VPWR VPWR _06588_ sky130_fd_sc_hd__a22o_1
X_13947_ _05440_ _05441_ _05437_ net123 VGND VGND VPWR VPWR _05443_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_72_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13878_ net611 net264 net255 net704 VGND VGND VPWR VPWR _05368_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_57_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15617_ _07214_ _07264_ VGND VGND VPWR VPWR _07265_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12829_ _04127_ _04131_ VGND VGND VPWR VPWR _04225_ sky130_fd_sc_hd__and2_1
XFILLER_0_17_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15548_ _07091_ _07092_ _07178_ VGND VGND VPWR VPWR _07189_ sky130_fd_sc_hd__a21o_1
XFILLER_0_127_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15479_ _07112_ _07113_ VGND VGND VPWR VPWR _07114_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout7 net296 VGND VGND VPWR VPWR net936 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_123_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09971_ _01238_ VGND VGND VPWR VPWR _01239_ sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_0_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08922_ _00200_ _00201_ _00202_ VGND VGND VPWR VPWR _00203_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_110_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08853_ _00116_ _00133_ _00134_ VGND VGND VPWR VPWR _00135_ sky130_fd_sc_hd__and3_1
XFILLER_0_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08784_ net640 net521 net433 net839 VGND VGND VPWR VPWR _08095_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_79_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09405_ _00678_ _00680_ VGND VGND VPWR VPWR _00681_ sky130_fd_sc_hd__xor2_1
XFILLER_0_137_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09336_ _00532_ _00533_ _00544_ _00545_ VGND VGND VPWR VPWR _00613_ sky130_fd_sc_hd__or4bb_1
XFILLER_0_118_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09267_ _00542_ _00543_ _00451_ _00535_ VGND VGND VPWR VPWR _00545_ sky130_fd_sc_hd__a211o_1
X_08218_ _02931_ _02964_ VGND VGND VPWR VPWR _02975_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_117_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09198_ Q_cos\[5\] _00476_ _02181_ VGND VGND VPWR VPWR _00477_ sky130_fd_sc_hd__mux2_1
XFILLER_0_132_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08149_ _02201_ _02212_ net561 net387 VGND VGND VPWR VPWR _02223_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_120_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11160_ net785 net444 VGND VGND VPWR VPWR _02405_ sky130_fd_sc_hd__nand2_1
X_10111_ _01359_ _01376_ VGND VGND VPWR VPWR _01377_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11091_ _02328_ _02329_ VGND VGND VPWR VPWR _02330_ sky130_fd_sc_hd__or2_1
XFILLER_0_101_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10042_ net627 net457 net448 net636 VGND VGND VPWR VPWR _01309_ sky130_fd_sc_hd__a22o_1
X_14850_ _06386_ _06409_ _06427_ VGND VGND VPWR VPWR _06429_ sky130_fd_sc_hd__a21o_1
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13801_ net704 net712 net264 net255 VGND VGND VPWR VPWR _05284_ sky130_fd_sc_hd__and4_1
X_14781_ _06349_ _06351_ _06352_ VGND VGND VPWR VPWR _06353_ sky130_fd_sc_hd__nand3_2
X_11993_ _03309_ _03311_ VGND VGND VPWR VPWR _03313_ sky130_fd_sc_hd__xnor2_1
X_13732_ _05187_ _05208_ VGND VGND VPWR VPWR _05209_ sky130_fd_sc_hd__xnor2_1
X_10944_ _02080_ VGND VGND VPWR VPWR _02172_ sky130_fd_sc_hd__inv_2
XFILLER_0_133_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13663_ _05132_ _05133_ VGND VGND VPWR VPWR _05135_ sky130_fd_sc_hd__nor2_1
X_10875_ _02062_ _02100_ _02061_ VGND VGND VPWR VPWR _02101_ sky130_fd_sc_hd__or3b_1
X_15402_ _06927_ _06929_ _06928_ VGND VGND VPWR VPWR _07030_ sky130_fd_sc_hd__a21bo_1
X_12614_ _03977_ _03978_ _03988_ VGND VGND VPWR VPWR _03989_ sky130_fd_sc_hd__a21oi_1
X_16382_ clknet_4_5_0_clk _00095_ net336 VGND VGND VPWR VPWR D_sin\[18\] sky130_fd_sc_hd__dfrtp_1
X_13594_ _04973_ _04975_ VGND VGND VPWR VPWR _05059_ sky130_fd_sc_hd__or2b_1
XFILLER_0_38_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15333_ net633 _06953_ _06954_ VGND VGND VPWR VPWR _06956_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_108_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12545_ _03911_ _03912_ VGND VGND VPWR VPWR _03913_ sky130_fd_sc_hd__or2_1
XFILLER_0_54_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15264_ _06816_ _06880_ VGND VGND VPWR VPWR _06881_ sky130_fd_sc_hd__xnor2_2
X_12476_ _03830_ _03831_ _03836_ VGND VGND VPWR VPWR _03837_ sky130_fd_sc_hd__a21o_1
XFILLER_0_123_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14215_ _05714_ _05733_ VGND VGND VPWR VPWR _05734_ sky130_fd_sc_hd__xor2_1
X_11427_ _02694_ _02695_ _02607_ VGND VGND VPWR VPWR _02697_ sky130_fd_sc_hd__a21o_1
XANTENNA_5 net15 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_15195_ _06688_ _06691_ _06690_ VGND VGND VPWR VPWR _06805_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_10_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14146_ net271 net146 _05658_ VGND VGND VPWR VPWR _05659_ sky130_fd_sc_hd__a21oi_1
X_11358_ _02570_ _02576_ VGND VGND VPWR VPWR _02621_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10309_ _01545_ _01546_ VGND VGND VPWR VPWR _01547_ sky130_fd_sc_hd__xnor2_1
X_14077_ _05582_ _05583_ VGND VGND VPWR VPWR _05584_ sky130_fd_sc_hd__xnor2_1
X_11289_ net141 net414 net405 net151 VGND VGND VPWR VPWR _02546_ sky130_fd_sc_hd__a22oi_2
X_13028_ net775 net268 VGND VGND VPWR VPWR _04442_ sky130_fd_sc_hd__nand2_1
XFILLER_0_83_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer17 _04230_ VGND VGND VPWR VPWR net823 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer28 net833 VGND VGND VPWR VPWR net834 sky130_fd_sc_hd__clkbuf_2
X_14979_ net941 _06117_ _06568_ _06569_ VGND VGND VPWR VPWR _06570_ sky130_fd_sc_hd__a211o_4
Xrebuffer39 net634 VGND VGND VPWR VPWR net845 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_89_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09121_ net583 net445 VGND VGND VPWR VPWR _00400_ sky130_fd_sc_hd__nand2_1
XFILLER_0_134_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer107 _06660_ VGND VGND VPWR VPWR net946 sky130_fd_sc_hd__dlygate4sd1_1
X_09052_ _00323_ _00330_ _00331_ VGND VGND VPWR VPWR _00332_ sky130_fd_sc_hd__and3_1
XFILLER_0_5_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09954_ _01218_ _01219_ _01221_ VGND VGND VPWR VPWR _01223_ sky130_fd_sc_hd__or3_1
X_08905_ _00186_ VGND VGND VPWR VPWR _00187_ sky130_fd_sc_hd__buf_4
X_09885_ _01087_ _01144_ _01154_ VGND VGND VPWR VPWR _01155_ sky130_fd_sc_hd__o21a_1
XFILLER_0_148_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08836_ net564 net574 net479 VGND VGND VPWR VPWR _00118_ sky130_fd_sc_hd__and3_1
X_08767_ _04119_ _04141_ VGND VGND VPWR VPWR _08078_ sky130_fd_sc_hd__nand2_1
XFILLER_0_95_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08698_ _08004_ _08007_ _08009_ VGND VGND VPWR VPWR _08010_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_138_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10660_ _01870_ _01884_ _01885_ VGND VGND VPWR VPWR _01886_ sky130_fd_sc_hd__nand3_2
XFILLER_0_137_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09319_ _00594_ _00595_ VGND VGND VPWR VPWR _00596_ sky130_fd_sc_hd__nor2_1
XFILLER_0_91_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_146_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10591_ _01814_ _01815_ _01745_ _01785_ VGND VGND VPWR VPWR _01817_ sky130_fd_sc_hd__o211ai_4
X_12330_ _03672_ _03676_ VGND VGND VPWR VPWR _03677_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_106_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12261_ net136 net460 net450 net145 VGND VGND VPWR VPWR _03602_ sky130_fd_sc_hd__a22o_1
XFILLER_0_106_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14000_ _05498_ _05499_ VGND VGND VPWR VPWR _05500_ sky130_fd_sc_hd__xnor2_1
X_11212_ _02455_ _02460_ _02461_ VGND VGND VPWR VPWR _02462_ sky130_fd_sc_hd__nand3_2
X_12192_ _03397_ _03468_ VGND VGND VPWR VPWR _03528_ sky130_fd_sc_hd__and2_1
X_11143_ _02379_ _02381_ VGND VGND VPWR VPWR _02387_ sky130_fd_sc_hd__nor2_1
XFILLER_0_128_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput86 net86 VGND VGND VPWR VPWR alpha[16] sky130_fd_sc_hd__clkbuf_4
Xoutput97 net97 VGND VGND VPWR VPWR alpha[9] sky130_fd_sc_hd__clkbuf_4
X_15951_ _07551_ _07555_ _07552_ VGND VGND VPWR VPWR _07627_ sky130_fd_sc_hd__o21ba_1
X_11074_ net490 _02309_ _02311_ VGND VGND VPWR VPWR _02312_ sky130_fd_sc_hd__a21bo_1
X_10025_ _01206_ _01241_ _01198_ VGND VGND VPWR VPWR _01292_ sky130_fd_sc_hd__o21ai_1
X_14902_ _06122_ _06233_ _06230_ _06232_ VGND VGND VPWR VPWR _06485_ sky130_fd_sc_hd__and4b_1
X_15882_ net287 net278 net648 net656 VGND VGND VPWR VPWR _07552_ sky130_fd_sc_hd__and4_1
X_14833_ net221 net597 VGND VGND VPWR VPWR _06411_ sky130_fd_sc_hd__nand2_1
XFILLER_0_144_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14764_ net197 net605 _06334_ _06332_ VGND VGND VPWR VPWR _06335_ sky130_fd_sc_hd__a31o_1
X_11976_ _03287_ _03293_ VGND VGND VPWR VPWR _03294_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_98_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13715_ _05105_ _05108_ _05106_ VGND VGND VPWR VPWR _05191_ sky130_fd_sc_hd__o21ba_1
X_10927_ _02141_ _02144_ _02136_ VGND VGND VPWR VPWR _02153_ sky130_fd_sc_hd__a21o_1
X_14695_ net197 net589 VGND VGND VPWR VPWR _06259_ sky130_fd_sc_hd__nand2_1
XFILLER_0_129_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13646_ _04990_ _04993_ VGND VGND VPWR VPWR _05116_ sky130_fd_sc_hd__nand2_1
X_10858_ _02047_ _02048_ _02040_ VGND VGND VPWR VPWR _02084_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16365_ clknet_4_15_0_clk _00078_ net343 VGND VGND VPWR VPWR D_sin\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_82_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13577_ _05039_ _05040_ VGND VGND VPWR VPWR _05041_ sky130_fd_sc_hd__nand2_1
XFILLER_0_143_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10789_ net760 net769 net419 net411 VGND VGND VPWR VPWR _02015_ sky130_fd_sc_hd__and4_1
X_15316_ _06934_ _06935_ _06926_ VGND VGND VPWR VPWR _06937_ sky130_fd_sc_hd__a21o_1
X_12528_ net223 net780 VGND VGND VPWR VPWR _03894_ sky130_fd_sc_hd__nor2_1
X_16296_ clknet_4_3_0_clk _00009_ net332 VGND VGND VPWR VPWR Q_cos\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_124_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15247_ _06739_ _06740_ _06741_ VGND VGND VPWR VPWR _06862_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_112_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12459_ _03816_ _03817_ VGND VGND VPWR VPWR _03818_ sky130_fd_sc_hd__or2_1
X_15178_ _06581_ _06678_ _06786_ VGND VGND VPWR VPWR _06787_ sky130_fd_sc_hd__a21o_1
X_14129_ _05638_ _05639_ VGND VGND VPWR VPWR _05640_ sky130_fd_sc_hd__nor2_1
Xfanout309 net60 VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__clkbuf_4
X_09670_ _00941_ _00942_ VGND VGND VPWR VPWR _00943_ sky130_fd_sc_hd__nor2_1
XFILLER_0_94_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08621_ _07336_ _07347_ _07358_ VGND VGND VPWR VPWR _07369_ sky130_fd_sc_hd__and3_1
XFILLER_0_118_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08552_ _06344_ _06465_ _06595_ _06606_ VGND VGND VPWR VPWR _06617_ sky130_fd_sc_hd__o211a_1
XFILLER_0_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08483_ net128 _05839_ _05828_ _05731_ VGND VGND VPWR VPWR _05860_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_9_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09104_ _00285_ _00289_ _00284_ VGND VGND VPWR VPWR _00384_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_72_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09035_ _00296_ _00314_ VGND VGND VPWR VPWR _00315_ sky130_fd_sc_hd__xor2_1
XFILLER_0_5_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_107_Left_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09937_ _01151_ _01198_ VGND VGND VPWR VPWR _01206_ sky130_fd_sc_hd__nand2_2
X_09868_ _01136_ _01137_ VGND VGND VPWR VPWR _01138_ sky130_fd_sc_hd__nor2_1
X_08819_ net593 net472 _08059_ _08058_ VGND VGND VPWR VPWR _08129_ sky130_fd_sc_hd__a31o_1
X_09799_ _00443_ _00689_ _01000_ VGND VGND VPWR VPWR _01070_ sky130_fd_sc_hd__nand3_2
X_11830_ net703 net711 net461 net451 VGND VGND VPWR VPWR _03135_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_116_Left_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11761_ _03039_ _03059_ VGND VGND VPWR VPWR _03060_ sky130_fd_sc_hd__xor2_1
XFILLER_0_68_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13500_ _04945_ _04860_ VGND VGND VPWR VPWR _04956_ sky130_fd_sc_hd__or2b_1
X_10712_ _01930_ _01931_ _01937_ VGND VGND VPWR VPWR _01938_ sky130_fd_sc_hd__o21a_1
X_14480_ net292 net282 net594 net609 VGND VGND VPWR VPWR _06022_ sky130_fd_sc_hd__and4_1
X_11692_ _02977_ _02979_ VGND VGND VPWR VPWR _02984_ sky130_fd_sc_hd__nor2_1
XFILLER_0_36_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13431_ _04537_ VGND VGND VPWR VPWR _04881_ sky130_fd_sc_hd__buf_4
X_10643_ _01857_ _01862_ _01861_ VGND VGND VPWR VPWR _01869_ sky130_fd_sc_hd__a21o_1
XFILLER_0_119_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16150_ _07833_ _07842_ VGND VGND VPWR VPWR _07843_ sky130_fd_sc_hd__xnor2_1
X_13362_ _04786_ _04805_ VGND VGND VPWR VPWR _04806_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_91_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10574_ _01796_ _01799_ VGND VGND VPWR VPWR _01800_ sky130_fd_sc_hd__xnor2_1
Xrebuffer8 net164 VGND VGND VPWR VPWR net814 sky130_fd_sc_hd__clkbuf_2
X_15101_ _06686_ _06701_ VGND VGND VPWR VPWR _06702_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12313_ _03505_ _03623_ _03495_ VGND VGND VPWR VPWR _03659_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_125_Left_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16081_ _07719_ _07722_ VGND VGND VPWR VPWR _07768_ sky130_fd_sc_hd__nor2_1
X_13293_ _04619_ _04699_ _04729_ _04730_ VGND VGND VPWR VPWR _04732_ sky130_fd_sc_hd__a211o_1
X_15032_ _06532_ _06534_ VGND VGND VPWR VPWR _06627_ sky130_fd_sc_hd__nand2_1
X_12244_ _03475_ _03491_ _03493_ VGND VGND VPWR VPWR _03585_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_121_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12175_ _03350_ _03509_ VGND VGND VPWR VPWR _03510_ sky130_fd_sc_hd__nand2_1
X_11126_ _02366_ _02367_ _02330_ VGND VGND VPWR VPWR _02369_ sky130_fd_sc_hd__o21ai_2
X_15934_ _07503_ _07529_ VGND VGND VPWR VPWR _07610_ sky130_fd_sc_hd__nand2_1
X_11057_ net774 net785 net462 net452 VGND VGND VPWR VPWR _02293_ sky130_fd_sc_hd__and4_1
X_10008_ _01256_ _01275_ VGND VGND VPWR VPWR _01276_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_64_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_134_Left_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15865_ _07533_ _07534_ VGND VGND VPWR VPWR _07535_ sky130_fd_sc_hd__nor2_1
X_14816_ _06390_ _06391_ VGND VGND VPWR VPWR _06392_ sky130_fd_sc_hd__xnor2_1
X_15796_ _07459_ VGND VGND VPWR VPWR _00106_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_148_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14747_ _06310_ _06314_ _06315_ VGND VGND VPWR VPWR _06316_ sky130_fd_sc_hd__nand3_4
XFILLER_0_80_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11959_ net229 net495 _03174_ _03173_ VGND VGND VPWR VPWR _03275_ sky130_fd_sc_hd__a31o_1
XFILLER_0_74_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14678_ net196 net598 VGND VGND VPWR VPWR _06240_ sky130_fd_sc_hd__nand2_1
XFILLER_0_55_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13629_ _05013_ _05011_ VGND VGND VPWR VPWR _05097_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_143_Left_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16348_ clknet_4_13_0_clk _00061_ net344 VGND VGND VPWR VPWR D_cos\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_54_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16279_ _07979_ _07982_ VGND VGND VPWR VPWR _07983_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_140_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout139 net140 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_129_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09722_ _00985_ _00993_ VGND VGND VPWR VPWR _00994_ sky130_fd_sc_hd__xnor2_1
X_09653_ _00768_ _00925_ VGND VGND VPWR VPWR _00926_ sky130_fd_sc_hd__xor2_4
X_08604_ _06190_ _06069_ _06179_ VGND VGND VPWR VPWR _07184_ sky130_fd_sc_hd__nand3_1
X_09584_ _00766_ _00857_ VGND VGND VPWR VPWR _00858_ sky130_fd_sc_hd__xor2_2
XFILLER_0_89_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_118_Right_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08535_ _06366_ _06421_ VGND VGND VPWR VPWR _06432_ sky130_fd_sc_hd__xor2_1
XFILLER_0_148_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08466_ _05623_ _05666_ VGND VGND VPWR VPWR _05677_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_18_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08397_ net568 net387 _04905_ _04916_ VGND VGND VPWR VPWR _04927_ sky130_fd_sc_hd__a31o_1
XFILLER_0_116_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09018_ _00218_ _00220_ _00219_ net488 VGND VGND VPWR VPWR _00298_ sky130_fd_sc_hd__a22o_1
XFILLER_0_20_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10290_ _01530_ VGND VGND VPWR VPWR _00043_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout640 net644 VGND VGND VPWR VPWR net640 sky130_fd_sc_hd__clkbuf_4
Xfanout651 net653 VGND VGND VPWR VPWR net651 sky130_fd_sc_hd__buf_4
Xfanout662 net896 VGND VGND VPWR VPWR net662 sky130_fd_sc_hd__buf_2
X_13980_ D_sin\[12\] _05478_ _04752_ VGND VGND VPWR VPWR _05479_ sky130_fd_sc_hd__mux2_1
Xfanout673 net674 VGND VGND VPWR VPWR net673 sky130_fd_sc_hd__buf_4
Xfanout684 net688 VGND VGND VPWR VPWR net684 sky130_fd_sc_hd__clkbuf_4
Xfanout695 net21 VGND VGND VPWR VPWR net695 sky130_fd_sc_hd__clkbuf_4
X_12931_ D_sin\[0\] _04336_ _03242_ VGND VGND VPWR VPWR _04337_ sky130_fd_sc_hd__mux2_1
X_15650_ _07224_ _07230_ VGND VGND VPWR VPWR _07300_ sky130_fd_sc_hd__or2b_1
X_12862_ net767 net293 net284 net775 VGND VGND VPWR VPWR _04261_ sky130_fd_sc_hd__and4_1
XFILLER_0_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14601_ _06130_ _06137_ _06136_ VGND VGND VPWR VPWR _06155_ sky130_fd_sc_hd__a21o_1
X_11813_ _03112_ _03113_ _03114_ VGND VGND VPWR VPWR _03117_ sky130_fd_sc_hd__a21o_1
X_15581_ net172 net873 net872 net182 VGND VGND VPWR VPWR _07225_ sky130_fd_sc_hd__a22oi_2
X_12793_ _04089_ _04094_ _04088_ VGND VGND VPWR VPWR _04186_ sky130_fd_sc_hd__a21bo_1
X_14532_ net188 net535 net541 net178 VGND VGND VPWR VPWR _06079_ sky130_fd_sc_hd__a22o_1
XFILLER_0_83_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11744_ _02946_ _02966_ _03041_ VGND VGND VPWR VPWR _03042_ sky130_fd_sc_hd__a21o_1
XFILLER_0_138_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14463_ _05997_ _06002_ VGND VGND VPWR VPWR _06004_ sky130_fd_sc_hd__xnor2_1
X_11675_ _02946_ _02966_ VGND VGND VPWR VPWR _02967_ sky130_fd_sc_hd__xor2_2
XFILLER_0_126_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16202_ _07854_ _07897_ _07898_ VGND VGND VPWR VPWR _07899_ sky130_fd_sc_hd__o21ai_1
X_13414_ _04778_ _04779_ _04862_ VGND VGND VPWR VPWR _04863_ sky130_fd_sc_hd__o21ai_2
X_10626_ _01659_ _01851_ VGND VGND VPWR VPWR _01852_ sky130_fd_sc_hd__and2_1
X_14394_ _05921_ _05922_ _05927_ VGND VGND VPWR VPWR _05928_ sky130_fd_sc_hd__a21o_1
XFILLER_0_52_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16133_ _07822_ _07824_ VGND VGND VPWR VPWR _07826_ sky130_fd_sc_hd__xor2_1
XFILLER_0_63_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13345_ _04700_ _04707_ _04787_ VGND VGND VPWR VPWR _04788_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_12_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10557_ _01763_ _01764_ _01781_ _01782_ VGND VGND VPWR VPWR _01783_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_59_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16064_ _07748_ _07750_ VGND VGND VPWR VPWR _07751_ sky130_fd_sc_hd__or2_1
X_13276_ net319 net195 VGND VGND VPWR VPWR _04713_ sky130_fd_sc_hd__nand2_1
X_10488_ _01702_ _01701_ _01700_ VGND VGND VPWR VPWR _01714_ sky130_fd_sc_hd__o21ai_1
X_15015_ _06607_ _06608_ VGND VGND VPWR VPWR _06609_ sky130_fd_sc_hd__xnor2_2
X_12227_ _03500_ _03558_ _03565_ VGND VGND VPWR VPWR _03566_ sky130_fd_sc_hd__nor3_1
XFILLER_0_121_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12158_ _03489_ _03490_ VGND VGND VPWR VPWR _03491_ sky130_fd_sc_hd__xnor2_1
X_11109_ net233 net414 net405 net320 VGND VGND VPWR VPWR _02350_ sky130_fd_sc_hd__a22o_1
X_12089_ net511 net443 VGND VGND VPWR VPWR _03416_ sky130_fd_sc_hd__nand2_1
X_15917_ _07584_ _07590_ VGND VGND VPWR VPWR _07591_ sky130_fd_sc_hd__xnor2_1
X_15848_ _07514_ _07515_ VGND VGND VPWR VPWR _07516_ sky130_fd_sc_hd__xor2_2
XFILLER_0_78_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15779_ _07439_ _07440_ VGND VGND VPWR VPWR _07441_ sky130_fd_sc_hd__nand2_1
XFILLER_0_115_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08320_ net558 net360 _03712_ _03701_ VGND VGND VPWR VPWR _04086_ sky130_fd_sc_hd__a31o_1
XFILLER_0_87_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08251_ net686 net695 net526 net437 VGND VGND VPWR VPWR _03333_ sky130_fd_sc_hd__and4_1
XFILLER_0_28_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08182_ net595 net352 net505 net603 VGND VGND VPWR VPWR _02583_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_54_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09705_ _00916_ _00915_ VGND VGND VPWR VPWR _00977_ sky130_fd_sc_hd__and2b_1
XFILLER_0_97_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09636_ net671 net465 VGND VGND VPWR VPWR _00909_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09567_ _00839_ _00840_ VGND VGND VPWR VPWR _00841_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08518_ net591 net388 VGND VGND VPWR VPWR _06245_ sky130_fd_sc_hd__nand2_1
XFILLER_0_93_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09498_ _00771_ _00772_ VGND VGND VPWR VPWR _00773_ sky130_fd_sc_hd__xor2_1
XFILLER_0_77_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08449_ net561 net416 VGND VGND VPWR VPWR _05492_ sky130_fd_sc_hd__and2_1
XFILLER_0_19_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11460_ _02618_ _02619_ _02731_ VGND VGND VPWR VPWR _02732_ sky130_fd_sc_hd__o21a_1
XFILLER_0_46_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10411_ net771 net354 net507 net779 VGND VGND VPWR VPWR _01637_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_135_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11391_ net318 net426 net367 VGND VGND VPWR VPWR _02657_ sky130_fd_sc_hd__and3_1
XFILLER_0_150_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13130_ _04546_ _04552_ VGND VGND VPWR VPWR _04553_ sky130_fd_sc_hd__xor2_1
X_10342_ _01563_ _01567_ _01571_ VGND VGND VPWR VPWR _01575_ sky130_fd_sc_hd__o21a_1
X_13061_ _04457_ _04476_ _04477_ VGND VGND VPWR VPWR _04478_ sky130_fd_sc_hd__and3_1
X_10273_ D_sin\[2\] _01514_ _01515_ VGND VGND VPWR VPWR _01516_ sky130_fd_sc_hd__o21a_1
XFILLER_0_103_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12012_ _03288_ _03292_ _03289_ VGND VGND VPWR VPWR _03332_ sky130_fd_sc_hd__o21ba_1
Xfanout470 net472 VGND VGND VPWR VPWR net470 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_136_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout481 net482 VGND VGND VPWR VPWR net481 sky130_fd_sc_hd__clkbuf_4
Xfanout492 net42 VGND VGND VPWR VPWR net492 sky130_fd_sc_hd__buf_4
X_13963_ _05456_ _05459_ VGND VGND VPWR VPWR _05461_ sky130_fd_sc_hd__xnor2_1
X_15702_ _07353_ _07356_ VGND VGND VPWR VPWR _07357_ sky130_fd_sc_hd__xnor2_1
X_12914_ _04255_ _04230_ _04316_ _04318_ VGND VGND VPWR VPWR _04319_ sky130_fd_sc_hd__o211ai_4
X_13894_ _05360_ _05361_ _05385_ VGND VGND VPWR VPWR _05386_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15633_ _07279_ _07280_ VGND VGND VPWR VPWR _07282_ sky130_fd_sc_hd__nor2_4
X_12845_ _04149_ _04154_ VGND VGND VPWR VPWR _04243_ sky130_fd_sc_hd__or2b_1
XFILLER_0_28_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15564_ _07105_ _07108_ _07206_ VGND VGND VPWR VPWR _07207_ sky130_fd_sc_hd__a21bo_1
X_12776_ _04140_ _04148_ VGND VGND VPWR VPWR _04167_ sky130_fd_sc_hd__nand2_1
XFILLER_0_127_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14515_ _06057_ _06059_ VGND VGND VPWR VPWR _06061_ sky130_fd_sc_hd__and2_1
X_11727_ _02955_ _02957_ _02956_ VGND VGND VPWR VPWR _03023_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_126_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15495_ _07127_ _07128_ _07130_ VGND VGND VPWR VPWR _07132_ sky130_fd_sc_hd__a21o_1
XFILLER_0_127_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14446_ net195 net535 VGND VGND VPWR VPWR _05985_ sky130_fd_sc_hd__nand2_1
X_11658_ _02862_ _02871_ _02947_ VGND VGND VPWR VPWR _02948_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_142_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10609_ _01616_ _01834_ VGND VGND VPWR VPWR _01835_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14377_ net326 net241 net687 net696 VGND VGND VPWR VPWR _05909_ sky130_fd_sc_hd__nand4_1
XFILLER_0_52_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11589_ _02861_ _02872_ VGND VGND VPWR VPWR _02873_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_141_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16116_ _07652_ _07746_ _07649_ VGND VGND VPWR VPWR _07807_ sky130_fd_sc_hd__a21o_1
X_13328_ net766 net251 VGND VGND VPWR VPWR _04769_ sky130_fd_sc_hd__nand2_1
X_16047_ _07652_ _07676_ _07649_ VGND VGND VPWR VPWR _07732_ sky130_fd_sc_hd__a21o_1
X_13259_ _04677_ _04692_ _04693_ VGND VGND VPWR VPWR _04694_ sky130_fd_sc_hd__nor3_1
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09421_ _00694_ _00695_ net646 net356 VGND VGND VPWR VPWR _00697_ sky130_fd_sc_hd__and4bb_1
X_09352_ net658 net356 _00626_ _00627_ VGND VGND VPWR VPWR _00629_ sky130_fd_sc_hd__nand4_2
XFILLER_0_47_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08303_ _03877_ _03888_ VGND VGND VPWR VPWR _03899_ sky130_fd_sc_hd__nor2_1
XFILLER_0_118_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09283_ _00462_ _00463_ _00560_ VGND VGND VPWR VPWR _00561_ sky130_fd_sc_hd__o21a_1
XFILLER_0_28_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08234_ net695 net417 VGND VGND VPWR VPWR _03149_ sky130_fd_sc_hd__nand2_1
XFILLER_0_145_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08165_ net577 net587 net352 net504 VGND VGND VPWR VPWR _02397_ sky130_fd_sc_hd__and4_1
XFILLER_0_133_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08998_ _00276_ _00277_ _08141_ _00195_ VGND VGND VPWR VPWR _00279_ sky130_fd_sc_hd__a211oi_2
X_10960_ next_state _02187_ _02188_ VGND VGND VPWR VPWR _00058_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_97_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09619_ _00786_ _00805_ _00892_ VGND VGND VPWR VPWR _00893_ sky130_fd_sc_hd__a21o_2
X_10891_ _02099_ _02116_ VGND VGND VPWR VPWR _02117_ sky130_fd_sc_hd__xnor2_1
X_12630_ _03991_ _04004_ _03992_ VGND VGND VPWR VPWR _04006_ sky130_fd_sc_hd__and3_2
X_12561_ _03920_ _03923_ _03922_ VGND VGND VPWR VPWR _03930_ sky130_fd_sc_hd__a21o_1
XFILLER_0_31_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11512_ _02738_ _02788_ VGND VGND VPWR VPWR _02789_ sky130_fd_sc_hd__xnor2_2
X_14300_ _05823_ _05824_ VGND VGND VPWR VPWR _05825_ sky130_fd_sc_hd__xnor2_1
X_15280_ _06814_ _06796_ VGND VGND VPWR VPWR _06897_ sky130_fd_sc_hd__or2b_1
XFILLER_0_53_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12492_ net218 net788 net804 net208 VGND VGND VPWR VPWR _03854_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_135_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14231_ _05750_ VGND VGND VPWR VPWR _00093_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_150_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11443_ _02700_ _02710_ VGND VGND VPWR VPWR _02714_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14162_ _05609_ _05674_ _05672_ _05673_ VGND VGND VPWR VPWR _05676_ sky130_fd_sc_hd__o211ai_1
X_11374_ net614 net705 net349 net509 VGND VGND VPWR VPWR _02639_ sky130_fd_sc_hd__nand4_2
XFILLER_0_22_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13113_ _04534_ VGND VGND VPWR VPWR _00079_ sky130_fd_sc_hd__clkbuf_1
X_10325_ _01560_ VGND VGND VPWR VPWR _00048_ sky130_fd_sc_hd__clkbuf_1
X_14093_ _05524_ _05600_ net298 VGND VGND VPWR VPWR _05602_ sky130_fd_sc_hd__o21a_1
X_13044_ net750 net758 net283 VGND VGND VPWR VPWR _04460_ sky130_fd_sc_hd__and3_1
X_10256_ D_sin\[1\] Q_cos\[1\] VGND VGND VPWR VPWR _01501_ sky130_fd_sc_hd__or2b_1
X_10187_ _01433_ _01436_ _01434_ VGND VGND VPWR VPWR _01442_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_89_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14995_ net276 net594 _06507_ _06506_ VGND VGND VPWR VPWR _06587_ sky130_fd_sc_hd__a31o_1
Xclkbuf_4_11_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_11_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_88_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13946_ _05437_ net123 _05440_ _05441_ VGND VGND VPWR VPWR _05442_ sky130_fd_sc_hd__o211a_1
XFILLER_0_88_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13877_ _05240_ _05244_ _05241_ VGND VGND VPWR VPWR _05367_ sky130_fd_sc_hd__o21ba_1
X_15616_ _07261_ _07263_ VGND VGND VPWR VPWR _07264_ sky130_fd_sc_hd__xor2_1
X_12828_ _04125_ _04126_ VGND VGND VPWR VPWR _04224_ sky130_fd_sc_hd__and2_1
XFILLER_0_146_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15547_ _07187_ _07183_ VGND VGND VPWR VPWR _07188_ sky130_fd_sc_hd__nand2_1
X_12759_ _04144_ _04147_ VGND VGND VPWR VPWR _04148_ sky130_fd_sc_hd__or2b_1
XFILLER_0_16_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15478_ _04538_ net575 VGND VGND VPWR VPWR _07113_ sky130_fd_sc_hd__nor2_1
XFILLER_0_71_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14429_ _05960_ _05965_ VGND VGND VPWR VPWR _05966_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout8 _00311_ VGND VGND VPWR VPWR net937 sky130_fd_sc_hd__buf_4
XFILLER_0_97_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09970_ _01201_ _01237_ net620 VGND VGND VPWR VPWR _01238_ sky130_fd_sc_hd__and3b_1
XFILLER_0_97_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08921_ net582 net469 net459 net583 VGND VGND VPWR VPWR _00202_ sky130_fd_sc_hd__a22o_1
XFILLER_0_0_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08852_ _00131_ _00132_ _00117_ VGND VGND VPWR VPWR _00134_ sky130_fd_sc_hd__a21o_1
XFILLER_0_137_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08783_ net650 net640 net521 net432 VGND VGND VPWR VPWR _08094_ sky130_fd_sc_hd__and4_1
XFILLER_0_137_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09404_ _00582_ _00583_ _00679_ VGND VGND VPWR VPWR _00680_ sky130_fd_sc_hd__o21a_1
XFILLER_0_1_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09335_ _00610_ _00611_ VGND VGND VPWR VPWR _00612_ sky130_fd_sc_hd__nor2_1
XFILLER_0_62_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09266_ _00451_ _00535_ _00542_ _00543_ VGND VGND VPWR VPWR _00544_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_35_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08217_ _02942_ _02953_ VGND VGND VPWR VPWR _02964_ sky130_fd_sc_hd__nor2_1
XFILLER_0_106_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09197_ _00469_ _00475_ VGND VGND VPWR VPWR _00476_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_31_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08148_ net543 net409 net398 net552 VGND VGND VPWR VPWR _02212_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_121_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10110_ _01360_ _01375_ VGND VGND VPWR VPWR _01376_ sky130_fd_sc_hd__xnor2_1
X_11090_ _02326_ _02327_ _02307_ VGND VGND VPWR VPWR _02329_ sky130_fd_sc_hd__a21oi_1
X_10041_ net627 net448 VGND VGND VPWR VPWR _01308_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13800_ net704 net264 net255 net712 VGND VGND VPWR VPWR _05283_ sky130_fd_sc_hd__a22oi_2
X_14780_ _06342_ _06343_ _06348_ VGND VGND VPWR VPWR _06352_ sky130_fd_sc_hd__a21o_1
X_11992_ _03202_ _03220_ _03310_ VGND VGND VPWR VPWR _03311_ sky130_fd_sc_hd__a21oi_2
X_10943_ _02114_ _02134_ _02149_ _02162_ _02169_ VGND VGND VPWR VPWR _02171_ sky130_fd_sc_hd__a311o_1
XFILLER_0_97_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13731_ _05190_ _05207_ VGND VGND VPWR VPWR _05208_ sky130_fd_sc_hd__xnor2_1
X_10874_ net760 net439 VGND VGND VPWR VPWR _02100_ sky130_fd_sc_hd__nand2_1
X_13662_ _05055_ _05039_ _05131_ VGND VGND VPWR VPWR _05133_ sky130_fd_sc_hd__and3_1
XFILLER_0_128_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15401_ _07025_ _07026_ _07027_ VGND VGND VPWR VPWR _07029_ sky130_fd_sc_hd__nand3_1
XFILLER_0_66_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12613_ _03985_ _03986_ VGND VGND VPWR VPWR _03988_ sky130_fd_sc_hd__xnor2_1
X_16381_ clknet_4_4_0_clk _00094_ net336 VGND VGND VPWR VPWR D_sin\[17\] sky130_fd_sc_hd__dfrtp_1
X_13593_ _04961_ _04979_ _05056_ VGND VGND VPWR VPWR _05058_ sky130_fd_sc_hd__a21o_1
XFILLER_0_108_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15332_ net201 net642 net633 net211 VGND VGND VPWR VPWR _06954_ sky130_fd_sc_hd__a22o_1
X_12544_ net162 net790 net805 net310 VGND VGND VPWR VPWR _03912_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_93_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15263_ _06877_ _06878_ VGND VGND VPWR VPWR _06880_ sky130_fd_sc_hd__and2b_1
XFILLER_0_81_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12475_ _03832_ _03834_ _03835_ VGND VGND VPWR VPWR _03836_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_136_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11426_ _02607_ _02694_ _02695_ VGND VGND VPWR VPWR _02696_ sky130_fd_sc_hd__nand3_4
X_14214_ _05730_ _05732_ VGND VGND VPWR VPWR _05733_ sky130_fd_sc_hd__xnor2_1
XANTENNA_6 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_15194_ _06797_ _06803_ VGND VGND VPWR VPWR _06804_ sky130_fd_sc_hd__xnor2_1
X_14145_ _05656_ _05657_ VGND VGND VPWR VPWR _05658_ sky130_fd_sc_hd__nor2_1
X_11357_ _02618_ _02619_ VGND VGND VPWR VPWR _02620_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_21_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10308_ _01537_ _01540_ _01538_ VGND VGND VPWR VPWR _01546_ sky130_fd_sc_hd__a21bo_1
X_14076_ net610 _04539_ VGND VGND VPWR VPWR _05583_ sky130_fd_sc_hd__nor2_1
X_11288_ _02543_ _02544_ VGND VGND VPWR VPWR _02545_ sky130_fd_sc_hd__xor2_2
X_13027_ net775 net274 _04363_ _04362_ VGND VGND VPWR VPWR _04441_ sky130_fd_sc_hd__a31o_1
X_10239_ _01485_ _01486_ VGND VGND VPWR VPWR _01487_ sky130_fd_sc_hd__nand2_1
Xrebuffer18 _06037_ VGND VGND VPWR VPWR net824 sky130_fd_sc_hd__clkbuf_1
X_14978_ _06566_ _06567_ _06501_ VGND VGND VPWR VPWR _06569_ sky130_fd_sc_hd__a21oi_1
Xrebuffer29 net834 VGND VGND VPWR VPWR net835 sky130_fd_sc_hd__buf_1
XFILLER_0_107_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13929_ _05421_ _05422_ VGND VGND VPWR VPWR _05423_ sky130_fd_sc_hd__xor2_1
XFILLER_0_107_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_146_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09120_ _00397_ _00398_ VGND VGND VPWR VPWR _00399_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer108 _04276_ VGND VGND VPWR VPWR net947 sky130_fd_sc_hd__dlygate4sd1_1
X_09051_ _00327_ _00328_ _00329_ VGND VGND VPWR VPWR _00331_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09953_ _01218_ _01219_ _01221_ VGND VGND VPWR VPWR _01222_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_148_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08904_ _02170_ VGND VGND VPWR VPWR _00186_ sky130_fd_sc_hd__buf_4
XFILLER_0_110_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09884_ _01074_ _01153_ VGND VGND VPWR VPWR _01154_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_29_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08835_ _08078_ _08085_ _08084_ VGND VGND VPWR VPWR _00117_ sky130_fd_sc_hd__a21o_1
X_08766_ _04185_ _04371_ _04382_ VGND VGND VPWR VPWR _08077_ sky130_fd_sc_hd__nand3_1
XFILLER_0_79_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08697_ net701 net408 _08008_ VGND VGND VPWR VPWR _08009_ sky130_fd_sc_hd__nand3_1
XFILLER_0_79_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09318_ net934 net530 net484 net474 VGND VGND VPWR VPWR _00595_ sky130_fd_sc_hd__and4_1
X_10590_ _01745_ _01785_ _01814_ _01815_ VGND VGND VPWR VPWR _01816_ sky130_fd_sc_hd__a211o_4
XFILLER_0_63_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09249_ net650 net658 net373 net364 VGND VGND VPWR VPWR _00527_ sky130_fd_sc_hd__nand4_2
XFILLER_0_90_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12260_ net136 net450 VGND VGND VPWR VPWR _03601_ sky130_fd_sc_hd__nand2_1
XFILLER_0_133_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11211_ _02458_ _02459_ _02351_ _02352_ VGND VGND VPWR VPWR _02461_ sky130_fd_sc_hd__o211ai_2
X_12191_ _03471_ _03526_ VGND VGND VPWR VPWR _03527_ sky130_fd_sc_hd__xor2_2
XFILLER_0_31_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11142_ _02385_ VGND VGND VPWR VPWR _00060_ sky130_fd_sc_hd__clkbuf_1
Xoutput87 net87 VGND VGND VPWR VPWR alpha[17] sky130_fd_sc_hd__clkbuf_4
X_15950_ _07549_ _07481_ _07568_ VGND VGND VPWR VPWR _07626_ sky130_fd_sc_hd__o21ai_1
X_11073_ net750 net490 net481 net759 VGND VGND VPWR VPWR _02311_ sky130_fd_sc_hd__a22o_1
Xoutput98 net98 VGND VGND VPWR VPWR beta[0] sky130_fd_sc_hd__clkbuf_4
X_10024_ _01069_ VGND VGND VPWR VPWR _01291_ sky130_fd_sc_hd__inv_2
X_14901_ _06236_ _06480_ VGND VGND VPWR VPWR _06484_ sky130_fd_sc_hd__and2_1
X_15881_ net286 net647 net656 net277 VGND VGND VPWR VPWR _07551_ sky130_fd_sc_hd__a22oi_2
X_14832_ _06379_ _06385_ _06384_ VGND VGND VPWR VPWR _06409_ sky130_fd_sc_hd__a21o_1
X_14763_ _06331_ _06332_ VGND VGND VPWR VPWR _06334_ sky130_fd_sc_hd__nor2_1
X_11975_ _03291_ _03292_ VGND VGND VPWR VPWR _03293_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_86_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13714_ _05104_ _05118_ _05189_ VGND VGND VPWR VPWR _05190_ sky130_fd_sc_hd__o21ai_1
X_10926_ _02114_ _02150_ _02132_ VGND VGND VPWR VPWR _02152_ sky130_fd_sc_hd__or3_1
XFILLER_0_129_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14694_ _06255_ _06257_ VGND VGND VPWR VPWR _06258_ sky130_fd_sc_hd__nor2_1
XFILLER_0_85_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10857_ _02052_ _02082_ VGND VGND VPWR VPWR _02083_ sky130_fd_sc_hd__and2b_1
X_13645_ _05113_ _05114_ VGND VGND VPWR VPWR _05115_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_26_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16364_ clknet_4_15_0_clk _00077_ net343 VGND VGND VPWR VPWR D_sin\[0\] sky130_fd_sc_hd__dfrtp_2
X_10788_ net760 net419 net411 net769 VGND VGND VPWR VPWR _02014_ sky130_fd_sc_hd__a22oi_2
X_13576_ _04958_ _05038_ VGND VGND VPWR VPWR _05040_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15315_ _06926_ _06934_ _06935_ VGND VGND VPWR VPWR _06936_ sky130_fd_sc_hd__nand3_1
XFILLER_0_136_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12527_ net223 net780 VGND VGND VPWR VPWR _03893_ sky130_fd_sc_hd__and2_1
X_16295_ clknet_4_3_0_clk _00008_ net332 VGND VGND VPWR VPWR Q_cos\[8\] sky130_fd_sc_hd__dfrtp_1
X_15246_ _04715_ _06858_ _06859_ VGND VGND VPWR VPWR _06861_ sky130_fd_sc_hd__a21o_1
X_12458_ _03814_ _03815_ _03769_ _03773_ VGND VGND VPWR VPWR _03817_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_78_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11409_ _02668_ _02675_ _02676_ VGND VGND VPWR VPWR _02677_ sky130_fd_sc_hd__nand3_1
XFILLER_0_2_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15177_ _06575_ _06577_ net810 _06675_ VGND VGND VPWR VPWR _06786_ sky130_fd_sc_hd__o211a_1
X_12389_ net190 net781 net789 net181 VGND VGND VPWR VPWR _03741_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_50_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14128_ net422 net249 _05637_ VGND VGND VPWR VPWR _05639_ sky130_fd_sc_hd__and3_1
XFILLER_0_120_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14059_ _05410_ _05513_ VGND VGND VPWR VPWR _05564_ sky130_fd_sc_hd__nor2_2
XFILLER_0_94_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08620_ _07184_ _07194_ _07314_ VGND VGND VPWR VPWR _07358_ sky130_fd_sc_hd__a21o_1
X_08551_ _06574_ _06584_ _06530_ VGND VGND VPWR VPWR _06606_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08482_ _05731_ _05828_ _05839_ net128 VGND VGND VPWR VPWR _05850_ sky130_fd_sc_hd__a211o_1
XFILLER_0_77_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09103_ _00292_ _00382_ VGND VGND VPWR VPWR _00383_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_94_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09034_ _00297_ _00313_ VGND VGND VPWR VPWR _00314_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_143_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout800 net801 VGND VGND VPWR VPWR net800 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09936_ _01203_ _01204_ VGND VGND VPWR VPWR _01205_ sky130_fd_sc_hd__xor2_1
X_09867_ _01132_ _01135_ VGND VGND VPWR VPWR _01137_ sky130_fd_sc_hd__nor2_1
X_08818_ _08127_ _08124_ _08122_ VGND VGND VPWR VPWR _08128_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_99_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09798_ _01068_ VGND VGND VPWR VPWR _01069_ sky130_fd_sc_hd__buf_2
X_08749_ net593 net469 VGND VGND VPWR VPWR _08060_ sky130_fd_sc_hd__nand2_1
X_11760_ _03042_ _03058_ VGND VGND VPWR VPWR _03059_ sky130_fd_sc_hd__xor2_1
XFILLER_0_95_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10711_ _01920_ _01936_ VGND VGND VPWR VPWR _01937_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11691_ _02983_ VGND VGND VPWR VPWR _00066_ sky130_fd_sc_hd__clkbuf_1
X_10642_ _01866_ _01867_ VGND VGND VPWR VPWR _01868_ sky130_fd_sc_hd__xnor2_1
X_13430_ _04877_ _04879_ VGND VGND VPWR VPWR _04880_ sky130_fd_sc_hd__xor2_2
XFILLER_0_36_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13361_ _04788_ _04804_ VGND VGND VPWR VPWR _04805_ sky130_fd_sc_hd__xor2_1
X_10573_ _01797_ _01798_ VGND VGND VPWR VPWR _01799_ sky130_fd_sc_hd__nor2_1
XFILLER_0_51_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15100_ _06699_ _06700_ VGND VGND VPWR VPWR _06701_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_134_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer9 _06771_ VGND VGND VPWR VPWR net815 sky130_fd_sc_hd__clkbuf_1
X_12312_ _03354_ _03624_ _03627_ VGND VGND VPWR VPWR _03657_ sky130_fd_sc_hd__a21bo_1
X_16080_ _07762_ _07761_ VGND VGND VPWR VPWR _07767_ sky130_fd_sc_hd__and2b_1
XFILLER_0_90_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13292_ _04727_ _04728_ _04708_ VGND VGND VPWR VPWR _04730_ sky130_fd_sc_hd__a21oi_1
X_15031_ _06538_ _06557_ net942 VGND VGND VPWR VPWR _06626_ sky130_fd_sc_hd__nand3_2
X_12243_ _03581_ _03582_ VGND VGND VPWR VPWR _03584_ sky130_fd_sc_hd__or2_1
XFILLER_0_32_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12174_ _03497_ _03508_ VGND VGND VPWR VPWR _03509_ sky130_fd_sc_hd__xor2_1
X_11125_ _02330_ _02366_ _02367_ VGND VGND VPWR VPWR _02368_ sky130_fd_sc_hd__or3_4
XFILLER_0_3_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15933_ _07606_ _07607_ VGND VGND VPWR VPWR _07609_ sky130_fd_sc_hd__or2_1
X_11056_ net774 net462 VGND VGND VPWR VPWR _02292_ sky130_fd_sc_hd__nand2_1
X_10007_ _01273_ _01274_ VGND VGND VPWR VPWR _01275_ sky130_fd_sc_hd__and2_1
X_15864_ _07530_ _07531_ _07462_ _07443_ VGND VGND VPWR VPWR _07534_ sky130_fd_sc_hd__o211a_1
X_14815_ net197 net700 _06381_ _06380_ VGND VGND VPWR VPWR _06391_ sky130_fd_sc_hd__a31oi_2
X_15795_ Q_sin\[10\] _07458_ _00186_ VGND VGND VPWR VPWR _07459_ sky130_fd_sc_hd__mux2_1
X_14746_ _06313_ _06312_ _06294_ _06292_ VGND VGND VPWR VPWR _06315_ sky130_fd_sc_hd__o211ai_4
X_11958_ _03272_ _03273_ VGND VGND VPWR VPWR _03274_ sky130_fd_sc_hd__nor2_1
XFILLER_0_86_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10909_ _02127_ _02128_ VGND VGND VPWR VPWR _02135_ sky130_fd_sc_hd__nor2_1
X_14677_ _06237_ _06238_ VGND VGND VPWR VPWR _06239_ sky130_fd_sc_hd__and2b_1
X_11889_ _03195_ _03196_ _03197_ _03198_ VGND VGND VPWR VPWR _03199_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_104_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13628_ _05084_ _05095_ VGND VGND VPWR VPWR _05096_ sky130_fd_sc_hd__xor2_1
XFILLER_0_27_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16347_ clknet_4_15_0_clk _00060_ net342 VGND VGND VPWR VPWR D_cos\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_109_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13559_ net321 net167 _05018_ _05019_ VGND VGND VPWR VPWR _05021_ sky130_fd_sc_hd__nand4_2
XFILLER_0_82_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16278_ _07924_ _07981_ VGND VGND VPWR VPWR _07982_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15229_ _06732_ _06734_ _06733_ net652 VGND VGND VPWR VPWR _06842_ sky130_fd_sc_hd__a22o_1
XFILLER_0_140_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout129 net132 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__buf_4
XFILLER_0_38_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09721_ _00991_ _00992_ VGND VGND VPWR VPWR _00993_ sky130_fd_sc_hd__xor2_1
X_09652_ _00853_ _00924_ VGND VGND VPWR VPWR _00925_ sky130_fd_sc_hd__xor2_4
X_08603_ _06344_ _06454_ _06443_ VGND VGND VPWR VPWR _07173_ sky130_fd_sc_hd__o21ai_1
X_09583_ _00850_ _00856_ VGND VGND VPWR VPWR _00857_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_145_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08534_ _06377_ _06410_ VGND VGND VPWR VPWR _06421_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_54_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08465_ _05633_ _05644_ _05655_ VGND VGND VPWR VPWR _05666_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_64_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08396_ net554 net562 net407 net396 VGND VGND VPWR VPWR _04916_ sky130_fd_sc_hd__and4_1
XFILLER_0_73_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09017_ _00217_ _00231_ _00232_ _00235_ VGND VGND VPWR VPWR _00297_ sky130_fd_sc_hd__a31o_1
XFILLER_0_60_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout630 net845 VGND VGND VPWR VPWR net630 sky130_fd_sc_hd__clkbuf_4
Xfanout641 net644 VGND VGND VPWR VPWR net641 sky130_fd_sc_hd__clkbuf_2
X_09919_ _01186_ _01187_ VGND VGND VPWR VPWR _01188_ sky130_fd_sc_hd__xor2_1
Xfanout652 net653 VGND VGND VPWR VPWR net652 sky130_fd_sc_hd__buf_6
Xfanout663 net895 VGND VGND VPWR VPWR net663 sky130_fd_sc_hd__buf_2
Xfanout674 net679 VGND VGND VPWR VPWR net674 sky130_fd_sc_hd__clkbuf_4
Xfanout685 net688 VGND VGND VPWR VPWR net685 sky130_fd_sc_hd__clkbuf_2
Xfanout696 net21 VGND VGND VPWR VPWR net696 sky130_fd_sc_hd__clkbuf_2
X_12930_ _04245_ _04333_ _04334_ _04335_ VGND VGND VPWR VPWR _04336_ sky130_fd_sc_hd__o211a_1
X_12861_ net767 net293 net283 net775 VGND VGND VPWR VPWR _04260_ sky130_fd_sc_hd__a22oi_1
X_14600_ _06145_ _06153_ VGND VGND VPWR VPWR _06154_ sky130_fd_sc_hd__nand2_1
X_11812_ _03112_ _03113_ _03114_ VGND VGND VPWR VPWR _03115_ sky130_fd_sc_hd__nand3_2
X_15580_ net193 net872 _07142_ _07141_ VGND VGND VPWR VPWR _07224_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_96_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12792_ _04177_ net869 _04183_ VGND VGND VPWR VPWR _04184_ sky130_fd_sc_hd__nand3_2
XFILLER_0_95_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14531_ _05985_ _05987_ _05986_ VGND VGND VPWR VPWR _06078_ sky130_fd_sc_hd__o21bai_1
X_11743_ _02948_ _02965_ VGND VGND VPWR VPWR _03041_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14462_ _05998_ _06001_ VGND VGND VPWR VPWR _06002_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11674_ _02948_ _02965_ VGND VGND VPWR VPWR _02966_ sky130_fd_sc_hd__xor2_2
X_16201_ net253 net638 net629 net262 VGND VGND VPWR VPWR _07898_ sky130_fd_sc_hd__a22o_1
X_13413_ _04775_ _04777_ VGND VGND VPWR VPWR _04862_ sky130_fd_sc_hd__or2_1
X_10625_ _01641_ _01646_ _01658_ VGND VGND VPWR VPWR _01851_ sky130_fd_sc_hd__or3_1
X_14393_ _05923_ _05924_ _05925_ VGND VGND VPWR VPWR _05927_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_36_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16132_ _07692_ _07698_ _07764_ _07823_ VGND VGND VPWR VPWR _07824_ sky130_fd_sc_hd__o31ai_4
X_10556_ _01765_ _01766_ _01780_ VGND VGND VPWR VPWR _01782_ sky130_fd_sc_hd__nand3_2
XFILLER_0_107_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13344_ _04701_ _04706_ VGND VGND VPWR VPWR _04787_ sky130_fd_sc_hd__and2_1
XFILLER_0_59_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16063_ _07747_ _07732_ VGND VGND VPWR VPWR _07750_ sky130_fd_sc_hd__and2b_1
X_10487_ _01702_ _01700_ _01701_ VGND VGND VPWR VPWR _01713_ sky130_fd_sc_hd__or3_1
X_13275_ net204 _04710_ _04711_ VGND VGND VPWR VPWR _04712_ sky130_fd_sc_hd__a21bo_1
X_15014_ net276 net584 VGND VGND VPWR VPWR _06608_ sky130_fd_sc_hd__and2_1
X_12226_ _03563_ _03564_ VGND VGND VPWR VPWR _03565_ sky130_fd_sc_hd__xnor2_1
X_12157_ net511 _00192_ VGND VGND VPWR VPWR _03490_ sky130_fd_sc_hd__nor2_1
X_11108_ _02347_ _02348_ VGND VGND VPWR VPWR _02349_ sky130_fd_sc_hd__xnor2_2
X_12088_ _03413_ _03414_ VGND VGND VPWR VPWR _03415_ sky130_fd_sc_hd__nor2_1
X_15916_ _07588_ _07589_ VGND VGND VPWR VPWR _07590_ sky130_fd_sc_hd__xnor2_1
X_11039_ _02271_ _02272_ _01816_ _01818_ VGND VGND VPWR VPWR _02274_ sky130_fd_sc_hd__o211ai_2
X_15847_ _07425_ _07428_ _07426_ VGND VGND VPWR VPWR _07515_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_59_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15778_ _07437_ _07438_ VGND VGND VPWR VPWR _07440_ sky130_fd_sc_hd__or2_1
XFILLER_0_115_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14729_ _06269_ _06282_ _06294_ _06295_ VGND VGND VPWR VPWR _06296_ sky130_fd_sc_hd__o211a_2
XFILLER_0_74_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08250_ net686 net526 net437 net695 VGND VGND VPWR VPWR _03322_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_145_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08181_ net595 net603 net352 net505 VGND VGND VPWR VPWR _02572_ sky130_fd_sc_hd__and4_1
XFILLER_0_61_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09704_ _00961_ _00963_ VGND VGND VPWR VPWR _00976_ sky130_fd_sc_hd__and2_1
X_09635_ _00906_ _00907_ VGND VGND VPWR VPWR _00908_ sky130_fd_sc_hd__nor2_1
X_09566_ net655 net493 VGND VGND VPWR VPWR _00840_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08517_ _06212_ _06223_ VGND VGND VPWR VPWR _06234_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09497_ net636 net356 VGND VGND VPWR VPWR _00772_ sky130_fd_sc_hd__nand2_1
XFILLER_0_148_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08448_ _05177_ _05166_ _05155_ VGND VGND VPWR VPWR _05481_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_93_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08379_ _04665_ _04698_ _04709_ net864 VGND VGND VPWR VPWR _04731_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_136_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10410_ net771 net779 net354 net507 VGND VGND VPWR VPWR _01636_ sky130_fd_sc_hd__and4_1
XFILLER_0_150_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11390_ net232 _02542_ _02543_ _02544_ VGND VGND VPWR VPWR _02656_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10341_ net132 _01572_ _01573_ _01574_ VGND VGND VPWR VPWR _00050_ sky130_fd_sc_hd__a31o_1
XFILLER_0_131_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13060_ _04474_ _04475_ _04459_ VGND VGND VPWR VPWR _04477_ sky130_fd_sc_hd__a21o_1
X_10272_ D_sin\[2\] _01514_ _01506_ _01502_ VGND VGND VPWR VPWR _01515_ sky130_fd_sc_hd__a211o_1
XFILLER_0_104_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12011_ _03325_ _03330_ VGND VGND VPWR VPWR _03331_ sky130_fd_sc_hd__xnor2_1
Xfanout460 net464 VGND VGND VPWR VPWR net460 sky130_fd_sc_hd__clkbuf_4
Xfanout471 net472 VGND VGND VPWR VPWR net471 sky130_fd_sc_hd__clkbuf_2
Xfanout482 net43 VGND VGND VPWR VPWR net482 sky130_fd_sc_hd__clkbuf_8
Xfanout493 net496 VGND VGND VPWR VPWR net493 sky130_fd_sc_hd__clkbuf_4
X_13962_ _05457_ _05458_ VGND VGND VPWR VPWR _05459_ sky130_fd_sc_hd__nor2_1
X_15701_ _07214_ _07354_ _07355_ VGND VGND VPWR VPWR _07356_ sky130_fd_sc_hd__o21a_1
X_12913_ _04278_ _04279_ _04314_ _04315_ VGND VGND VPWR VPWR _04318_ sky130_fd_sc_hd__a22o_4
X_13893_ _05364_ _05383_ VGND VGND VPWR VPWR _05385_ sky130_fd_sc_hd__xor2_1
X_15632_ _07060_ _07052_ _07218_ VGND VGND VPWR VPWR _07280_ sky130_fd_sc_hd__and3b_1
X_12844_ _04237_ _04241_ VGND VGND VPWR VPWR _04242_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15563_ _07099_ _07104_ VGND VGND VPWR VPWR _07206_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12775_ _04156_ _04162_ _04165_ VGND VGND VPWR VPWR _04166_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_29_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14514_ _06057_ _06059_ VGND VGND VPWR VPWR _06060_ sky130_fd_sc_hd__nor2_1
X_11726_ _03017_ _03019_ _03020_ VGND VGND VPWR VPWR _03022_ sky130_fd_sc_hd__nand3_1
X_15494_ _07127_ _07128_ _07130_ VGND VGND VPWR VPWR _07131_ sky130_fd_sc_hd__nand3_1
XFILLER_0_138_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14445_ _05979_ _05982_ _05980_ VGND VGND VPWR VPWR _05984_ sky130_fd_sc_hd__a21o_1
XFILLER_0_83_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11657_ _02864_ _02870_ VGND VGND VPWR VPWR _02947_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10608_ net744 net390 _01614_ _01615_ VGND VGND VPWR VPWR _01834_ sky130_fd_sc_hd__o2bb2a_1
X_14376_ net326 net687 net696 net241 VGND VGND VPWR VPWR _05908_ sky130_fd_sc_hd__a22o_1
X_11588_ _02862_ _02871_ VGND VGND VPWR VPWR _02872_ sky130_fd_sc_hd__xor2_2
XFILLER_0_141_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16115_ _07653_ _07805_ VGND VGND VPWR VPWR _07806_ sky130_fd_sc_hd__xnor2_1
X_13327_ _04766_ _04767_ VGND VGND VPWR VPWR _04768_ sky130_fd_sc_hd__nor2_1
XFILLER_0_134_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10539_ _01748_ _01753_ VGND VGND VPWR VPWR _01765_ sky130_fd_sc_hd__or2b_1
X_16046_ _07704_ _07729_ VGND VGND VPWR VPWR _07731_ sky130_fd_sc_hd__nor2_1
XFILLER_0_110_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13258_ _04690_ _04691_ _04682_ VGND VGND VPWR VPWR _04693_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_86_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12209_ _03538_ _03545_ VGND VGND VPWR VPWR _03546_ sky130_fd_sc_hd__xnor2_1
X_13189_ _04498_ _04507_ _04506_ VGND VGND VPWR VPWR _04618_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_126_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09420_ net646 net356 _00694_ _00695_ VGND VGND VPWR VPWR _00696_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_149_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09351_ net658 net356 _00626_ _00627_ VGND VGND VPWR VPWR _00628_ sky130_fd_sc_hd__a22o_1
XFILLER_0_87_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08302_ net583 net593 net489 net479 VGND VGND VPWR VPWR _03888_ sky130_fd_sc_hd__and4_1
XFILLER_0_19_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09282_ _00464_ _00392_ VGND VGND VPWR VPWR _00560_ sky130_fd_sc_hd__or2b_1
XFILLER_0_117_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08233_ _03105_ _03116_ _03127_ VGND VGND VPWR VPWR _03138_ sky130_fd_sc_hd__or3_4
XFILLER_0_51_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08164_ net595 net497 VGND VGND VPWR VPWR _02386_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_10_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08997_ _08141_ _00195_ _00276_ _00277_ VGND VGND VPWR VPWR _00278_ sky130_fd_sc_hd__o211a_1
X_09618_ _00788_ _00802_ _00803_ VGND VGND VPWR VPWR _00892_ sky130_fd_sc_hd__and3_1
X_10890_ _02108_ _02107_ VGND VGND VPWR VPWR _02116_ sky130_fd_sc_hd__or2b_1
XFILLER_0_66_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09549_ _00819_ _00823_ VGND VGND VPWR VPWR _00824_ sky130_fd_sc_hd__xor2_1
XFILLER_0_93_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12560_ _03927_ _03928_ VGND VGND VPWR VPWR _03929_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_26_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11511_ _02786_ _02787_ VGND VGND VPWR VPWR _02788_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_135_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12491_ _03849_ _03852_ VGND VGND VPWR VPWR _03853_ sky130_fd_sc_hd__nand2_1
XFILLER_0_124_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14230_ D_sin\[16\] _05749_ _05626_ VGND VGND VPWR VPWR _05750_ sky130_fd_sc_hd__mux2_1
X_11442_ _02712_ VGND VGND VPWR VPWR _00063_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_150_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11373_ net614 net349 net509 net705 VGND VGND VPWR VPWR _02638_ sky130_fd_sc_hd__a22o_1
X_14161_ _05672_ _05673_ _05609_ _05674_ VGND VGND VPWR VPWR _05675_ sky130_fd_sc_hd__a211o_1
XFILLER_0_132_850 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10324_ net923 _01559_ net129 VGND VGND VPWR VPWR _01560_ sky130_fd_sc_hd__mux2_1
X_13112_ D_sin\[2\] _04533_ _03242_ VGND VGND VPWR VPWR _04534_ sky130_fd_sc_hd__mux2_1
X_14092_ net298 net138 _05526_ VGND VGND VPWR VPWR _05600_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_131_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10255_ Q_cos\[1\] D_sin\[1\] VGND VGND VPWR VPWR _01500_ sky130_fd_sc_hd__or2b_1
X_13043_ _04384_ _04391_ _04390_ VGND VGND VPWR VPWR _04459_ sky130_fd_sc_hd__a21o_1
XFILLER_0_147_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10186_ _01439_ _01440_ VGND VGND VPWR VPWR _01441_ sky130_fd_sc_hd__or2_1
XFILLER_0_100_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14994_ _06501_ _06566_ _06567_ VGND VGND VPWR VPWR _06586_ sky130_fd_sc_hd__nand3_2
Xfanout290 net62 VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__buf_4
X_13945_ _05356_ _05344_ _05345_ VGND VGND VPWR VPWR _05441_ sky130_fd_sc_hd__or3_1
X_13876_ _05365_ _05257_ VGND VGND VPWR VPWR _05366_ sky130_fd_sc_hd__or2_1
X_15615_ _07139_ _07167_ _07262_ VGND VGND VPWR VPWR _07263_ sky130_fd_sc_hd__a21o_1
XFILLER_0_9_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12827_ _04204_ _04205_ _04221_ VGND VGND VPWR VPWR _04223_ sky130_fd_sc_hd__nand3_2
XFILLER_0_29_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15546_ _07081_ _07179_ _07180_ VGND VGND VPWR VPWR _07187_ sky130_fd_sc_hd__or3_1
XFILLER_0_127_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12758_ _04145_ _04144_ _04146_ VGND VGND VPWR VPWR _04147_ sky130_fd_sc_hd__or3_1
XFILLER_0_112_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11709_ _03000_ _03001_ _02993_ VGND VGND VPWR VPWR _03003_ sky130_fd_sc_hd__a21o_1
X_15477_ _07109_ _07111_ VGND VGND VPWR VPWR _07112_ sky130_fd_sc_hd__xor2_2
XFILLER_0_71_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12689_ _04062_ _04070_ VGND VGND VPWR VPWR _04071_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_115_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14428_ _05961_ _05964_ VGND VGND VPWR VPWR _05965_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14359_ _05887_ _05888_ net300 net702 VGND VGND VPWR VPWR _05889_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_97_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08920_ net574 net459 VGND VGND VPWR VPWR _00201_ sky130_fd_sc_hd__nand2_1
X_16029_ net247 net672 VGND VGND VPWR VPWR _07712_ sky130_fd_sc_hd__nand2_1
X_08851_ _00117_ _00131_ _00132_ VGND VGND VPWR VPWR _00133_ sky130_fd_sc_hd__nand3_1
X_08782_ net659 net413 VGND VGND VPWR VPWR _08093_ sky130_fd_sc_hd__nand2_1
X_09403_ _00576_ _00581_ VGND VGND VPWR VPWR _00679_ sky130_fd_sc_hd__nand2_1
XFILLER_0_94_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09334_ _00608_ _00609_ _00592_ VGND VGND VPWR VPWR _00611_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_75_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09265_ _00539_ _00540_ _00541_ VGND VGND VPWR VPWR _00543_ sky130_fd_sc_hd__nand3_2
XFILLER_0_118_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08216_ net593 net602 net489 net479 VGND VGND VPWR VPWR _02953_ sky130_fd_sc_hd__and4_1
X_09196_ _08037_ _00287_ _00470_ _00471_ _00474_ VGND VGND VPWR VPWR _00475_ sky130_fd_sc_hd__o311a_4
XFILLER_0_16_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08147_ net543 net552 net409 net398 VGND VGND VPWR VPWR _02201_ sky130_fd_sc_hd__and4_1
XFILLER_0_132_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10040_ net626 net465 _01239_ _01201_ VGND VGND VPWR VPWR _01307_ sky130_fd_sc_hd__a31o_1
X_11991_ _03219_ _03204_ VGND VGND VPWR VPWR _03310_ sky130_fd_sc_hd__and2b_1
X_13730_ _05205_ _05206_ VGND VGND VPWR VPWR _05207_ sky130_fd_sc_hd__nand2_1
X_10942_ _02168_ _02151_ VGND VGND VPWR VPWR _02169_ sky130_fd_sc_hd__nor2_1
XFILLER_0_98_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13661_ _05055_ _05039_ _05131_ VGND VGND VPWR VPWR _05132_ sky130_fd_sc_hd__a21oi_2
X_10873_ _02094_ _02098_ VGND VGND VPWR VPWR _02099_ sky130_fd_sc_hd__nor2_1
X_15400_ _07025_ _07026_ _07027_ VGND VGND VPWR VPWR _07028_ sky130_fd_sc_hd__a21o_1
X_12612_ _03938_ _03940_ _03939_ VGND VGND VPWR VPWR _03986_ sky130_fd_sc_hd__o21ba_1
X_16380_ clknet_4_4_0_clk _00093_ net336 VGND VGND VPWR VPWR D_sin\[16\] sky130_fd_sc_hd__dfrtp_4
X_13592_ _04963_ _04978_ VGND VGND VPWR VPWR _05056_ sky130_fd_sc_hd__and2_1
XFILLER_0_66_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15331_ net211 net201 net642 VGND VGND VPWR VPWR _06953_ sky130_fd_sc_hd__and3_1
X_12543_ net162 net310 net790 net805 VGND VGND VPWR VPWR _03911_ sky130_fd_sc_hd__and4_1
XFILLER_0_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15262_ _06875_ _06876_ _06765_ _06817_ VGND VGND VPWR VPWR _06878_ sky130_fd_sc_hd__a211o_1
X_12474_ net330 net245 net764 net772 VGND VGND VPWR VPWR _03835_ sky130_fd_sc_hd__and4_1
X_14213_ net422 _04539_ VGND VGND VPWR VPWR _05732_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11425_ _02691_ _02693_ _02565_ net121 VGND VGND VPWR VPWR _02695_ sky130_fd_sc_hd__a211o_1
XFILLER_0_112_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15193_ _06800_ _06801_ VGND VGND VPWR VPWR _06803_ sky130_fd_sc_hd__xnor2_1
XANTENNA_7 net60 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14144_ net288 net279 net137 net793 VGND VGND VPWR VPWR _05657_ sky130_fd_sc_hd__and4_1
XFILLER_0_6_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11356_ _02574_ _02575_ _02573_ VGND VGND VPWR VPWR _02619_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_132_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10307_ _01543_ _01544_ VGND VGND VPWR VPWR _01545_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14075_ _05577_ _05581_ VGND VGND VPWR VPWR _05582_ sky130_fd_sc_hd__xor2_1
XFILLER_0_67_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11287_ net318 net385 VGND VGND VPWR VPWR _02544_ sky130_fd_sc_hd__nand2_1
X_13026_ _04341_ _04342_ _04428_ _04429_ VGND VGND VPWR VPWR _04440_ sky130_fd_sc_hd__o211ai_4
X_10238_ Q_sin\[17\] D_cos\[17\] VGND VGND VPWR VPWR _01486_ sky130_fd_sc_hd__or2b_1
X_10169_ _01426_ VGND VGND VPWR VPWR _00026_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_107_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14977_ _06501_ _06566_ _06567_ VGND VGND VPWR VPWR _06568_ sky130_fd_sc_hd__and3_1
XFILLER_0_88_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer19 _06674_ VGND VGND VPWR VPWR net825 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_89_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13928_ net231 net299 _05333_ _05332_ VGND VGND VPWR VPWR _05422_ sky130_fd_sc_hd__a31o_1
XFILLER_0_88_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13859_ net167 net795 VGND VGND VPWR VPWR _05347_ sky130_fd_sc_hd__nand2_2
XFILLER_0_69_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15529_ _07066_ _07063_ VGND VGND VPWR VPWR _07169_ sky130_fd_sc_hd__and2b_1
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09050_ _00327_ _00328_ _00329_ VGND VGND VPWR VPWR _00330_ sky130_fd_sc_hd__nand3_1
Xrebuffer109 _04052_ VGND VGND VPWR VPWR net948 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09952_ _01120_ _01141_ _01220_ VGND VGND VPWR VPWR _01221_ sky130_fd_sc_hd__a21oi_1
X_08903_ _08128_ _00184_ VGND VGND VPWR VPWR _00185_ sky130_fd_sc_hd__xnor2_2
X_09883_ _01149_ _01152_ VGND VGND VPWR VPWR _01153_ sky130_fd_sc_hd__xor2_1
X_08834_ _08068_ _08070_ VGND VGND VPWR VPWR _00116_ sky130_fd_sc_hd__nand2_1
X_08765_ _08074_ _08075_ VGND VGND VPWR VPWR _08076_ sky130_fd_sc_hd__nand2_1
X_08696_ _08004_ _08007_ VGND VGND VPWR VPWR _08008_ sky130_fd_sc_hd__xor2_1
XFILLER_0_68_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09317_ net934 net484 net474 net530 VGND VGND VPWR VPWR _00594_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_48_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09248_ net650 net373 net364 net658 VGND VGND VPWR VPWR _00526_ sky130_fd_sc_hd__a22o_1
XFILLER_0_7_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09179_ _00456_ _00457_ VGND VGND VPWR VPWR _00458_ sky130_fd_sc_hd__xnor2_1
Xclkbuf_4_10_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_10_0_clk sky130_fd_sc_hd__clkbuf_8
X_11210_ _02351_ _02352_ _02458_ _02459_ VGND VGND VPWR VPWR _02460_ sky130_fd_sc_hd__a211o_1
X_12190_ _03524_ _03525_ VGND VGND VPWR VPWR _03526_ sky130_fd_sc_hd__xnor2_2
X_11141_ D_cos\[2\] _02384_ _01379_ VGND VGND VPWR VPWR _02385_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11072_ net747 net759 net481 VGND VGND VPWR VPWR _02309_ sky130_fd_sc_hd__and3_1
Xoutput88 net88 VGND VGND VPWR VPWR alpha[18] sky130_fd_sc_hd__clkbuf_4
Xoutput99 net99 VGND VGND VPWR VPWR beta[10] sky130_fd_sc_hd__clkbuf_4
X_10023_ _01285_ _01284_ VGND VGND VPWR VPWR _01290_ sky130_fd_sc_hd__and2b_1
X_14900_ _06483_ VGND VGND VPWR VPWR _00096_ sky130_fd_sc_hd__clkbuf_1
X_15880_ _07284_ _07491_ VGND VGND VPWR VPWR _07550_ sky130_fd_sc_hd__nor2_1
X_14831_ _06393_ _06394_ _06392_ VGND VGND VPWR VPWR _06408_ sky130_fd_sc_hd__o21ai_1
X_14762_ net212 net202 net588 net597 VGND VGND VPWR VPWR _06332_ sky130_fd_sc_hd__and4_1
X_11974_ net703 net444 VGND VGND VPWR VPWR _03292_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13713_ _05119_ _05103_ VGND VGND VPWR VPWR _05189_ sky130_fd_sc_hd__or2b_1
X_10925_ _02150_ _02132_ _02114_ VGND VGND VPWR VPWR _02151_ sky130_fd_sc_hd__o21ai_1
X_14693_ net212 net202 net569 net579 VGND VGND VPWR VPWR _06257_ sky130_fd_sc_hd__and4_1
XFILLER_0_86_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13644_ net513 net299 VGND VGND VPWR VPWR _05114_ sky130_fd_sc_hd__nand2_1
X_10856_ _02079_ _02081_ VGND VGND VPWR VPWR _02082_ sky130_fd_sc_hd__or2_1
XFILLER_0_27_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16363_ clknet_4_4_0_clk _00076_ net335 VGND VGND VPWR VPWR D_cos\[18\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_137_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13575_ _04958_ _05038_ VGND VGND VPWR VPWR _05039_ sky130_fd_sc_hd__nand2_1
X_10787_ net752 net439 VGND VGND VPWR VPWR _02013_ sky130_fd_sc_hd__nand2_1
X_15314_ _06930_ _06931_ _06932_ VGND VGND VPWR VPWR _06935_ sky130_fd_sc_hd__a21o_1
X_12526_ _03884_ _03887_ _03891_ VGND VGND VPWR VPWR _03892_ sky130_fd_sc_hd__a21bo_1
X_16294_ clknet_4_9_0_clk _00007_ net340 VGND VGND VPWR VPWR Q_cos\[7\] sky130_fd_sc_hd__dfrtp_1
X_15245_ _04715_ _06858_ _06859_ VGND VGND VPWR VPWR _06860_ sky130_fd_sc_hd__nand3_2
X_12457_ _03769_ _03773_ _03814_ _03815_ VGND VGND VPWR VPWR _03816_ sky130_fd_sc_hd__o211a_1
XFILLER_0_124_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11408_ _02673_ _02674_ _02669_ VGND VGND VPWR VPWR _02676_ sky130_fd_sc_hd__a21o_1
XFILLER_0_124_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15176_ _06783_ _06784_ VGND VGND VPWR VPWR _06785_ sky130_fd_sc_hd__nor2_1
XFILLER_0_111_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12388_ net189 net179 net781 net789 VGND VGND VPWR VPWR _03740_ sky130_fd_sc_hd__and4_1
X_14127_ net422 net249 _05637_ VGND VGND VPWR VPWR _05638_ sky130_fd_sc_hd__a21oi_1
X_11339_ _02599_ _02600_ VGND VGND VPWR VPWR _02601_ sky130_fd_sc_hd__xor2_1
X_14058_ _05498_ _05499_ _05562_ VGND VGND VPWR VPWR _05563_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_118_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13009_ _04419_ _04420_ _04314_ _04316_ VGND VGND VPWR VPWR _04422_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_27_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08550_ _06530_ _06574_ _06584_ VGND VGND VPWR VPWR _06595_ sky130_fd_sc_hd__nand3_2
XFILLER_0_89_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08481_ _05308_ _05329_ _05318_ VGND VGND VPWR VPWR _05839_ sky130_fd_sc_hd__o21a_1
XFILLER_0_134_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09102_ _00379_ _00381_ VGND VGND VPWR VPWR _00382_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_17_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09033_ _00310_ _00312_ VGND VGND VPWR VPWR _00313_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_26_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout801 net806 VGND VGND VPWR VPWR net801 sky130_fd_sc_hd__clkbuf_4
X_09935_ net635 net465 VGND VGND VPWR VPWR _01204_ sky130_fd_sc_hd__nand2_1
X_09866_ _01132_ _01135_ VGND VGND VPWR VPWR _01136_ sky130_fd_sc_hd__and2_1
X_08817_ _05992_ _08031_ _08035_ VGND VGND VPWR VPWR _08127_ sky130_fd_sc_hd__o21ai_1
X_09797_ _00764_ _01000_ VGND VGND VPWR VPWR _01068_ sky130_fd_sc_hd__or2_1
X_08748_ _08057_ _08058_ VGND VGND VPWR VPWR _08059_ sky130_fd_sc_hd__nor2_1
X_08679_ _07987_ _07889_ VGND VGND VPWR VPWR _07991_ sky130_fd_sc_hd__or2_1
XFILLER_0_67_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10710_ _01934_ _01935_ VGND VGND VPWR VPWR _01936_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11690_ D_cos\[8\] _02982_ _01379_ VGND VGND VPWR VPWR _02983_ sky130_fd_sc_hd__mux2_1
XFILLER_0_95_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10641_ net753 net389 VGND VGND VPWR VPWR _01867_ sky130_fd_sc_hd__nand2_1
XFILLER_0_119_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13360_ _04793_ _04803_ VGND VGND VPWR VPWR _04804_ sky130_fd_sc_hd__xor2_1
X_10572_ net233 net522 net394 net616 VGND VGND VPWR VPWR _01798_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_118_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12311_ net313 _00193_ _03613_ _03612_ VGND VGND VPWR VPWR _03656_ sky130_fd_sc_hd__o31a_1
XFILLER_0_133_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13291_ _04708_ _04727_ _04728_ VGND VGND VPWR VPWR _04729_ sky130_fd_sc_hd__and3_1
XFILLER_0_106_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15030_ _06623_ _06624_ VGND VGND VPWR VPWR _06625_ sky130_fd_sc_hd__or2_1
X_12242_ _03514_ _03517_ _03579_ _03580_ VGND VGND VPWR VPWR _03582_ sky130_fd_sc_hd__a211oi_2
XPHY_EDGE_ROW_2_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12173_ _03353_ _03506_ VGND VGND VPWR VPWR _03508_ sky130_fd_sc_hd__xor2_1
XFILLER_0_102_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11124_ _02363_ _02364_ _02264_ _02331_ VGND VGND VPWR VPWR _02367_ sky130_fd_sc_hd__o211a_1
X_15932_ _07581_ _07582_ _07605_ VGND VGND VPWR VPWR _07607_ sky130_fd_sc_hd__nor3_1
X_11055_ net776 net471 _02215_ _02214_ VGND VGND VPWR VPWR _02291_ sky130_fd_sc_hd__a31o_1
X_10006_ _01271_ _01272_ VGND VGND VPWR VPWR _01274_ sky130_fd_sc_hd__or2_1
X_15863_ _07462_ _07443_ _07530_ _07531_ VGND VGND VPWR VPWR _07533_ sky130_fd_sc_hd__a211oi_1
X_14814_ net188 net700 VGND VGND VPWR VPWR _06390_ sky130_fd_sc_hd__nand2_1
X_15794_ _07374_ _07457_ VGND VGND VPWR VPWR _07458_ sky130_fd_sc_hd__xnor2_1
X_14745_ _06292_ _06294_ _06312_ _06313_ VGND VGND VPWR VPWR _06314_ sky130_fd_sc_hd__a211o_2
XPHY_EDGE_ROW_48_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11957_ net145 net495 _03269_ _03271_ VGND VGND VPWR VPWR _03273_ sky130_fd_sc_hd__and4_1
X_10908_ _02132_ _02133_ VGND VGND VPWR VPWR _02134_ sky130_fd_sc_hd__nor2_1
X_14676_ net212 net579 net588 net202 VGND VGND VPWR VPWR _06238_ sky130_fd_sc_hd__a22o_1
X_11888_ _03101_ _03124_ VGND VGND VPWR VPWR _03198_ sky130_fd_sc_hd__or2_1
XFILLER_0_67_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13627_ _05085_ _05094_ VGND VGND VPWR VPWR _05095_ sky130_fd_sc_hd__xor2_1
XFILLER_0_73_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10839_ _02059_ _02063_ _02060_ VGND VGND VPWR VPWR _02065_ sky130_fd_sc_hd__nand3_1
XFILLER_0_144_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16346_ clknet_4_15_0_clk _00059_ net343 VGND VGND VPWR VPWR D_cos\[1\] sky130_fd_sc_hd__dfrtp_1
X_13558_ net319 net167 _05018_ _05019_ VGND VGND VPWR VPWR _05020_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_132_Right_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12509_ _03771_ _03772_ _03770_ VGND VGND VPWR VPWR _03873_ sky130_fd_sc_hd__a21oi_1
X_16277_ _07980_ _07925_ _07649_ VGND VGND VPWR VPWR _07981_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_140_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13489_ _04942_ _04944_ VGND VGND VPWR VPWR _04945_ sky130_fd_sc_hd__xor2_2
XFILLER_0_112_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15228_ _06755_ _06757_ VGND VGND VPWR VPWR _06841_ sky130_fd_sc_hd__nand2_1
XFILLER_0_120_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15159_ net931 _06764_ _06656_ _06731_ VGND VGND VPWR VPWR _06766_ sky130_fd_sc_hd__o211a_1
XFILLER_0_140_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09720_ net645 net493 _00913_ _00912_ VGND VGND VPWR VPWR _00992_ sky130_fd_sc_hd__a31o_1
X_09651_ net622 net357 VGND VGND VPWR VPWR _00924_ sky130_fd_sc_hd__nand2_2
X_08602_ _06344_ _06443_ _06454_ VGND VGND VPWR VPWR _07162_ sky130_fd_sc_hd__or3_4
X_09582_ _00768_ _00855_ VGND VGND VPWR VPWR _00856_ sky130_fd_sc_hd__xor2_1
X_08533_ _06388_ _06399_ VGND VGND VPWR VPWR _06410_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08464_ net591 net595 net377 net368 VGND VGND VPWR VPWR _05655_ sky130_fd_sc_hd__and4_1
XFILLER_0_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08395_ net554 net407 net396 net562 VGND VGND VPWR VPWR _04905_ sky130_fd_sc_hd__a22o_1
XFILLER_0_147_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09016_ _00207_ _00208_ _00295_ VGND VGND VPWR VPWR _00296_ sky130_fd_sc_hd__a21o_1
XFILLER_0_131_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout620 net625 VGND VGND VPWR VPWR net620 sky130_fd_sc_hd__buf_2
Xfanout631 net845 VGND VGND VPWR VPWR net631 sky130_fd_sc_hd__buf_4
X_09918_ _01123_ _01126_ _01124_ VGND VGND VPWR VPWR _01187_ sky130_fd_sc_hd__o21ba_1
Xfanout642 net644 VGND VGND VPWR VPWR net642 sky130_fd_sc_hd__buf_8
Xfanout653 net26 VGND VGND VPWR VPWR net653 sky130_fd_sc_hd__buf_6
Xfanout664 net665 VGND VGND VPWR VPWR net664 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_95_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout675 net679 VGND VGND VPWR VPWR net675 sky130_fd_sc_hd__clkbuf_4
Xfanout686 net688 VGND VGND VPWR VPWR net686 sky130_fd_sc_hd__buf_6
X_09849_ _01056_ _01059_ VGND VGND VPWR VPWR _01119_ sky130_fd_sc_hd__or2_1
Xfanout697 net698 VGND VGND VPWR VPWR net697 sky130_fd_sc_hd__clkbuf_4
X_12860_ _04198_ _04190_ VGND VGND VPWR VPWR _04259_ sky130_fd_sc_hd__or2b_4
X_11811_ _03017_ _03020_ _03019_ VGND VGND VPWR VPWR _03114_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_96_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12791_ _04179_ _04182_ VGND VGND VPWR VPWR _04183_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_139_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14530_ net169 net559 _06001_ _06000_ VGND VGND VPWR VPWR _06077_ sky130_fd_sc_hd__a31o_1
XFILLER_0_96_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11742_ _02915_ _02917_ _03038_ VGND VGND VPWR VPWR _03039_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_49_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14461_ _05999_ _06000_ VGND VGND VPWR VPWR _06001_ sky130_fd_sc_hd__nor2_1
XFILLER_0_50_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11673_ _02954_ _02963_ VGND VGND VPWR VPWR _02965_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_48_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16200_ net253 net628 VGND VGND VPWR VPWR _07897_ sky130_fd_sc_hd__nand2_1
X_13412_ _04762_ _04782_ _04781_ VGND VGND VPWR VPWR _04860_ sky130_fd_sc_hd__a21o_1
X_10624_ _01762_ _01825_ _01848_ _01849_ VGND VGND VPWR VPWR _01850_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_107_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14392_ net326 net241 net696 net536 VGND VGND VPWR VPWR _05925_ sky130_fd_sc_hd__and4_1
XFILLER_0_52_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16131_ _07689_ _07701_ _07763_ VGND VGND VPWR VPWR _07823_ sky130_fd_sc_hd__a21bo_1
X_13343_ _04682_ _04691_ _04690_ VGND VGND VPWR VPWR _04786_ sky130_fd_sc_hd__a21boi_2
X_10555_ _01765_ _01766_ _01780_ VGND VGND VPWR VPWR _01781_ sky130_fd_sc_hd__a21o_1
X_16062_ _07732_ _07747_ VGND VGND VPWR VPWR _07748_ sky130_fd_sc_hd__and2b_1
X_13274_ net234 net204 net153 net214 VGND VGND VPWR VPWR _04711_ sky130_fd_sc_hd__a22o_1
X_10486_ _01705_ _01706_ _01711_ VGND VGND VPWR VPWR _01712_ sky130_fd_sc_hd__nand3_2
XFILLER_0_20_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15013_ net566 _06604_ _06605_ VGND VGND VPWR VPWR _06607_ sky130_fd_sc_hd__a21bo_1
X_12225_ net313 net443 VGND VGND VPWR VPWR _03564_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12156_ _03486_ _03488_ VGND VGND VPWR VPWR _03489_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_20_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11107_ net515 net386 VGND VGND VPWR VPWR _02348_ sky130_fd_sc_hd__nand2_1
X_12087_ net313 net422 net460 net450 VGND VGND VPWR VPWR _03414_ sky130_fd_sc_hd__and4_1
X_15915_ net247 net690 VGND VGND VPWR VPWR _07589_ sky130_fd_sc_hd__nand2_1
X_11038_ _01816_ _01818_ _02271_ _02272_ VGND VGND VPWR VPWR _02273_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_56_Left_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15846_ _07507_ _07513_ VGND VGND VPWR VPWR _07514_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_91_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15777_ _07437_ _07438_ VGND VGND VPWR VPWR _07439_ sky130_fd_sc_hd__nand2_1
X_12989_ net321 net225 VGND VGND VPWR VPWR _04400_ sky130_fd_sc_hd__nand2_1
X_14728_ _06292_ _06293_ _06288_ VGND VGND VPWR VPWR _06295_ sky130_fd_sc_hd__a21o_1
X_14659_ _06196_ _06217_ _06218_ VGND VGND VPWR VPWR _06219_ sky130_fd_sc_hd__and3_1
XFILLER_0_7_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08180_ net603 net497 net949 _02452_ VGND VGND VPWR VPWR _02561_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_131_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16329_ clknet_4_8_0_clk _00042_ net346 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_6_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_65_Left_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09703_ _00965_ _00964_ VGND VGND VPWR VPWR _00975_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_74_Left_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09634_ net654 net662 net483 net473 VGND VGND VPWR VPWR _00907_ sky130_fd_sc_hd__and4_1
XFILLER_0_78_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09565_ _00837_ _00838_ VGND VGND VPWR VPWR _00839_ sky130_fd_sc_hd__nor2_1
X_08516_ net568 net578 net407 net396 VGND VGND VPWR VPWR _06223_ sky130_fd_sc_hd__and4_1
X_09496_ net630 _00769_ _00770_ VGND VGND VPWR VPWR _00771_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_37_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08447_ _05177_ _05155_ _05166_ VGND VGND VPWR VPWR _05471_ sky130_fd_sc_hd__or3_1
XFILLER_0_92_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_83_Left_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08378_ _03420_ _03431_ _03442_ VGND VGND VPWR VPWR _04720_ sky130_fd_sc_hd__and3_1
XFILLER_0_150_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10340_ net129 net101 VGND VGND VPWR VPWR _01574_ sky130_fd_sc_hd__and2b_1
XFILLER_0_60_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10271_ Q_cos\[2\] VGND VGND VPWR VPWR _01514_ sky130_fd_sc_hd__inv_2
XFILLER_0_131_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12010_ _03328_ _03329_ VGND VGND VPWR VPWR _03330_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_92_Left_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout450 net454 VGND VGND VPWR VPWR net450 sky130_fd_sc_hd__clkbuf_4
Xfanout461 net464 VGND VGND VPWR VPWR net461 sky130_fd_sc_hd__buf_2
Xfanout472 net44 VGND VGND VPWR VPWR net472 sky130_fd_sc_hd__buf_4
X_13961_ _05375_ _05374_ VGND VGND VPWR VPWR _05458_ sky130_fd_sc_hd__and2b_1
Xfanout483 net484 VGND VGND VPWR VPWR net483 sky130_fd_sc_hd__clkbuf_4
Xfanout494 net496 VGND VGND VPWR VPWR net494 sky130_fd_sc_hd__clkbuf_2
X_15700_ _07261_ _07263_ VGND VGND VPWR VPWR _07355_ sky130_fd_sc_hd__nand2_1
X_12912_ _04278_ net903 _04314_ _04315_ VGND VGND VPWR VPWR _04316_ sky130_fd_sc_hd__nand4_4
X_13892_ _05366_ _05382_ VGND VGND VPWR VPWR _05383_ sky130_fd_sc_hd__xnor2_2
X_15631_ _07060_ _07219_ VGND VGND VPWR VPWR _07279_ sky130_fd_sc_hd__and2_2
X_12843_ _04039_ _04238_ _04239_ VGND VGND VPWR VPWR _04241_ sky130_fd_sc_hd__o21ai_1
X_15562_ _07202_ _07203_ VGND VGND VPWR VPWR _07204_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12774_ _04164_ _04149_ _04157_ VGND VGND VPWR VPWR _04165_ sky130_fd_sc_hd__nor3_1
X_14513_ net273 net601 VGND VGND VPWR VPWR _06059_ sky130_fd_sc_hd__and2_1
XFILLER_0_28_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11725_ _03017_ _03019_ _03020_ VGND VGND VPWR VPWR _03021_ sky130_fd_sc_hd__a21o_1
XFILLER_0_138_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15493_ _07025_ _07027_ _07026_ VGND VGND VPWR VPWR _07130_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_84_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14444_ _05979_ _05980_ _05982_ VGND VGND VPWR VPWR _05983_ sky130_fd_sc_hd__nand3_1
XFILLER_0_9_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11656_ _02836_ _02845_ _02843_ VGND VGND VPWR VPWR _02946_ sky130_fd_sc_hd__a21o_1
XFILLER_0_126_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10607_ _01827_ _01828_ _01832_ VGND VGND VPWR VPWR _01833_ sky130_fd_sc_hd__a21o_1
XFILLER_0_142_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14375_ net222 net537 VGND VGND VPWR VPWR _05907_ sky130_fd_sc_hd__and2_1
XFILLER_0_107_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11587_ _02864_ _02870_ VGND VGND VPWR VPWR _02871_ sky130_fd_sc_hd__xor2_2
XFILLER_0_135_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16114_ _07794_ _07804_ VGND VGND VPWR VPWR _07805_ sky130_fd_sc_hd__xnor2_1
X_13326_ net748 net757 net268 net258 VGND VGND VPWR VPWR _04767_ sky130_fd_sc_hd__and4_1
X_10538_ _01679_ _01684_ VGND VGND VPWR VPWR _01764_ sky130_fd_sc_hd__and2_1
XFILLER_0_101_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16045_ _07704_ _07729_ VGND VGND VPWR VPWR _07730_ sky130_fd_sc_hd__and2_1
X_13257_ _04682_ _04690_ _04691_ VGND VGND VPWR VPWR _04692_ sky130_fd_sc_hd__and3_1
X_10469_ _01693_ _01694_ VGND VGND VPWR VPWR _01695_ sky130_fd_sc_hd__nor2_1
XFILLER_0_122_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12208_ _03353_ _03544_ VGND VGND VPWR VPWR _03545_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_20_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13188_ _04614_ _04615_ _04606_ VGND VGND VPWR VPWR _04617_ sky130_fd_sc_hd__a21o_1
X_12139_ next_state _03469_ _03470_ VGND VGND VPWR VPWR _00072_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_19_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15829_ _07493_ _07494_ VGND VGND VPWR VPWR _07495_ sky130_fd_sc_hd__nor2_1
XFILLER_0_149_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09350_ net650 net640 net373 net364 VGND VGND VPWR VPWR _00627_ sky130_fd_sc_hd__nand4_2
X_08301_ net583 net489 net479 net593 VGND VGND VPWR VPWR _03877_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_145_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09281_ _00482_ _00558_ VGND VGND VPWR VPWR _00559_ sky130_fd_sc_hd__xor2_1
XFILLER_0_7_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08232_ net667 net526 net433 net677 VGND VGND VPWR VPWR _03127_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_144_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08163_ _02354_ _02365_ VGND VGND VPWR VPWR _02376_ sky130_fd_sc_hd__or2b_1
XFILLER_0_132_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08996_ _00274_ _00275_ _00196_ _00175_ VGND VGND VPWR VPWR _00277_ sky130_fd_sc_hd__a211o_1
X_09617_ _00889_ _00890_ VGND VGND VPWR VPWR _00891_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_97_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09548_ _00475_ _00656_ _00820_ _00822_ VGND VGND VPWR VPWR _00823_ sky130_fd_sc_hd__o31a_4
XFILLER_0_148_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09479_ _00752_ _00753_ VGND VGND VPWR VPWR _00754_ sky130_fd_sc_hd__nor2_1
XFILLER_0_108_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11510_ _02653_ _02686_ _02685_ VGND VGND VPWR VPWR _02787_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_136_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12490_ net223 net788 _03850_ _03851_ VGND VGND VPWR VPWR _03852_ sky130_fd_sc_hd__a31o_1
XFILLER_0_65_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11441_ D_cos\[5\] _02711_ _01379_ VGND VGND VPWR VPWR _02712_ sky130_fd_sc_hd__mux2_1
XFILLER_0_135_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14160_ _05610_ _05588_ _05589_ VGND VGND VPWR VPWR _05674_ sky130_fd_sc_hd__nor3_1
X_11372_ _02634_ _02635_ VGND VGND VPWR VPWR _02636_ sky130_fd_sc_hd__xor2_1
XFILLER_0_150_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13111_ _04439_ _04532_ VGND VGND VPWR VPWR _04533_ sky130_fd_sc_hd__xnor2_1
X_10323_ _01557_ _01558_ VGND VGND VPWR VPWR _01559_ sky130_fd_sc_hd__xnor2_1
X_14091_ net298 net795 VGND VGND VPWR VPWR _05599_ sky130_fd_sc_hd__nand2_1
X_13042_ _04373_ _04375_ VGND VGND VPWR VPWR _04457_ sky130_fd_sc_hd__nand2_1
X_10254_ _01498_ _01499_ net133 net917 VGND VGND VPWR VPWR _00038_ sky130_fd_sc_hd__o2bb2a_1
X_10185_ D_cos\[10\] Q_sin\[10\] VGND VGND VPWR VPWR _01440_ sky130_fd_sc_hd__and2b_1
X_14993_ net120 _06581_ VGND VGND VPWR VPWR _06585_ sky130_fd_sc_hd__nor2_1
Xfanout280 net281 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__buf_2
Xfanout291 net62 VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__clkbuf_4
X_13944_ _05354_ _05355_ VGND VGND VPWR VPWR _05440_ sky130_fd_sc_hd__or2b_1
XFILLER_0_89_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13875_ _05238_ _05239_ _05254_ VGND VGND VPWR VPWR _05365_ sky130_fd_sc_hd__a21oi_1
X_15614_ _07164_ _07166_ VGND VGND VPWR VPWR _07262_ sky130_fd_sc_hd__nor2_1
X_12826_ _04204_ _04205_ _04221_ VGND VGND VPWR VPWR _04222_ sky130_fd_sc_hd__a21o_2
XFILLER_0_8_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15545_ next_state _07183_ _07185_ _07186_ VGND VGND VPWR VPWR _00103_ sky130_fd_sc_hd__a31o_1
X_12757_ _04078_ _04143_ _04006_ _04142_ VGND VGND VPWR VPWR _04146_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_127_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11708_ _02993_ _03000_ _03001_ VGND VGND VPWR VPWR _03002_ sky130_fd_sc_hd__nand3_1
XFILLER_0_139_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15476_ _07000_ _07005_ _07110_ VGND VGND VPWR VPWR _07111_ sky130_fd_sc_hd__a21o_1
XFILLER_0_126_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12688_ _04063_ _04069_ VGND VGND VPWR VPWR _04070_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_115_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14427_ _05962_ _05963_ VGND VGND VPWR VPWR _05964_ sky130_fd_sc_hd__nor2_1
XFILLER_0_112_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11639_ _02856_ _02926_ VGND VGND VPWR VPWR _02927_ sky130_fd_sc_hd__nand2_1
XFILLER_0_127_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14358_ net160 net599 net607 net309 VGND VGND VPWR VPWR _05888_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_108_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13309_ _04642_ VGND VGND VPWR VPWR _04749_ sky130_fd_sc_hd__inv_2
XFILLER_0_123_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14289_ next_state _05812_ _05813_ VGND VGND VPWR VPWR _00094_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_150_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16028_ _07709_ _07710_ VGND VGND VPWR VPWR _07711_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_882 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08850_ _00129_ _00130_ _00122_ VGND VGND VPWR VPWR _00132_ sky130_fd_sc_hd__a21o_1
X_08781_ _08088_ _08091_ VGND VGND VPWR VPWR _08092_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_46_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09402_ _00676_ _00677_ VGND VGND VPWR VPWR _00678_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_149_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09333_ _00592_ _00608_ _00609_ VGND VGND VPWR VPWR _00610_ sky130_fd_sc_hd__and3_1
XFILLER_0_1_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09264_ _00539_ _00540_ _00541_ VGND VGND VPWR VPWR _00542_ sky130_fd_sc_hd__a21o_1
XFILLER_0_63_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08215_ net595 net489 net478 net602 VGND VGND VPWR VPWR _02942_ sky130_fd_sc_hd__a22oi_2
X_09195_ _00284_ _00472_ _00473_ VGND VGND VPWR VPWR _00474_ sky130_fd_sc_hd__a21o_1
XFILLER_0_15_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08146_ _02181_ VGND VGND VPWR VPWR next_state sky130_fd_sc_hd__buf_4
XFILLER_0_114_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08979_ _00256_ _00257_ _00258_ VGND VGND VPWR VPWR _00260_ sky130_fd_sc_hd__a21o_1
X_11990_ _03307_ _03308_ VGND VGND VPWR VPWR _03309_ sky130_fd_sc_hd__xnor2_1
X_10941_ _02095_ _02167_ VGND VGND VPWR VPWR _02168_ sky130_fd_sc_hd__xnor2_1
X_13660_ _05058_ _05130_ VGND VGND VPWR VPWR _05131_ sky130_fd_sc_hd__xnor2_1
X_10872_ net802 net389 _02093_ VGND VGND VPWR VPWR _02098_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_66_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12611_ _03979_ _03984_ VGND VGND VPWR VPWR _03985_ sky130_fd_sc_hd__xor2_1
XFILLER_0_94_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13591_ _05037_ _05035_ VGND VGND VPWR VPWR _05055_ sky130_fd_sc_hd__or2b_1
X_15330_ _06942_ _06951_ VGND VGND VPWR VPWR _06952_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12542_ _03787_ _03786_ VGND VGND VPWR VPWR _03909_ sky130_fd_sc_hd__or2b_1
XFILLER_0_54_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15261_ _06765_ _06817_ _06875_ _06876_ VGND VGND VPWR VPWR _06877_ sky130_fd_sc_hd__o211a_1
XFILLER_0_108_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12473_ net330 net764 net772 net245 VGND VGND VPWR VPWR _03834_ sky130_fd_sc_hd__a22oi_1
X_14212_ _05726_ _05729_ VGND VGND VPWR VPWR _05730_ sky130_fd_sc_hd__xnor2_1
X_11424_ _02565_ net121 _02691_ _02693_ VGND VGND VPWR VPWR _02694_ sky130_fd_sc_hd__o211ai_4
X_15192_ net251 net592 VGND VGND VPWR VPWR _06801_ sky130_fd_sc_hd__nand2_1
XANTENNA_8 net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14143_ net279 net137 net793 net288 VGND VGND VPWR VPWR _05656_ sky130_fd_sc_hd__a22oi_1
X_11355_ _02611_ _02617_ VGND VGND VPWR VPWR _02618_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_120_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10306_ Q_cos\[8\] D_sin\[8\] VGND VGND VPWR VPWR _01544_ sky130_fd_sc_hd__or2b_1
X_14074_ _05578_ _05580_ VGND VGND VPWR VPWR _05581_ sky130_fd_sc_hd__nor2_1
X_11286_ _02538_ _02540_ _02542_ net232 VGND VGND VPWR VPWR _02543_ sky130_fd_sc_hd__a22o_1
XFILLER_0_120_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13025_ _04432_ _04436_ VGND VGND VPWR VPWR _04439_ sky130_fd_sc_hd__nand2_1
X_10237_ D_cos\[17\] Q_sin\[17\] VGND VGND VPWR VPWR _01485_ sky130_fd_sc_hd__or2b_1
X_10168_ net95 _01425_ net135 VGND VGND VPWR VPWR _01426_ sky130_fd_sc_hd__mux2_1
XFILLER_0_83_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10099_ _01296_ _01364_ VGND VGND VPWR VPWR _01365_ sky130_fd_sc_hd__xor2_1
X_14976_ _06564_ net944 net831 net818 VGND VGND VPWR VPWR _06567_ sky130_fd_sc_hd__o211ai_2
X_13927_ _05419_ _05420_ VGND VGND VPWR VPWR _05421_ sky130_fd_sc_hd__nor2_1
X_13858_ _05260_ VGND VGND VPWR VPWR _05346_ sky130_fd_sc_hd__inv_2
XFILLER_0_123_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12809_ net906 _04200_ _04169_ _04099_ VGND VGND VPWR VPWR _04203_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_8_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13789_ _05165_ _05175_ _05270_ VGND VGND VPWR VPWR _05271_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_29_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15528_ _07139_ _07167_ VGND VGND VPWR VPWR _07168_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15459_ _07077_ _06995_ VGND VGND VPWR VPWR _07092_ sky130_fd_sc_hd__or2b_1
XFILLER_0_115_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09951_ _01140_ _01122_ VGND VGND VPWR VPWR _01220_ sky130_fd_sc_hd__and2b_1
XFILLER_0_40_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08902_ net808 _00183_ VGND VGND VPWR VPWR _00184_ sky130_fd_sc_hd__xor2_2
X_09882_ net493 _01150_ _01151_ VGND VGND VPWR VPWR _01152_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_57_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08833_ _08048_ _08142_ VGND VGND VPWR VPWR _00115_ sky130_fd_sc_hd__xor2_1
XFILLER_0_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08764_ _08072_ _08073_ _08054_ _08055_ VGND VGND VPWR VPWR _08075_ sky130_fd_sc_hd__a211o_1
X_08695_ net701 net417 _08005_ _08006_ VGND VGND VPWR VPWR _08007_ sky130_fd_sc_hd__a31o_1
XFILLER_0_95_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_146_Right_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09316_ _00524_ _00531_ _00530_ VGND VGND VPWR VPWR _00593_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_75_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09247_ _00446_ _00448_ _00447_ VGND VGND VPWR VPWR _00525_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09178_ _00347_ _00365_ _00364_ VGND VGND VPWR VPWR _00457_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_16_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11140_ _02290_ _02383_ VGND VGND VPWR VPWR _02384_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_102_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11071_ _02236_ _02243_ _02242_ VGND VGND VPWR VPWR _02308_ sky130_fd_sc_hd__a21o_1
Xoutput89 net89 VGND VGND VPWR VPWR alpha[1] sky130_fd_sc_hd__clkbuf_4
X_10022_ _01289_ VGND VGND VPWR VPWR _00016_ sky130_fd_sc_hd__clkbuf_1
X_14830_ _06405_ _06369_ _06329_ _06406_ VGND VGND VPWR VPWR _06407_ sky130_fd_sc_hd__o211a_1
XFILLER_0_98_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14761_ net212 net588 net597 net202 VGND VGND VPWR VPWR _06331_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_98_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11973_ _03288_ _03289_ VGND VGND VPWR VPWR _03291_ sky130_fd_sc_hd__nor2_1
X_10924_ _02130_ _02117_ VGND VGND VPWR VPWR _02150_ sky130_fd_sc_hd__and2b_1
X_13712_ net749 _04539_ _05074_ _05186_ VGND VGND VPWR VPWR _05187_ sky130_fd_sc_hd__o31ai_2
X_14692_ net212 net569 net579 net202 VGND VGND VPWR VPWR _06255_ sky130_fd_sc_hd__a22oi_1
XPHY_EDGE_ROW_113_Right_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10855_ _02079_ _02080_ _02072_ VGND VGND VPWR VPWR _02081_ sky130_fd_sc_hd__and3b_1
X_13643_ _05110_ _05111_ VGND VGND VPWR VPWR _05113_ sky130_fd_sc_hd__nor2_1
XFILLER_0_39_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16362_ clknet_4_5_0_clk _00075_ net335 VGND VGND VPWR VPWR D_cos\[17\] sky130_fd_sc_hd__dfrtp_1
X_13574_ _05035_ _05037_ VGND VGND VPWR VPWR _05038_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10786_ _01985_ _01984_ _01983_ VGND VGND VPWR VPWR _02012_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_82_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15313_ _06930_ _06931_ _06932_ VGND VGND VPWR VPWR _06934_ sky130_fd_sc_hd__nand3_1
X_12525_ _03889_ _03890_ VGND VGND VPWR VPWR _03891_ sky130_fd_sc_hd__or2_1
X_16293_ clknet_4_9_0_clk _00006_ net340 VGND VGND VPWR VPWR Q_cos\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_26_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15244_ net220 net633 VGND VGND VPWR VPWR _06859_ sky130_fd_sc_hd__nand2_1
X_12456_ _03812_ _03813_ _03777_ VGND VGND VPWR VPWR _03815_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_35_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11407_ _02669_ _02673_ _02674_ VGND VGND VPWR VPWR _02675_ sky130_fd_sc_hd__nand3_1
XFILLER_0_50_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15175_ _06780_ _06782_ net810 VGND VGND VPWR VPWR _06784_ sky130_fd_sc_hd__a21boi_1
X_12387_ net171 net805 VGND VGND VPWR VPWR _03739_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14126_ _05635_ _05636_ VGND VGND VPWR VPWR _05637_ sky130_fd_sc_hd__nor2_1
X_11338_ _02489_ _02493_ _02488_ VGND VGND VPWR VPWR _02600_ sky130_fd_sc_hd__o21ba_1
X_14057_ _05494_ _05497_ VGND VGND VPWR VPWR _05562_ sky130_fd_sc_hd__or2_1
X_11269_ _02522_ _02523_ VGND VGND VPWR VPWR _02524_ sky130_fd_sc_hd__or2_1
X_13008_ _04314_ _04316_ _04419_ _04420_ VGND VGND VPWR VPWR _04421_ sky130_fd_sc_hd__a211o_1
X_14959_ _06545_ _06546_ _06547_ VGND VGND VPWR VPWR _06548_ sky130_fd_sc_hd__or3_4
X_08480_ _05731_ _05807_ _05817_ VGND VGND VPWR VPWR _05828_ sky130_fd_sc_hd__nand3_1
XFILLER_0_49_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09101_ _00380_ _00278_ VGND VGND VPWR VPWR _00381_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_143_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09032_ net602 net937 VGND VGND VPWR VPWR _00312_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout802 net803 VGND VGND VPWR VPWR net802 sky130_fd_sc_hd__buf_2
X_09934_ _01200_ _01202_ VGND VGND VPWR VPWR _01203_ sky130_fd_sc_hd__nor2_1
XFILLER_0_68_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09865_ _01133_ _01134_ VGND VGND VPWR VPWR _01135_ sky130_fd_sc_hd__nor2_1
X_08816_ _08126_ VGND VGND VPWR VPWR _00001_ sky130_fd_sc_hd__clkbuf_1
X_09796_ _01045_ _01065_ VGND VGND VPWR VPWR _01067_ sky130_fd_sc_hd__or2_1
XFILLER_0_84_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08747_ net574 net586 net489 net479 VGND VGND VPWR VPWR _08058_ sky130_fd_sc_hd__and4_1
XFILLER_0_68_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08678_ net606 net408 net397 net701 VGND VGND VPWR VPWR _07987_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_49_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10640_ _01864_ _01865_ VGND VGND VPWR VPWR _01866_ sky130_fd_sc_hd__nor2_1
XFILLER_0_75_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10571_ net233 net616 net522 net394 VGND VGND VPWR VPWR _01797_ sky130_fd_sc_hd__and4_1
XFILLER_0_146_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12310_ _03647_ _03652_ _03645_ VGND VGND VPWR VPWR _03655_ sky130_fd_sc_hd__a21oi_1
X_13290_ _04724_ _04725_ _04726_ VGND VGND VPWR VPWR _04728_ sky130_fd_sc_hd__a21o_1
XFILLER_0_106_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12241_ _03579_ _03580_ _03514_ _03517_ VGND VGND VPWR VPWR _03581_ sky130_fd_sc_hd__o211a_1
XFILLER_0_134_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12172_ _03503_ _03505_ VGND VGND VPWR VPWR _03506_ sky130_fd_sc_hd__xor2_1
X_11123_ _02264_ _02331_ _02363_ _02364_ VGND VGND VPWR VPWR _02366_ sky130_fd_sc_hd__a211oi_4
X_15931_ _07581_ _07582_ _07605_ VGND VGND VPWR VPWR _07606_ sky130_fd_sc_hd__o21a_1
X_11054_ _02189_ _02285_ _02289_ VGND VGND VPWR VPWR _02290_ sky130_fd_sc_hd__o21a_1
X_10005_ _01271_ _01272_ VGND VGND VPWR VPWR _01273_ sky130_fd_sc_hd__nand2_1
X_15862_ _07528_ _07529_ _07419_ _07447_ VGND VGND VPWR VPWR _07531_ sky130_fd_sc_hd__a211oi_1
X_14813_ _06353_ _06372_ _06387_ VGND VGND VPWR VPWR _06389_ sky130_fd_sc_hd__nand3_1
X_15793_ _07375_ _07455_ VGND VGND VPWR VPWR _07457_ sky130_fd_sc_hd__xor2_1
XFILLER_0_99_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14744_ _06156_ _06170_ _06171_ VGND VGND VPWR VPWR _06313_ sky130_fd_sc_hd__and3_1
X_11956_ net145 net495 _03269_ _03271_ VGND VGND VPWR VPWR _03272_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_58_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_103_Left_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10907_ _02115_ _02131_ VGND VGND VPWR VPWR _02133_ sky130_fd_sc_hd__nor2_1
X_14675_ net212 net202 net579 net588 VGND VGND VPWR VPWR _06237_ sky130_fd_sc_hd__and4_1
XFILLER_0_58_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11887_ _03099_ _03100_ VGND VGND VPWR VPWR _03197_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10838_ _02059_ _02060_ _02063_ VGND VGND VPWR VPWR _02064_ sky130_fd_sc_hd__a21o_1
X_13626_ _05087_ _05093_ VGND VGND VPWR VPWR _05094_ sky130_fd_sc_hd__xor2_1
XFILLER_0_104_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16345_ clknet_4_14_0_clk _00058_ net343 VGND VGND VPWR VPWR D_cos\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_82_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10769_ _01973_ _01972_ VGND VGND VPWR VPWR _01995_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_125_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13557_ net234 net933 net174 net152 VGND VGND VPWR VPWR _05019_ sky130_fd_sc_hd__nand4_2
XFILLER_0_137_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12508_ _03870_ _03871_ VGND VGND VPWR VPWR _03872_ sky130_fd_sc_hd__and2_1
XFILLER_0_120_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16276_ _07650_ VGND VGND VPWR VPWR _07980_ sky130_fd_sc_hd__inv_2
X_13488_ _04784_ _04837_ _04943_ VGND VGND VPWR VPWR _04944_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_42_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15227_ _06818_ _06839_ VGND VGND VPWR VPWR _06840_ sky130_fd_sc_hd__xor2_2
X_12439_ _03793_ _03794_ _03795_ VGND VGND VPWR VPWR _03796_ sky130_fd_sc_hd__nand3_1
XFILLER_0_140_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_112_Left_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15158_ _06656_ _06731_ net931 _06764_ VGND VGND VPWR VPWR _06765_ sky130_fd_sc_hd__a211oi_2
X_14109_ _05501_ _05505_ VGND VGND VPWR VPWR _05619_ sky130_fd_sc_hd__nor2_1
X_15089_ net273 net575 net584 net266 VGND VGND VPWR VPWR _06689_ sky130_fd_sc_hd__a22o_1
XFILLER_0_129_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09650_ net630 net356 _00853_ _00769_ VGND VGND VPWR VPWR _00923_ sky130_fd_sc_hd__a31o_1
X_08601_ _07096_ _07140_ VGND VGND VPWR VPWR _07151_ sky130_fd_sc_hd__and2b_1
XFILLER_0_145_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09581_ _00853_ _00854_ VGND VGND VPWR VPWR _00855_ sky130_fd_sc_hd__xor2_1
X_08532_ net596 net377 net368 net604 VGND VGND VPWR VPWR _06399_ sky130_fd_sc_hd__a22oi_2
XPHY_EDGE_ROW_121_Left_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08463_ net587 net377 net368 net595 VGND VGND VPWR VPWR _05644_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_77_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08394_ _04861_ _04883_ VGND VGND VPWR VPWR _04894_ sky130_fd_sc_hd__and2_1
XFILLER_0_92_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09015_ net602 net442 _00209_ VGND VGND VPWR VPWR _00295_ sky130_fd_sc_hd__and3_1
XFILLER_0_131_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_130_Left_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout610 net613 VGND VGND VPWR VPWR net610 sky130_fd_sc_hd__clkbuf_4
Xfanout621 net622 VGND VGND VPWR VPWR net621 sky130_fd_sc_hd__buf_6
X_09917_ _01179_ _01185_ VGND VGND VPWR VPWR _01186_ sky130_fd_sc_hd__xnor2_1
Xfanout632 net634 VGND VGND VPWR VPWR net632 sky130_fd_sc_hd__buf_6
Xfanout643 net644 VGND VGND VPWR VPWR net643 sky130_fd_sc_hd__buf_6
Xfanout654 net655 VGND VGND VPWR VPWR net654 sky130_fd_sc_hd__clkbuf_4
Xfanout665 net895 VGND VGND VPWR VPWR net665 sky130_fd_sc_hd__clkbuf_4
Xfanout676 net679 VGND VGND VPWR VPWR net676 sky130_fd_sc_hd__clkbuf_2
X_09848_ _01043_ _01027_ _01099_ _01100_ VGND VGND VPWR VPWR _01118_ sky130_fd_sc_hd__a211oi_1
Xfanout687 net688 VGND VGND VPWR VPWR net687 sky130_fd_sc_hd__clkbuf_2
Xfanout698 net20 VGND VGND VPWR VPWR net698 sky130_fd_sc_hd__buf_4
X_09779_ net662 net671 net455 net446 VGND VGND VPWR VPWR _01050_ sky130_fd_sc_hd__and4_1
X_11810_ net316 net496 _03110_ _03111_ VGND VGND VPWR VPWR _03113_ sky130_fd_sc_hd__nand4_2
X_12790_ _04180_ _04181_ VGND VGND VPWR VPWR _04182_ sky130_fd_sc_hd__nor2_1
XFILLER_0_95_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11741_ net748 _00191_ _02918_ VGND VGND VPWR VPWR _03038_ sky130_fd_sc_hd__or3_1
XFILLER_0_138_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14460_ net188 net178 net542 net550 VGND VGND VPWR VPWR _06000_ sky130_fd_sc_hd__and4_1
XFILLER_0_55_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11672_ _02961_ _02962_ VGND VGND VPWR VPWR _02963_ sky130_fd_sc_hd__and2b_1
XFILLER_0_83_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10623_ _01839_ _01843_ _01844_ _01728_ VGND VGND VPWR VPWR _01849_ sky130_fd_sc_hd__o211ai_2
X_13411_ _04758_ _04842_ VGND VGND VPWR VPWR _04859_ sky130_fd_sc_hd__or2b_2
X_14391_ net326 net696 net536 net241 VGND VGND VPWR VPWR _05924_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_64_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16130_ _07767_ _07821_ VGND VGND VPWR VPWR _07822_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_91_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13342_ _04762_ _04783_ VGND VGND VPWR VPWR _04784_ sky130_fd_sc_hd__xor2_1
X_10554_ _01772_ _01779_ VGND VGND VPWR VPWR _01780_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_63_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16061_ _07652_ _07746_ VGND VGND VPWR VPWR _07747_ sky130_fd_sc_hd__xnor2_1
X_13273_ net234 net214 net153 VGND VGND VPWR VPWR _04710_ sky130_fd_sc_hd__and3_1
XFILLER_0_59_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10485_ _01709_ _01710_ VGND VGND VPWR VPWR _01711_ sky130_fd_sc_hd__nor2_1
XFILLER_0_122_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15012_ net291 net566 net575 net282 VGND VGND VPWR VPWR _06605_ sky130_fd_sc_hd__a22o_1
X_12224_ _03560_ _03562_ VGND VGND VPWR VPWR _03563_ sky130_fd_sc_hd__nor2_1
XFILLER_0_121_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12155_ _03419_ _03487_ VGND VGND VPWR VPWR _03488_ sky130_fd_sc_hd__nor2_1
X_11106_ _02344_ _02157_ _02345_ _02346_ VGND VGND VPWR VPWR _02347_ sky130_fd_sc_hd__o31a_1
X_12086_ net313 net460 net450 net422 VGND VGND VPWR VPWR _03413_ sky130_fd_sc_hd__a22oi_2
X_15914_ _07585_ _07587_ VGND VGND VPWR VPWR _07588_ sky130_fd_sc_hd__nor2_1
X_11037_ _02269_ _02270_ _02233_ VGND VGND VPWR VPWR _02272_ sky130_fd_sc_hd__o21a_1
X_15845_ _07511_ _07512_ VGND VGND VPWR VPWR _07513_ sky130_fd_sc_hd__xnor2_2
X_15776_ _04881_ net547 VGND VGND VPWR VPWR _07438_ sky130_fd_sc_hd__or2_1
XFILLER_0_87_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12988_ _04395_ _04398_ VGND VGND VPWR VPWR _04399_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_148_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14727_ _06288_ _06292_ _06293_ VGND VGND VPWR VPWR _06294_ sky130_fd_sc_hd__nand3_4
X_11939_ _03189_ _03252_ VGND VGND VPWR VPWR _03253_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_46_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14658_ _06215_ _06214_ _06199_ _06187_ VGND VGND VPWR VPWR _06218_ sky130_fd_sc_hd__a211o_1
XFILLER_0_28_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13609_ net749 _04538_ VGND VGND VPWR VPWR _05075_ sky130_fd_sc_hd__nor2_1
XFILLER_0_15_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14589_ net324 net239 net544 net553 VGND VGND VPWR VPWR _06142_ sky130_fd_sc_hd__nand4_2
XFILLER_0_6_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16328_ clknet_4_10_0_clk _00041_ net346 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_40_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16259_ _07960_ _07929_ VGND VGND VPWR VPWR _07961_ sky130_fd_sc_hd__nor2_1
XFILLER_0_23_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09702_ _00969_ _00971_ _00967_ VGND VGND VPWR VPWR _00974_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_4_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09633_ net654 net483 net473 net662 VGND VGND VPWR VPWR _00906_ sky130_fd_sc_hd__a22oi_1
X_09564_ net646 net636 net347 net500 VGND VGND VPWR VPWR _00838_ sky130_fd_sc_hd__and4_1
X_08515_ net568 net407 net396 net578 VGND VGND VPWR VPWR _06212_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_148_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09495_ net622 net373 net364 net630 VGND VGND VPWR VPWR _00770_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_78_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08446_ _05438_ _05449_ VGND VGND VPWR VPWR _05460_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_37_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08377_ _03420_ _03431_ _03442_ VGND VGND VPWR VPWR _04709_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_135_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10270_ _01511_ _01512_ VGND VGND VPWR VPWR _01513_ sky130_fd_sc_hd__nand2_1
Xfanout440 net49 VGND VGND VPWR VPWR net440 sky130_fd_sc_hd__buf_2
Xfanout451 net454 VGND VGND VPWR VPWR net451 sky130_fd_sc_hd__buf_2
Xfanout462 net464 VGND VGND VPWR VPWR net462 sky130_fd_sc_hd__clkbuf_4
Xfanout473 net474 VGND VGND VPWR VPWR net473 sky130_fd_sc_hd__clkbuf_4
X_13960_ _05367_ _05372_ VGND VGND VPWR VPWR _05457_ sky130_fd_sc_hd__and2b_1
Xfanout484 net487 VGND VGND VPWR VPWR net484 sky130_fd_sc_hd__buf_4
Xfanout495 net496 VGND VGND VPWR VPWR net495 sky130_fd_sc_hd__clkbuf_4
X_12911_ net878 _04313_ _04188_ _04280_ VGND VGND VPWR VPWR _04315_ sky130_fd_sc_hd__o211ai_4
X_13891_ _05380_ _05381_ VGND VGND VPWR VPWR _05382_ sky130_fd_sc_hd__xnor2_2
X_15630_ _07193_ _07212_ _07211_ VGND VGND VPWR VPWR _07278_ sky130_fd_sc_hd__a21bo_1
X_12842_ _04138_ _04079_ VGND VGND VPWR VPWR _04239_ sky130_fd_sc_hd__or2b_1
XFILLER_0_68_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15561_ _07101_ _07103_ VGND VGND VPWR VPWR _07203_ sky130_fd_sc_hd__or2_1
XFILLER_0_68_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12773_ _04012_ VGND VGND VPWR VPWR _04164_ sky130_fd_sc_hd__inv_2
XFILLER_0_28_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14512_ _06055_ _06056_ VGND VGND VPWR VPWR _06057_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11724_ net425 net496 VGND VGND VPWR VPWR _03020_ sky130_fd_sc_hd__and2_1
X_15492_ net297 net683 _07125_ _07126_ VGND VGND VPWR VPWR _07128_ sky130_fd_sc_hd__nand4_2
X_14443_ _05976_ _05978_ _05977_ VGND VGND VPWR VPWR _05982_ sky130_fd_sc_hd__o21ai_1
X_11655_ _02941_ _02944_ VGND VGND VPWR VPWR _02945_ sky130_fd_sc_hd__xor2_2
XFILLER_0_127_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10606_ _01829_ _01830_ _01831_ VGND VGND VPWR VPWR _01832_ sky130_fd_sc_hd__o21bai_1
X_14374_ _05902_ _05903_ _05905_ VGND VGND VPWR VPWR _05906_ sky130_fd_sc_hd__or3_1
X_11586_ _02868_ _02869_ VGND VGND VPWR VPWR _02870_ sky130_fd_sc_hd__xor2_2
XFILLER_0_51_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16113_ _07706_ _07802_ VGND VGND VPWR VPWR _07804_ sky130_fd_sc_hd__xnor2_1
X_10537_ _01673_ _01678_ VGND VGND VPWR VPWR _01763_ sky130_fd_sc_hd__and2b_1
X_13325_ net748 net268 net258 net757 VGND VGND VPWR VPWR _04766_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_12_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16044_ _07726_ _07728_ VGND VGND VPWR VPWR _07729_ sky130_fd_sc_hd__nor2_1
X_10468_ _01686_ _01689_ _01692_ VGND VGND VPWR VPWR _01694_ sky130_fd_sc_hd__and3_1
X_13256_ _04686_ _04688_ _04689_ VGND VGND VPWR VPWR _04691_ sky130_fd_sc_hd__a21o_1
XFILLER_0_150_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12207_ _03505_ _03543_ VGND VGND VPWR VPWR _03544_ sky130_fd_sc_hd__xor2_1
X_13187_ _04606_ _04614_ _04615_ VGND VGND VPWR VPWR _04616_ sky130_fd_sc_hd__nand3_1
X_10399_ net754 net762 net379 net370 VGND VGND VPWR VPWR _01625_ sky130_fd_sc_hd__nand4_1
X_12138_ net913 _00187_ VGND VGND VPWR VPWR _03470_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12069_ _03320_ _03394_ VGND VGND VPWR VPWR _03395_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15828_ _07489_ _07406_ _07492_ VGND VGND VPWR VPWR _07494_ sky130_fd_sc_hd__and3_1
X_15759_ _07417_ _07322_ _07415_ _07416_ VGND VGND VPWR VPWR _07419_ sky130_fd_sc_hd__o211a_1
XFILLER_0_47_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08300_ _03658_ _03734_ VGND VGND VPWR VPWR _03866_ sky130_fd_sc_hd__or2b_1
X_09280_ _00555_ _00557_ VGND VGND VPWR VPWR _00558_ sky130_fd_sc_hd__xor2_1
XFILLER_0_75_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08231_ net686 net413 VGND VGND VPWR VPWR _03116_ sky130_fd_sc_hd__nand2_1
XFILLER_0_144_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08162_ _02234_ _02288_ VGND VGND VPWR VPWR _02365_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_133_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08995_ _00196_ _00175_ _00274_ _00275_ VGND VGND VPWR VPWR _00276_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_97_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09616_ _00784_ _00807_ VGND VGND VPWR VPWR _00890_ sky130_fd_sc_hd__or2_2
XFILLER_0_78_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09547_ _00655_ _00658_ _00736_ _00821_ VGND VGND VPWR VPWR _00822_ sky130_fd_sc_hd__a31oi_1
XFILLER_0_78_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09478_ net646 net655 net347 net500 VGND VGND VPWR VPWR _00753_ sky130_fd_sc_hd__and4_1
XFILLER_0_109_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08429_ _05242_ _05253_ _05264_ VGND VGND VPWR VPWR _05275_ sky130_fd_sc_hd__nand3_1
XFILLER_0_53_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11440_ _02709_ _02710_ VGND VGND VPWR VPWR _02711_ sky130_fd_sc_hd__and2b_1
XFILLER_0_135_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11371_ net740 net470 VGND VGND VPWR VPWR _02635_ sky130_fd_sc_hd__nand2_1
XFILLER_0_150_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10322_ _01549_ _01552_ _01550_ VGND VGND VPWR VPWR _01558_ sky130_fd_sc_hd__a21bo_1
X_13110_ _04440_ _04531_ VGND VGND VPWR VPWR _04532_ sky130_fd_sc_hd__xnor2_2
X_14090_ _05596_ _05597_ VGND VGND VPWR VPWR _05598_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_132_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13041_ _04351_ _04455_ VGND VGND VPWR VPWR _04456_ sky130_fd_sc_hd__xor2_1
X_10253_ _01497_ Q_cos\[0\] net134 VGND VGND VPWR VPWR _01499_ sky130_fd_sc_hd__o21a_1
X_10184_ Q_sin\[10\] D_cos\[10\] VGND VGND VPWR VPWR _01439_ sky130_fd_sc_hd__and2b_1
X_14992_ _06583_ VGND VGND VPWR VPWR _00097_ sky130_fd_sc_hd__clkbuf_1
Xfanout270 net272 VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__clkbuf_4
Xfanout281 net63 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__buf_4
Xfanout292 net62 VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__clkbuf_2
X_13943_ _05436_ _05429_ _05430_ VGND VGND VPWR VPWR _05439_ sky130_fd_sc_hd__nor3_1
XFILLER_0_88_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13874_ _05295_ _05296_ _05363_ VGND VGND VPWR VPWR _05364_ sky130_fd_sc_hd__o21ai_2
X_15613_ _07239_ _07259_ VGND VGND VPWR VPWR _07261_ sky130_fd_sc_hd__xor2_2
X_12825_ _04213_ _04220_ VGND VGND VPWR VPWR _04221_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15544_ _02181_ Q_sin\[7\] VGND VGND VPWR VPWR _07186_ sky130_fd_sc_hd__and2b_1
X_12756_ _04002_ VGND VGND VPWR VPWR _04145_ sky130_fd_sc_hd__inv_2
XFILLER_0_29_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11707_ _02998_ _02999_ _02994_ VGND VGND VPWR VPWR _03001_ sky130_fd_sc_hd__a21o_1
X_15475_ _07007_ _07006_ VGND VGND VPWR VPWR _07110_ sky130_fd_sc_hd__and2b_1
XFILLER_0_84_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12687_ _04065_ _04068_ VGND VGND VPWR VPWR _04069_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14426_ net188 net551 net559 net178 VGND VGND VPWR VPWR _05963_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_21_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11638_ net796 net385 _02853_ _02854_ VGND VGND VPWR VPWR _02926_ sky130_fd_sc_hd__a22o_1
XFILLER_0_21_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14357_ net160 net309 net599 net607 VGND VGND VPWR VPWR _05887_ sky130_fd_sc_hd__and4_1
X_11569_ _02451_ _02774_ _02850_ VGND VGND VPWR VPWR _02851_ sky130_fd_sc_hd__a21o_1
XFILLER_0_123_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13308_ _04649_ _04747_ VGND VGND VPWR VPWR _04748_ sky130_fd_sc_hd__xnor2_4
X_14288_ net910 _00187_ VGND VGND VPWR VPWR _05813_ sky130_fd_sc_hd__nor2_1
XFILLER_0_122_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16027_ net261 net252 net656 net664 VGND VGND VPWR VPWR _07710_ sky130_fd_sc_hd__and4_1
X_13239_ _04655_ _04671_ VGND VGND VPWR VPWR _04672_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_110_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08780_ _08089_ _08090_ VGND VGND VPWR VPWR _08091_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_127_Right_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09401_ _00578_ _00580_ VGND VGND VPWR VPWR _00677_ sky130_fd_sc_hd__or2_1
XFILLER_0_1_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09332_ _00606_ _00607_ _00593_ VGND VGND VPWR VPWR _00609_ sky130_fd_sc_hd__a21o_1
XFILLER_0_62_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09263_ _00443_ _00535_ VGND VGND VPWR VPWR _00541_ sky130_fd_sc_hd__nor2_2
XFILLER_0_16_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08214_ net698 net469 VGND VGND VPWR VPWR _02931_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09194_ _00292_ _00382_ VGND VGND VPWR VPWR _00473_ sky130_fd_sc_hd__nor2_1
X_08145_ _02170_ VGND VGND VPWR VPWR _02181_ sky130_fd_sc_hd__buf_4
XFILLER_0_30_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08978_ _00256_ _00257_ _00258_ VGND VGND VPWR VPWR _00259_ sky130_fd_sc_hd__nand3_1
XFILLER_0_97_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10940_ _02164_ _02166_ VGND VGND VPWR VPWR _02167_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_97_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10871_ _02095_ _02096_ VGND VGND VPWR VPWR _02097_ sky130_fd_sc_hd__or2_1
XFILLER_0_78_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12610_ _03982_ _03983_ VGND VGND VPWR VPWR _03984_ sky130_fd_sc_hd__and2b_1
XFILLER_0_39_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13590_ _05052_ _05053_ VGND VGND VPWR VPWR _05054_ sky130_fd_sc_hd__nand2_1
XFILLER_0_149_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12541_ _03780_ _03785_ VGND VGND VPWR VPWR _03908_ sky130_fd_sc_hd__or2b_1
XFILLER_0_66_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15260_ _06873_ _06874_ _06840_ VGND VGND VPWR VPWR _06876_ sky130_fd_sc_hd__a21o_1
XFILLER_0_136_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12472_ net223 net780 VGND VGND VPWR VPWR _03832_ sky130_fd_sc_hd__nand2_1
XFILLER_0_136_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14211_ _05727_ _05728_ VGND VGND VPWR VPWR _05729_ sky130_fd_sc_hd__nor2_1
X_11423_ _02689_ _02690_ _02628_ VGND VGND VPWR VPWR _02693_ sky130_fd_sc_hd__a21o_1
X_15191_ _06798_ _06799_ VGND VGND VPWR VPWR _06800_ sky130_fd_sc_hd__or2_1
XFILLER_0_61_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_9 net62 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_11354_ _02614_ _02616_ VGND VGND VPWR VPWR _02617_ sky130_fd_sc_hd__xnor2_2
X_14142_ _05598_ _05603_ _05653_ VGND VGND VPWR VPWR _05654_ sky130_fd_sc_hd__a21o_1
X_10305_ D_sin\[8\] Q_cos\[8\] VGND VGND VPWR VPWR _01543_ sky130_fd_sc_hd__or2b_1
X_11285_ _02541_ VGND VGND VPWR VPWR _02542_ sky130_fd_sc_hd__buf_2
X_14073_ _05493_ _05491_ VGND VGND VPWR VPWR _05580_ sky130_fd_sc_hd__and2b_1
XFILLER_0_131_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13024_ next_state _04435_ _04436_ _04438_ VGND VGND VPWR VPWR _00078_ sky130_fd_sc_hd__a31o_1
X_10236_ net130 _01482_ _01483_ _01484_ VGND VGND VPWR VPWR _00035_ sky130_fd_sc_hd__a31o_1
X_10167_ _01423_ _01424_ VGND VGND VPWR VPWR _01425_ sky130_fd_sc_hd__xnor2_1
X_10098_ _01363_ _01308_ _01312_ VGND VGND VPWR VPWR _01364_ sky130_fd_sc_hd__mux2_1
X_14975_ net830 _06112_ _06564_ _06565_ VGND VGND VPWR VPWR _06566_ sky130_fd_sc_hd__a211o_4
XFILLER_0_16_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13926_ _05417_ _05418_ net298 net149 VGND VGND VPWR VPWR _05420_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_107_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13857_ _05342_ _05343_ _05322_ VGND VGND VPWR VPWR _05345_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_29_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12808_ _04099_ _04169_ _04200_ _04201_ VGND VGND VPWR VPWR _04202_ sky130_fd_sc_hd__a211o_1
XFILLER_0_69_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13788_ _04930_ _05082_ VGND VGND VPWR VPWR _05270_ sky130_fd_sc_hd__nand2_2
XFILLER_0_57_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15527_ _07164_ _07166_ VGND VGND VPWR VPWR _07167_ sky130_fd_sc_hd__xor2_1
X_12739_ net302 net784 _04030_ _04029_ VGND VGND VPWR VPWR _04126_ sky130_fd_sc_hd__a31o_1
XFILLER_0_139_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15458_ _07076_ _07074_ VGND VGND VPWR VPWR _07091_ sky130_fd_sc_hd__or2b_1
XFILLER_0_4_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14409_ _05939_ _05941_ _05940_ VGND VGND VPWR VPWR _05944_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_53_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15389_ _06997_ _07015_ VGND VGND VPWR VPWR _07016_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_114_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09950_ _01161_ _01164_ _01216_ _01217_ VGND VGND VPWR VPWR _01219_ sky130_fd_sc_hd__o211a_1
XFILLER_0_111_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08901_ _00181_ _00182_ VGND VGND VPWR VPWR _00183_ sky130_fd_sc_hd__xnor2_2
X_09881_ net620 net493 _01084_ VGND VGND VPWR VPWR _01151_ sky130_fd_sc_hd__a21o_1
XFILLER_0_148_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08832_ _08140_ _08141_ VGND VGND VPWR VPWR _08142_ sky130_fd_sc_hd__or2_1
X_08763_ _08054_ _08055_ _08072_ _08073_ VGND VGND VPWR VPWR _08074_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08694_ net598 net606 net525 net436 VGND VGND VPWR VPWR _08006_ sky130_fd_sc_hd__and4_1
XFILLER_0_79_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09315_ _00511_ _00519_ _00518_ VGND VGND VPWR VPWR _00592_ sky130_fd_sc_hd__a21o_1
XFILLER_0_75_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09246_ _00436_ _00438_ VGND VGND VPWR VPWR _00524_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09177_ _00442_ _00455_ VGND VGND VPWR VPWR _00456_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_44_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11070_ _02225_ _02227_ VGND VGND VPWR VPWR _02307_ sky130_fd_sc_hd__nand2_1
Xoutput79 net79 VGND VGND VPWR VPWR alpha[0] sky130_fd_sc_hd__buf_2
X_10021_ Q_cos\[16\] _01288_ _00661_ VGND VGND VPWR VPWR _01289_ sky130_fd_sc_hd__mux2_2
X_14760_ _06296_ _06301_ _06302_ VGND VGND VPWR VPWR _06330_ sky130_fd_sc_hd__or3_1
X_11972_ net511 net610 net461 net451 VGND VGND VPWR VPWR _03289_ sky130_fd_sc_hd__and4_1
X_13711_ _05071_ _05073_ VGND VGND VPWR VPWR _05186_ sky130_fd_sc_hd__or2b_1
X_10923_ _02145_ _02147_ _02148_ _02144_ VGND VGND VPWR VPWR _02149_ sky130_fd_sc_hd__and4b_1
XFILLER_0_98_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14691_ _06241_ _06252_ _06253_ VGND VGND VPWR VPWR _06254_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13642_ net316 net425 net158 net307 VGND VGND VPWR VPWR _05111_ sky130_fd_sc_hd__and4_1
X_10854_ _02068_ _02076_ _02078_ VGND VGND VPWR VPWR _02080_ sky130_fd_sc_hd__nand3_1
XFILLER_0_94_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16361_ clknet_4_4_0_clk _00074_ net336 VGND VGND VPWR VPWR D_cos\[16\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_109_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13573_ _04886_ _04940_ _04939_ VGND VGND VPWR VPWR _05037_ sky130_fd_sc_hd__a21oi_1
X_10785_ _01985_ _01983_ _01984_ VGND VGND VPWR VPWR _02011_ sky130_fd_sc_hd__or3_1
XFILLER_0_81_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15312_ _06826_ _06828_ _06827_ VGND VGND VPWR VPWR _06932_ sky130_fd_sc_hd__a21bo_1
X_12524_ _03884_ _03887_ VGND VGND VPWR VPWR _03890_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_137_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16292_ clknet_4_11_0_clk _00005_ net340 VGND VGND VPWR VPWR Q_cos\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_137_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15243_ net323 net238 net624 VGND VGND VPWR VPWR _06858_ sky130_fd_sc_hd__a21boi_2
X_12455_ _03777_ _03812_ _03813_ VGND VGND VPWR VPWR _03814_ sky130_fd_sc_hd__or3_1
XFILLER_0_78_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11406_ _02451_ _02671_ _02672_ VGND VGND VPWR VPWR _02674_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_1_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15174_ net825 _06780_ _06782_ VGND VGND VPWR VPWR _06783_ sky130_fd_sc_hd__and3b_2
X_12386_ net198 net781 _03704_ _03703_ VGND VGND VPWR VPWR _03738_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14125_ net228 net313 net263 net254 VGND VGND VPWR VPWR _05636_ sky130_fd_sc_hd__and4_1
X_11337_ _02497_ _02598_ VGND VGND VPWR VPWR _02599_ sky130_fd_sc_hd__xnor2_1
X_14056_ _05548_ _05545_ VGND VGND VPWR VPWR _05561_ sky130_fd_sc_hd__and2b_1
X_11268_ _02520_ _02521_ _02501_ VGND VGND VPWR VPWR _02523_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_120_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13007_ _04417_ _04418_ _04381_ VGND VGND VPWR VPWR _04420_ sky130_fd_sc_hd__o21a_1
X_10219_ _01460_ _01466_ _01469_ VGND VGND VPWR VPWR _01470_ sky130_fd_sc_hd__o21a_1
XFILLER_0_94_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11199_ _02437_ _02447_ VGND VGND VPWR VPWR _02448_ sky130_fd_sc_hd__xor2_2
X_14958_ net237 net901 net642 net322 VGND VGND VPWR VPWR _06547_ sky130_fd_sc_hd__a22oi_2
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13909_ _05229_ _05400_ _05401_ VGND VGND VPWR VPWR _05402_ sky130_fd_sc_hd__a21oi_2
X_14889_ _06308_ _06324_ _06325_ VGND VGND VPWR VPWR _06472_ sky130_fd_sc_hd__nand3_1
XFILLER_0_89_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09100_ _00196_ _00175_ _00274_ _00275_ VGND VGND VPWR VPWR _00380_ sky130_fd_sc_hd__o211a_1
XFILLER_0_127_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09031_ _00190_ VGND VGND VPWR VPWR _00311_ sky130_fd_sc_hd__buf_1
XFILLER_0_142_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_143_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09933_ net626 _01201_ VGND VGND VPWR VPWR _01202_ sky130_fd_sc_hd__and2_1
Xfanout803 net806 VGND VGND VPWR VPWR net803 sky130_fd_sc_hd__clkbuf_4
X_09864_ _01055_ _01054_ VGND VGND VPWR VPWR _01134_ sky130_fd_sc_hd__and2b_1
X_08815_ Q_cos\[1\] _08125_ _02181_ VGND VGND VPWR VPWR _08126_ sky130_fd_sc_hd__mux2_1
X_09795_ _01045_ _01065_ VGND VGND VPWR VPWR _01066_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08746_ net574 net489 net479 net583 VGND VGND VPWR VPWR _08057_ sky130_fd_sc_hd__a22oi_1
X_08677_ _07933_ _07965_ VGND VGND VPWR VPWR _07976_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10570_ net707 net385 VGND VGND VPWR VPWR _01796_ sky130_fd_sc_hd__nand2_1
XFILLER_0_134_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09229_ net532 net484 net474 net540 VGND VGND VPWR VPWR _00507_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_133_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12240_ _03553_ _03578_ VGND VGND VPWR VPWR _03580_ sky130_fd_sc_hd__and2_1
XFILLER_0_121_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12171_ _03504_ VGND VGND VPWR VPWR _03505_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_31_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11122_ _02361_ _02362_ _02342_ VGND VGND VPWR VPWR _02364_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_101_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15930_ _07583_ _07604_ VGND VGND VPWR VPWR _07605_ sky130_fd_sc_hd__xnor2_1
X_11053_ _02190_ _02284_ VGND VGND VPWR VPWR _02289_ sky130_fd_sc_hd__nand2_1
X_10004_ net662 _00192_ VGND VGND VPWR VPWR _01272_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15861_ _07419_ _07447_ _07528_ _07529_ VGND VGND VPWR VPWR _07530_ sky130_fd_sc_hd__o211a_1
X_14812_ _06379_ _06386_ VGND VGND VPWR VPWR _06387_ sky130_fd_sc_hd__nand2_1
X_15792_ _07452_ _07454_ VGND VGND VPWR VPWR _07455_ sky130_fd_sc_hd__xor2_1
X_14743_ _06156_ _06171_ _06170_ VGND VGND VPWR VPWR _06312_ sky130_fd_sc_hd__a21oi_2
X_11955_ net136 _03270_ VGND VGND VPWR VPWR _03271_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10906_ _02115_ _02131_ VGND VGND VPWR VPWR _02132_ sky130_fd_sc_hd__and2_1
X_14674_ _06122_ _06235_ VGND VGND VPWR VPWR _06236_ sky130_fd_sc_hd__xnor2_2
X_11886_ _03194_ _03183_ _03184_ VGND VGND VPWR VPWR _03196_ sky130_fd_sc_hd__nor3_1
X_13625_ _05091_ _05092_ VGND VGND VPWR VPWR _05093_ sky130_fd_sc_hd__xnor2_1
X_10837_ net760 net439 _02061_ _02062_ VGND VGND VPWR VPWR _02063_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16344_ clknet_4_8_0_clk _00057_ net333 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_66_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13556_ net234 net174 net152 net933 VGND VGND VPWR VPWR _05018_ sky130_fd_sc_hd__a22o_1
XFILLER_0_13_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10768_ _01980_ _01992_ _01991_ VGND VGND VPWR VPWR _01994_ sky130_fd_sc_hd__a21o_1
X_12507_ _03868_ _03869_ _03863_ VGND VGND VPWR VPWR _03871_ sky130_fd_sc_hd__a21o_1
X_16275_ _07972_ _07978_ VGND VGND VPWR VPWR _07979_ sky130_fd_sc_hd__xor2_1
X_13487_ _04835_ _04836_ VGND VGND VPWR VPWR _04943_ sky130_fd_sc_hd__and2b_1
XFILLER_0_54_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10699_ _01923_ _01924_ VGND VGND VPWR VPWR _01925_ sky130_fd_sc_hd__nor2_1
X_15226_ _06837_ _06838_ VGND VGND VPWR VPWR _06839_ sky130_fd_sc_hd__nor2_1
X_12438_ _03790_ _03792_ _03791_ VGND VGND VPWR VPWR _03795_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_2_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15157_ _06750_ _06751_ _06762_ VGND VGND VPWR VPWR _06764_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_2_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12369_ net223 net772 VGND VGND VPWR VPWR _03719_ sky130_fd_sc_hd__nand2_1
X_14108_ _05616_ _05617_ VGND VGND VPWR VPWR _05618_ sky130_fd_sc_hd__nor2_1
X_15088_ net259 net592 VGND VGND VPWR VPWR _06688_ sky130_fd_sc_hd__nand2_1
XFILLER_0_129_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14039_ _05463_ _05446_ VGND VGND VPWR VPWR _05543_ sky130_fd_sc_hd__and2b_1
XFILLER_0_38_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08600_ net604 net388 _07129_ _07118_ VGND VGND VPWR VPWR _07140_ sky130_fd_sc_hd__a31o_1
X_09580_ net630 net356 VGND VGND VPWR VPWR _00854_ sky130_fd_sc_hd__nand2_1
XFILLER_0_145_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08531_ net596 net604 net377 net368 VGND VGND VPWR VPWR _06388_ sky130_fd_sc_hd__and4_1
XFILLER_0_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08462_ net603 net363 VGND VGND VPWR VPWR _05633_ sky130_fd_sc_hd__nand2_1
XFILLER_0_147_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08393_ _02594_ _04872_ VGND VGND VPWR VPWR _04883_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_878 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09014_ _00212_ _00213_ _00293_ VGND VGND VPWR VPWR _00294_ sky130_fd_sc_hd__a21o_1
XFILLER_0_103_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold120 net114 VGND VGND VPWR VPWR net926 sky130_fd_sc_hd__dlygate4sd3_1
Xfanout600 net31 VGND VGND VPWR VPWR net600 sky130_fd_sc_hd__buf_2
Xfanout611 net613 VGND VGND VPWR VPWR net611 sky130_fd_sc_hd__buf_2
Xfanout622 net624 VGND VGND VPWR VPWR net622 sky130_fd_sc_hd__buf_4
X_09916_ _01183_ _01184_ VGND VGND VPWR VPWR _01185_ sky130_fd_sc_hd__nor2_1
Xfanout633 net634 VGND VGND VPWR VPWR net633 sky130_fd_sc_hd__clkbuf_2
Xfanout644 net27 VGND VGND VPWR VPWR net644 sky130_fd_sc_hd__buf_12
Xfanout655 net25 VGND VGND VPWR VPWR net655 sky130_fd_sc_hd__clkbuf_4
Xfanout666 net670 VGND VGND VPWR VPWR net666 sky130_fd_sc_hd__clkbuf_4
X_09847_ _01109_ _01113_ _01116_ VGND VGND VPWR VPWR _01117_ sky130_fd_sc_hd__o21bai_1
Xfanout677 net679 VGND VGND VPWR VPWR net677 sky130_fd_sc_hd__buf_6
Xfanout688 net22 VGND VGND VPWR VPWR net688 sky130_fd_sc_hd__clkbuf_8
Xfanout699 net20 VGND VGND VPWR VPWR net699 sky130_fd_sc_hd__buf_2
X_09778_ net662 net455 net446 net671 VGND VGND VPWR VPWR _01049_ sky130_fd_sc_hd__a22oi_2
X_08729_ _03778_ _03822_ _04437_ net863 VGND VGND VPWR VPWR _08040_ sky130_fd_sc_hd__o211a_1
XFILLER_0_95_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11740_ _03034_ _03036_ VGND VGND VPWR VPWR _03037_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_95_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11671_ _02958_ _02959_ _02960_ VGND VGND VPWR VPWR _02962_ sky130_fd_sc_hd__a21o_1
XFILLER_0_37_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13410_ _04845_ net119 _04857_ VGND VGND VPWR VPWR _04858_ sky130_fd_sc_hd__o21a_1
XFILLER_0_138_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10622_ _01658_ _01845_ _01846_ _01847_ VGND VGND VPWR VPWR _01848_ sky130_fd_sc_hd__or4_4
X_14390_ net222 net543 VGND VGND VPWR VPWR _05923_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13341_ _04781_ _04782_ VGND VGND VPWR VPWR _04783_ sky130_fd_sc_hd__and2b_1
XFILLER_0_24_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10553_ _01777_ _01778_ VGND VGND VPWR VPWR _01779_ sky130_fd_sc_hd__xnor2_1
X_16060_ _07734_ _07745_ VGND VGND VPWR VPWR _07746_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_106_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13272_ _04700_ _04707_ VGND VGND VPWR VPWR _04708_ sky130_fd_sc_hd__xor2_1
X_10484_ net724 net390 _01707_ _01708_ VGND VGND VPWR VPWR _01710_ sky130_fd_sc_hd__o2bb2a_1
X_15011_ net291 net282 net576 VGND VGND VPWR VPWR _06604_ sky130_fd_sc_hd__and3_1
X_12223_ net227 net145 net460 net450 VGND VGND VPWR VPWR _03562_ sky130_fd_sc_hd__and4_1
X_12154_ _03422_ _03421_ VGND VGND VPWR VPWR _03487_ sky130_fd_sc_hd__and2b_1
X_11105_ net141 net523 net395 net426 VGND VGND VPWR VPWR _02346_ sky130_fd_sc_hd__a22o_1
X_12085_ _03352_ _03372_ _03411_ VGND VGND VPWR VPWR _03412_ sky130_fd_sc_hd__a21o_1
X_15913_ net261 net252 net672 net681 VGND VGND VPWR VPWR _07587_ sky130_fd_sc_hd__and4_1
X_11036_ _02233_ _02269_ _02270_ VGND VGND VPWR VPWR _02271_ sky130_fd_sc_hd__nor3_2
X_15844_ net248 net531 VGND VGND VPWR VPWR _07512_ sky130_fd_sc_hd__nand2_1
X_15775_ _07432_ _07436_ VGND VGND VPWR VPWR _07437_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_91_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12987_ _04396_ _04397_ VGND VGND VPWR VPWR _04398_ sky130_fd_sc_hd__nor2_1
XFILLER_0_24_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14726_ _06153_ _06291_ _06290_ VGND VGND VPWR VPWR _06293_ sky130_fd_sc_hd__a21o_1
X_11938_ net794 net358 _00851_ _03251_ VGND VGND VPWR VPWR _03252_ sky130_fd_sc_hd__a31o_2
XFILLER_0_115_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14657_ _06187_ _06199_ _06214_ _06215_ VGND VGND VPWR VPWR _06217_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_86_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11869_ _03111_ _03113_ VGND VGND VPWR VPWR _03177_ sky130_fd_sc_hd__nand2_1
XFILLER_0_145_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13608_ _05071_ _05073_ VGND VGND VPWR VPWR _05074_ sky130_fd_sc_hd__xor2_2
XFILLER_0_39_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14588_ net324 net545 net553 net239 VGND VGND VPWR VPWR _06141_ sky130_fd_sc_hd__a22o_1
XFILLER_0_27_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16327_ clknet_4_15_0_clk _00040_ net346 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_43_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13539_ _04983_ _04997_ _04998_ VGND VGND VPWR VPWR _04999_ sky130_fd_sc_hd__nand3_1
XFILLER_0_27_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16258_ _07926_ _07916_ VGND VGND VPWR VPWR _07960_ sky130_fd_sc_hd__and2b_1
XFILLER_0_125_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15209_ net291 net282 net549 VGND VGND VPWR VPWR _06820_ sky130_fd_sc_hd__and3_1
X_16189_ _07831_ _07885_ VGND VGND VPWR VPWR _07886_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09701_ _00973_ VGND VGND VPWR VPWR _00011_ sky130_fd_sc_hd__clkbuf_1
X_09632_ _00850_ net856 VGND VGND VPWR VPWR _00905_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09563_ net636 net347 net500 net646 VGND VGND VPWR VPWR _00837_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_78_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08514_ _06069_ _06179_ _06190_ VGND VGND VPWR VPWR _06201_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_77_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09494_ net622 net373 net364 VGND VGND VPWR VPWR _00769_ sky130_fd_sc_hd__and3_1
XFILLER_0_65_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08445_ net578 net387 VGND VGND VPWR VPWR _05449_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08376_ _04665_ _04676_ _04687_ VGND VGND VPWR VPWR _04698_ sky130_fd_sc_hd__nand3_1
XFILLER_0_46_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout430 net431 VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__buf_4
Xfanout441 net442 VGND VGND VPWR VPWR net441 sky130_fd_sc_hd__clkbuf_4
Xfanout452 net454 VGND VGND VPWR VPWR net452 sky130_fd_sc_hd__clkbuf_4
Xfanout463 net464 VGND VGND VPWR VPWR net463 sky130_fd_sc_hd__buf_2
Xfanout474 net477 VGND VGND VPWR VPWR net474 sky130_fd_sc_hd__buf_4
Xfanout485 net487 VGND VGND VPWR VPWR net485 sky130_fd_sc_hd__buf_4
Xfanout496 net41 VGND VGND VPWR VPWR net496 sky130_fd_sc_hd__buf_4
X_12910_ _04188_ _04280_ _04312_ _04313_ VGND VGND VPWR VPWR _04314_ sky130_fd_sc_hd__a211o_4
X_13890_ net721 _04881_ VGND VGND VPWR VPWR _05381_ sky130_fd_sc_hd__or2_1
X_12841_ _04079_ _04138_ VGND VGND VPWR VPWR _04238_ sky130_fd_sc_hd__and2b_1
X_15560_ _07196_ _07201_ VGND VGND VPWR VPWR _07202_ sky130_fd_sc_hd__xnor2_2
X_12772_ _04016_ _04157_ VGND VGND VPWR VPWR _04162_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14511_ net292 net285 net585 net592 VGND VGND VPWR VPWR _06056_ sky130_fd_sc_hd__and4_1
X_11723_ net229 net316 net350 net503 VGND VGND VPWR VPWR _03019_ sky130_fd_sc_hd__nand4_1
X_15491_ net297 net683 _07125_ _07126_ VGND VGND VPWR VPWR _07127_ sky130_fd_sc_hd__a22o_1
X_14442_ _05940_ _05941_ _05939_ VGND VGND VPWR VPWR _05980_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_138_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11654_ _02861_ _02872_ _02943_ VGND VGND VPWR VPWR _02944_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_126_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10605_ net726 net735 net418 net410 VGND VGND VPWR VPWR _01831_ sky130_fd_sc_hd__and4_1
XFILLER_0_107_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14373_ net322 net678 net687 net237 VGND VGND VPWR VPWR _05905_ sky130_fd_sc_hd__a22oi_2
X_11585_ net318 net358 VGND VGND VPWR VPWR _02869_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16112_ _07800_ _07801_ VGND VGND VPWR VPWR _07802_ sky130_fd_sc_hd__xor2_1
X_13324_ net749 net274 _04679_ _04678_ net284 VGND VGND VPWR VPWR _04765_ sky130_fd_sc_hd__a32o_1
X_10536_ _01689_ _01759_ _01760_ _01761_ VGND VGND VPWR VPWR _01762_ sky130_fd_sc_hd__and4_2
XFILLER_0_107_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16043_ _07707_ _07708_ _07725_ VGND VGND VPWR VPWR _07728_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_108_Right_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13255_ _04686_ _04688_ _04689_ VGND VGND VPWR VPWR _04690_ sky130_fd_sc_hd__nand3_1
X_10467_ _01686_ _01689_ _01692_ VGND VGND VPWR VPWR _01693_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_122_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12206_ _03541_ _03542_ VGND VGND VPWR VPWR _03543_ sky130_fd_sc_hd__or2_1
XFILLER_0_110_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13186_ _04612_ _04613_ _04501_ _04607_ VGND VGND VPWR VPWR _04615_ sky130_fd_sc_hd__a211o_1
X_10398_ net751 net762 net379 net370 VGND VGND VPWR VPWR _01624_ sky130_fd_sc_hd__and4_1
XFILLER_0_19_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12137_ _03406_ _03468_ VGND VGND VPWR VPWR _03469_ sky130_fd_sc_hd__xnor2_1
X_12068_ _03390_ _03393_ VGND VGND VPWR VPWR _03394_ sky130_fd_sc_hd__xnor2_1
X_11019_ net233 net434 VGND VGND VPWR VPWR _02252_ sky130_fd_sc_hd__nand2_1
XFILLER_0_126_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15827_ _07489_ _07406_ _07492_ VGND VGND VPWR VPWR _07493_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_150_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15758_ _07415_ _07416_ _07417_ _07322_ VGND VGND VPWR VPWR _07418_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_87_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14709_ net187 net177 net597 net607 VGND VGND VPWR VPWR _06274_ sky130_fd_sc_hd__and4_1
X_15689_ _07340_ _07342_ VGND VGND VPWR VPWR _07343_ sky130_fd_sc_hd__xnor2_1
X_08230_ net666 net677 net520 net433 VGND VGND VPWR VPWR _03105_ sky130_fd_sc_hd__and4_1
XFILLER_0_145_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08161_ _02310_ _02343_ VGND VGND VPWR VPWR _02354_ sky130_fd_sc_hd__nor2_1
XFILLER_0_144_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08994_ _00272_ _00273_ _00214_ VGND VGND VPWR VPWR _00275_ sky130_fd_sc_hd__a21o_1
X_09615_ _00887_ _00888_ VGND VGND VPWR VPWR _00889_ sky130_fd_sc_hd__nand2_2
XFILLER_0_97_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09546_ _00649_ _00652_ _00735_ VGND VGND VPWR VPWR _00821_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_66_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09477_ net646 net347 net500 net655 VGND VGND VPWR VPWR _00752_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_93_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08428_ _05090_ _05232_ _05221_ VGND VGND VPWR VPWR _05264_ sky130_fd_sc_hd__a21o_1
XFILLER_0_108_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08359_ _03789_ _03800_ _03811_ _03029_ VGND VGND VPWR VPWR _04513_ sky130_fd_sc_hd__a22oi_4
X_11370_ _02632_ _02633_ VGND VGND VPWR VPWR _02634_ sky130_fd_sc_hd__or2_1
XFILLER_0_132_842 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10321_ _01555_ _01556_ VGND VGND VPWR VPWR _01557_ sky130_fd_sc_hd__or2_1
XFILLER_0_15_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13040_ _04453_ _04454_ VGND VGND VPWR VPWR _04455_ sky130_fd_sc_hd__or2_1
X_10252_ _01497_ Q_cos\[0\] VGND VGND VPWR VPWR _01498_ sky130_fd_sc_hd__nand2_1
XFILLER_0_131_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10183_ _01438_ VGND VGND VPWR VPWR _00028_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_100_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14991_ Q_sin\[1\] _06582_ _05626_ VGND VGND VPWR VPWR _06583_ sky130_fd_sc_hd__mux2_1
Xfanout260 net66 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__clkbuf_4
Xfanout271 net272 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__clkbuf_4
Xfanout282 net285 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__clkbuf_4
X_13942_ _05429_ _05430_ _05436_ VGND VGND VPWR VPWR _05437_ sky130_fd_sc_hd__o21a_1
Xfanout293 net295 VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__buf_2
X_13873_ _05291_ _05294_ VGND VGND VPWR VPWR _05363_ sky130_fd_sc_hd__or2_1
XFILLER_0_69_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15612_ _07240_ _07258_ VGND VGND VPWR VPWR _07259_ sky130_fd_sc_hd__xor2_2
X_12824_ _04214_ _04219_ VGND VGND VPWR VPWR _04220_ sky130_fd_sc_hd__xor2_1
XFILLER_0_29_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15543_ _07182_ _07089_ _07090_ VGND VGND VPWR VPWR _07185_ sky130_fd_sc_hd__or3_1
XFILLER_0_57_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12755_ _04142_ _04006_ _04143_ _04078_ VGND VGND VPWR VPWR _04144_ sky130_fd_sc_hd__o211a_1
XFILLER_0_56_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11706_ _02994_ _02998_ _02999_ VGND VGND VPWR VPWR _03000_ sky130_fd_sc_hd__nand3_1
X_15474_ _07105_ _07108_ VGND VGND VPWR VPWR _07109_ sky130_fd_sc_hd__xnor2_2
X_12686_ _04066_ _04067_ VGND VGND VPWR VPWR _04068_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14425_ net188 net178 net551 net559 VGND VGND VPWR VPWR _05962_ sky130_fd_sc_hd__and4_1
X_11637_ _02924_ _02858_ _02850_ VGND VGND VPWR VPWR _02925_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_108_850 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14356_ _05863_ _05870_ _05885_ VGND VGND VPWR VPWR _05886_ sky130_fd_sc_hd__a21oi_4
X_11568_ net49 _02775_ VGND VGND VPWR VPWR _02850_ sky130_fd_sc_hd__and2_2
XFILLER_0_123_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13307_ _04744_ _04746_ VGND VGND VPWR VPWR _04747_ sky130_fd_sc_hd__xnor2_2
X_10519_ _01742_ _01743_ _01744_ VGND VGND VPWR VPWR _01745_ sky130_fd_sc_hd__nand3_4
X_14287_ _05805_ _05811_ VGND VGND VPWR VPWR _05812_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11499_ net797 net414 net405 VGND VGND VPWR VPWR _02775_ sky130_fd_sc_hd__and3_1
X_16026_ net261 net656 net664 net252 VGND VGND VPWR VPWR _07709_ sky130_fd_sc_hd__a22oi_1
X_13238_ _04669_ _04670_ VGND VGND VPWR VPWR _04671_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13169_ net615 net175 _04593_ _04594_ VGND VGND VPWR VPWR _04596_ sky130_fd_sc_hd__nand4_2
XFILLER_0_137_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09400_ _00670_ _00675_ VGND VGND VPWR VPWR _00676_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_94_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09331_ _00593_ _00606_ _00607_ VGND VGND VPWR VPWR _00608_ sky130_fd_sc_hd__nand3_1
XFILLER_0_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09262_ _00536_ _00537_ _00538_ VGND VGND VPWR VPWR _00540_ sky130_fd_sc_hd__nand3_1
XFILLER_0_35_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08213_ _02855_ _02909_ VGND VGND VPWR VPWR _02920_ sky130_fd_sc_hd__xnor2_1
X_09193_ _00292_ _00382_ VGND VGND VPWR VPWR _00472_ sky130_fd_sc_hd__nand2_1
XFILLER_0_16_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08144_ _02159_ VGND VGND VPWR VPWR _02170_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_132_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08977_ _00154_ _00155_ _00156_ VGND VGND VPWR VPWR _00258_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_98_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10870_ net802 net379 _02091_ _02094_ VGND VGND VPWR VPWR _02096_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_97_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09529_ _00802_ _00803_ VGND VGND VPWR VPWR _00804_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12540_ _03777_ _03812_ _03813_ VGND VGND VPWR VPWR _03907_ sky130_fd_sc_hd__nor3_1
XFILLER_0_148_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12471_ _03721_ _03720_ _03719_ VGND VGND VPWR VPWR _03831_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_46_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14210_ _05642_ _05641_ VGND VGND VPWR VPWR _05728_ sky130_fd_sc_hd__and2b_1
X_11422_ _02628_ _02689_ _02690_ VGND VGND VPWR VPWR _02691_ sky130_fd_sc_hd__nand3_2
X_15190_ net265 net932 net575 net584 VGND VGND VPWR VPWR _06799_ sky130_fd_sc_hd__and4_1
XFILLER_0_117_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14141_ net298 _05524_ VGND VGND VPWR VPWR _05653_ sky130_fd_sc_hd__and2_1
X_11353_ net765 net444 VGND VGND VPWR VPWR _02616_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_89_Left_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10304_ _01542_ VGND VGND VPWR VPWR _00045_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_104_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14072_ _05485_ _05490_ VGND VGND VPWR VPWR _05578_ sky130_fd_sc_hd__and2b_1
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11284_ net797 net522 net394 VGND VGND VPWR VPWR _02541_ sky130_fd_sc_hd__and3_1
X_13023_ _02181_ D_sin\[1\] VGND VGND VPWR VPWR _04438_ sky130_fd_sc_hd__and2b_1
X_10235_ net131 net86 VGND VGND VPWR VPWR _01484_ sky130_fd_sc_hd__and2b_1
X_10166_ _01415_ _01418_ _01416_ VGND VGND VPWR VPWR _01424_ sky130_fd_sc_hd__a21bo_1
X_10097_ net627 net448 _01259_ VGND VGND VPWR VPWR _01363_ sky130_fd_sc_hd__and3_1
X_14974_ _06561_ _06562_ _06526_ VGND VGND VPWR VPWR _06565_ sky130_fd_sc_hd__o21a_1
XFILLER_0_89_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13925_ net298 net148 _05417_ _05418_ VGND VGND VPWR VPWR _05419_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_16_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13856_ _05322_ _05342_ _05343_ VGND VGND VPWR VPWR _05344_ sky130_fd_sc_hd__and3_1
XFILLER_0_76_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12807_ _04188_ _04189_ _04199_ VGND VGND VPWR VPWR _04201_ sky130_fd_sc_hd__and3_1
XFILLER_0_85_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13787_ _05165_ _05268_ VGND VGND VPWR VPWR _05269_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_32_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10999_ _02227_ _02228_ _02211_ VGND VGND VPWR VPWR _02230_ sky130_fd_sc_hd__a21o_1
XFILLER_0_123_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15526_ _07050_ _07062_ _07165_ VGND VGND VPWR VPWR _07166_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_123_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12738_ _04121_ _04124_ VGND VGND VPWR VPWR _04125_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_17_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15457_ _06993_ _06979_ _07083_ VGND VGND VPWR VPWR _07090_ sky130_fd_sc_hd__a21boi_1
X_12669_ _04045_ _04047_ _04046_ VGND VGND VPWR VPWR _04049_ sky130_fd_sc_hd__a21o_1
X_14408_ _05903_ _05905_ _05902_ VGND VGND VPWR VPWR _05943_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_113_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15388_ _06999_ _07014_ VGND VGND VPWR VPWR _07015_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14339_ net169 net590 _05865_ _05866_ VGND VGND VPWR VPWR _05867_ sky130_fd_sc_hd__and4_1
XFILLER_0_142_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08900_ _03073_ _08117_ _08116_ VGND VGND VPWR VPWR _00182_ sky130_fd_sc_hd__a21bo_1
X_16009_ _07689_ _07690_ VGND VGND VPWR VPWR _07691_ sky130_fd_sc_hd__and2_1
X_09880_ _01083_ _01084_ _00987_ VGND VGND VPWR VPWR _01150_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08831_ _08072_ _08074_ _08139_ VGND VGND VPWR VPWR _08141_ sky130_fd_sc_hd__a21oi_2
X_08762_ _08070_ _08071_ _08056_ VGND VGND VPWR VPWR _08073_ sky130_fd_sc_hd__a21o_1
X_08693_ net598 net525 net436 net606 VGND VGND VPWR VPWR _08005_ sky130_fd_sc_hd__a22o_1
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09314_ _00573_ _00590_ VGND VGND VPWR VPWR _00591_ sky130_fd_sc_hd__xor2_1
XFILLER_0_35_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09245_ _00505_ _00522_ VGND VGND VPWR VPWR _00523_ sky130_fd_sc_hd__xor2_2
XFILLER_0_91_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_146_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09176_ _00453_ _00454_ VGND VGND VPWR VPWR _00455_ sky130_fd_sc_hd__xor2_2
XFILLER_0_105_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10020_ _01234_ _01287_ VGND VGND VPWR VPWR _01288_ sky130_fd_sc_hd__xnor2_1
X_11971_ net512 net461 net451 net610 VGND VGND VPWR VPWR _03288_ sky130_fd_sc_hd__a22oi_2
X_13710_ _05183_ _05184_ VGND VGND VPWR VPWR _05185_ sky130_fd_sc_hd__xnor2_1
X_10922_ net770 net528 _02143_ VGND VGND VPWR VPWR _02148_ sky130_fd_sc_hd__a21o_1
X_14690_ _06251_ _06246_ _06247_ VGND VGND VPWR VPWR _06253_ sky130_fd_sc_hd__nand3_1
XFILLER_0_58_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13641_ net316 net158 net307 net425 VGND VGND VPWR VPWR _05110_ sky130_fd_sc_hd__a22oi_2
X_10853_ _02068_ _02076_ _02078_ VGND VGND VPWR VPWR _02079_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_67_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16360_ clknet_4_7_0_clk _00073_ net336 VGND VGND VPWR VPWR D_cos\[15\] sky130_fd_sc_hd__dfrtp_1
X_13572_ _04980_ _05034_ VGND VGND VPWR VPWR _05035_ sky130_fd_sc_hd__xnor2_1
X_10784_ _01990_ _01987_ _01989_ VGND VGND VPWR VPWR _02010_ sky130_fd_sc_hd__nand3_1
X_15311_ _06927_ _06928_ _06929_ VGND VGND VPWR VPWR _06931_ sky130_fd_sc_hd__nand3_1
X_12523_ net218 net804 VGND VGND VPWR VPWR _03889_ sky130_fd_sc_hd__nand2_1
X_16291_ clknet_4_11_0_clk _00004_ net341 VGND VGND VPWR VPWR Q_cos\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_82_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15242_ _06854_ _06855_ VGND VGND VPWR VPWR _06856_ sky130_fd_sc_hd__xnor2_1
X_12454_ _03809_ _03810_ _03764_ _03779_ VGND VGND VPWR VPWR _03813_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_124_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11405_ _02671_ _02672_ _02451_ VGND VGND VPWR VPWR _02673_ sky130_fd_sc_hd__a21bo_1
X_15173_ _06778_ _06779_ _06681_ VGND VGND VPWR VPWR _06782_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12385_ _03728_ _03735_ _03736_ VGND VGND VPWR VPWR _03737_ sky130_fd_sc_hd__and3_2
XFILLER_0_111_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14124_ net228 net263 net254 net313 VGND VGND VPWR VPWR _05635_ sky130_fd_sc_hd__a22oi_1
X_11336_ _02596_ _02597_ VGND VGND VPWR VPWR _02598_ sky130_fd_sc_hd__nor2_1
X_14055_ _05552_ _05556_ _05550_ VGND VGND VPWR VPWR _05560_ sky130_fd_sc_hd__o21bai_1
X_11267_ _02501_ _02520_ _02521_ VGND VGND VPWR VPWR _02522_ sky130_fd_sc_hd__and3_1
X_13006_ _04381_ _04417_ _04418_ VGND VGND VPWR VPWR _04419_ sky130_fd_sc_hd__nor3_2
X_10218_ _01467_ _01468_ VGND VGND VPWR VPWR _01469_ sky130_fd_sc_hd__nor2_1
X_11198_ _02445_ _02446_ VGND VGND VPWR VPWR _02447_ sky130_fd_sc_hd__and2b_1
XFILLER_0_27_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10149_ D_cos\[5\] Q_sin\[5\] VGND VGND VPWR VPWR _01409_ sky130_fd_sc_hd__or2b_1
XFILLER_0_27_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14957_ net322 net237 net652 net642 VGND VGND VPWR VPWR _06546_ sky130_fd_sc_hd__and4_1
X_13908_ _05219_ _05223_ _05314_ VGND VGND VPWR VPWR _05401_ sky130_fd_sc_hd__a21oi_1
X_14888_ _06217_ _06218_ _06196_ VGND VGND VPWR VPWR _06471_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_134_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_843 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13839_ net317 net289 net280 net424 VGND VGND VPWR VPWR _05325_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_57_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15509_ _07051_ _06960_ VGND VGND VPWR VPWR _07147_ sky130_fd_sc_hd__or2_1
XFILLER_0_127_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09030_ _00306_ _00309_ VGND VGND VPWR VPWR _00310_ sky130_fd_sc_hd__xor2_1
XFILLER_0_143_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09932_ net620 net484 net474 VGND VGND VPWR VPWR _01201_ sky130_fd_sc_hd__and3_1
XFILLER_0_110_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout804 net805 VGND VGND VPWR VPWR net804 sky130_fd_sc_hd__clkbuf_4
X_09863_ _01048_ _01053_ VGND VGND VPWR VPWR _01133_ sky130_fd_sc_hd__and2b_1
X_08814_ _08037_ _08124_ VGND VGND VPWR VPWR _08125_ sky130_fd_sc_hd__xnor2_1
X_09794_ _01063_ _01064_ VGND VGND VPWR VPWR _01065_ sky130_fd_sc_hd__nor2_1
X_08745_ _04086_ _04163_ _04152_ VGND VGND VPWR VPWR _08056_ sky130_fd_sc_hd__a21o_1
X_08676_ net606 net416 _07944_ _07954_ VGND VGND VPWR VPWR _07965_ sky130_fd_sc_hd__a31o_1
XFILLER_0_67_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09228_ _00433_ _00441_ _00439_ VGND VGND VPWR VPWR _00506_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_118_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09159_ net675 net356 _00435_ _00436_ VGND VGND VPWR VPWR _00438_ sky130_fd_sc_hd__nand4_1
XFILLER_0_16_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12170_ _03444_ _03495_ VGND VGND VPWR VPWR _03504_ sky130_fd_sc_hd__or2b_1
X_11121_ _02342_ _02361_ _02362_ VGND VGND VPWR VPWR _02363_ sky130_fd_sc_hd__and3_1
XFILLER_0_31_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11052_ _02287_ VGND VGND VPWR VPWR _00059_ sky130_fd_sc_hd__clkbuf_1
X_10003_ _01268_ _01270_ VGND VGND VPWR VPWR _01271_ sky130_fd_sc_hd__xnor2_1
X_15860_ _07502_ _07503_ _07527_ VGND VGND VPWR VPWR _07529_ sky130_fd_sc_hd__nand3_1
X_14811_ _06379_ _06384_ _06385_ VGND VGND VPWR VPWR _06386_ sky130_fd_sc_hd__nand3_2
X_15791_ _07278_ _07357_ _07453_ VGND VGND VPWR VPWR _07454_ sky130_fd_sc_hd__a21oi_1
X_14742_ _06308_ _06309_ VGND VGND VPWR VPWR _06310_ sky130_fd_sc_hd__nor2_1
X_11954_ net792 net349 net502 VGND VGND VPWR VPWR _03270_ sky130_fd_sc_hd__and3_1
X_10905_ _02117_ _02130_ VGND VGND VPWR VPWR _02131_ sky130_fd_sc_hd__xnor2_1
X_14673_ _06230_ _06232_ _06233_ VGND VGND VPWR VPWR _06235_ sky130_fd_sc_hd__a21bo_1
X_11885_ _03183_ _03184_ _03194_ VGND VGND VPWR VPWR _03195_ sky130_fd_sc_hd__o21a_1
XFILLER_0_67_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13624_ net230 net167 VGND VGND VPWR VPWR _05092_ sky130_fd_sc_hd__nand2_1
X_10836_ net769 net777 net419 net410 VGND VGND VPWR VPWR _02062_ sky130_fd_sc_hd__and4_1
XFILLER_0_104_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_17_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16343_ clknet_4_5_0_clk _00056_ net335 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__dfrtp_1
X_13555_ _04922_ _04924_ _04923_ VGND VGND VPWR VPWR _05017_ sky130_fd_sc_hd__a21bo_1
X_10767_ _01980_ _01991_ _01992_ VGND VGND VPWR VPWR _01993_ sky130_fd_sc_hd__nand3_2
X_12506_ _03863_ _03868_ _03869_ VGND VGND VPWR VPWR _03870_ sky130_fd_sc_hd__nand3_1
X_16274_ _07973_ _07977_ VGND VGND VPWR VPWR _07978_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_42_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13486_ _04886_ _04941_ VGND VGND VPWR VPWR _04942_ sky130_fd_sc_hd__xnor2_2
X_10698_ _01915_ _01916_ _01922_ VGND VGND VPWR VPWR _01924_ sky130_fd_sc_hd__and3_1
XFILLER_0_81_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15225_ _06834_ _06836_ _06819_ VGND VGND VPWR VPWR _06838_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_81_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12437_ _03754_ _03755_ _03753_ VGND VGND VPWR VPWR _03794_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_22_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15156_ _06750_ _06751_ _06762_ VGND VGND VPWR VPWR _06763_ sky130_fd_sc_hd__nor3b_1
X_12368_ _03694_ _03693_ _03692_ VGND VGND VPWR VPWR _03718_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_50_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14107_ _05614_ _05615_ _05611_ _05613_ VGND VGND VPWR VPWR _05617_ sky130_fd_sc_hd__o211a_1
XFILLER_0_10_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11319_ _02577_ _02578_ VGND VGND VPWR VPWR _02579_ sky130_fd_sc_hd__xnor2_2
X_15087_ net566 _06604_ _06608_ _06605_ VGND VGND VPWR VPWR _06687_ sky130_fd_sc_hd__a22o_1
XFILLER_0_120_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12299_ _03582_ _03594_ _03642_ VGND VGND VPWR VPWR _03644_ sky130_fd_sc_hd__or3_1
XPHY_EDGE_ROW_26_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14038_ _05540_ _05541_ VGND VGND VPWR VPWR _05542_ sky130_fd_sc_hd__nor2_1
XFILLER_0_38_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15989_ net155 net304 net619 VGND VGND VPWR VPWR _07669_ sky130_fd_sc_hd__o21a_1
X_08530_ net699 net363 VGND VGND VPWR VPWR _06377_ sky130_fd_sc_hd__nand2_1
X_08461_ _05590_ _05612_ VGND VGND VPWR VPWR _05623_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_148_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_35_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08392_ net699 net499 _02572_ _02583_ VGND VGND VPWR VPWR _04872_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_46_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09013_ _00211_ _00197_ VGND VGND VPWR VPWR _00293_ sky130_fd_sc_hd__and2b_1
XFILLER_0_72_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold110 Q_sin\[17\] VGND VGND VPWR VPWR net916 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_13_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold121 net91 VGND VGND VPWR VPWR net927 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_41_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_44_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout601 net609 VGND VGND VPWR VPWR net601 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_111_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout612 net613 VGND VGND VPWR VPWR net612 sky130_fd_sc_hd__clkbuf_4
X_09915_ net662 net441 _01182_ VGND VGND VPWR VPWR _01184_ sky130_fd_sc_hd__and3_1
Xfanout623 net624 VGND VGND VPWR VPWR net623 sky130_fd_sc_hd__buf_4
Xfanout634 net28 VGND VGND VPWR VPWR net634 sky130_fd_sc_hd__buf_6
Xfanout645 net646 VGND VGND VPWR VPWR net645 sky130_fd_sc_hd__clkbuf_4
Xfanout656 net657 VGND VGND VPWR VPWR net656 sky130_fd_sc_hd__clkbuf_4
X_09846_ _01106_ _01107_ _01037_ VGND VGND VPWR VPWR _01116_ sky130_fd_sc_hd__nor3b_1
Xfanout667 net670 VGND VGND VPWR VPWR net667 sky130_fd_sc_hd__buf_2
Xfanout678 net679 VGND VGND VPWR VPWR net678 sky130_fd_sc_hd__buf_2
Xfanout689 net692 VGND VGND VPWR VPWR net689 sky130_fd_sc_hd__buf_4
X_09777_ _00981_ _00984_ _00982_ VGND VGND VPWR VPWR _01048_ sky130_fd_sc_hd__o21ba_1
X_08728_ _04502_ net880 _08038_ _02703_ VGND VGND VPWR VPWR _08039_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_68_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08659_ _07684_ _07760_ _07369_ _07770_ VGND VGND VPWR VPWR _07781_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_96_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11670_ _02958_ _02959_ _02960_ VGND VGND VPWR VPWR _02961_ sky130_fd_sc_hd__and3_1
XFILLER_0_49_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10621_ _01646_ _01657_ _01656_ _01652_ VGND VGND VPWR VPWR _01847_ sky130_fd_sc_hd__o211a_1
XFILLER_0_119_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13340_ _04764_ _04780_ VGND VGND VPWR VPWR _04782_ sky130_fd_sc_hd__nand2_1
XFILLER_0_119_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10552_ _01674_ _01676_ _01675_ VGND VGND VPWR VPWR _01778_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_107_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13271_ _04701_ _04706_ VGND VGND VPWR VPWR _04707_ sky130_fd_sc_hd__xor2_2
X_10483_ _01707_ _01708_ net724 net390 VGND VGND VPWR VPWR _01709_ sky130_fd_sc_hd__and4bb_1
X_15010_ _06528_ _06536_ _06535_ VGND VGND VPWR VPWR _06603_ sky130_fd_sc_hd__a21o_1
XFILLER_0_60_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12222_ net227 net450 _03559_ VGND VGND VPWR VPWR _03560_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_121_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12153_ _03483_ _03484_ VGND VGND VPWR VPWR _03486_ sky130_fd_sc_hd__xor2_1
XFILLER_0_130_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11104_ net141 net395 VGND VGND VPWR VPWR _02345_ sky130_fd_sc_hd__nand2_1
X_12084_ _03353_ _03371_ VGND VGND VPWR VPWR _03411_ sky130_fd_sc_hd__nor2_1
X_15912_ net261 net672 net681 net252 VGND VGND VPWR VPWR _07585_ sky130_fd_sc_hd__a22oi_2
X_11035_ _02266_ _02268_ _01812_ _02235_ VGND VGND VPWR VPWR _02270_ sky130_fd_sc_hd__o211a_1
X_15843_ _07508_ _07509_ VGND VGND VPWR VPWR _07511_ sky130_fd_sc_hd__nor2_1
X_15774_ _07433_ _07435_ VGND VGND VPWR VPWR _07436_ sky130_fd_sc_hd__nor2_1
X_12986_ net430 net215 net205 net514 VGND VGND VPWR VPWR _04397_ sky130_fd_sc_hd__a22oi_1
X_14725_ _06153_ _06290_ _06291_ VGND VGND VPWR VPWR _06292_ sky130_fd_sc_hd__nand3_4
X_11937_ _03089_ VGND VGND VPWR VPWR _03251_ sky130_fd_sc_hd__inv_2
XFILLER_0_28_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14656_ _06187_ _06199_ _06214_ _06215_ VGND VGND VPWR VPWR _06216_ sky130_fd_sc_hd__o211a_1
X_11868_ _03174_ _03175_ VGND VGND VPWR VPWR _03176_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_74_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10819_ _02042_ _02044_ VGND VGND VPWR VPWR _02045_ sky130_fd_sc_hd__nor2_1
X_13607_ _04964_ _04969_ _05072_ VGND VGND VPWR VPWR _05073_ sky130_fd_sc_hd__a21o_1
XFILLER_0_7_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14587_ net221 net560 VGND VGND VPWR VPWR _06140_ sky130_fd_sc_hd__and2_1
X_11799_ _03099_ _03100_ VGND VGND VPWR VPWR _03101_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_131_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16326_ clknet_4_10_0_clk _00039_ net346 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_43_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13538_ _04995_ _04996_ _04988_ VGND VGND VPWR VPWR _04998_ sky130_fd_sc_hd__a21o_1
XFILLER_0_131_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16257_ _07894_ _07912_ _07914_ VGND VGND VPWR VPWR _07959_ sky130_fd_sc_hd__a21bo_1
X_13469_ net214 net204 net143 net798 VGND VGND VPWR VPWR _04923_ sky130_fd_sc_hd__nand4_1
XFILLER_0_113_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15208_ _06752_ _06760_ _06758_ VGND VGND VPWR VPWR _06819_ sky130_fd_sc_hd__a21o_1
X_16188_ _07883_ _07884_ VGND VGND VPWR VPWR _07885_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_10_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15139_ _06646_ _06738_ _06742_ _06743_ VGND VGND VPWR VPWR _06744_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_11_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09700_ Q_cos\[11\] _00972_ _00661_ VGND VGND VPWR VPWR _00973_ sky130_fd_sc_hd__mux2_1
XFILLER_0_65_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09631_ _00768_ _00855_ VGND VGND VPWR VPWR _00904_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09562_ _00834_ _00835_ VGND VGND VPWR VPWR _00836_ sky130_fd_sc_hd__xnor2_1
X_08513_ _06168_ _06113_ _06124_ VGND VGND VPWR VPWR _06190_ sky130_fd_sc_hd__nand3_1
X_09493_ net383 _00615_ _00614_ VGND VGND VPWR VPWR _00768_ sky130_fd_sc_hd__a21boi_4
X_08444_ _05416_ _05427_ VGND VGND VPWR VPWR _05438_ sky130_fd_sc_hd__nor2_1
XFILLER_0_148_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08375_ _02354_ _02365_ VGND VGND VPWR VPWR _04687_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_147_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_868 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_52_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout420 net421 VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__buf_6
Xfanout431 net5 VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__clkbuf_4
Xfanout442 net445 VGND VGND VPWR VPWR net442 sky130_fd_sc_hd__buf_4
Xfanout453 net454 VGND VGND VPWR VPWR net453 sky130_fd_sc_hd__clkbuf_2
Xfanout464 net45 VGND VGND VPWR VPWR net464 sky130_fd_sc_hd__clkbuf_4
Xfanout475 net477 VGND VGND VPWR VPWR net475 sky130_fd_sc_hd__clkbuf_4
Xfanout486 net487 VGND VGND VPWR VPWR net486 sky130_fd_sc_hd__buf_2
X_09829_ _01007_ _01030_ _01096_ _01098_ VGND VGND VPWR VPWR _01100_ sky130_fd_sc_hd__a211oi_4
Xfanout497 net499 VGND VGND VPWR VPWR net497 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_61_Left_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12840_ _04233_ _04236_ VGND VGND VPWR VPWR _04237_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12771_ _04021_ _04022_ _04156_ _04159_ _04160_ VGND VGND VPWR VPWR _04161_ sky130_fd_sc_hd__o2111ai_2
X_14510_ net292 net585 net592 net285 VGND VGND VPWR VPWR _06055_ sky130_fd_sc_hd__a22oi_1
X_11722_ net229 net350 net503 net316 VGND VGND VPWR VPWR _03017_ sky130_fd_sc_hd__a22o_1
X_15490_ net156 net305 net665 net674 VGND VGND VPWR VPWR _07126_ sky130_fd_sc_hd__nand4_2
XFILLER_0_138_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14441_ _05976_ _05977_ _05978_ VGND VGND VPWR VPWR _05979_ sky130_fd_sc_hd__or3_4
X_11653_ _02860_ _02859_ VGND VGND VPWR VPWR _02943_ sky130_fd_sc_hd__and2b_1
XFILLER_0_139_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10604_ net726 net418 net410 net735 VGND VGND VPWR VPWR _01830_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_25_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14372_ net220 net695 VGND VGND VPWR VPWR _05903_ sky130_fd_sc_hd__nand2_1
X_11584_ net375 _02865_ _02867_ VGND VGND VPWR VPWR _02868_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_51_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16111_ _07669_ _07742_ net936 _07668_ VGND VGND VPWR VPWR _07801_ sky130_fd_sc_hd__a2bb2o_2
XFILLER_0_91_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13323_ _04675_ _04696_ _04694_ VGND VGND VPWR VPWR _04764_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_135_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_70_Left_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10535_ _01686_ _01688_ _01687_ VGND VGND VPWR VPWR _01761_ sky130_fd_sc_hd__a21o_1
XFILLER_0_150_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16042_ _07707_ _07708_ _07725_ VGND VGND VPWR VPWR _07726_ sky130_fd_sc_hd__a21oi_1
X_13254_ _04575_ _04573_ _04574_ VGND VGND VPWR VPWR _04689_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_10_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10466_ _01690_ _01691_ VGND VGND VPWR VPWR _01692_ sky130_fd_sc_hd__xnor2_1
X_12205_ net136 net467 _03540_ VGND VGND VPWR VPWR _03542_ sky130_fd_sc_hd__and3_1
XFILLER_0_122_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13185_ _04501_ _04607_ _04612_ _04613_ VGND VGND VPWR VPWR _04614_ sky130_fd_sc_hd__o211ai_2
X_10397_ _01617_ _01622_ VGND VGND VPWR VPWR _01623_ sky130_fd_sc_hd__or2b_1
XFILLER_0_103_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12136_ _03407_ _03467_ VGND VGND VPWR VPWR _03468_ sky130_fd_sc_hd__xor2_1
X_12067_ _03391_ _03311_ _03392_ VGND VGND VPWR VPWR _03393_ sky130_fd_sc_hd__o21ba_1
X_11018_ _02247_ _02250_ VGND VGND VPWR VPWR _02251_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_35_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15826_ _07284_ _07491_ VGND VGND VPWR VPWR _07492_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_149_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15757_ _07295_ _07296_ VGND VGND VPWR VPWR _07417_ sky130_fd_sc_hd__and2_1
X_12969_ _04375_ _04376_ _04359_ VGND VGND VPWR VPWR _04378_ sky130_fd_sc_hd__a21o_1
XFILLER_0_143_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14708_ net76 net702 VGND VGND VPWR VPWR _06273_ sky130_fd_sc_hd__nand2_1
X_15688_ _07202_ _07203_ _07341_ VGND VGND VPWR VPWR _07342_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_47_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14639_ _06189_ _06191_ _06195_ VGND VGND VPWR VPWR _06197_ sky130_fd_sc_hd__and3_1
XFILLER_0_144_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_109_Left_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08160_ net587 net360 _02321_ _02332_ VGND VGND VPWR VPWR _02343_ sky130_fd_sc_hd__and4_1
XFILLER_0_55_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16309_ clknet_4_15_0_clk _00022_ net342 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_31_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08993_ _00214_ _00272_ net811 VGND VGND VPWR VPWR _00274_ sky130_fd_sc_hd__nand3_2
X_09614_ _00864_ _00865_ _00885_ _00886_ VGND VGND VPWR VPWR _00888_ sky130_fd_sc_hd__or4_4
X_09545_ _00655_ _00736_ VGND VGND VPWR VPWR _00820_ sky130_fd_sc_hd__nand2_1
X_09476_ _00749_ _00750_ VGND VGND VPWR VPWR _00751_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08427_ _04959_ _05003_ VGND VGND VPWR VPWR _05253_ sky130_fd_sc_hd__xnor2_1
X_08358_ _04480_ _04491_ VGND VGND VPWR VPWR _04502_ sky130_fd_sc_hd__nor2_1
XFILLER_0_61_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_144_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08289_ _03658_ _03734_ VGND VGND VPWR VPWR _03745_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_22_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10320_ D_sin\[10\] Q_cos\[10\] VGND VGND VPWR VPWR _01556_ sky130_fd_sc_hd__and2b_1
XFILLER_0_131_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10251_ D_sin\[0\] VGND VGND VPWR VPWR _01497_ sky130_fd_sc_hd__inv_2
X_10182_ net97 _01437_ net130 VGND VGND VPWR VPWR _01438_ sky130_fd_sc_hd__mux2_1
XFILLER_0_100_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14990_ _06580_ _06581_ VGND VGND VPWR VPWR _06582_ sky130_fd_sc_hd__nor2_1
Xfanout250 net251 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__clkbuf_4
Xfanout261 net262 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__clkbuf_4
Xfanout272 net64 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__buf_4
Xfanout283 net285 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__buf_2
X_13941_ _05431_ _05435_ VGND VGND VPWR VPWR _05436_ sky130_fd_sc_hd__xnor2_1
Xfanout294 net295 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_89_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13872_ _05359_ _05274_ _05357_ _05358_ VGND VGND VPWR VPWR _05361_ sky130_fd_sc_hd__a211o_1
X_15611_ _07256_ _07257_ VGND VGND VPWR VPWR _07258_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12823_ _04215_ _04217_ VGND VGND VPWR VPWR _04219_ sky130_fd_sc_hd__nand2_1
X_15542_ _07089_ _07090_ _07182_ VGND VGND VPWR VPWR _07183_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_141_Right_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12754_ _04074_ _04077_ _04076_ VGND VGND VPWR VPWR _04143_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_84_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11705_ net150 net358 _02995_ _02997_ VGND VGND VPWR VPWR _02999_ sky130_fd_sc_hd__nand4_2
X_15473_ _07106_ VGND VGND VPWR VPWR _07108_ sky130_fd_sc_hd__inv_2
XFILLER_0_126_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12685_ net189 net744 net754 net179 VGND VGND VPWR VPWR _04067_ sky130_fd_sc_hd__a22oi_2
X_14424_ net169 net571 VGND VGND VPWR VPWR _05961_ sky130_fd_sc_hd__nand2_1
X_11636_ _02451_ _02774_ VGND VGND VPWR VPWR _02924_ sky130_fd_sc_hd__nand2_1
XFILLER_0_52_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14355_ _05880_ _05884_ VGND VGND VPWR VPWR _05885_ sky130_fd_sc_hd__xnor2_2
X_11567_ _02828_ _02848_ VGND VGND VPWR VPWR _02849_ sky130_fd_sc_hd__xor2_2
XFILLER_0_107_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10518_ _01735_ _01736_ _01741_ VGND VGND VPWR VPWR _01744_ sky130_fd_sc_hd__a21o_1
X_13306_ _04745_ _04635_ VGND VGND VPWR VPWR _04746_ sky130_fd_sc_hd__nor2_1
X_14286_ _05556_ _05684_ _05806_ _05808_ _05810_ VGND VGND VPWR VPWR _05811_ sky130_fd_sc_hd__o311ai_4
XFILLER_0_123_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11498_ net414 net405 net797 VGND VGND VPWR VPWR _02774_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_150_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16025_ _07655_ _07675_ VGND VGND VPWR VPWR _07708_ sky130_fd_sc_hd__or2b_1
X_13237_ net784 _04537_ VGND VGND VPWR VPWR _04670_ sky130_fd_sc_hd__nor2_1
X_10449_ net751 net761 net353 net507 VGND VGND VPWR VPWR _01675_ sky130_fd_sc_hd__and4_1
XFILLER_0_21_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13168_ net615 net174 _04593_ _04594_ VGND VGND VPWR VPWR _04595_ sky130_fd_sc_hd__a22o_1
X_12119_ _03350_ _03448_ VGND VGND VPWR VPWR _03449_ sky130_fd_sc_hd__nand2_1
X_13099_ _04417_ _04419_ _04518_ _04519_ VGND VGND VPWR VPWR _04520_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_46_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15809_ net304 net637 net629 net155 VGND VGND VPWR VPWR _07473_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_88_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09330_ _00604_ _00605_ _00598_ VGND VGND VPWR VPWR _00607_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09261_ _00536_ _00537_ _00538_ VGND VGND VPWR VPWR _00539_ sky130_fd_sc_hd__a21o_1
XFILLER_0_8_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08212_ _02866_ _02898_ VGND VGND VPWR VPWR _02909_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_28_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09192_ _00288_ _00383_ _00284_ _00285_ VGND VGND VPWR VPWR _00471_ sky130_fd_sc_hd__or4bb_4
XFILLER_0_7_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08143_ net133 net78 VGND VGND VPWR VPWR _02159_ sky130_fd_sc_hd__and2b_1
XFILLER_0_133_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08976_ _00254_ _00255_ net631 net432 VGND VGND VPWR VPWR _00257_ sky130_fd_sc_hd__a2bb2o_1
X_09528_ _00800_ _00801_ VGND VGND VPWR VPWR _00803_ sky130_fd_sc_hd__or2_1
XFILLER_0_66_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09459_ _00733_ _00734_ VGND VGND VPWR VPWR _00735_ sky130_fd_sc_hd__nand2_1
XFILLER_0_94_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12470_ _03721_ _03719_ _03720_ VGND VGND VPWR VPWR _03830_ sky130_fd_sc_hd__or3_1
XFILLER_0_136_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11421_ _02687_ _02688_ _02560_ _02629_ VGND VGND VPWR VPWR _02690_ sky130_fd_sc_hd__a211o_1
XFILLER_0_123_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14140_ _05630_ _05650_ VGND VGND VPWR VPWR _05652_ sky130_fd_sc_hd__nor2_1
X_11352_ _02612_ _02613_ VGND VGND VPWR VPWR _02614_ sky130_fd_sc_hd__nor2_1
XFILLER_0_132_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10303_ net926 _01541_ net133 VGND VGND VPWR VPWR _01542_ sky130_fd_sc_hd__mux2_1
XFILLER_0_120_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14071_ _05575_ _05576_ VGND VGND VPWR VPWR _05577_ sky130_fd_sc_hd__xor2_1
X_11283_ net797 net522 VGND VGND VPWR VPWR _02540_ sky130_fd_sc_hd__nand2_1
XFILLER_0_131_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13022_ _04334_ _04335_ _04339_ _04434_ VGND VGND VPWR VPWR _04436_ sky130_fd_sc_hd__a31o_1
X_10234_ _01474_ _01480_ _01481_ VGND VGND VPWR VPWR _01483_ sky130_fd_sc_hd__or3_1
X_10165_ _01421_ _01422_ VGND VGND VPWR VPWR _01423_ sky130_fd_sc_hd__nand2_1
XFILLER_0_83_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10096_ _01070_ _01299_ _01291_ VGND VGND VPWR VPWR _01362_ sky130_fd_sc_hd__a21oi_1
X_14973_ _06526_ _06561_ _06562_ VGND VGND VPWR VPWR _06564_ sky130_fd_sc_hd__nor3_4
X_13924_ net157 net306 net139 net795 VGND VGND VPWR VPWR _05418_ sky130_fd_sc_hd__and4_1
X_13855_ _05323_ _05324_ _05341_ VGND VGND VPWR VPWR _05343_ sky130_fd_sc_hd__nand3_1
X_12806_ _04188_ _04189_ _04199_ VGND VGND VPWR VPWR _04200_ sky130_fd_sc_hd__a21oi_2
X_10998_ _02211_ _02227_ _02228_ VGND VGND VPWR VPWR _02229_ sky130_fd_sc_hd__nand3_2
X_13786_ _05259_ _05267_ VGND VGND VPWR VPWR _05268_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15525_ _07061_ _07059_ VGND VGND VPWR VPWR _07165_ sky130_fd_sc_hd__and2b_1
X_12737_ _04122_ _04123_ VGND VGND VPWR VPWR _04124_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15456_ _06989_ _07088_ VGND VGND VPWR VPWR _07089_ sky130_fd_sc_hd__nor2_1
X_12668_ _04045_ _04046_ _04047_ VGND VGND VPWR VPWR _04048_ sky130_fd_sc_hd__nand3_1
XFILLER_0_65_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14407_ _05939_ _05940_ _05941_ VGND VGND VPWR VPWR _05942_ sky130_fd_sc_hd__or3_1
X_11619_ net720 net470 _02834_ _02832_ VGND VGND VPWR VPWR _02905_ sky130_fd_sc_hd__a31o_1
XFILLER_0_5_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15387_ _07012_ _07013_ VGND VGND VPWR VPWR _07014_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_114_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12599_ _03970_ _03971_ VGND VGND VPWR VPWR _03972_ sky130_fd_sc_hd__nor2_1
XFILLER_0_142_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14338_ net187 net571 net581 net177 VGND VGND VPWR VPWR _05866_ sky130_fd_sc_hd__a22o_1
XFILLER_0_123_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14269_ _05791_ _05737_ VGND VGND VPWR VPWR _05792_ sky130_fd_sc_hd__nor2_1
XFILLER_0_148_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16008_ _07622_ _07623_ _07688_ VGND VGND VPWR VPWR _07690_ sky130_fd_sc_hd__or3_1
X_08830_ _08072_ _08074_ _08139_ VGND VGND VPWR VPWR _08140_ sky130_fd_sc_hd__and3_1
XFILLER_0_57_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08761_ _08056_ _08070_ _08071_ VGND VGND VPWR VPWR _08072_ sky130_fd_sc_hd__nand3_2
X_08692_ _08002_ _08003_ VGND VGND VPWR VPWR _08004_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_48_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09313_ _00575_ _00589_ VGND VGND VPWR VPWR _00590_ sky130_fd_sc_hd__xor2_1
XFILLER_0_137_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09244_ _00506_ _00521_ VGND VGND VPWR VPWR _00522_ sky130_fd_sc_hd__xor2_2
XFILLER_0_35_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_146_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09175_ _00352_ _00360_ _00359_ VGND VGND VPWR VPWR _00454_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_133_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08959_ net403 _00149_ _00152_ _00150_ VGND VGND VPWR VPWR _00240_ sky130_fd_sc_hd__a22o_1
X_11970_ _03166_ _03169_ _03167_ VGND VGND VPWR VPWR _03287_ sky130_fd_sc_hd__o21ba_1
X_10921_ _02140_ _02146_ net778 net527 VGND VGND VPWR VPWR _02147_ sky130_fd_sc_hd__and4b_1
XFILLER_0_67_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10852_ _02034_ _02077_ VGND VGND VPWR VPWR _02078_ sky130_fd_sc_hd__nand2_1
X_13640_ _05107_ _05108_ VGND VGND VPWR VPWR _05109_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_78_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10783_ _01977_ _02008_ VGND VGND VPWR VPWR _02009_ sky130_fd_sc_hd__xnor2_1
X_13571_ _05031_ _05033_ VGND VGND VPWR VPWR _05034_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15310_ _06927_ _06928_ _06929_ VGND VGND VPWR VPWR _06930_ sky130_fd_sc_hd__a21o_1
X_12522_ net223 net804 _03885_ _03886_ VGND VGND VPWR VPWR _03887_ sky130_fd_sc_hd__a31o_1
X_16290_ clknet_4_10_0_clk _00003_ net341 VGND VGND VPWR VPWR Q_cos\[3\] sky130_fd_sc_hd__dfrtp_1
X_15241_ net193 net660 VGND VGND VPWR VPWR _06855_ sky130_fd_sc_hd__nand2_1
X_12453_ _03764_ _03779_ _03809_ _03810_ VGND VGND VPWR VPWR _03812_ sky130_fd_sc_hd__o211a_2
XFILLER_0_136_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11404_ net141 net797 net414 net405 VGND VGND VPWR VPWR _02672_ sky130_fd_sc_hd__nand4_2
X_15172_ _06681_ net861 _06779_ VGND VGND VPWR VPWR _06780_ sky130_fd_sc_hd__nand3_1
X_12384_ _03709_ _03710_ _03726_ VGND VGND VPWR VPWR _03736_ sky130_fd_sc_hd__a21o_1
XFILLER_0_50_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11335_ _02593_ _02595_ _02479_ _02481_ VGND VGND VPWR VPWR _02597_ sky130_fd_sc_hd__a211oi_1
X_14123_ _05594_ _05597_ _05595_ VGND VGND VPWR VPWR _05634_ sky130_fd_sc_hd__o21ba_1
X_14054_ _05559_ VGND VGND VPWR VPWR _00090_ sky130_fd_sc_hd__clkbuf_1
X_11266_ _02518_ _02519_ _02502_ VGND VGND VPWR VPWR _02521_ sky130_fd_sc_hd__a21o_1
X_10217_ D_cos\[14\] Q_sin\[14\] VGND VGND VPWR VPWR _01468_ sky130_fd_sc_hd__and2b_1
X_13005_ _04414_ _04416_ _04310_ _04383_ VGND VGND VPWR VPWR _04418_ sky130_fd_sc_hd__o211a_1
X_11197_ _02443_ _02444_ _02439_ VGND VGND VPWR VPWR _02446_ sky130_fd_sc_hd__a21o_1
X_10148_ _01408_ VGND VGND VPWR VPWR _00023_ sky130_fd_sc_hd__clkbuf_1
X_14956_ net220 net660 VGND VGND VPWR VPWR _06545_ sky130_fd_sc_hd__nand2_2
X_10079_ next_state _01344_ _01345_ VGND VGND VPWR VPWR _00017_ sky130_fd_sc_hd__a21oi_1
X_13907_ _05225_ _05315_ VGND VGND VPWR VPWR _05400_ sky130_fd_sc_hd__nor2_1
X_14887_ _06230_ _06469_ VGND VGND VPWR VPWR _06470_ sky130_fd_sc_hd__or2_1
X_13838_ _05259_ _05267_ VGND VGND VPWR VPWR _05324_ sky130_fd_sc_hd__or2b_1
XFILLER_0_97_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13769_ net317 net298 VGND VGND VPWR VPWR _05249_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15508_ _07052_ _07145_ VGND VGND VPWR VPWR _07146_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_150_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15439_ _07068_ _07070_ VGND VGND VPWR VPWR _07071_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09931_ net620 net484 net474 net626 VGND VGND VPWR VPWR _01200_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_68_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout805 net806 VGND VGND VPWR VPWR net805 sky130_fd_sc_hd__buf_2
XFILLER_0_0_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09862_ _01130_ _01131_ VGND VGND VPWR VPWR _01132_ sky130_fd_sc_hd__xor2_1
X_08813_ net853 _08123_ VGND VGND VPWR VPWR _08124_ sky130_fd_sc_hd__and2_4
X_09793_ _01046_ _01047_ _01062_ VGND VGND VPWR VPWR _01064_ sky130_fd_sc_hd__and3_1
XFILLER_0_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08744_ _03932_ _04009_ VGND VGND VPWR VPWR _08055_ sky130_fd_sc_hd__and2_1
XFILLER_0_84_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08675_ net588 net598 net525 net436 VGND VGND VPWR VPWR _07954_ sky130_fd_sc_hd__and4_1
XFILLER_0_48_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09227_ _00420_ _00428_ _00427_ VGND VGND VPWR VPWR _00505_ sky130_fd_sc_hd__a21o_1
XFILLER_0_17_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09158_ net675 net357 _00435_ _00436_ VGND VGND VPWR VPWR _00437_ sky130_fd_sc_hd__a22o_1
XFILLER_0_114_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09089_ _00366_ _00367_ _00338_ _00266_ VGND VGND VPWR VPWR _00369_ sky130_fd_sc_hd__a211o_1
XFILLER_0_102_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11120_ _02358_ _02359_ _02360_ VGND VGND VPWR VPWR _02362_ sky130_fd_sc_hd__a21o_1
X_11051_ D_cos\[1\] _02286_ _01379_ VGND VGND VPWR VPWR _02287_ sky130_fd_sc_hd__mux2_1
X_10002_ _01179_ _01183_ _01184_ _01269_ VGND VGND VPWR VPWR _01270_ sky130_fd_sc_hd__o31a_1
X_14810_ _06373_ _06374_ _06378_ VGND VGND VPWR VPWR _06385_ sky130_fd_sc_hd__a21o_1
X_15790_ _07356_ _07353_ VGND VGND VPWR VPWR _07453_ sky130_fd_sc_hd__and2b_1
X_14741_ _06304_ _06305_ _06307_ VGND VGND VPWR VPWR _06309_ sky130_fd_sc_hd__and3_1
X_11953_ net792 net349 net502 net136 VGND VGND VPWR VPWR _03269_ sky130_fd_sc_hd__a22o_1
XFILLER_0_58_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10904_ _02125_ _02129_ VGND VGND VPWR VPWR _02130_ sky130_fd_sc_hd__nor2_1
XFILLER_0_58_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14672_ _06226_ _06228_ net828 _06231_ VGND VGND VPWR VPWR _06233_ sky130_fd_sc_hd__a211o_1
X_11884_ _03191_ _03193_ VGND VGND VPWR VPWR _03194_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_79_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13623_ _05088_ _05089_ VGND VGND VPWR VPWR _05091_ sky130_fd_sc_hd__nor2_1
X_10835_ net769 net419 net410 net777 VGND VGND VPWR VPWR _02061_ sky130_fd_sc_hd__a22o_1
XFILLER_0_27_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16342_ clknet_4_5_0_clk _00055_ net335 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dfrtp_1
X_13554_ _04913_ _04915_ VGND VGND VPWR VPWR _05016_ sky130_fd_sc_hd__nand2_2
X_10766_ _01883_ _01877_ _01882_ VGND VGND VPWR VPWR _01992_ sky130_fd_sc_hd__a21o_1
XFILLER_0_125_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12505_ _03737_ _03867_ _03864_ _03865_ VGND VGND VPWR VPWR _03869_ sky130_fd_sc_hd__o211ai_2
X_16273_ _07974_ _07975_ VGND VGND VPWR VPWR _07977_ sky130_fd_sc_hd__nand2_1
X_10697_ _01915_ _01916_ _01922_ VGND VGND VPWR VPWR _01923_ sky130_fd_sc_hd__a21oi_2
X_13485_ _04939_ _04940_ VGND VGND VPWR VPWR _04941_ sky130_fd_sc_hd__or2b_1
X_15224_ _06819_ _06834_ _06836_ VGND VGND VPWR VPWR _06837_ sky130_fd_sc_hd__and3_1
X_12436_ _03790_ _03791_ _03792_ VGND VGND VPWR VPWR _03793_ sky130_fd_sc_hd__or3_1
XFILLER_0_23_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15155_ _06752_ _06761_ VGND VGND VPWR VPWR _06762_ sky130_fd_sc_hd__xnor2_1
X_12367_ _03694_ _03692_ _03693_ VGND VGND VPWR VPWR _03717_ sky130_fd_sc_hd__or3_1
XFILLER_0_23_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14106_ _05611_ _05613_ _05614_ _05615_ VGND VGND VPWR VPWR _05616_ sky130_fd_sc_hd__a211oi_1
X_11318_ _02394_ _02395_ _02398_ _02393_ VGND VGND VPWR VPWR _02578_ sky130_fd_sc_hd__o22a_1
X_15086_ _06603_ _06619_ net870 net894 VGND VGND VPWR VPWR _06686_ sky130_fd_sc_hd__a31o_1
X_12298_ _03582_ _03594_ _03642_ VGND VGND VPWR VPWR _03643_ sky130_fd_sc_hd__o21ai_2
X_11249_ _02437_ _02446_ _02445_ VGND VGND VPWR VPWR _02502_ sky130_fd_sc_hd__a21o_1
X_14037_ _05443_ _05467_ _05538_ _05539_ VGND VGND VPWR VPWR _05541_ sky130_fd_sc_hd__o211a_1
XFILLER_0_129_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15988_ net155 net304 net619 VGND VGND VPWR VPWR _07668_ sky130_fd_sc_hd__and3_1
XFILLER_0_54_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14939_ _06524_ _06525_ VGND VGND VPWR VPWR _06526_ sky130_fd_sc_hd__nand2_1
XFILLER_0_145_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08460_ _04970_ _05601_ VGND VGND VPWR VPWR _05612_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_148_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08391_ net603 net699 net352 net505 VGND VGND VPWR VPWR _04861_ sky130_fd_sc_hd__and4_1
XFILLER_0_147_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09012_ _00194_ _00281_ _00280_ VGND VGND VPWR VPWR _00292_ sky130_fd_sc_hd__a21bo_4
XFILLER_0_131_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold111 net98 VGND VGND VPWR VPWR net917 sky130_fd_sc_hd__dlygate4sd3_1
Xhold122 Q_cos\[2\] VGND VGND VPWR VPWR net928 sky130_fd_sc_hd__dlygate4sd3_1
X_09914_ net662 net441 _01182_ VGND VGND VPWR VPWR _01183_ sky130_fd_sc_hd__a21oi_1
Xfanout602 net609 VGND VGND VPWR VPWR net602 sky130_fd_sc_hd__buf_2
Xfanout613 net618 VGND VGND VPWR VPWR net613 sky130_fd_sc_hd__buf_2
XFILLER_0_0_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout624 net625 VGND VGND VPWR VPWR net624 sky130_fd_sc_hd__buf_4
Xfanout635 net636 VGND VGND VPWR VPWR net635 sky130_fd_sc_hd__buf_2
Xfanout646 net26 VGND VGND VPWR VPWR net646 sky130_fd_sc_hd__clkbuf_4
X_09845_ _01115_ VGND VGND VPWR VPWR _00013_ sky130_fd_sc_hd__clkbuf_1
Xfanout657 net25 VGND VGND VPWR VPWR net657 sky130_fd_sc_hd__clkbuf_4
Xfanout668 net669 VGND VGND VPWR VPWR net668 sky130_fd_sc_hd__clkbuf_4
Xfanout679 net23 VGND VGND VPWR VPWR net679 sky130_fd_sc_hd__buf_4
X_09776_ _00977_ _00978_ _00995_ VGND VGND VPWR VPWR _01047_ sky130_fd_sc_hd__o21ai_1
X_08727_ _04480_ _04491_ _04829_ VGND VGND VPWR VPWR _08038_ sky130_fd_sc_hd__or3_4
X_08658_ _07336_ _07358_ _07347_ VGND VGND VPWR VPWR _07770_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_95_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08589_ _06998_ _07009_ VGND VGND VPWR VPWR _07020_ sky130_fd_sc_hd__or2b_1
XFILLER_0_48_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10620_ _01728_ _01844_ _01843_ _01839_ VGND VGND VPWR VPWR _01846_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_36_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10551_ _01773_ _01776_ VGND VGND VPWR VPWR _01777_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_146_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10482_ net429 net529 net935 net715 VGND VGND VPWR VPWR _01708_ sky130_fd_sc_hd__a22oi_1
X_13270_ _04704_ _04705_ VGND VGND VPWR VPWR _04706_ sky130_fd_sc_hd__xor2_2
XFILLER_0_121_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12221_ net145 net460 VGND VGND VPWR VPWR _03559_ sky130_fd_sc_hd__nand2_1
X_12152_ _03413_ _03416_ _03414_ VGND VGND VPWR VPWR _03484_ sky130_fd_sc_hd__o21ba_1
X_11103_ net426 VGND VGND VPWR VPWR _02344_ sky130_fd_sc_hd__inv_2
X_12083_ _03338_ _03339_ _03408_ VGND VGND VPWR VPWR _03410_ sky130_fd_sc_hd__o21ai_1
X_15911_ _07468_ _07471_ _07469_ VGND VGND VPWR VPWR _07584_ sky130_fd_sc_hd__o21ba_1
X_11034_ _01812_ _02235_ _02266_ _02268_ VGND VGND VPWR VPWR _02269_ sky130_fd_sc_hd__a211oi_4
X_15842_ net261 net252 net681 net690 VGND VGND VPWR VPWR _07509_ sky130_fd_sc_hd__and4_1
X_15773_ _07339_ _07338_ VGND VGND VPWR VPWR _07435_ sky130_fd_sc_hd__and2b_1
X_12985_ net430 net514 net215 net205 VGND VGND VPWR VPWR _04396_ sky130_fd_sc_hd__and4_1
XFILLER_0_99_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14724_ _06145_ _06152_ _06151_ VGND VGND VPWR VPWR _06291_ sky130_fd_sc_hd__a21o_1
XFILLER_0_86_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11936_ _03087_ _03190_ _03249_ VGND VGND VPWR VPWR _03250_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_59_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14655_ _06213_ _06205_ _06204_ VGND VGND VPWR VPWR _06215_ sky130_fd_sc_hd__nand3b_2
X_11867_ net229 net495 VGND VGND VPWR VPWR _03175_ sky130_fd_sc_hd__nand2_1
X_13606_ _04972_ _04971_ VGND VGND VPWR VPWR _05072_ sky130_fd_sc_hd__and2b_1
X_10818_ _02037_ _02043_ VGND VGND VPWR VPWR _02044_ sky130_fd_sc_hd__or2_1
X_14586_ _06127_ _06125_ _06126_ VGND VGND VPWR VPWR _06139_ sky130_fd_sc_hd__or3_1
X_11798_ _02992_ _03002_ _03003_ _02990_ VGND VGND VPWR VPWR _03100_ sky130_fd_sc_hd__a31o_1
X_16325_ clknet_4_10_0_clk _00038_ net341 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_125_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13537_ _04988_ _04995_ _04996_ VGND VGND VPWR VPWR _04997_ sky130_fd_sc_hd__nand3_2
XFILLER_0_70_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10749_ net787 net355 net508 net803 VGND VGND VPWR VPWR _01975_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_40_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16256_ _07897_ _07957_ VGND VGND VPWR VPWR _07958_ sky130_fd_sc_hd__xnor2_1
X_13468_ net204 net143 net798 net214 VGND VGND VPWR VPWR _04922_ sky130_fd_sc_hd__a22o_1
X_15207_ _06721_ _06723_ VGND VGND VPWR VPWR _06818_ sky130_fd_sc_hd__nand2_2
X_12419_ net162 net805 VGND VGND VPWR VPWR _03774_ sky130_fd_sc_hd__nand2_1
X_16187_ _07817_ _07818_ _07816_ VGND VGND VPWR VPWR _07884_ sky130_fd_sc_hd__o21ai_2
X_13399_ _04434_ _04532_ VGND VGND VPWR VPWR _04847_ sky130_fd_sc_hd__nor2_1
X_15138_ _06740_ _06741_ _06739_ VGND VGND VPWR VPWR _06743_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_121_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15069_ _06665_ _06666_ _06601_ VGND VGND VPWR VPWR _06668_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_10_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09630_ _00836_ _00843_ _00902_ VGND VGND VPWR VPWR _00903_ sky130_fd_sc_hd__a21o_1
X_09561_ net680 net465 VGND VGND VPWR VPWR _00835_ sky130_fd_sc_hd__nand2_1
X_08512_ _06113_ _06124_ _06168_ VGND VGND VPWR VPWR _06179_ sky130_fd_sc_hd__a21o_1
X_09492_ _00695_ _00697_ VGND VGND VPWR VPWR _00767_ sky130_fd_sc_hd__or2_1
XFILLER_0_148_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08443_ net562 net568 net407 net396 VGND VGND VPWR VPWR _05427_ sky130_fd_sc_hd__and4_1
XFILLER_0_81_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08374_ _04524_ _04654_ _04644_ VGND VGND VPWR VPWR _04676_ sky130_fd_sc_hd__a21o_1
XFILLER_0_46_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout410 net411 VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__buf_6
Xfanout421 net50 VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__buf_6
Xfanout432 net433 VGND VGND VPWR VPWR net432 sky130_fd_sc_hd__buf_6
Xfanout443 net444 VGND VGND VPWR VPWR net443 sky130_fd_sc_hd__clkbuf_4
Xfanout454 net46 VGND VGND VPWR VPWR net454 sky130_fd_sc_hd__clkbuf_8
Xfanout465 net466 VGND VGND VPWR VPWR net465 sky130_fd_sc_hd__clkbuf_4
Xfanout476 net477 VGND VGND VPWR VPWR net476 sky130_fd_sc_hd__clkbuf_2
X_09828_ _01096_ _01098_ _01007_ _01030_ VGND VGND VPWR VPWR _01099_ sky130_fd_sc_hd__o211a_1
Xfanout487 net42 VGND VGND VPWR VPWR net487 sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_122_Right_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout498 net499 VGND VGND VPWR VPWR net498 sky130_fd_sc_hd__clkbuf_4
X_09759_ _01029_ _01030_ VGND VGND VPWR VPWR _01031_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12770_ _04157_ _04158_ VGND VGND VPWR VPWR _04160_ sky130_fd_sc_hd__or2_1
XFILLER_0_68_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11721_ _03014_ _03015_ VGND VGND VPWR VPWR _03016_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_56_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14440_ net322 net659 net669 net237 VGND VGND VPWR VPWR _05978_ sky130_fd_sc_hd__a22oi_2
X_11652_ _02929_ _02940_ VGND VGND VPWR VPWR _02941_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_138_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10603_ net717 net438 VGND VGND VPWR VPWR _01829_ sky130_fd_sc_hd__nand2_1
X_14371_ net322 net237 net677 net686 VGND VGND VPWR VPWR _05902_ sky130_fd_sc_hd__and4_1
XFILLER_0_64_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11583_ net150 net375 net366 net232 VGND VGND VPWR VPWR _02867_ sky130_fd_sc_hd__a22o_1
XFILLER_0_135_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16110_ _07798_ _07799_ VGND VGND VPWR VPWR _07800_ sky130_fd_sc_hd__or2_1
XFILLER_0_107_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13322_ _04669_ _04670_ _04761_ VGND VGND VPWR VPWR _04762_ sky130_fd_sc_hd__a21o_1
X_10534_ _01757_ _01756_ _01728_ _01725_ VGND VGND VPWR VPWR _01760_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_24_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16041_ _07723_ _07724_ VGND VGND VPWR VPWR _07725_ sky130_fd_sc_hd__xnor2_1
X_10465_ net801 net462 VGND VGND VPWR VPWR _01691_ sky130_fd_sc_hd__nand2_1
X_13253_ _04683_ _04684_ _04685_ VGND VGND VPWR VPWR _04688_ sky130_fd_sc_hd__nand3_1
XFILLER_0_150_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12204_ net136 net467 _03540_ VGND VGND VPWR VPWR _03541_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_20_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10396_ _01618_ _01621_ VGND VGND VPWR VPWR _01622_ sky130_fd_sc_hd__xnor2_1
X_13184_ _04609_ _04610_ _04608_ VGND VGND VPWR VPWR _04613_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_103_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12135_ _03463_ _03466_ VGND VGND VPWR VPWR _03467_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_19_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12066_ _03307_ _03308_ VGND VGND VPWR VPWR _03392_ sky130_fd_sc_hd__and2b_1
XFILLER_0_19_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11017_ _02248_ _02249_ VGND VGND VPWR VPWR _02250_ sky130_fd_sc_hd__nor2_1
XFILLER_0_126_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15825_ _07404_ _07490_ VGND VGND VPWR VPWR _07491_ sky130_fd_sc_hd__xor2_4
XFILLER_0_126_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15756_ _07414_ _07396_ _07397_ VGND VGND VPWR VPWR _07416_ sky130_fd_sc_hd__or3_2
XFILLER_0_99_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12968_ _04359_ _04375_ _04376_ VGND VGND VPWR VPWR _04377_ sky130_fd_sc_hd__nand3_2
X_14707_ net197 net597 _06238_ _06237_ VGND VGND VPWR VPWR _06272_ sky130_fd_sc_hd__a31o_1
XFILLER_0_75_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11919_ _03229_ _03231_ VGND VGND VPWR VPWR _03232_ sky130_fd_sc_hd__xor2_2
X_15687_ _07196_ _07201_ VGND VGND VPWR VPWR _07341_ sky130_fd_sc_hd__and2b_1
X_12899_ _04299_ _04300_ _04298_ VGND VGND VPWR VPWR _04302_ sky130_fd_sc_hd__o21ai_1
X_14638_ _06189_ _06191_ _06195_ VGND VGND VPWR VPWR _06196_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_129_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14569_ net943 _06118_ net824 _06041_ VGND VGND VPWR VPWR _06120_ sky130_fd_sc_hd__a211oi_4
X_16308_ clknet_4_14_0_clk _00021_ net342 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_42_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16239_ _07890_ _07938_ VGND VGND VPWR VPWR _07940_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08992_ _00270_ _00271_ _00169_ _00215_ VGND VGND VPWR VPWR _00273_ sky130_fd_sc_hd__a211o_1
X_09613_ _00864_ _00865_ _00885_ _00886_ VGND VGND VPWR VPWR _00887_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_78_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09544_ _00817_ _00818_ VGND VGND VPWR VPWR _00819_ sky130_fd_sc_hd__or2_2
XFILLER_0_78_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09475_ net689 net466 VGND VGND VPWR VPWR _00750_ sky130_fd_sc_hd__nand2_1
X_08426_ _05090_ _05221_ _05232_ VGND VGND VPWR VPWR _05242_ sky130_fd_sc_hd__nand3_2
XFILLER_0_19_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08357_ _04458_ _04469_ _03094_ VGND VGND VPWR VPWR _04491_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_135_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08288_ _03669_ _03723_ VGND VGND VPWR VPWR _03734_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_34_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10250_ _01496_ VGND VGND VPWR VPWR _00037_ sky130_fd_sc_hd__clkbuf_1
X_10181_ _01435_ _01436_ VGND VGND VPWR VPWR _01437_ sky130_fd_sc_hd__xnor2_2
Xfanout240 net241 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__clkbuf_2
Xfanout251 net67 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__buf_4
Xfanout262 net269 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__buf_4
Xfanout273 net276 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__clkbuf_4
X_13940_ _05434_ VGND VGND VPWR VPWR _05435_ sky130_fd_sc_hd__inv_2
Xfanout284 net285 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__clkbuf_4
Xfanout295 net62 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__clkbuf_4
X_13871_ _05357_ _05358_ _05359_ _05274_ VGND VGND VPWR VPWR _05360_ sky130_fd_sc_hd__o211ai_2
X_15610_ _07241_ _07255_ VGND VGND VPWR VPWR _07257_ sky130_fd_sc_hd__nand2_1
X_12822_ _04216_ VGND VGND VPWR VPWR _04217_ sky130_fd_sc_hd__inv_2
XFILLER_0_96_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15541_ _07081_ _07181_ VGND VGND VPWR VPWR _07182_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_96_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12753_ _03991_ VGND VGND VPWR VPWR _04142_ sky130_fd_sc_hd__inv_2
X_11704_ net150 net358 _02995_ _02997_ VGND VGND VPWR VPWR _02998_ sky130_fd_sc_hd__a22o_1
X_15472_ _07001_ _07004_ _07002_ VGND VGND VPWR VPWR _07106_ sky130_fd_sc_hd__o21ba_1
X_12684_ net189 net179 net744 net754 VGND VGND VPWR VPWR _04066_ sky130_fd_sc_hd__and4_1
XFILLER_0_84_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14423_ _05914_ _05917_ VGND VGND VPWR VPWR _05960_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11635_ _02902_ _02922_ VGND VGND VPWR VPWR _02923_ sky130_fd_sc_hd__xor2_2
XFILLER_0_71_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14354_ _05881_ _05883_ VGND VGND VPWR VPWR _05884_ sky130_fd_sc_hd__nor2_1
X_11566_ _02830_ _02847_ VGND VGND VPWR VPWR _02848_ sky130_fd_sc_hd__xor2_2
XFILLER_0_135_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13305_ _04543_ _04522_ _04630_ _04631_ VGND VGND VPWR VPWR _04745_ sky130_fd_sc_hd__o211a_1
XFILLER_0_52_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10517_ _01706_ _01711_ _01705_ VGND VGND VPWR VPWR _01743_ sky130_fd_sc_hd__a21bo_1
X_14285_ _05809_ _05691_ _05747_ VGND VGND VPWR VPWR _05810_ sky130_fd_sc_hd__o21ai_1
X_11497_ _02771_ _02772_ VGND VGND VPWR VPWR _02773_ sky130_fd_sc_hd__xor2_2
XFILLER_0_122_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16024_ _07706_ _07674_ VGND VGND VPWR VPWR _07707_ sky130_fd_sc_hd__or2_1
X_13236_ _04664_ _04668_ VGND VGND VPWR VPWR _04669_ sky130_fd_sc_hd__xor2_1
XFILLER_0_122_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10448_ net765 net498 VGND VGND VPWR VPWR _01674_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13167_ net427 net518 net195 net185 VGND VGND VPWR VPWR _04594_ sky130_fd_sc_hd__nand4_2
X_10379_ net106 _01607_ net130 VGND VGND VPWR VPWR _01608_ sky130_fd_sc_hd__mux2_1
X_12118_ _03436_ _03447_ VGND VGND VPWR VPWR _03448_ sky130_fd_sc_hd__xnor2_1
X_13098_ _04516_ _04517_ _04481_ VGND VGND VPWR VPWR _04519_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_137_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12049_ _03352_ _03372_ VGND VGND VPWR VPWR _03373_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_137_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15808_ _07470_ _07471_ VGND VGND VPWR VPWR _07472_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15739_ _07394_ _07395_ _07376_ _07377_ VGND VGND VPWR VPWR _07397_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_88_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09260_ net640 net383 VGND VGND VPWR VPWR _00538_ sky130_fd_sc_hd__and2_1
XFILLER_0_118_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08211_ _02877_ _02888_ VGND VGND VPWR VPWR _02898_ sky130_fd_sc_hd__nor2_1
X_09191_ _00383_ _00285_ _00284_ VGND VGND VPWR VPWR _00470_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_8_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08975_ _00254_ _00255_ net631 net432 VGND VGND VPWR VPWR _00256_ sky130_fd_sc_hd__or4bb_4
X_09527_ _00800_ _00801_ VGND VGND VPWR VPWR _00802_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09458_ _00730_ _00732_ VGND VGND VPWR VPWR _00734_ sky130_fd_sc_hd__nand2_1
XFILLER_0_108_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08409_ _05036_ _05047_ VGND VGND VPWR VPWR _05057_ sky130_fd_sc_hd__xnor2_1
X_09389_ _00575_ _00589_ VGND VGND VPWR VPWR _00665_ sky130_fd_sc_hd__nor2_1
XFILLER_0_136_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11420_ _02560_ _02629_ _02687_ _02688_ VGND VGND VPWR VPWR _02689_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_105_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11351_ net747 net756 net462 net452 VGND VGND VPWR VPWR _02613_ sky130_fd_sc_hd__and4_1
XFILLER_0_116_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_866 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10302_ _01539_ _01540_ VGND VGND VPWR VPWR _01541_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_21_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14070_ _05486_ _05489_ _05487_ VGND VGND VPWR VPWR _05576_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_128_Left_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11282_ net232 net394 VGND VGND VPWR VPWR _02538_ sky130_fd_sc_hd__nand2_1
X_13021_ _04340_ _04434_ VGND VGND VPWR VPWR _04435_ sky130_fd_sc_hd__or2b_1
XFILLER_0_131_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10233_ _01474_ _01480_ _01481_ VGND VGND VPWR VPWR _01482_ sky130_fd_sc_hd__o21ai_1
X_10164_ Q_sin\[7\] D_cos\[7\] VGND VGND VPWR VPWR _01422_ sky130_fd_sc_hd__or2b_1
X_10095_ _01303_ _01327_ _01302_ VGND VGND VPWR VPWR _01361_ sky130_fd_sc_hd__a21oi_1
X_14972_ _06559_ _06560_ _06106_ _06527_ VGND VGND VPWR VPWR _06562_ sky130_fd_sc_hd__o211a_1
XFILLER_0_89_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13923_ net306 net139 net795 net157 VGND VGND VPWR VPWR _05417_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_107_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_137_Left_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13854_ _05323_ _05324_ _05341_ VGND VGND VPWR VPWR _05342_ sky130_fd_sc_hd__a21o_1
XFILLER_0_88_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12805_ _04190_ _04198_ VGND VGND VPWR VPWR _04199_ sky130_fd_sc_hd__xnor2_2
X_13785_ _05168_ _05266_ VGND VGND VPWR VPWR _05267_ sky130_fd_sc_hd__xor2_1
X_10997_ _02225_ _02226_ _02217_ VGND VGND VPWR VPWR _02228_ sky130_fd_sc_hd__a21o_1
X_15524_ _07149_ _07163_ VGND VGND VPWR VPWR _07164_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_96_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12736_ net162 net763 net766 net311 VGND VGND VPWR VPWR _04123_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_139_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15455_ _06981_ _07084_ VGND VGND VPWR VPWR _07088_ sky130_fd_sc_hd__or2b_1
X_12667_ _04041_ _04044_ _04043_ VGND VGND VPWR VPWR _04047_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_5_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14406_ net322 net669 net678 net237 VGND VGND VPWR VPWR _05941_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_127_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11618_ _02828_ _02848_ _02903_ VGND VGND VPWR VPWR _02904_ sky130_fd_sc_hd__a21o_1
X_15386_ _04537_ net584 VGND VGND VPWR VPWR _07013_ sky130_fd_sc_hd__nor2_1
X_12598_ net199 net744 _03968_ _03969_ VGND VGND VPWR VPWR _03971_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_108_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_146_Left_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14337_ net187 net177 net571 net581 VGND VGND VPWR VPWR _05865_ sky130_fd_sc_hd__nand4_1
X_11549_ _02762_ _02765_ _02766_ VGND VGND VPWR VPWR _02829_ sky130_fd_sc_hd__and3_1
XFILLER_0_12_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14268_ _05708_ _05707_ VGND VGND VPWR VPWR _05791_ sky130_fd_sc_hd__and2b_1
XFILLER_0_0_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16007_ _07622_ _07623_ _07688_ VGND VGND VPWR VPWR _07689_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_111_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13219_ _04560_ _04544_ VGND VGND VPWR VPWR _04650_ sky130_fd_sc_hd__and2b_1
XFILLER_0_20_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14199_ net228 net263 net146 net254 VGND VGND VPWR VPWR _05716_ sky130_fd_sc_hd__and4_1
XFILLER_0_0_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08760_ _08068_ _08069_ _08061_ VGND VGND VPWR VPWR _08071_ sky130_fd_sc_hd__a21o_1
X_08691_ _07954_ _07944_ VGND VGND VPWR VPWR _08003_ sky130_fd_sc_hd__and2b_1
XFILLER_0_79_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09312_ _00587_ _00588_ VGND VGND VPWR VPWR _00589_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09243_ _00511_ _00520_ VGND VGND VPWR VPWR _00521_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_7_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09174_ _00451_ _00452_ VGND VGND VPWR VPWR _00453_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08958_ _00142_ _00144_ VGND VGND VPWR VPWR _00239_ sky130_fd_sc_hd__nand2_1
X_08889_ _00137_ _00169_ _00170_ VGND VGND VPWR VPWR _00171_ sky130_fd_sc_hd__or3_4
XFILLER_0_98_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10920_ net791 net439 net419 net803 VGND VGND VPWR VPWR _02146_ sky130_fd_sc_hd__a22o_1
XFILLER_0_85_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10851_ _02026_ _02027_ _02033_ VGND VGND VPWR VPWR _02077_ sky130_fd_sc_hd__a21o_1
XFILLER_0_137_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13570_ _04909_ _04936_ _05032_ VGND VGND VPWR VPWR _05033_ sky130_fd_sc_hd__a21oi_2
X_10782_ _02005_ _02004_ VGND VGND VPWR VPWR _02008_ sky130_fd_sc_hd__or2b_1
XFILLER_0_94_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12521_ net330 net245 net780 net788 VGND VGND VPWR VPWR _03886_ sky130_fd_sc_hd__and4_1
XFILLER_0_81_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15240_ _06852_ _06853_ VGND VGND VPWR VPWR _06854_ sky130_fd_sc_hd__nor2_1
X_12452_ _03807_ _03808_ _03788_ VGND VGND VPWR VPWR _03810_ sky130_fd_sc_hd__a21o_1
XFILLER_0_50_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11403_ net797 net414 net405 net141 VGND VGND VPWR VPWR _02671_ sky130_fd_sc_hd__a22o_1
X_15171_ _06776_ _06777_ net855 _06683_ VGND VGND VPWR VPWR _06779_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_105_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12383_ _03729_ _03733_ VGND VGND VPWR VPWR _03735_ sky130_fd_sc_hd__xnor2_1
X_14122_ _05516_ _05604_ _05631_ VGND VGND VPWR VPWR _05632_ sky130_fd_sc_hd__a21bo_1
X_11334_ _02479_ _02481_ _02593_ _02595_ VGND VGND VPWR VPWR _02596_ sky130_fd_sc_hd__o211a_1
X_14053_ D_sin\[13\] _05557_ _04752_ VGND VGND VPWR VPWR _05559_ sky130_fd_sc_hd__mux2_1
X_11265_ _02502_ _02518_ _02519_ VGND VGND VPWR VPWR _02520_ sky130_fd_sc_hd__nand3_1
X_13004_ _04310_ _04383_ _04414_ _04416_ VGND VGND VPWR VPWR _04417_ sky130_fd_sc_hd__a211oi_4
X_10216_ Q_sin\[14\] D_cos\[14\] VGND VGND VPWR VPWR _01467_ sky130_fd_sc_hd__and2b_1
X_11196_ _02439_ _02443_ _02444_ VGND VGND VPWR VPWR _02445_ sky130_fd_sc_hd__and3_1
X_10147_ net92 _01407_ net135 VGND VGND VPWR VPWR _01408_ sky130_fd_sc_hd__mux2_1
XFILLER_0_118_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14955_ _06539_ _06543_ VGND VGND VPWR VPWR _06544_ sky130_fd_sc_hd__xnor2_2
X_10078_ net914 _00187_ VGND VGND VPWR VPWR _01345_ sky130_fd_sc_hd__nor2_1
X_13906_ _05397_ _05398_ VGND VGND VPWR VPWR _05399_ sky130_fd_sc_hd__nor2_1
X_14886_ _06228_ _06229_ _06216_ _06219_ VGND VGND VPWR VPWR _06469_ sky130_fd_sc_hd__a211oi_1
X_13837_ _05168_ _05266_ VGND VGND VPWR VPWR _05323_ sky130_fd_sc_hd__or2_1
XFILLER_0_58_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13768_ _05246_ _05247_ VGND VGND VPWR VPWR _05248_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15507_ _07143_ _07144_ VGND VGND VPWR VPWR _07145_ sky130_fd_sc_hd__xnor2_1
X_12719_ net191 net180 net736 net744 VGND VGND VPWR VPWR _04104_ sky130_fd_sc_hd__and4_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13699_ _05171_ _05172_ VGND VGND VPWR VPWR _05173_ sky130_fd_sc_hd__xor2_1
XFILLER_0_128_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15438_ _06941_ _06968_ _07069_ VGND VGND VPWR VPWR _07070_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_150_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15369_ _06901_ _06917_ VGND VGND VPWR VPWR _06994_ sky130_fd_sc_hd__or2b_1
XFILLER_0_53_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09930_ _01149_ _01152_ _01198_ VGND VGND VPWR VPWR _01199_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_110_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout806 net1 VGND VGND VPWR VPWR net806 sky130_fd_sc_hd__buf_2
X_09861_ _01049_ _01052_ _01050_ VGND VGND VPWR VPWR _01131_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_110_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08812_ _04851_ _05970_ net808 _08121_ VGND VGND VPWR VPWR _08123_ sky130_fd_sc_hd__a2bb2o_1
X_09792_ _01046_ _01047_ _01062_ VGND VGND VPWR VPWR _01063_ sky130_fd_sc_hd__a21oi_1
X_08743_ _03998_ _03987_ VGND VGND VPWR VPWR _08054_ sky130_fd_sc_hd__and2b_1
XFILLER_0_84_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08674_ net588 net525 net436 net598 VGND VGND VPWR VPWR _07944_ sky130_fd_sc_hd__a22o_1
XFILLER_0_49_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_124_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09226_ _00484_ _00503_ VGND VGND VPWR VPWR _00504_ sky130_fd_sc_hd__xor2_1
XFILLER_0_119_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09157_ net658 net666 net373 net364 VGND VGND VPWR VPWR _00436_ sky130_fd_sc_hd__nand4_2
XFILLER_0_44_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09088_ _00338_ _00266_ _00366_ _00367_ VGND VGND VPWR VPWR _00368_ sky130_fd_sc_hd__o211ai_2
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11050_ _02189_ _02285_ VGND VGND VPWR VPWR _02286_ sky130_fd_sc_hd__xor2_1
XFILLER_0_101_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10001_ _01187_ _01186_ VGND VGND VPWR VPWR _01269_ sky130_fd_sc_hd__or2b_1
X_14740_ _06304_ _06305_ _06307_ VGND VGND VPWR VPWR _06308_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_99_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11952_ _03265_ _03266_ VGND VGND VPWR VPWR _03267_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10903_ _02127_ _02128_ VGND VGND VPWR VPWR _02129_ sky130_fd_sc_hd__and2_1
X_14671_ net829 _06231_ _06226_ _06228_ VGND VGND VPWR VPWR _06232_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_86_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11883_ _02992_ _03096_ _03097_ _02990_ VGND VGND VPWR VPWR _03193_ sky130_fd_sc_hd__a31o_1
XFILLER_0_98_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13622_ net933 net174 net152 net143 VGND VGND VPWR VPWR _05089_ sky130_fd_sc_hd__and4_1
X_10834_ _02015_ _02014_ _02013_ VGND VGND VPWR VPWR _02060_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_66_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16341_ clknet_4_0_0_clk _00054_ net334 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__dfrtp_1
X_13553_ _05011_ _05013_ VGND VGND VPWR VPWR _05015_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_27_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10765_ _01987_ _01989_ _01990_ VGND VGND VPWR VPWR _01991_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_66_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12504_ _03864_ _03865_ _03737_ _03867_ VGND VGND VPWR VPWR _03868_ sky130_fd_sc_hd__a211o_1
X_16272_ _04540_ net648 net638 net247 VGND VGND VPWR VPWR _07975_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_81_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13484_ _04887_ _04833_ _04937_ VGND VGND VPWR VPWR _04940_ sky130_fd_sc_hd__or3b_1
X_10696_ _01920_ _01921_ VGND VGND VPWR VPWR _01922_ sky130_fd_sc_hd__or2_1
XFILLER_0_70_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15223_ _06832_ _06833_ _06825_ VGND VGND VPWR VPWR _06836_ sky130_fd_sc_hd__a21o_1
XFILLER_0_124_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12435_ net329 net717 net727 net244 VGND VGND VPWR VPWR _03792_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_23_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15154_ _06758_ _06760_ VGND VGND VPWR VPWR _06761_ sky130_fd_sc_hd__or2b_1
XFILLER_0_105_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12366_ _03714_ _03715_ VGND VGND VPWR VPWR _03716_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_136_Right_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14105_ _05537_ _05505_ _05506_ VGND VGND VPWR VPWR _05615_ sky130_fd_sc_hd__nor3_1
X_11317_ _02570_ _02576_ VGND VGND VPWR VPWR _02577_ sky130_fd_sc_hd__xnor2_2
X_15085_ net945 _06564_ _06663_ _06664_ VGND VGND VPWR VPWR _06685_ sky130_fd_sc_hd__o211a_1
X_12297_ _03639_ _03641_ VGND VGND VPWR VPWR _03642_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_129_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14036_ _05538_ _05539_ _05443_ _05467_ VGND VGND VPWR VPWR _05540_ sky130_fd_sc_hd__a211oi_1
X_11248_ _02426_ _02428_ VGND VGND VPWR VPWR _02501_ sky130_fd_sc_hd__nand2_1
X_11179_ _02423_ _02424_ _02425_ VGND VGND VPWR VPWR _02426_ sky130_fd_sc_hd__nand3_2
X_15987_ net936 net628 VGND VGND VPWR VPWR _07667_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14938_ _06522_ _06523_ _06502_ _06503_ VGND VGND VPWR VPWR _06525_ sky130_fd_sc_hd__a211o_1
XFILLER_0_89_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14869_ _06444_ _06448_ _06426_ _06449_ VGND VGND VPWR VPWR _06450_ sky130_fd_sc_hd__a211o_1
XFILLER_0_147_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08390_ _02703_ _04840_ VGND VGND VPWR VPWR _04851_ sky130_fd_sc_hd__xnor2_2
X_09011_ _00291_ VGND VGND VPWR VPWR _00003_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold112 net79 VGND VGND VPWR VPWR net918 sky130_fd_sc_hd__dlygate4sd3_1
Xhold123 net111 VGND VGND VPWR VPWR net929 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_103_Right_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09913_ _01180_ _01181_ VGND VGND VPWR VPWR _01182_ sky130_fd_sc_hd__nor2_1
Xfanout603 net608 VGND VGND VPWR VPWR net603 sky130_fd_sc_hd__clkbuf_4
Xfanout614 net618 VGND VGND VPWR VPWR net614 sky130_fd_sc_hd__clkbuf_4
Xfanout625 net29 VGND VGND VPWR VPWR net625 sky130_fd_sc_hd__buf_4
Xfanout636 net865 VGND VGND VPWR VPWR net636 sky130_fd_sc_hd__clkbuf_4
X_09844_ Q_cos\[13\] _01114_ _00661_ VGND VGND VPWR VPWR _01115_ sky130_fd_sc_hd__mux2_1
Xfanout647 net648 VGND VGND VPWR VPWR net647 sky130_fd_sc_hd__clkbuf_4
Xfanout658 net661 VGND VGND VPWR VPWR net658 sky130_fd_sc_hd__buf_4
Xfanout669 net670 VGND VGND VPWR VPWR net669 sky130_fd_sc_hd__buf_6
X_09775_ _00994_ _00980_ VGND VGND VPWR VPWR _01046_ sky130_fd_sc_hd__or2b_1
X_08726_ _06003_ _08029_ _08034_ _08036_ VGND VGND VPWR VPWR _08037_ sky130_fd_sc_hd__a211oi_4
X_08657_ _07695_ _07738_ _07749_ VGND VGND VPWR VPWR _07760_ sky130_fd_sc_hd__or3_1
XFILLER_0_95_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08588_ _05871_ _06988_ _06977_ _06922_ VGND VGND VPWR VPWR _07009_ sky130_fd_sc_hd__a211o_1
XFILLER_0_37_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10550_ _01774_ _01775_ VGND VGND VPWR VPWR _01776_ sky130_fd_sc_hd__nor2_1
XFILLER_0_106_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09209_ _00485_ _00431_ _00486_ VGND VGND VPWR VPWR _00487_ sky130_fd_sc_hd__o21ba_1
X_10481_ net429 net715 net529 net935 VGND VGND VPWR VPWR _01707_ sky130_fd_sc_hd__and4_1
X_12220_ net145 net467 _03501_ VGND VGND VPWR VPWR _03558_ sky130_fd_sc_hd__and3_1
X_12151_ _03476_ _03482_ VGND VGND VPWR VPWR _03483_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_20_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11102_ _02333_ _02341_ VGND VGND VPWR VPWR _02342_ sky130_fd_sc_hd__xor2_2
X_12082_ _03334_ _03337_ VGND VGND VPWR VPWR _03408_ sky130_fd_sc_hd__or2_1
X_15910_ _07516_ _07519_ _07524_ VGND VGND VPWR VPWR _07583_ sky130_fd_sc_hd__o21ai_2
X_11033_ _02264_ _02265_ _02246_ VGND VGND VPWR VPWR _02268_ sky130_fd_sc_hd__a21oi_2
X_15841_ net261 net681 net690 net252 VGND VGND VPWR VPWR _07508_ sky130_fd_sc_hd__a22oi_2
X_15772_ _07331_ _07337_ VGND VGND VPWR VPWR _07433_ sky130_fd_sc_hd__and2b_1
X_12984_ net615 net194 VGND VGND VPWR VPWR _04395_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14723_ _06260_ _06265_ _06264_ VGND VGND VPWR VPWR _06290_ sky130_fd_sc_hd__a21bo_1
X_11935_ _02850_ _02856_ _02926_ VGND VGND VPWR VPWR _03249_ sky130_fd_sc_hd__nand3_2
XFILLER_0_24_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14654_ _06204_ _06205_ _06213_ VGND VGND VPWR VPWR _06214_ sky130_fd_sc_hd__a21bo_1
X_11866_ _03172_ _03173_ VGND VGND VPWR VPWR _03174_ sky130_fd_sc_hd__nor2_1
XFILLER_0_86_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13605_ _05069_ _05070_ VGND VGND VPWR VPWR _05071_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_145_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10817_ _02036_ _02035_ _02034_ _02026_ VGND VGND VPWR VPWR _02043_ sky130_fd_sc_hd__o211a_1
X_14585_ _06130_ _06136_ _06137_ VGND VGND VPWR VPWR _06138_ sky130_fd_sc_hd__nand3_2
X_11797_ _03087_ _03098_ VGND VGND VPWR VPWR _03099_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_138_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16324_ clknet_4_5_0_clk _00037_ net335 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_82_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13536_ _04991_ _04993_ _04994_ VGND VGND VPWR VPWR _04996_ sky130_fd_sc_hd__a21o_1
X_10748_ _01972_ _01973_ VGND VGND VPWR VPWR _01974_ sky130_fd_sc_hd__or2b_1
X_16255_ _07917_ _07924_ _07921_ VGND VGND VPWR VPWR _07957_ sky130_fd_sc_hd__a21oi_1
X_13467_ _04718_ _04824_ VGND VGND VPWR VPWR _04921_ sky130_fd_sc_hd__nor2_4
X_10679_ _01901_ _01903_ _01902_ VGND VGND VPWR VPWR _01905_ sky130_fd_sc_hd__a21o_1
X_15206_ _06730_ _06765_ net892 VGND VGND VPWR VPWR _06817_ sky130_fd_sc_hd__nor3_1
XFILLER_0_112_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12418_ _03770_ _03771_ _03772_ VGND VGND VPWR VPWR _03773_ sky130_fd_sc_hd__and3_1
X_16186_ _07881_ _07882_ VGND VGND VPWR VPWR _07883_ sky130_fd_sc_hd__or2_1
X_13398_ _04844_ _04845_ VGND VGND VPWR VPWR _04846_ sky130_fd_sc_hd__nor2_2
XFILLER_0_51_884 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15137_ _06739_ _06740_ _06741_ VGND VGND VPWR VPWR _06742_ sky130_fd_sc_hd__or3_4
XFILLER_0_11_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12349_ net328 net243 net735 net743 VGND VGND VPWR VPWR _03697_ sky130_fd_sc_hd__nand4_2
XFILLER_0_50_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15068_ _06601_ _06665_ _06666_ VGND VGND VPWR VPWR _06667_ sky130_fd_sc_hd__and3_4
XFILLER_0_49_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14019_ _05517_ _05518_ _05519_ VGND VGND VPWR VPWR _05521_ sky130_fd_sc_hd__nor3_1
X_09560_ _00832_ _00833_ VGND VGND VPWR VPWR _00834_ sky130_fd_sc_hd__nor2_1
X_08511_ _06135_ _06146_ _06157_ VGND VGND VPWR VPWR _06168_ sky130_fd_sc_hd__o21bai_1
X_09491_ _00765_ VGND VGND VPWR VPWR _00766_ sky130_fd_sc_hd__buf_2
XFILLER_0_78_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08442_ net562 net407 net396 net568 VGND VGND VPWR VPWR _05416_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_147_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08373_ _04524_ _04644_ _04654_ VGND VGND VPWR VPWR _04665_ sky130_fd_sc_hd__nand3_2
XFILLER_0_105_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout400 net401 VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__clkbuf_1
Xfanout411 net412 VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__clkbuf_4
Xfanout422 net424 VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__buf_2
XFILLER_0_10_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout433 net434 VGND VGND VPWR VPWR net433 sky130_fd_sc_hd__buf_6
Xfanout444 net445 VGND VGND VPWR VPWR net444 sky130_fd_sc_hd__buf_4
Xfanout455 net457 VGND VGND VPWR VPWR net455 sky130_fd_sc_hd__clkbuf_4
Xfanout466 net44 VGND VGND VPWR VPWR net466 sky130_fd_sc_hd__clkbuf_4
X_09827_ _01097_ VGND VGND VPWR VPWR _01098_ sky130_fd_sc_hd__inv_2
Xfanout477 net482 VGND VGND VPWR VPWR net477 sky130_fd_sc_hd__buf_4
Xfanout488 net492 VGND VGND VPWR VPWR net488 sky130_fd_sc_hd__clkbuf_4
Xfanout499 net41 VGND VGND VPWR VPWR net499 sky130_fd_sc_hd__buf_4
X_09758_ _01006_ _01007_ _01027_ _01028_ VGND VGND VPWR VPWR _01030_ sky130_fd_sc_hd__nand4_4
XFILLER_0_96_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08709_ _07997_ _07998_ _07999_ VGND VGND VPWR VPWR _08021_ sky130_fd_sc_hd__o21a_1
X_09689_ _00883_ _00868_ VGND VGND VPWR VPWR _00962_ sky130_fd_sc_hd__and2b_1
X_11720_ net703 net468 VGND VGND VPWR VPWR _03015_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11651_ _02930_ _02939_ VGND VGND VPWR VPWR _02940_ sky130_fd_sc_hd__xor2_2
XFILLER_0_139_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10602_ _01717_ _01716_ _01715_ VGND VGND VPWR VPWR _01828_ sky130_fd_sc_hd__o21ai_1
X_14370_ _05886_ _05900_ _05881_ VGND VGND VPWR VPWR _05901_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_119_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11582_ net232 net150 net366 VGND VGND VPWR VPWR _02865_ sky130_fd_sc_hd__and3_1
XFILLER_0_52_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13321_ _04664_ _04668_ VGND VGND VPWR VPWR _04761_ sky130_fd_sc_hd__nor2_1
X_10533_ _01725_ _01728_ _01756_ _01757_ VGND VGND VPWR VPWR _01759_ sky130_fd_sc_hd__a211o_1
XFILLER_0_17_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16040_ _04538_ net681 VGND VGND VPWR VPWR _07724_ sky130_fd_sc_hd__nor2_1
X_13252_ _04683_ _04684_ _04685_ VGND VGND VPWR VPWR _04686_ sky130_fd_sc_hd__a21o_1
X_10464_ _01680_ _01681_ _01682_ VGND VGND VPWR VPWR _01690_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12203_ _03499_ net792 _01237_ VGND VGND VPWR VPWR _03540_ sky130_fd_sc_hd__and3b_1
XFILLER_0_110_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13183_ _04608_ _04609_ _04610_ VGND VGND VPWR VPWR _04612_ sky130_fd_sc_hd__or3_1
X_10395_ _01619_ _01620_ VGND VGND VPWR VPWR _01621_ sky130_fd_sc_hd__nor2_1
XFILLER_0_103_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12134_ _03385_ _03465_ _03384_ VGND VGND VPWR VPWR _03466_ sky130_fd_sc_hd__a21oi_1
X_12065_ _03200_ _03223_ _03307_ VGND VGND VPWR VPWR _03391_ sky130_fd_sc_hd__and3_1
X_11016_ net151 net523 net395 net515 VGND VGND VPWR VPWR _02249_ sky130_fd_sc_hd__a22oi_1
X_15824_ net165 net625 VGND VGND VPWR VPWR _07490_ sky130_fd_sc_hd__nand2_2
XFILLER_0_126_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15755_ _07396_ _07397_ _07414_ VGND VGND VPWR VPWR _07415_ sky130_fd_sc_hd__o21ai_1
X_12967_ _04373_ _04374_ _04365_ VGND VGND VPWR VPWR _04376_ sky130_fd_sc_hd__a21o_1
X_14706_ net700 _06270_ VGND VGND VPWR VPWR _06271_ sky130_fd_sc_hd__nand2_1
X_11918_ _03131_ _03150_ _03230_ VGND VGND VPWR VPWR _03231_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_59_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15686_ _07338_ _07339_ VGND VGND VPWR VPWR _07340_ sky130_fd_sc_hd__xor2_1
XFILLER_0_129_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12898_ _04298_ _04299_ _04300_ VGND VGND VPWR VPWR _04301_ sky130_fd_sc_hd__or3_1
XFILLER_0_142_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14637_ _06192_ _06194_ VGND VGND VPWR VPWR _06195_ sky130_fd_sc_hd__xnor2_1
X_11849_ _03042_ _03058_ VGND VGND VPWR VPWR _03156_ sky130_fd_sc_hd__nand2_1
XFILLER_0_145_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14568_ net824 _06041_ net943 _06118_ VGND VGND VPWR VPWR _06119_ sky130_fd_sc_hd__o211a_1
XFILLER_0_144_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16307_ clknet_4_15_0_clk _00020_ net342 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13519_ net757 _04537_ VGND VGND VPWR VPWR _04977_ sky130_fd_sc_hd__nor2_1
X_14499_ net265 net697 _06042_ VGND VGND VPWR VPWR _06043_ sky130_fd_sc_hd__and3_1
XFILLER_0_141_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16238_ _07890_ _07938_ VGND VGND VPWR VPWR _07939_ sky130_fd_sc_hd__and2_1
XFILLER_0_30_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16169_ _07862_ _07863_ VGND VGND VPWR VPWR _07864_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08991_ _00169_ _00215_ _00270_ _00271_ VGND VGND VPWR VPWR _00272_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_76_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09612_ _00866_ _00884_ VGND VGND VPWR VPWR _00886_ sky130_fd_sc_hd__nor2_1
X_09543_ _00733_ _00816_ VGND VGND VPWR VPWR _00818_ sky130_fd_sc_hd__and2_1
XFILLER_0_92_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09474_ _00747_ _00748_ VGND VGND VPWR VPWR _00749_ sky130_fd_sc_hd__nor2_1
XFILLER_0_38_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08425_ _04633_ _04600_ _04622_ VGND VGND VPWR VPWR _05232_ sky130_fd_sc_hd__a21o_1
XFILLER_0_148_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08356_ _03094_ _04458_ _04469_ VGND VGND VPWR VPWR _04480_ sky130_fd_sc_hd__and3_1
XFILLER_0_117_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08287_ _03680_ _03712_ VGND VGND VPWR VPWR _03723_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_132_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10180_ _01427_ _01430_ _01428_ VGND VGND VPWR VPWR _01436_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_100_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout230 net231 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__clkbuf_4
Xfanout241 net69 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__clkbuf_4
Xfanout252 net253 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__clkbuf_4
Xfanout263 net264 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__clkbuf_4
Xfanout274 net275 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__clkbuf_4
Xfanout285 net63 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__buf_4
Xfanout296 net299 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__buf_2
X_13870_ _05269_ _05271_ VGND VGND VPWR VPWR _05359_ sky130_fd_sc_hd__or2b_1
XFILLER_0_69_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12821_ net294 net283 net776 net783 VGND VGND VPWR VPWR _04216_ sky130_fd_sc_hd__and4_1
XFILLER_0_69_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15540_ _07179_ _07180_ VGND VGND VPWR VPWR _07181_ sky130_fd_sc_hd__nor2_1
X_12752_ _04039_ _04139_ VGND VGND VPWR VPWR _04140_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_29_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11703_ net142 net796 net375 net366 VGND VGND VPWR VPWR _02997_ sky130_fd_sc_hd__nand4_2
X_15471_ _07099_ _07104_ VGND VGND VPWR VPWR _07105_ sky130_fd_sc_hd__xor2_2
X_12683_ net171 net762 VGND VGND VPWR VPWR _04065_ sky130_fd_sc_hd__nand2_1
XFILLER_0_127_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14422_ _05857_ _05859_ _05858_ VGND VGND VPWR VPWR _05958_ sky130_fd_sc_hd__o21ba_1
X_11634_ _02904_ _02921_ VGND VGND VPWR VPWR _02922_ sky130_fd_sc_hd__xor2_2
XFILLER_0_126_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14353_ net291 net601 net698 net282 VGND VGND VPWR VPWR _05883_ sky130_fd_sc_hd__a22oi_1
X_11565_ _02836_ _02846_ VGND VGND VPWR VPWR _02847_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_64_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13304_ _04651_ _04743_ VGND VGND VPWR VPWR _04744_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_123_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10516_ _01735_ _01736_ _01741_ VGND VGND VPWR VPWR _01742_ sky130_fd_sc_hd__nand3_2
X_14284_ _05693_ VGND VGND VPWR VPWR _05809_ sky130_fd_sc_hd__inv_2
XFILLER_0_150_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11496_ net150 net385 VGND VGND VPWR VPWR _02772_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16023_ _07550_ _07656_ VGND VGND VPWR VPWR _07706_ sky130_fd_sc_hd__nor2_2
X_13235_ _04553_ _04666_ _04667_ VGND VGND VPWR VPWR _04668_ sky130_fd_sc_hd__a21oi_1
X_10447_ _01631_ _01633_ _01632_ VGND VGND VPWR VPWR _01673_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_0_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13166_ net427 net195 net184 net514 VGND VGND VPWR VPWR _04593_ sky130_fd_sc_hd__a22o_1
X_10378_ _01603_ _01606_ VGND VGND VPWR VPWR _01607_ sky130_fd_sc_hd__xnor2_1
X_12117_ _03353_ _03446_ VGND VGND VPWR VPWR _03447_ sky130_fd_sc_hd__xor2_1
X_13097_ _04481_ _04516_ _04517_ VGND VGND VPWR VPWR _04518_ sky130_fd_sc_hd__or3_1
X_12048_ _03354_ _03371_ VGND VGND VPWR VPWR _03372_ sky130_fd_sc_hd__xnor2_1
X_15807_ net270 net672 VGND VGND VPWR VPWR _07471_ sky130_fd_sc_hd__nand2_1
X_13999_ net704 _04538_ VGND VGND VPWR VPWR _05499_ sky130_fd_sc_hd__or2_1
X_15738_ _07376_ _07377_ _07394_ _07395_ VGND VGND VPWR VPWR _07396_ sky130_fd_sc_hd__o211a_1
XFILLER_0_47_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15669_ _07297_ _07320_ VGND VGND VPWR VPWR _07321_ sky130_fd_sc_hd__and2_1
X_08210_ net567 net351 net504 net577 VGND VGND VPWR VPWR _02888_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_8_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09190_ _00467_ _00468_ VGND VGND VPWR VPWR _00469_ sky130_fd_sc_hd__nor2_1
XFILLER_0_114_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08974_ net621 net520 net48 VGND VGND VPWR VPWR _00255_ sky130_fd_sc_hd__and3_4
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09526_ net556 net937 VGND VGND VPWR VPWR _00801_ sky130_fd_sc_hd__or2_1
XFILLER_0_94_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09457_ _00730_ _00732_ VGND VGND VPWR VPWR _00733_ sky130_fd_sc_hd__or2_1
X_08408_ _02626_ _02648_ VGND VGND VPWR VPWR _05047_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_49_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09388_ _00652_ _00663_ VGND VGND VPWR VPWR _00664_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08339_ _04262_ _04273_ _04251_ VGND VGND VPWR VPWR _04295_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_62_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11350_ net747 net462 net452 net756 VGND VGND VPWR VPWR _02612_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_117_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10301_ _01531_ _01534_ _01532_ VGND VGND VPWR VPWR _01540_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_132_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11281_ _02526_ _02536_ VGND VGND VPWR VPWR _02537_ sky130_fd_sc_hd__xor2_2
X_13020_ _04432_ _04433_ VGND VGND VPWR VPWR _04434_ sky130_fd_sc_hd__nand2_1
X_10232_ D_cos\[16\] Q_sin\[16\] VGND VGND VPWR VPWR _01481_ sky130_fd_sc_hd__xnor2_1
X_10163_ D_cos\[7\] Q_sin\[7\] VGND VGND VPWR VPWR _01421_ sky130_fd_sc_hd__or2b_1
X_10094_ _01335_ _01334_ VGND VGND VPWR VPWR _01360_ sky130_fd_sc_hd__or2b_1
X_14971_ _06106_ _06527_ _06559_ _06560_ VGND VGND VPWR VPWR _06561_ sky130_fd_sc_hd__a211oi_4
X_13922_ _05413_ _05414_ VGND VGND VPWR VPWR _05415_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13853_ _05338_ _05339_ VGND VGND VPWR VPWR _05341_ sky130_fd_sc_hd__or2_1
X_12804_ _04191_ _04197_ VGND VGND VPWR VPWR _04198_ sky130_fd_sc_hd__xnor2_2
X_10996_ _02217_ _02225_ _02226_ VGND VGND VPWR VPWR _02227_ sky130_fd_sc_hd__nand3_1
XFILLER_0_97_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13784_ _05263_ _05265_ VGND VGND VPWR VPWR _05266_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15523_ _07150_ _07161_ VGND VGND VPWR VPWR _07163_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_139_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12735_ net162 net311 net762 net766 VGND VGND VPWR VPWR _04122_ sky130_fd_sc_hd__and4_1
XFILLER_0_84_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15454_ _07087_ VGND VGND VPWR VPWR _00102_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12666_ _03960_ _03961_ _03959_ VGND VGND VPWR VPWR _04046_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_37_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14405_ net220 net687 VGND VGND VPWR VPWR _05940_ sky130_fd_sc_hd__nand2_1
X_11617_ _02830_ _02847_ VGND VGND VPWR VPWR _02903_ sky130_fd_sc_hd__nor2_1
X_15385_ _07008_ _07011_ VGND VGND VPWR VPWR _07012_ sky130_fd_sc_hd__xor2_2
X_12597_ _03968_ _03969_ net198 net744 VGND VGND VPWR VPWR _03970_ sky130_fd_sc_hd__and4bb_1
X_14336_ net187 net177 net571 net581 VGND VGND VPWR VPWR _05864_ sky130_fd_sc_hd__and4_1
XFILLER_0_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11548_ _02747_ _02755_ _02754_ VGND VGND VPWR VPWR _02828_ sky130_fd_sc_hd__a21o_1
XFILLER_0_52_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14267_ _05766_ _05789_ VGND VGND VPWR VPWR _05790_ sky130_fd_sc_hd__xnor2_1
X_11479_ _02638_ _02640_ _02639_ VGND VGND VPWR VPWR _02753_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_150_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16006_ _07686_ _07687_ VGND VGND VPWR VPWR _07688_ sky130_fd_sc_hd__xnor2_1
X_13218_ _04541_ _04638_ _04637_ VGND VGND VPWR VPWR _04649_ sky130_fd_sc_hd__a21bo_1
X_14198_ net263 net146 net254 net228 VGND VGND VPWR VPWR _05715_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_0_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13149_ net710 net713 net170 net163 VGND VGND VPWR VPWR _04574_ sky130_fd_sc_hd__nand4_1
XFILLER_0_0_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08690_ net606 net416 VGND VGND VPWR VPWR _08002_ sky130_fd_sc_hd__nand2_1
XFILLER_0_73_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09311_ net574 _00190_ VGND VGND VPWR VPWR _00588_ sky130_fd_sc_hd__or2_1
XFILLER_0_146_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09242_ _00518_ _00519_ VGND VGND VPWR VPWR _00520_ sky130_fd_sc_hd__and2b_1
XFILLER_0_91_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09173_ _00450_ _00449_ _00445_ _00358_ VGND VGND VPWR VPWR _00452_ sky130_fd_sc_hd__o211a_1
XFILLER_0_28_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08957_ _00148_ _00165_ _00166_ VGND VGND VPWR VPWR _00238_ sky130_fd_sc_hd__nand3_2
X_08888_ _00167_ _00168_ _08104_ _00138_ VGND VGND VPWR VPWR _00170_ sky130_fd_sc_hd__o211a_1
XFILLER_0_98_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10850_ _02068_ _02074_ _02075_ VGND VGND VPWR VPWR _02076_ sky130_fd_sc_hd__nand3_1
XFILLER_0_79_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09509_ _00741_ _00742_ _00782_ VGND VGND VPWR VPWR _00784_ sky130_fd_sc_hd__o21a_1
XFILLER_0_149_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10781_ _01942_ _01961_ _02006_ VGND VGND VPWR VPWR _02007_ sky130_fd_sc_hd__and3_1
X_12520_ net330 net780 net788 net245 VGND VGND VPWR VPWR _03885_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_117_Right_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12451_ _03788_ _03807_ _03808_ VGND VGND VPWR VPWR _03809_ sky130_fd_sc_hd__nand3_2
XFILLER_0_35_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11402_ _02451_ _02546_ _02547_ VGND VGND VPWR VPWR _02669_ sky130_fd_sc_hd__o21bai_1
X_15170_ _06669_ _06683_ _06776_ _06777_ VGND VGND VPWR VPWR _06778_ sky130_fd_sc_hd__a211o_1
XFILLER_0_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12382_ _03731_ _03732_ VGND VGND VPWR VPWR _03733_ sky130_fd_sc_hd__nand2_1
X_14121_ _05593_ _05605_ VGND VGND VPWR VPWR _05631_ sky130_fd_sc_hd__or2b_1
X_11333_ _02591_ _02592_ _02499_ VGND VGND VPWR VPWR _02595_ sky130_fd_sc_hd__a21o_1
XFILLER_0_50_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14052_ _05552_ _05556_ VGND VGND VPWR VPWR _05557_ sky130_fd_sc_hd__xor2_2
X_11264_ _02515_ _02516_ _02508_ VGND VGND VPWR VPWR _02519_ sky130_fd_sc_hd__a21o_1
X_13003_ _04412_ _04413_ _04394_ VGND VGND VPWR VPWR _04416_ sky130_fd_sc_hd__a21oi_2
X_10215_ _01453_ _01459_ _01462_ VGND VGND VPWR VPWR _01466_ sky130_fd_sc_hd__o21a_1
X_11195_ net614 net367 _02440_ _02442_ VGND VGND VPWR VPWR _02444_ sky130_fd_sc_hd__nand4_2
X_10146_ _01405_ _01406_ VGND VGND VPWR VPWR _01407_ sky130_fd_sc_hd__xnor2_1
X_10077_ _01339_ _01343_ VGND VGND VPWR VPWR _01344_ sky130_fd_sc_hd__xnor2_1
X_14954_ _06540_ _06542_ VGND VGND VPWR VPWR _06543_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13905_ _05312_ _05396_ VGND VGND VPWR VPWR _05398_ sky130_fd_sc_hd__nor2_1
X_14885_ _06329_ _06369_ _06407_ _06466_ _06467_ VGND VGND VPWR VPWR _06468_ sky130_fd_sc_hd__o221a_1
X_13836_ _05245_ _05252_ _05321_ VGND VGND VPWR VPWR _05322_ sky130_fd_sc_hd__a21o_1
XFILLER_0_134_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10979_ _02206_ _02207_ VGND VGND VPWR VPWR _02208_ sky130_fd_sc_hd__nor2_1
X_13767_ net230 net157 net306 net149 VGND VGND VPWR VPWR _05247_ sky130_fd_sc_hd__and4_1
XFILLER_0_85_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15506_ net193 net872 VGND VGND VPWR VPWR _07144_ sky130_fd_sc_hd__nand2_1
X_12718_ net170 net754 VGND VGND VPWR VPWR _04103_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13698_ net167 net148 VGND VGND VPWR VPWR _05172_ sky130_fd_sc_hd__nand2_1
X_15437_ _06965_ _06967_ VGND VGND VPWR VPWR _07069_ sky130_fd_sc_hd__and2b_1
X_12649_ net294 net800 VGND VGND VPWR VPWR _04027_ sky130_fd_sc_hd__nand2_1
XFILLER_0_143_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15368_ _06896_ _06976_ VGND VGND VPWR VPWR _06993_ sky130_fd_sc_hd__or2_1
XFILLER_0_87_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14319_ _05837_ _05845_ VGND VGND VPWR VPWR _05846_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15299_ _06901_ _06917_ VGND VGND VPWR VPWR _06918_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09860_ _01128_ _01129_ VGND VGND VPWR VPWR _01130_ sky130_fd_sc_hd__nor2_1
X_08811_ _04851_ _05970_ _08120_ _08121_ VGND VGND VPWR VPWR _08122_ sky130_fd_sc_hd__or4bb_4
X_09791_ _01060_ _01061_ VGND VGND VPWR VPWR _01062_ sky130_fd_sc_hd__xnor2_1
X_08742_ _08051_ _08052_ VGND VGND VPWR VPWR _08053_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08673_ _07608_ _07922_ VGND VGND VPWR VPWR _07933_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09225_ _00487_ _00502_ VGND VGND VPWR VPWR _00503_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_63_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09156_ net658 net373 net364 net666 VGND VGND VPWR VPWR _00435_ sky130_fd_sc_hd__a22o_1
XFILLER_0_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09087_ _00364_ _00365_ _00347_ VGND VGND VPWR VPWR _00367_ sky130_fd_sc_hd__a21o_1
XFILLER_0_142_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10000_ _01266_ _01267_ VGND VGND VPWR VPWR _01268_ sky130_fd_sc_hd__xor2_2
X_09989_ net635 net465 _01203_ VGND VGND VPWR VPWR _01257_ sky130_fd_sc_hd__and3_1
XFILLER_0_99_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11951_ net423 net467 VGND VGND VPWR VPWR _03266_ sky130_fd_sc_hd__nand2_1
XFILLER_0_98_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10902_ _02124_ _02121_ VGND VGND VPWR VPWR _02128_ sky130_fd_sc_hd__xnor2_1
X_14670_ _06037_ _06038_ _06040_ VGND VGND VPWR VPWR _06231_ sky130_fd_sc_hd__o21ba_1
X_11882_ _02992_ _03190_ VGND VGND VPWR VPWR _03191_ sky130_fd_sc_hd__xnor2_1
X_10833_ _02015_ _02013_ _02014_ VGND VGND VPWR VPWR _02059_ sky130_fd_sc_hd__or3_1
X_13621_ net174 net152 net143 net933 VGND VGND VPWR VPWR _05088_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_104_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16340_ clknet_4_0_0_clk _00053_ net334 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dfrtp_1
X_10764_ _01981_ _01986_ _01982_ VGND VGND VPWR VPWR _01990_ sky130_fd_sc_hd__nand3_1
X_13552_ _04921_ _04925_ _04926_ _05012_ VGND VGND VPWR VPWR _05013_ sky130_fd_sc_hd__o31a_1
XFILLER_0_137_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12503_ _03728_ _03736_ _03735_ VGND VGND VPWR VPWR _03867_ sky130_fd_sc_hd__a21oi_1
X_16271_ net247 net638 net648 _04540_ VGND VGND VPWR VPWR _07974_ sky130_fd_sc_hd__a211o_1
X_13483_ _04887_ _04833_ _04937_ VGND VGND VPWR VPWR _04939_ sky130_fd_sc_hd__o21ba_1
X_10695_ _01917_ _01919_ VGND VGND VPWR VPWR _01921_ sky130_fd_sc_hd__nor2_1
XFILLER_0_109_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15222_ _06825_ _06832_ _06833_ VGND VGND VPWR VPWR _06834_ sky130_fd_sc_hd__nand3_1
X_12434_ net224 net735 VGND VGND VPWR VPWR _03791_ sky130_fd_sc_hd__nand2_1
XFILLER_0_81_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15153_ _06756_ _06757_ _06753_ VGND VGND VPWR VPWR _06760_ sky130_fd_sc_hd__a21o_1
X_12365_ net198 net788 VGND VGND VPWR VPWR _03715_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11316_ _02574_ _02575_ VGND VGND VPWR VPWR _02576_ sky130_fd_sc_hd__xor2_2
X_14104_ _05534_ _05535_ VGND VGND VPWR VPWR _05614_ sky130_fd_sc_hd__and2_1
X_15084_ _06495_ _06600_ VGND VGND VPWR VPWR _06684_ sky130_fd_sc_hd__nor2_1
X_12296_ _03557_ _03576_ _03640_ VGND VGND VPWR VPWR _03641_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_22_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14035_ _05537_ _05505_ _05506_ VGND VGND VPWR VPWR _05539_ sky130_fd_sc_hd__or3_1
X_11247_ _02435_ _02470_ _02471_ VGND VGND VPWR VPWR _02500_ sky130_fd_sc_hd__nor3_1
XFILLER_0_38_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11178_ _02315_ _02317_ _02316_ VGND VGND VPWR VPWR _02425_ sky130_fd_sc_hd__a21bo_1
X_10129_ _01390_ _01386_ _01391_ VGND VGND VPWR VPWR _01392_ sky130_fd_sc_hd__o21ai_1
X_15986_ _07558_ _07560_ VGND VGND VPWR VPWR _07666_ sky130_fd_sc_hd__nor2_1
XFILLER_0_54_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14937_ _06502_ _06503_ _06522_ _06523_ VGND VGND VPWR VPWR _06524_ sky130_fd_sc_hd__o211ai_2
X_14868_ _06419_ _06425_ _06424_ VGND VGND VPWR VPWR _06449_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_89_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13819_ _05302_ _05303_ VGND VGND VPWR VPWR _05304_ sky130_fd_sc_hd__nor2_1
X_14799_ _06347_ _06345_ _06346_ VGND VGND VPWR VPWR _06373_ sky130_fd_sc_hd__nand3_1
XFILLER_0_57_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09010_ Q_cos\[3\] _00290_ _02181_ VGND VGND VPWR VPWR _00291_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold102 Q_sin\[4\] VGND VGND VPWR VPWR net908 sky130_fd_sc_hd__dlygate4sd3_1
Xhold113 net117 VGND VGND VPWR VPWR net919 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_41_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09912_ net645 net654 net455 net446 VGND VGND VPWR VPWR _01181_ sky130_fd_sc_hd__and4_1
XFILLER_0_1_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout604 net608 VGND VGND VPWR VPWR net604 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_111_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout615 net618 VGND VGND VPWR VPWR net615 sky130_fd_sc_hd__buf_2
Xfanout626 net627 VGND VGND VPWR VPWR net626 sky130_fd_sc_hd__buf_2
X_09843_ _01109_ _01113_ VGND VGND VPWR VPWR _01114_ sky130_fd_sc_hd__xor2_1
Xfanout637 net639 VGND VGND VPWR VPWR net637 sky130_fd_sc_hd__clkbuf_4
Xfanout648 net649 VGND VGND VPWR VPWR net648 sky130_fd_sc_hd__buf_2
Xfanout659 net661 VGND VGND VPWR VPWR net659 sky130_fd_sc_hd__buf_6
XPHY_EDGE_ROW_13_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09774_ _01023_ _01024_ _01044_ VGND VGND VPWR VPWR _01045_ sky130_fd_sc_hd__o21ai_2
X_08725_ _08035_ VGND VGND VPWR VPWR _08036_ sky130_fd_sc_hd__inv_2
X_08656_ _07510_ _07521_ _07673_ VGND VGND VPWR VPWR _07749_ sky130_fd_sc_hd__a21oi_1
X_08587_ _06922_ _06977_ _06988_ _05871_ VGND VGND VPWR VPWR _06998_ sky130_fd_sc_hd__o211a_1
XFILLER_0_49_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_22_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09208_ _00415_ _00430_ VGND VGND VPWR VPWR _00486_ sky130_fd_sc_hd__nor2_1
XFILLER_0_91_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10480_ _01699_ _01704_ _01703_ VGND VGND VPWR VPWR _01706_ sky130_fd_sc_hd__a21o_1
XFILLER_0_32_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09139_ _00416_ _00417_ VGND VGND VPWR VPWR _00418_ sky130_fd_sc_hd__or2_1
XFILLER_0_60_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12150_ _03480_ _03481_ VGND VGND VPWR VPWR _03482_ sky130_fd_sc_hd__nor2_1
X_11101_ _02339_ _02340_ VGND VGND VPWR VPWR _02341_ sky130_fd_sc_hd__and2b_1
X_12081_ _03393_ _03390_ VGND VGND VPWR VPWR _03407_ sky130_fd_sc_hd__and2b_1
XFILLER_0_130_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11032_ _02246_ _02264_ _02265_ VGND VGND VPWR VPWR _02266_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_31_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15840_ _07380_ _07383_ _07381_ VGND VGND VPWR VPWR _07507_ sky130_fd_sc_hd__o21ba_1
X_15771_ _07430_ _07431_ VGND VGND VPWR VPWR _07432_ sky130_fd_sc_hd__xor2_2
X_12983_ _04384_ _04392_ VGND VGND VPWR VPWR _04394_ sky130_fd_sc_hd__xor2_2
X_14722_ _06286_ _06287_ VGND VGND VPWR VPWR _06288_ sky130_fd_sc_hd__xnor2_2
X_11934_ _03234_ _03232_ VGND VGND VPWR VPWR _03248_ sky130_fd_sc_hd__and2b_1
X_14653_ _06206_ _06211_ VGND VGND VPWR VPWR _06213_ sky130_fd_sc_hd__xnor2_1
X_11865_ net147 net140 net349 net502 VGND VGND VPWR VPWR _03173_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_40_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13604_ _04966_ _04968_ VGND VGND VPWR VPWR _05070_ sky130_fd_sc_hd__or2_1
X_10816_ _02040_ _02041_ VGND VGND VPWR VPWR _02042_ sky130_fd_sc_hd__or2_1
X_14584_ _06123_ _06129_ _06128_ VGND VGND VPWR VPWR _06137_ sky130_fd_sc_hd__a21o_1
X_11796_ _03096_ _03097_ VGND VGND VPWR VPWR _03098_ sky130_fd_sc_hd__and2_1
XFILLER_0_54_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16323_ clknet_4_4_0_clk _00036_ net335 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dfrtp_1
X_13535_ _04991_ _04993_ _04994_ VGND VGND VPWR VPWR _04995_ sky130_fd_sc_hd__nand3_1
XFILLER_0_131_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10747_ _01965_ _01967_ VGND VGND VPWR VPWR _01973_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16254_ _07951_ _07953_ _07955_ VGND VGND VPWR VPWR _07956_ sky130_fd_sc_hd__mux2_1
XFILLER_0_125_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10678_ _01901_ _01902_ _01903_ VGND VGND VPWR VPWR _01904_ sky130_fd_sc_hd__nand3_4
X_13466_ _04910_ _04919_ VGND VGND VPWR VPWR _04920_ sky130_fd_sc_hd__xor2_2
XFILLER_0_54_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15205_ _06795_ _06815_ VGND VGND VPWR VPWR _06816_ sky130_fd_sc_hd__xor2_2
XFILLER_0_113_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12417_ _03766_ _03768_ _03727_ _03737_ VGND VGND VPWR VPWR _03772_ sky130_fd_sc_hd__a211o_1
X_16185_ _07876_ _07877_ _07880_ VGND VGND VPWR VPWR _07882_ sky130_fd_sc_hd__and3_1
X_13397_ _04755_ _04843_ VGND VGND VPWR VPWR _04845_ sky130_fd_sc_hd__nor2_1
XFILLER_0_106_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15136_ net323 net68 net623 VGND VGND VPWR VPWR _06741_ sky130_fd_sc_hd__and3_1
X_12348_ net223 net753 VGND VGND VPWR VPWR _03696_ sky130_fd_sc_hd__and2_1
XFILLER_0_10_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15067_ _06663_ _06664_ net945 _06564_ VGND VGND VPWR VPWR _06666_ sky130_fd_sc_hd__a211o_1
X_12279_ net792 net467 VGND VGND VPWR VPWR _03622_ sky130_fd_sc_hd__nand2_1
X_14018_ _05517_ _05518_ _05519_ VGND VGND VPWR VPWR _05520_ sky130_fd_sc_hd__o21a_1
XFILLER_0_4_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15969_ _07625_ _07646_ VGND VGND VPWR VPWR _07647_ sky130_fd_sc_hd__and2_1
X_08510_ net560 net569 net524 net435 VGND VGND VPWR VPWR _06157_ sky130_fd_sc_hd__and4_1
X_09490_ _00443_ _00689_ _00764_ VGND VGND VPWR VPWR _00765_ sky130_fd_sc_hd__a21bo_1
X_08441_ _05210_ _05123_ _05199_ VGND VGND VPWR VPWR _05405_ sky130_fd_sc_hd__nand3_1
XFILLER_0_148_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08372_ _03388_ net888 _03377_ VGND VGND VPWR VPWR _04654_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_144_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout401 net52 VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__buf_6
Xfanout412 net51 VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__buf_6
Xfanout423 net424 VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__clkbuf_2
Xfanout434 net49 VGND VGND VPWR VPWR net434 sky130_fd_sc_hd__buf_8
Xfanout445 net47 VGND VGND VPWR VPWR net445 sky130_fd_sc_hd__buf_6
Xfanout456 net457 VGND VGND VPWR VPWR net456 sky130_fd_sc_hd__clkbuf_2
X_09826_ _01095_ _01066_ _01067_ VGND VGND VPWR VPWR _01097_ sky130_fd_sc_hd__nand3_1
Xfanout467 net44 VGND VGND VPWR VPWR net467 sky130_fd_sc_hd__clkbuf_4
Xfanout478 net482 VGND VGND VPWR VPWR net478 sky130_fd_sc_hd__clkbuf_4
Xfanout489 net492 VGND VGND VPWR VPWR net489 sky130_fd_sc_hd__buf_2
X_09757_ _01006_ _01007_ _01027_ _01028_ VGND VGND VPWR VPWR _01029_ sky130_fd_sc_hd__a22o_1
X_08708_ _07879_ _07996_ _07998_ _08019_ VGND VGND VPWR VPWR _08020_ sky130_fd_sc_hd__a211o_1
X_09688_ _00959_ _00960_ VGND VGND VPWR VPWR _00961_ sky130_fd_sc_hd__nor2_1
X_08639_ net701 net388 _07532_ _07543_ VGND VGND VPWR VPWR _07564_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_49_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11650_ _02937_ _02938_ VGND VGND VPWR VPWR _02939_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10601_ _01717_ _01715_ _01716_ VGND VGND VPWR VPWR _01827_ sky130_fd_sc_hd__or3_1
X_11581_ _02771_ _02772_ _02863_ VGND VGND VPWR VPWR _02864_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_119_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10532_ _01725_ _01728_ _01756_ _01757_ VGND VGND VPWR VPWR _01758_ sky130_fd_sc_hd__a211oi_2
X_13320_ _04653_ _04672_ _04759_ VGND VGND VPWR VPWR _04760_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_36_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10463_ _01686_ _01687_ _01688_ VGND VGND VPWR VPWR _01689_ sky130_fd_sc_hd__nand3_2
XFILLER_0_122_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13251_ net723 net301 VGND VGND VPWR VPWR _04685_ sky130_fd_sc_hd__and2_1
X_12202_ _03503_ _03505_ _03495_ VGND VGND VPWR VPWR _03538_ sky130_fd_sc_hd__o21ai_1
X_13182_ net327 net798 net68 VGND VGND VPWR VPWR _04610_ sky130_fd_sc_hd__and3_1
X_10394_ net741 net379 net370 net751 VGND VGND VPWR VPWR _01620_ sky130_fd_sc_hd__a22oi_2
X_12133_ _03389_ VGND VGND VPWR VPWR _03465_ sky130_fd_sc_hd__inv_2
XFILLER_0_102_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12064_ _03386_ _03389_ VGND VGND VPWR VPWR _03390_ sky130_fd_sc_hd__xnor2_1
X_11015_ net515 net151 net523 net394 VGND VGND VPWR VPWR _02248_ sky130_fd_sc_hd__and4_1
X_15823_ _07402_ VGND VGND VPWR VPWR _07489_ sky130_fd_sc_hd__inv_2
XFILLER_0_35_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15754_ _07411_ _07413_ VGND VGND VPWR VPWR _07414_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12966_ _04365_ _04373_ _04374_ VGND VGND VPWR VPWR _04375_ sky130_fd_sc_hd__nand3_2
X_14705_ net187 net177 net605 VGND VGND VPWR VPWR _06270_ sky130_fd_sc_hd__and3_1
XFILLER_0_87_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11917_ _03148_ _03132_ VGND VGND VPWR VPWR _03230_ sky130_fd_sc_hd__and2b_1
X_15685_ _07197_ _07200_ _07198_ VGND VGND VPWR VPWR _07339_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_129_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12897_ net327 net234 net242 net321 VGND VGND VPWR VPWR _04300_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_51_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14636_ _05889_ _06193_ VGND VGND VPWR VPWR _06194_ sky130_fd_sc_hd__nor2_1
XFILLER_0_74_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11848_ _03152_ _03154_ VGND VGND VPWR VPWR _03155_ sky130_fd_sc_hd__xor2_1
XFILLER_0_55_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_144_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14567_ _06115_ _06116_ _06049_ VGND VGND VPWR VPWR _06118_ sky130_fd_sc_hd__a21o_1
XFILLER_0_138_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11779_ _02707_ _03075_ _03076_ _03079_ VGND VGND VPWR VPWR _03080_ sky130_fd_sc_hd__o211a_4
XFILLER_0_55_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16306_ clknet_4_15_0_clk _00019_ net343 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_83_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13518_ _04973_ _04975_ VGND VGND VPWR VPWR _04976_ sky130_fd_sc_hd__xor2_2
X_14498_ net273 net697 _06021_ _06022_ VGND VGND VPWR VPWR _06042_ sky130_fd_sc_hd__a31o_1
XFILLER_0_3_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16237_ _07936_ _07937_ VGND VGND VPWR VPWR _07938_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_140_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13449_ _04897_ _04898_ _04899_ VGND VGND VPWR VPWR _04901_ sky130_fd_sc_hd__nand3_1
XFILLER_0_24_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16168_ _07775_ _07778_ _07861_ VGND VGND VPWR VPWR _07863_ sky130_fd_sc_hd__o21ai_1
X_15119_ _06718_ _06719_ _06720_ VGND VGND VPWR VPWR _06722_ sky130_fd_sc_hd__a21o_1
XFILLER_0_50_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08990_ _00268_ _00269_ _00237_ VGND VGND VPWR VPWR _00271_ sky130_fd_sc_hd__o21ai_1
X_16099_ _07786_ _07787_ VGND VGND VPWR VPWR _07788_ sky130_fd_sc_hd__xnor2_1
X_09611_ _00866_ _00884_ VGND VGND VPWR VPWR _00885_ sky130_fd_sc_hd__and2_1
X_09542_ _00733_ _00816_ VGND VGND VPWR VPWR _00817_ sky130_fd_sc_hd__nor2_1
XFILLER_0_92_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09473_ net673 net680 net487 net477 VGND VGND VPWR VPWR _00748_ sky130_fd_sc_hd__and4_1
XFILLER_0_93_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08424_ _05123_ _05199_ _05210_ VGND VGND VPWR VPWR _05221_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_19_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08355_ _04437_ _04447_ _03778_ _03822_ VGND VGND VPWR VPWR _04469_ sky130_fd_sc_hd__a211o_1
XFILLER_0_34_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08286_ _03691_ _03701_ VGND VGND VPWR VPWR _03712_ sky130_fd_sc_hd__nor2_1
XFILLER_0_150_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_144_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout220 net226 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__buf_6
Xfanout231 net236 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__buf_2
Xfanout242 net246 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__buf_4
Xfanout253 net260 VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__buf_4
Xfanout264 net269 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__clkbuf_4
Xfanout275 net276 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__buf_2
Xfanout286 net287 VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__clkbuf_4
X_09809_ _01076_ _01077_ _01078_ VGND VGND VPWR VPWR _01080_ sky130_fd_sc_hd__nor3_1
Xfanout297 net299 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__clkbuf_2
X_12820_ net294 net776 net783 net283 VGND VGND VPWR VPWR _04215_ sky130_fd_sc_hd__a22o_1
XFILLER_0_97_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12751_ _04079_ _04138_ VGND VGND VPWR VPWR _04139_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11702_ net796 net375 net366 net142 VGND VGND VPWR VPWR _02995_ sky130_fd_sc_hd__a22o_1
X_15470_ _07102_ _07103_ VGND VGND VPWR VPWR _07104_ sky130_fd_sc_hd__nor2_1
X_12682_ _03968_ _03970_ VGND VGND VPWR VPWR _04063_ sky130_fd_sc_hd__nor2_1
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14421_ _05953_ _05955_ _05954_ VGND VGND VPWR VPWR _05957_ sky130_fd_sc_hd__a21o_1
X_11633_ _02918_ _02919_ VGND VGND VPWR VPWR _02921_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_21_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14352_ net291 net282 net601 net697 VGND VGND VPWR VPWR _05881_ sky130_fd_sc_hd__and4_1
XFILLER_0_119_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11564_ _02843_ _02845_ VGND VGND VPWR VPWR _02846_ sky130_fd_sc_hd__and2b_1
XFILLER_0_107_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13303_ _04740_ _04741_ VGND VGND VPWR VPWR _04743_ sky130_fd_sc_hd__xnor2_2
X_10515_ _01737_ _01740_ VGND VGND VPWR VPWR _01741_ sky130_fd_sc_hd__xnor2_2
X_11495_ _02345_ _02540_ _02542_ net141 VGND VGND VPWR VPWR _02771_ sky130_fd_sc_hd__a22o_1
XFILLER_0_107_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14283_ _05685_ _05806_ VGND VGND VPWR VPWR _05808_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_123_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16022_ _07641_ _07642_ _07703_ VGND VGND VPWR VPWR _07704_ sky130_fd_sc_hd__o21ai_1
X_10446_ _01670_ _01671_ VGND VGND VPWR VPWR _01672_ sky130_fd_sc_hd__or2b_1
X_13234_ _04546_ _04552_ VGND VGND VPWR VPWR _04667_ sky130_fd_sc_hd__and2_1
XFILLER_0_150_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10377_ D_sin\[16\] _01604_ _01605_ VGND VGND VPWR VPWR _01606_ sky130_fd_sc_hd__o21a_1
X_13165_ net215 _04494_ _04497_ _04495_ VGND VGND VPWR VPWR _04592_ sky130_fd_sc_hd__a22o_1
X_12116_ _03441_ _03445_ VGND VGND VPWR VPWR _03446_ sky130_fd_sc_hd__xnor2_1
X_13096_ _04514_ _04515_ _04412_ _04482_ VGND VGND VPWR VPWR _04517_ sky130_fd_sc_hd__o211a_1
X_12047_ _03361_ _03370_ VGND VGND VPWR VPWR _03371_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_46_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15806_ _07468_ _07469_ VGND VGND VPWR VPWR _07470_ sky130_fd_sc_hd__nor2_1
X_13998_ _05494_ _05497_ VGND VGND VPWR VPWR _05498_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_149_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15737_ _07290_ _07378_ _07393_ VGND VGND VPWR VPWR _07395_ sky130_fd_sc_hd__nand3_1
X_12949_ _04354_ _04355_ VGND VGND VPWR VPWR _04356_ sky130_fd_sc_hd__nor2_1
XFILLER_0_62_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15668_ _07318_ _07319_ VGND VGND VPWR VPWR _07320_ sky130_fd_sc_hd__or2_1
XFILLER_0_28_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14619_ _05931_ _05928_ _05930_ VGND VGND VPWR VPWR _06175_ sky130_fd_sc_hd__a21o_1
XFILLER_0_56_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15599_ net272 net531 VGND VGND VPWR VPWR _07245_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08973_ net621 net520 net48 VGND VGND VPWR VPWR _00254_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_46_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09525_ _00797_ _00799_ VGND VGND VPWR VPWR _00800_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_149_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09456_ _00571_ _00647_ _00731_ VGND VGND VPWR VPWR _00732_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_93_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08407_ _04959_ _05014_ _05025_ VGND VGND VPWR VPWR _05036_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_81_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09387_ _00657_ _00658_ _00655_ VGND VGND VPWR VPWR _00663_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_47_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08338_ _04251_ _04262_ _04273_ VGND VGND VPWR VPWR _04284_ sky130_fd_sc_hd__or3_4
X_08269_ _03496_ _03507_ _03518_ VGND VGND VPWR VPWR _03529_ sky130_fd_sc_hd__nand3_2
XFILLER_0_132_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10300_ _01537_ _01538_ VGND VGND VPWR VPWR _01539_ sky130_fd_sc_hd__nand2_1
XFILLER_0_61_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11280_ _02534_ _02535_ VGND VGND VPWR VPWR _02536_ sky130_fd_sc_hd__and2b_1
XFILLER_0_61_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10231_ _01467_ _01470_ _01476_ VGND VGND VPWR VPWR _01480_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_5_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10162_ _01420_ VGND VGND VPWR VPWR _00025_ sky130_fd_sc_hd__clkbuf_1
X_10093_ _01349_ _01358_ VGND VGND VPWR VPWR _01359_ sky130_fd_sc_hd__xnor2_1
X_14970_ _06557_ _06558_ _06538_ VGND VGND VPWR VPWR _06560_ sky130_fd_sc_hd__a21oi_2
X_13921_ net424 net272 VGND VGND VPWR VPWR _05414_ sky130_fd_sc_hd__nand2_1
X_13852_ _05330_ _05337_ VGND VGND VPWR VPWR _05339_ sky130_fd_sc_hd__nor2_1
X_12803_ _04192_ _04195_ VGND VGND VPWR VPWR _04197_ sky130_fd_sc_hd__xnor2_2
X_13783_ net167 net139 _05262_ VGND VGND VPWR VPWR _05265_ sky130_fd_sc_hd__nand3_1
X_10995_ _02221_ _02222_ _02224_ VGND VGND VPWR VPWR _02226_ sky130_fd_sc_hd__a21o_1
X_15522_ _07159_ _07160_ VGND VGND VPWR VPWR _07161_ sky130_fd_sc_hd__nand2_1
X_12734_ net302 net776 VGND VGND VPWR VPWR _04121_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15453_ Q_sin\[6\] _07085_ _05626_ VGND VGND VPWR VPWR _07087_ sky130_fd_sc_hd__mux2_1
X_12665_ _04041_ _04043_ _04044_ VGND VGND VPWR VPWR _04045_ sky130_fd_sc_hd__or3_1
XFILLER_0_139_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14404_ net322 net237 net669 net678 VGND VGND VPWR VPWR _05939_ sky130_fd_sc_hd__and4_1
X_11616_ net756 _00191_ _02823_ _02901_ VGND VGND VPWR VPWR _02902_ sky130_fd_sc_hd__o31ai_4
X_15384_ _06908_ _06910_ _07010_ VGND VGND VPWR VPWR _07011_ sky130_fd_sc_hd__a21o_1
X_12596_ net216 net727 net736 net206 VGND VGND VPWR VPWR _03969_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_142_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14335_ _05856_ _05862_ VGND VGND VPWR VPWR _05863_ sky130_fd_sc_hd__or2b_1
XFILLER_0_80_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11547_ _02806_ _02826_ VGND VGND VPWR VPWR _02827_ sky130_fd_sc_hd__xnor2_2
X_14266_ _05768_ _05788_ VGND VGND VPWR VPWR _05789_ sky130_fd_sc_hd__xor2_1
X_11478_ _02748_ _02749_ _02750_ VGND VGND VPWR VPWR _02752_ sky130_fd_sc_hd__nand3_1
X_16005_ _07583_ _07604_ _07602_ VGND VGND VPWR VPWR _07687_ sky130_fd_sc_hd__a21oi_1
X_13217_ _04648_ VGND VGND VPWR VPWR _00080_ sky130_fd_sc_hd__clkbuf_1
X_10429_ _01654_ _01651_ VGND VGND VPWR VPWR _01655_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_122_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14197_ _05654_ _05664_ _05713_ VGND VGND VPWR VPWR _05714_ sky130_fd_sc_hd__a21bo_1
X_13148_ net708 net170 net163 net713 VGND VGND VPWR VPWR _04573_ sky130_fd_sc_hd__a22o_1
XFILLER_0_148_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13079_ _04496_ _04497_ VGND VGND VPWR VPWR _04498_ sky130_fd_sc_hd__xnor2_2
X_09310_ _00584_ _00586_ VGND VGND VPWR VPWR _00587_ sky130_fd_sc_hd__xor2_2
XFILLER_0_145_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09241_ _00515_ _00516_ _00517_ VGND VGND VPWR VPWR _00519_ sky130_fd_sc_hd__a21o_1
XFILLER_0_146_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_880 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09172_ _00358_ _00445_ _00449_ _00450_ VGND VGND VPWR VPWR _00451_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_7_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08956_ _00235_ _00236_ VGND VGND VPWR VPWR _00237_ sky130_fd_sc_hd__or2_1
X_08887_ _08104_ _00138_ _00167_ _00168_ VGND VGND VPWR VPWR _00169_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_67_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09508_ _00741_ _00742_ _00782_ VGND VGND VPWR VPWR _00783_ sky130_fd_sc_hd__nor3_1
XFILLER_0_78_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10780_ _01977_ _02004_ _02005_ VGND VGND VPWR VPWR _02006_ sky130_fd_sc_hd__a21o_1
XFILLER_0_93_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09439_ _00713_ _00714_ VGND VGND VPWR VPWR _00715_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_35_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12450_ _03804_ _03806_ _03805_ VGND VGND VPWR VPWR _03808_ sky130_fd_sc_hd__a21o_1
XFILLER_0_136_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11401_ _02666_ _02667_ VGND VGND VPWR VPWR _02668_ sky130_fd_sc_hd__xor2_1
X_12381_ net189 net789 net804 net179 VGND VGND VPWR VPWR _03732_ sky130_fd_sc_hd__a22o_1
XFILLER_0_50_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14120_ _05582_ _05583_ _05629_ VGND VGND VPWR VPWR _05630_ sky130_fd_sc_hd__a21o_1
X_11332_ _02499_ _02591_ _02592_ VGND VGND VPWR VPWR _02593_ sky130_fd_sc_hd__nand3_1
XFILLER_0_22_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14051_ _05229_ _05400_ net118 _05555_ VGND VGND VPWR VPWR _05556_ sky130_fd_sc_hd__a31oi_4
XFILLER_0_120_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11263_ _02508_ _02515_ _02516_ VGND VGND VPWR VPWR _02518_ sky130_fd_sc_hd__nand3_1
XFILLER_0_104_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13002_ _04394_ _04412_ _04413_ VGND VGND VPWR VPWR _04414_ sky130_fd_sc_hd__and3_1
X_10214_ net131 _01463_ _01464_ _01465_ VGND VGND VPWR VPWR _00032_ sky130_fd_sc_hd__a31o_1
X_11194_ net614 net367 _02440_ _02442_ VGND VGND VPWR VPWR _02443_ sky130_fd_sc_hd__a22o_1
X_10145_ _01395_ _01400_ _01396_ VGND VGND VPWR VPWR _01406_ sky130_fd_sc_hd__a21bo_1
X_10076_ _01113_ _01340_ _01342_ VGND VGND VPWR VPWR _01343_ sky130_fd_sc_hd__o21ai_2
X_14953_ net211 net668 net675 net200 VGND VGND VPWR VPWR _06542_ sky130_fd_sc_hd__a22oi_2
X_13904_ _05312_ _05396_ VGND VGND VPWR VPWR _05397_ sky130_fd_sc_hd__and2_1
X_14884_ _06406_ _06329_ _06405_ VGND VGND VPWR VPWR _06467_ sky130_fd_sc_hd__a21o_1
X_13835_ _05251_ _05250_ VGND VGND VPWR VPWR _05321_ sky130_fd_sc_hd__and2b_1
XFILLER_0_97_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13766_ net230 net306 net149 net157 VGND VGND VPWR VPWR _05246_ sky130_fd_sc_hd__a22oi_1
X_10978_ _01781_ _01783_ _02205_ VGND VGND VPWR VPWR _02207_ sky130_fd_sc_hd__and3_1
X_15505_ _07141_ _07142_ VGND VGND VPWR VPWR _07143_ sky130_fd_sc_hd__nor2b_1
XFILLER_0_73_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12717_ _04050_ _04052_ VGND VGND VPWR VPWR _04102_ sky130_fd_sc_hd__nor2_2
X_13697_ _05169_ _05170_ VGND VGND VPWR VPWR _05171_ sky130_fd_sc_hd__nor2_1
XFILLER_0_38_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15436_ _07039_ _07067_ VGND VGND VPWR VPWR _07068_ sky130_fd_sc_hd__xnor2_1
X_12648_ _03985_ _04024_ _04025_ VGND VGND VPWR VPWR _04026_ sky130_fd_sc_hd__a21oi_1
X_15367_ _06981_ _06989_ _06979_ VGND VGND VPWR VPWR _06992_ sky130_fd_sc_hd__o21a_1
X_12579_ _03948_ _03947_ _03809_ _03807_ VGND VGND VPWR VPWR _03950_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_142_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14318_ _05838_ _05844_ VGND VGND VPWR VPWR _05845_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_68_Left_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15298_ _06915_ _06916_ VGND VGND VPWR VPWR _06917_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_80_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14249_ _05694_ _05703_ _05769_ VGND VGND VPWR VPWR _05770_ sky130_fd_sc_hd__a21bo_1
X_08810_ _08118_ _08119_ _08038_ _08039_ VGND VGND VPWR VPWR _08121_ sky130_fd_sc_hd__o211ai_1
X_09790_ net689 _00191_ VGND VGND VPWR VPWR _01061_ sky130_fd_sc_hd__or2_1
X_08741_ _04031_ _04053_ _08050_ VGND VGND VPWR VPWR _08052_ sky130_fd_sc_hd__and3_1
XFILLER_0_84_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08672_ _07629_ _07619_ VGND VGND VPWR VPWR _07922_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_77_Left_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09224_ _00500_ _00501_ VGND VGND VPWR VPWR _00502_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_146_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09155_ net658 net383 _00349_ _00348_ net392 VGND VGND VPWR VPWR _00434_ sky130_fd_sc_hd__a32o_1
XPHY_EDGE_ROW_86_Left_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09086_ _00347_ _00364_ _00365_ VGND VGND VPWR VPWR _00366_ sky130_fd_sc_hd__nand3_1
XFILLER_0_114_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09988_ _01075_ _01207_ _01255_ VGND VGND VPWR VPWR _01256_ sky130_fd_sc_hd__a21bo_1
X_08939_ net548 net497 net488 net557 VGND VGND VPWR VPWR _00220_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_95_Left_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_150_Right_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11950_ _03263_ _03264_ VGND VGND VPWR VPWR _03265_ sky130_fd_sc_hd__nor2_1
X_10901_ _02126_ _02115_ VGND VGND VPWR VPWR _02127_ sky130_fd_sc_hd__nor2_1
X_11881_ _03185_ _03189_ VGND VGND VPWR VPWR _03190_ sky130_fd_sc_hd__xnor2_1
X_13620_ _05086_ _05009_ VGND VGND VPWR VPWR _05087_ sky130_fd_sc_hd__or2_1
X_10832_ _02056_ _02057_ VGND VGND VPWR VPWR _02058_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_79_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13551_ net225 _04823_ VGND VGND VPWR VPWR _05012_ sky130_fd_sc_hd__nand2_1
X_10763_ _01964_ _01988_ VGND VGND VPWR VPWR _01989_ sky130_fd_sc_hd__nor2_1
XFILLER_0_54_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12502_ _03840_ _03824_ _03841_ VGND VGND VPWR VPWR _03865_ sky130_fd_sc_hd__or3_1
X_16270_ net270 net625 _07837_ _07834_ VGND VGND VPWR VPWR _07973_ sky130_fd_sc_hd__a31o_1
XFILLER_0_54_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13482_ _04909_ _04936_ VGND VGND VPWR VPWR _04937_ sky130_fd_sc_hd__xnor2_1
X_10694_ _01917_ _01919_ VGND VGND VPWR VPWR _01920_ sky130_fd_sc_hd__and2_1
X_15221_ _06829_ _06830_ _06831_ VGND VGND VPWR VPWR _06833_ sky130_fd_sc_hd__a21o_1
X_12433_ net329 net244 net717 net727 VGND VGND VPWR VPWR _03790_ sky130_fd_sc_hd__and4_1
XFILLER_0_23_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15152_ _06753_ _06756_ _06757_ VGND VGND VPWR VPWR _06758_ sky130_fd_sc_hd__and3_1
XFILLER_0_50_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12364_ _03711_ _03713_ VGND VGND VPWR VPWR _03714_ sky130_fd_sc_hd__nor2_1
X_14103_ _05610_ _05588_ _05589_ VGND VGND VPWR VPWR _05613_ sky130_fd_sc_hd__or3_1
XFILLER_0_1_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11315_ net774 net444 VGND VGND VPWR VPWR _02575_ sky130_fd_sc_hd__nand2_1
X_15083_ _06499_ _06669_ _06670_ VGND VGND VPWR VPWR _06683_ sky130_fd_sc_hd__nand3_1
XFILLER_0_105_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12295_ _03577_ _03555_ VGND VGND VPWR VPWR _03640_ sky130_fd_sc_hd__and2b_1
X_14034_ _05505_ _05506_ _05537_ VGND VGND VPWR VPWR _05538_ sky130_fd_sc_hd__o21ai_1
X_11246_ _02407_ _02409_ _02498_ VGND VGND VPWR VPWR _02499_ sky130_fd_sc_hd__a21o_1
XFILLER_0_129_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11177_ _02422_ _02420_ _02421_ VGND VGND VPWR VPWR _02424_ sky130_fd_sc_hd__nand3_1
X_10128_ D_cos\[2\] Q_sin\[2\] VGND VGND VPWR VPWR _01391_ sky130_fd_sc_hd__xnor2_1
X_15985_ _07663_ _07664_ VGND VGND VPWR VPWR _07665_ sky130_fd_sc_hd__nor2_1
XFILLER_0_145_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10059_ _01324_ _01325_ VGND VGND VPWR VPWR _01326_ sky130_fd_sc_hd__nor2_1
X_14936_ _06520_ _06521_ _06504_ VGND VGND VPWR VPWR _06523_ sky130_fd_sc_hd__a21o_1
XFILLER_0_54_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14867_ _06411_ _06445_ _06446_ _06442_ _06447_ VGND VGND VPWR VPWR _06448_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_58_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13818_ _05277_ _05278_ _05300_ _05301_ VGND VGND VPWR VPWR _05303_ sky130_fd_sc_hd__and4bb_1
X_14798_ _06349_ _06352_ _06351_ VGND VGND VPWR VPWR _06372_ sky130_fd_sc_hd__a21o_1
XFILLER_0_147_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13749_ _05042_ _05052_ _05135_ VGND VGND VPWR VPWR _05228_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_58_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15419_ _07047_ _07048_ VGND VGND VPWR VPWR _07049_ sky130_fd_sc_hd__and2b_1
X_16399_ clknet_4_5_0_clk _00112_ net336 VGND VGND VPWR VPWR Q_sin\[16\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_53_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold103 D_cos\[7\] VGND VGND VPWR VPWR net909 sky130_fd_sc_hd__dlygate4sd3_1
Xhold114 net110 VGND VGND VPWR VPWR net920 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_123_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09911_ net645 net455 net446 net654 VGND VGND VPWR VPWR _01180_ sky130_fd_sc_hd__a22oi_1
Xfanout605 net608 VGND VGND VPWR VPWR net605 sky130_fd_sc_hd__buf_2
Xfanout616 net618 VGND VGND VPWR VPWR net616 sky130_fd_sc_hd__clkbuf_4
X_09842_ _00823_ _01110_ _01111_ _01112_ VGND VGND VPWR VPWR _01113_ sky130_fd_sc_hd__o211a_4
Xfanout627 net634 VGND VGND VPWR VPWR net627 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_95_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout638 net639 VGND VGND VPWR VPWR net638 sky130_fd_sc_hd__clkbuf_2
Xfanout649 net26 VGND VGND VPWR VPWR net649 sky130_fd_sc_hd__clkbuf_4
X_09773_ _01019_ _01022_ VGND VGND VPWR VPWR _01044_ sky130_fd_sc_hd__or2_1
XFILLER_0_28_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08724_ _04851_ _05893_ _05959_ VGND VGND VPWR VPWR _08035_ sky130_fd_sc_hd__or3_1
X_08655_ _07716_ _07727_ VGND VGND VPWR VPWR _07738_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08586_ _05850_ _05860_ _05785_ VGND VGND VPWR VPWR _06988_ sky130_fd_sc_hd__a21o_1
XFILLER_0_95_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09207_ _00413_ VGND VGND VPWR VPWR _00485_ sky130_fd_sc_hd__inv_2
X_09138_ net540 net548 net488 net478 VGND VGND VPWR VPWR _00417_ sky130_fd_sc_hd__and4_1
XFILLER_0_32_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09069_ net641 net402 net392 net650 VGND VGND VPWR VPWR _00349_ sky130_fd_sc_hd__a22o_1
X_11100_ _02337_ _02338_ _02334_ VGND VGND VPWR VPWR _02340_ sky130_fd_sc_hd__a21o_1
X_12080_ _03397_ _03403_ _03395_ VGND VGND VPWR VPWR _03406_ sky130_fd_sc_hd__a21o_1
X_11031_ _02261_ _02262_ _02263_ VGND VGND VPWR VPWR _02265_ sky130_fd_sc_hd__a21o_1
X_15770_ _07332_ _07335_ _07333_ VGND VGND VPWR VPWR _07431_ sky130_fd_sc_hd__o21ba_1
X_12982_ _04390_ _04391_ VGND VGND VPWR VPWR _04392_ sky130_fd_sc_hd__and2b_1
XFILLER_0_99_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14721_ _06273_ _06275_ _06274_ VGND VGND VPWR VPWR _06287_ sky130_fd_sc_hd__o21ba_1
X_11933_ _03244_ _03240_ _03245_ VGND VGND VPWR VPWR _03247_ sky130_fd_sc_hd__a21o_1
XFILLER_0_99_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14652_ _06209_ _06210_ VGND VGND VPWR VPWR _06211_ sky130_fd_sc_hd__xnor2_1
X_11864_ net140 net349 net502 net147 VGND VGND VPWR VPWR _03172_ sky130_fd_sc_hd__a22oi_1
X_13603_ _05062_ _05067_ VGND VGND VPWR VPWR _05069_ sky130_fd_sc_hd__xnor2_2
X_10815_ net802 net355 _02038_ _02039_ VGND VGND VPWR VPWR _02041_ sky130_fd_sc_hd__a211oi_1
X_14583_ _06133_ _06134_ VGND VGND VPWR VPWR _06136_ sky130_fd_sc_hd__xnor2_2
X_11795_ _03093_ _03095_ _03088_ VGND VGND VPWR VPWR _03097_ sky130_fd_sc_hd__a21o_1
X_16322_ clknet_4_7_0_clk _00035_ net336 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dfrtp_1
X_13534_ _04897_ _04899_ _04898_ VGND VGND VPWR VPWR _04994_ sky130_fd_sc_hd__a21bo_1
X_10746_ _01969_ _01970_ _01971_ VGND VGND VPWR VPWR _01972_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_138_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16253_ _07937_ _07936_ VGND VGND VPWR VPWR _07955_ sky130_fd_sc_hd__or2b_1
XFILLER_0_82_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13465_ _04917_ _04918_ VGND VGND VPWR VPWR _04919_ sky130_fd_sc_hd__and2b_1
X_10677_ _01836_ _01833_ _01835_ VGND VGND VPWR VPWR _01903_ sky130_fd_sc_hd__a21o_1
X_15204_ _06796_ _06814_ VGND VGND VPWR VPWR _06815_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_35_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12416_ _03727_ _03737_ _03766_ _03768_ VGND VGND VPWR VPWR _03771_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_35_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16184_ _07876_ _07877_ _07880_ VGND VGND VPWR VPWR _07881_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_23_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13396_ _04755_ _04843_ VGND VGND VPWR VPWR _04844_ sky130_fd_sc_hd__and2_1
XFILLER_0_112_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15135_ net323 net623 net68 VGND VGND VPWR VPWR _06740_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_105_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12347_ _03692_ _03693_ _03694_ VGND VGND VPWR VPWR _03695_ sky130_fd_sc_hd__o21bai_1
X_15066_ net945 _06564_ net851 _06664_ VGND VGND VPWR VPWR _06665_ sky130_fd_sc_hd__o211ai_1
X_12278_ _03505_ _03543_ _03495_ VGND VGND VPWR VPWR _03621_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_121_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14017_ net315 net271 VGND VGND VPWR VPWR _05519_ sky130_fd_sc_hd__nand2_1
X_11229_ _02389_ _02479_ _02480_ VGND VGND VPWR VPWR _02481_ sky130_fd_sc_hd__nor3_2
XFILLER_0_120_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15968_ _07644_ _07645_ VGND VGND VPWR VPWR _07646_ sky130_fd_sc_hd__nor2_1
X_14919_ _06077_ _06085_ _06084_ VGND VGND VPWR VPWR _06504_ sky130_fd_sc_hd__a21o_1
X_15899_ _07282_ _07495_ _07279_ VGND VGND VPWR VPWR _07571_ sky130_fd_sc_hd__a21o_1
XFILLER_0_148_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08440_ _05079_ _05384_ VGND VGND VPWR VPWR _05395_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_81_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08371_ _04600_ _04622_ _04633_ VGND VGND VPWR VPWR _04644_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_147_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout402 net403 VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__buf_4
Xfanout413 net421 VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__clkbuf_4
Xfanout424 net431 VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__clkbuf_4
Xfanout435 net436 VGND VGND VPWR VPWR net435 sky130_fd_sc_hd__clkbuf_4
Xfanout446 net448 VGND VGND VPWR VPWR net446 sky130_fd_sc_hd__clkbuf_4
X_09825_ _01066_ _01067_ _01095_ VGND VGND VPWR VPWR _01096_ sky130_fd_sc_hd__a21oi_2
Xfanout457 net459 VGND VGND VPWR VPWR net457 sky130_fd_sc_hd__buf_2
Xfanout468 net44 VGND VGND VPWR VPWR net468 sky130_fd_sc_hd__clkbuf_2
Xfanout479 net482 VGND VGND VPWR VPWR net479 sky130_fd_sc_hd__clkbuf_2
X_09756_ _01009_ _01026_ VGND VGND VPWR VPWR _01028_ sky130_fd_sc_hd__or2_1
X_08707_ _08011_ _08016_ _08017_ _07997_ _08018_ VGND VGND VPWR VPWR _08019_ sky130_fd_sc_hd__o2111ai_1
X_09687_ _00957_ _00958_ _00865_ _00901_ VGND VGND VPWR VPWR _00960_ sky130_fd_sc_hd__a211oi_1
X_08638_ _07532_ _07543_ net701 net388 VGND VGND VPWR VPWR _07553_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_96_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08569_ _05579_ _05677_ _05688_ VGND VGND VPWR VPWR _06802_ sky130_fd_sc_hd__and3_1
XFILLER_0_37_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10600_ _01722_ _01719_ _01721_ VGND VGND VPWR VPWR _01826_ sky130_fd_sc_hd__nand3_1
X_11580_ net141 _02542_ VGND VGND VPWR VPWR _02863_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10531_ _01745_ _01746_ _01755_ VGND VGND VPWR VPWR _01757_ sky130_fd_sc_hd__and3_1
XFILLER_0_91_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13250_ net705 net713 net161 net312 VGND VGND VPWR VPWR _04684_ sky130_fd_sc_hd__nand4_1
XFILLER_0_17_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10462_ _01669_ _01672_ _01685_ VGND VGND VPWR VPWR _01688_ sky130_fd_sc_hd__nand3_1
X_12201_ _03524_ _03525_ VGND VGND VPWR VPWR _03537_ sky130_fd_sc_hd__and2b_1
XFILLER_0_150_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13181_ net327 net798 net68 VGND VGND VPWR VPWR _04609_ sky130_fd_sc_hd__a21oi_1
X_10393_ net741 net751 net379 net370 VGND VGND VPWR VPWR _01619_ sky130_fd_sc_hd__and4_1
XFILLER_0_32_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12132_ _03461_ _03462_ VGND VGND VPWR VPWR _03463_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_103_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12063_ _03285_ _03305_ _03387_ VGND VGND VPWR VPWR _03389_ sky130_fd_sc_hd__a21oi_2
X_11014_ net614 net385 VGND VGND VPWR VPWR _02247_ sky130_fd_sc_hd__nand2_1
X_15822_ _07484_ _07485_ _07464_ VGND VGND VPWR VPWR _07487_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_126_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15753_ _07398_ _07399_ _07410_ VGND VGND VPWR VPWR _07413_ sky130_fd_sc_hd__a21o_1
X_12965_ _04369_ _04370_ _04372_ VGND VGND VPWR VPWR _04374_ sky130_fd_sc_hd__a21o_1
X_14704_ _06254_ _06266_ _06268_ VGND VGND VPWR VPWR _06269_ sky130_fd_sc_hd__and3_2
X_11916_ _03224_ _03228_ VGND VGND VPWR VPWR _03229_ sky130_fd_sc_hd__xor2_2
X_15684_ _07331_ _07337_ VGND VGND VPWR VPWR _07338_ sky130_fd_sc_hd__xnor2_1
X_12896_ net327 net234 net242 net320 VGND VGND VPWR VPWR _04299_ sky130_fd_sc_hd__and4_1
X_14635_ net303 net698 _05887_ _05888_ VGND VGND VPWR VPWR _06193_ sky130_fd_sc_hd__o2bb2a_1
X_11847_ _03037_ _03060_ _03153_ VGND VGND VPWR VPWR _03154_ sky130_fd_sc_hd__a21o_1
XFILLER_0_129_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14566_ _06049_ _06115_ _06116_ VGND VGND VPWR VPWR _06117_ sky130_fd_sc_hd__nand3_4
XFILLER_0_55_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11778_ _02980_ _03077_ _03074_ _03078_ VGND VGND VPWR VPWR _03079_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_83_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16305_ clknet_4_5_0_clk _00018_ net337 VGND VGND VPWR VPWR Q_cos\[18\] sky130_fd_sc_hd__dfrtp_1
X_13517_ _04874_ _04876_ _04974_ VGND VGND VPWR VPWR _04975_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_43_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10729_ _01951_ _01954_ VGND VGND VPWR VPWR _01955_ sky130_fd_sc_hd__xor2_1
X_14497_ _06037_ _06038_ _06040_ VGND VGND VPWR VPWR _06041_ sky130_fd_sc_hd__nor3b_4
XFILLER_0_42_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16236_ _07876_ _07880_ _07877_ VGND VGND VPWR VPWR _07937_ sky130_fd_sc_hd__a21boi_1
X_13448_ _04897_ _04898_ _04899_ VGND VGND VPWR VPWR _04900_ sky130_fd_sc_hd__a21o_1
XFILLER_0_141_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16167_ _07775_ _07778_ _07861_ VGND VGND VPWR VPWR _07862_ sky130_fd_sc_hd__or3_1
XFILLER_0_3_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13379_ _04718_ _04824_ VGND VGND VPWR VPWR _04825_ sky130_fd_sc_hd__xor2_2
XFILLER_0_11_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15118_ _06718_ _06719_ _06720_ VGND VGND VPWR VPWR _06721_ sky130_fd_sc_hd__nand3_2
X_16098_ _04538_ net672 VGND VGND VPWR VPWR _07787_ sky130_fd_sc_hd__or2_1
X_15049_ net323 net238 net643 net632 VGND VGND VPWR VPWR _06646_ sky130_fd_sc_hd__and4_1
XFILLER_0_76_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09610_ _00868_ _00883_ VGND VGND VPWR VPWR _00884_ sky130_fd_sc_hd__xnor2_1
X_09541_ _00814_ _00815_ VGND VGND VPWR VPWR _00816_ sky130_fd_sc_hd__xor2_1
XFILLER_0_78_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09472_ net673 net487 net477 net680 VGND VGND VPWR VPWR _00747_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_148_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08423_ _05134_ _05188_ _05144_ VGND VGND VPWR VPWR _05210_ sky130_fd_sc_hd__nand3_1
XFILLER_0_93_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08354_ _03778_ _03822_ _04437_ net862 VGND VGND VPWR VPWR _04458_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_117_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08285_ net542 net551 net378 net369 VGND VGND VPWR VPWR _03701_ sky130_fd_sc_hd__and4_1
XFILLER_0_116_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout210 net211 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__buf_6
Xfanout221 net222 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__clkbuf_4
Xfanout232 net236 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__clkbuf_4
Xfanout243 net246 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__buf_4
Xfanout254 net260 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__clkbuf_4
Xfanout265 net269 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__clkbuf_4
Xfanout276 net64 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__clkbuf_4
X_09808_ _01076_ _01077_ _01078_ VGND VGND VPWR VPWR _01079_ sky130_fd_sc_hd__o21a_1
Xfanout287 net290 VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__buf_4
Xfanout298 net299 VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__buf_2
X_09739_ _00906_ _00909_ _00907_ VGND VGND VPWR VPWR _01011_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_96_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12750_ _04115_ _04137_ VGND VGND VPWR VPWR _04138_ sky130_fd_sc_hd__xnor2_1
X_11701_ net385 _02854_ _02542_ VGND VGND VPWR VPWR _02994_ sky130_fd_sc_hd__a21o_2
X_12681_ _04061_ _03982_ VGND VGND VPWR VPWR _04062_ sky130_fd_sc_hd__nor2_1
X_14420_ _05953_ _05954_ _05955_ VGND VGND VPWR VPWR _05956_ sky130_fd_sc_hd__nand3_4
X_11632_ net747 _00190_ VGND VGND VPWR VPWR _02919_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14351_ _05876_ _05879_ VGND VGND VPWR VPWR _05880_ sky130_fd_sc_hd__xor2_2
XFILLER_0_92_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11563_ _02840_ _02841_ _02842_ VGND VGND VPWR VPWR _02845_ sky130_fd_sc_hd__a21o_1
X_13302_ _04628_ _04630_ VGND VGND VPWR VPWR _04741_ sky130_fd_sc_hd__nand2_1
X_10514_ _01738_ _01739_ VGND VGND VPWR VPWR _01740_ sky130_fd_sc_hd__and2b_1
X_14282_ _05683_ _05748_ VGND VGND VPWR VPWR _05806_ sky130_fd_sc_hd__nand2_1
X_11494_ _02761_ _02769_ VGND VGND VPWR VPWR _02770_ sky130_fd_sc_hd__xor2_2
XFILLER_0_134_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16021_ _07636_ _07639_ VGND VGND VPWR VPWR _07703_ sky130_fd_sc_hd__or2_1
X_13233_ _04554_ VGND VGND VPWR VPWR _04666_ sky130_fd_sc_hd__inv_2
XFILLER_0_122_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10445_ _01663_ _01668_ VGND VGND VPWR VPWR _01671_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13164_ _04486_ _04488_ VGND VGND VPWR VPWR _04591_ sky130_fd_sc_hd__nand2_1
X_10376_ D_sin\[16\] _01604_ _01590_ _01596_ VGND VGND VPWR VPWR _01605_ sky130_fd_sc_hd__a211o_1
XFILLER_0_103_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12115_ net495 _03443_ _03444_ VGND VGND VPWR VPWR _03445_ sky130_fd_sc_hd__a21oi_1
X_13095_ _04412_ _04482_ _04514_ _04515_ VGND VGND VPWR VPWR _04516_ sky130_fd_sc_hd__a211oi_4
X_12046_ _03368_ _03369_ VGND VGND VPWR VPWR _03370_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15805_ net286 net277 net656 net664 VGND VGND VPWR VPWR _07469_ sky130_fd_sc_hd__and4_1
X_13997_ _05495_ _05496_ VGND VGND VPWR VPWR _05497_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15736_ _07290_ _07378_ _07393_ VGND VGND VPWR VPWR _07394_ sky130_fd_sc_hd__a21o_1
X_12948_ net947 _04278_ _04353_ VGND VGND VPWR VPWR _04355_ sky130_fd_sc_hd__and3_1
XFILLER_0_62_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15667_ _07316_ _07317_ _07298_ _07299_ VGND VGND VPWR VPWR _07319_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_75_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12879_ _04188_ _04189_ _04199_ VGND VGND VPWR VPWR _04280_ sky130_fd_sc_hd__nand3_2
XFILLER_0_134_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14618_ _06136_ _06137_ _06130_ VGND VGND VPWR VPWR _06174_ sky130_fd_sc_hd__a21bo_1
X_15598_ _07242_ _07243_ VGND VGND VPWR VPWR _07244_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14549_ _06095_ _06096_ _06094_ VGND VGND VPWR VPWR _06098_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_71_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16219_ net270 net619 VGND VGND VPWR VPWR _07918_ sky130_fd_sc_hd__nand2_1
XFILLER_0_113_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08972_ _00249_ _00252_ VGND VGND VPWR VPWR _00253_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09524_ _00676_ _00677_ _00798_ VGND VGND VPWR VPWR _00799_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_148_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09455_ _00646_ _00643_ VGND VGND VPWR VPWR _00731_ sky130_fd_sc_hd__and2b_1
XFILLER_0_149_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08406_ _04927_ _04949_ VGND VGND VPWR VPWR _05025_ sky130_fd_sc_hd__and2_1
XFILLER_0_143_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09386_ _00662_ VGND VGND VPWR VPWR _00007_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08337_ net650 net521 net433 net659 VGND VGND VPWR VPWR _04273_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_19_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08268_ _03464_ _03485_ _03474_ VGND VGND VPWR VPWR _03518_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_105_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08199_ net551 net558 net378 net369 VGND VGND VPWR VPWR _02768_ sky130_fd_sc_hd__and4_1
X_10230_ net130 _01477_ _01478_ _01479_ VGND VGND VPWR VPWR _00034_ sky130_fd_sc_hd__a31o_1
XFILLER_0_131_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10161_ net94 _01419_ net133 VGND VGND VPWR VPWR _01420_ sky130_fd_sc_hd__mux2_1
X_10092_ _01350_ _01357_ VGND VGND VPWR VPWR _01358_ sky130_fd_sc_hd__xnor2_1
X_13920_ _05411_ _05412_ VGND VGND VPWR VPWR _05413_ sky130_fd_sc_hd__nor2_1
XFILLER_0_88_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13851_ _05330_ _05337_ VGND VGND VPWR VPWR _05338_ sky130_fd_sc_hd__and2_1
X_12802_ _04193_ _04194_ VGND VGND VPWR VPWR _04195_ sky130_fd_sc_hd__nor2_1
XFILLER_0_69_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13782_ net167 net138 _05262_ VGND VGND VPWR VPWR _05263_ sky130_fd_sc_hd__a21o_1
X_10994_ _02221_ _02222_ _02224_ VGND VGND VPWR VPWR _02225_ sky130_fd_sc_hd__nand3_1
X_15521_ _07156_ _07158_ _07152_ VGND VGND VPWR VPWR _07160_ sky130_fd_sc_hd__a21o_1
X_12733_ _04062_ _04070_ VGND VGND VPWR VPWR _04120_ sky130_fd_sc_hd__or2b_1
XFILLER_0_69_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_106_Left_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15452_ _06992_ _07084_ VGND VGND VPWR VPWR _07085_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_139_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12664_ net328 net516 net617 net243 VGND VGND VPWR VPWR _04044_ sky130_fd_sc_hd__a22oi_2
X_14403_ _05934_ _05935_ _05936_ VGND VGND VPWR VPWR _05938_ sky130_fd_sc_hd__nand3_1
X_11615_ _02819_ _02821_ VGND VGND VPWR VPWR _02901_ sky130_fd_sc_hd__or2b_1
XFILLER_0_5_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15383_ _06902_ _06907_ VGND VGND VPWR VPWR _07010_ sky130_fd_sc_hd__and2_1
X_12595_ net216 net206 net727 net737 VGND VGND VPWR VPWR _03968_ sky130_fd_sc_hd__and4_1
XFILLER_0_25_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14334_ _05857_ _05861_ VGND VGND VPWR VPWR _05862_ sky130_fd_sc_hd__xnor2_1
X_11546_ _02809_ _02825_ VGND VGND VPWR VPWR _02826_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_123_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14265_ _05770_ _05787_ VGND VGND VPWR VPWR _05788_ sky130_fd_sc_hd__xnor2_1
X_11477_ _02748_ _02749_ _02750_ VGND VGND VPWR VPWR _02751_ sky130_fd_sc_hd__a21o_1
X_16004_ _07683_ _07685_ VGND VGND VPWR VPWR _07686_ sky130_fd_sc_hd__nor2_1
X_13216_ D_sin\[3\] _04647_ _03242_ VGND VGND VPWR VPWR _04648_ sky130_fd_sc_hd__mux2_1
XFILLER_0_111_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10428_ _01638_ _01647_ VGND VGND VPWR VPWR _01654_ sky130_fd_sc_hd__nor2_1
X_14196_ _05516_ _05663_ VGND VGND VPWR VPWR _05713_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_115_Left_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13147_ _04568_ _04571_ VGND VGND VPWR VPWR _04572_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_148_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10359_ Q_cos\[15\] D_sin\[15\] VGND VGND VPWR VPWR _01590_ sky130_fd_sc_hd__and2b_1
X_13078_ net514 net194 VGND VGND VPWR VPWR _04497_ sky130_fd_sc_hd__and2_1
X_12029_ _03274_ _03275_ VGND VGND VPWR VPWR _03351_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_124_Left_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15719_ _07359_ _07361_ VGND VGND VPWR VPWR _07375_ sky130_fd_sc_hd__or2_1
XFILLER_0_76_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09240_ _00515_ _00516_ _00517_ VGND VGND VPWR VPWR _00518_ sky130_fd_sc_hd__and3_1
XFILLER_0_8_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09171_ _00446_ _00447_ _00448_ VGND VGND VPWR VPWR _00450_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_90_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_133_Left_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_131_Right_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08955_ _00233_ _00234_ _00216_ VGND VGND VPWR VPWR _00236_ sky130_fd_sc_hd__a21oi_1
X_08886_ _00165_ _00166_ _00148_ VGND VGND VPWR VPWR _00168_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_98_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_142_Left_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09507_ _00780_ _00781_ VGND VGND VPWR VPWR _00782_ sky130_fd_sc_hd__nor2_1
XFILLER_0_66_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09438_ net673 net494 VGND VGND VPWR VPWR _00714_ sky130_fd_sc_hd__nand2_1
XFILLER_0_137_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09369_ _00504_ _00644_ _00645_ VGND VGND VPWR VPWR _00646_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_136_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11400_ net232 net385 VGND VGND VPWR VPWR _02667_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12380_ net804 _03730_ VGND VGND VPWR VPWR _03731_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11331_ net871 _02590_ _02475_ _02477_ VGND VGND VPWR VPWR _02592_ sky130_fd_sc_hd__o211ai_2
X_14050_ _05401_ _05553_ _05554_ _05476_ VGND VGND VPWR VPWR _05555_ sky130_fd_sc_hd__a22o_1
X_11262_ _02512_ _02513_ _02514_ VGND VGND VPWR VPWR _02516_ sky130_fd_sc_hd__a21o_1
XFILLER_0_132_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13001_ _04409_ _04410_ _04411_ VGND VGND VPWR VPWR _04413_ sky130_fd_sc_hd__a21o_1
X_10213_ net131 net83 VGND VGND VPWR VPWR _01465_ sky130_fd_sc_hd__and2b_1
X_11193_ net426 net515 net386 net376 VGND VGND VPWR VPWR _02442_ sky130_fd_sc_hd__nand4_2
X_10144_ _01403_ _01404_ VGND VGND VPWR VPWR _01405_ sky130_fd_sc_hd__nand2_1
XFILLER_0_118_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10075_ _01232_ _01228_ _01287_ _01341_ VGND VGND VPWR VPWR _01342_ sky130_fd_sc_hd__o31a_1
X_14952_ net210 net200 net668 net675 VGND VGND VPWR VPWR _06540_ sky130_fd_sc_hd__and4_1
X_13903_ _05392_ _05394_ VGND VGND VPWR VPWR _05396_ sky130_fd_sc_hd__xnor2_1
X_14883_ _06458_ _06459_ _06463_ _06464_ VGND VGND VPWR VPWR _06466_ sky130_fd_sc_hd__o31ai_1
X_13834_ _05319_ VGND VGND VPWR VPWR _05320_ sky130_fd_sc_hd__inv_2
XFILLER_0_43_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13765_ _05243_ _05244_ VGND VGND VPWR VPWR _05245_ sky130_fd_sc_hd__xnor2_1
X_10977_ _01781_ _01783_ _02205_ VGND VGND VPWR VPWR _02206_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_58_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15504_ net210 net200 net623 VGND VGND VPWR VPWR _07142_ sky130_fd_sc_hd__o21a_1
X_12716_ _04065_ _04067_ _04066_ VGND VGND VPWR VPWR _04101_ sky130_fd_sc_hd__o21ba_1
X_13696_ net933 net174 net138 net798 VGND VGND VPWR VPWR _05170_ sky130_fd_sc_hd__and4_1
XFILLER_0_128_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15435_ _07063_ _07066_ VGND VGND VPWR VPWR _07067_ sky130_fd_sc_hd__xnor2_1
X_12647_ _03979_ _03984_ VGND VGND VPWR VPWR _04025_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15366_ _06991_ VGND VGND VPWR VPWR _00101_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_53_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12578_ _03807_ _03809_ _03947_ _03948_ VGND VGND VPWR VPWR _03949_ sky130_fd_sc_hd__a211o_2
XFILLER_0_13_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11529_ _02739_ VGND VGND VPWR VPWR _02807_ sky130_fd_sc_hd__inv_2
X_14317_ _05772_ _05843_ VGND VGND VPWR VPWR _05844_ sky130_fd_sc_hd__xnor2_1
X_15297_ _04881_ net592 VGND VGND VPWR VPWR _06916_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14248_ _05516_ _05702_ VGND VGND VPWR VPWR _05769_ sky130_fd_sc_hd__nand2_1
XFILLER_0_40_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14179_ _05661_ _05662_ _05653_ VGND VGND VPWR VPWR _05694_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_110_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08740_ _04031_ _04053_ _08050_ VGND VGND VPWR VPWR _08051_ sky130_fd_sc_hd__a21oi_1
X_08671_ _07575_ _07900_ VGND VGND VPWR VPWR _07911_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_88_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_146_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09223_ net583 net937 VGND VGND VPWR VPWR _00501_ sky130_fd_sc_hd__nor2_1
XFILLER_0_91_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09154_ _00343_ _00344_ _00342_ VGND VGND VPWR VPWR _00433_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_133_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09085_ _00361_ _00362_ _00363_ VGND VGND VPWR VPWR _00365_ sky130_fd_sc_hd__a21o_1
XFILLER_0_16_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09987_ _01199_ _01208_ VGND VGND VPWR VPWR _01255_ sky130_fd_sc_hd__nand2_1
X_08938_ net548 net557 net497 VGND VGND VPWR VPWR _00219_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_150_Left_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08869_ net402 _00149_ _00150_ VGND VGND VPWR VPWR _00151_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_99_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10900_ net761 net527 net935 net803 VGND VGND VPWR VPWR _02126_ sky130_fd_sc_hd__a22oi_1
X_11880_ _02994_ _03188_ VGND VGND VPWR VPWR _03189_ sky130_fd_sc_hd__xnor2_4
X_10831_ net786 net389 VGND VGND VPWR VPWR _02057_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13550_ _04921_ _05010_ VGND VGND VPWR VPWR _05011_ sky130_fd_sc_hd__xnor2_2
X_10762_ net770 net390 _01962_ _01963_ VGND VGND VPWR VPWR _01988_ sky130_fd_sc_hd__o2bb2a_1
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12501_ _03825_ _03826_ _03839_ VGND VGND VPWR VPWR _03864_ sky130_fd_sc_hd__nand3_1
XFILLER_0_54_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13481_ _04933_ _04935_ VGND VGND VPWR VPWR _04936_ sky130_fd_sc_hd__xnor2_2
X_10693_ _01650_ _01918_ VGND VGND VPWR VPWR _01919_ sky130_fd_sc_hd__nor2_1
XFILLER_0_35_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15220_ _06829_ _06830_ _06831_ VGND VGND VPWR VPWR _06832_ sky130_fd_sc_hd__nand3_1
XFILLER_0_124_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12432_ _03786_ _03787_ VGND VGND VPWR VPWR _03788_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_124_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15151_ net173 net685 _06754_ _06755_ VGND VGND VPWR VPWR _06757_ sky130_fd_sc_hd__nand4_1
XFILLER_0_2_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12363_ net217 net772 net781 net207 VGND VGND VPWR VPWR _03713_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_133_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14102_ _05588_ _05589_ _05610_ VGND VGND VPWR VPWR _05611_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_22_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11314_ _02395_ _02571_ _02573_ VGND VGND VPWR VPWR _02574_ sky130_fd_sc_hd__a21o_1
X_15082_ _04540_ net697 VGND VGND VPWR VPWR _06681_ sky130_fd_sc_hd__nor2_1
X_12294_ _03636_ _03638_ VGND VGND VPWR VPWR _03639_ sky130_fd_sc_hd__xor2_1
X_14033_ _05534_ _05535_ VGND VGND VPWR VPWR _05537_ sky130_fd_sc_hd__xnor2_1
X_11245_ _02406_ _02391_ VGND VGND VPWR VPWR _02498_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11176_ _02420_ _02421_ _02422_ VGND VGND VPWR VPWR _02423_ sky130_fd_sc_hd__a21o_1
X_10127_ Q_sin\[1\] D_cos\[1\] VGND VGND VPWR VPWR _01390_ sky130_fd_sc_hd__and2b_1
X_15984_ _07659_ _07660_ _07661_ VGND VGND VPWR VPWR _07664_ sky130_fd_sc_hd__nor3_1
X_10058_ _01305_ _01323_ VGND VGND VPWR VPWR _01325_ sky130_fd_sc_hd__nor2_1
X_14935_ _06504_ _06520_ _06521_ VGND VGND VPWR VPWR _06522_ sky130_fd_sc_hd__nand3_2
X_14866_ net213 net702 _06439_ _06441_ VGND VGND VPWR VPWR _06447_ sky130_fd_sc_hd__a22oi_1
X_13817_ _05277_ _05278_ _05300_ _05301_ VGND VGND VPWR VPWR _05302_ sky130_fd_sc_hd__a2bb2oi_1
X_14797_ _06364_ _06370_ VGND VGND VPWR VPWR _06371_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13748_ _05045_ _05048_ _05136_ VGND VGND VPWR VPWR _05227_ sky130_fd_sc_hd__nand3_1
XFILLER_0_85_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13679_ net230 net158 net307 net316 VGND VGND VPWR VPWR _05151_ sky130_fd_sc_hd__a22oi_1
X_15418_ _07045_ _07046_ _07041_ VGND VGND VPWR VPWR _07048_ sky130_fd_sc_hd__a21o_1
X_16398_ clknet_4_4_0_clk _00111_ net337 VGND VGND VPWR VPWR Q_sin\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_115_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15349_ _06919_ _06972_ VGND VGND VPWR VPWR _06973_ sky130_fd_sc_hd__xnor2_1
Xhold104 D_sin\[17\] VGND VGND VPWR VPWR net910 sky130_fd_sc_hd__dlygate4sd3_1
Xhold115 net81 VGND VGND VPWR VPWR net921 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_41_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09910_ _01145_ _01148_ _01146_ VGND VGND VPWR VPWR _01179_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_1_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout606 net607 VGND VGND VPWR VPWR net606 sky130_fd_sc_hd__buf_2
X_09841_ _00975_ _00967_ _01039_ VGND VGND VPWR VPWR _01112_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_1_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout617 net618 VGND VGND VPWR VPWR net617 sky130_fd_sc_hd__clkbuf_2
Xfanout628 net629 VGND VGND VPWR VPWR net628 sky130_fd_sc_hd__clkbuf_4
Xfanout639 net644 VGND VGND VPWR VPWR net639 sky130_fd_sc_hd__buf_2
X_09772_ _01025_ _01010_ VGND VGND VPWR VPWR _01043_ sky130_fd_sc_hd__or2b_1
X_08723_ _05992_ _08030_ VGND VGND VPWR VPWR _08034_ sky130_fd_sc_hd__and2b_1
XFILLER_0_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08654_ net701 net378 _07532_ _07553_ VGND VGND VPWR VPWR _07727_ sky130_fd_sc_hd__a211o_1
XFILLER_0_139_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08585_ _06922_ _06933_ _06759_ VGND VGND VPWR VPWR _06977_ sky130_fd_sc_hd__nor3b_1
XFILLER_0_88_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09206_ _00408_ _00409_ _00483_ VGND VGND VPWR VPWR _00484_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_106_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09137_ net540 net488 net478 net548 VGND VGND VPWR VPWR _00416_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_121_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09068_ net650 net641 net402 VGND VGND VPWR VPWR _00348_ sky130_fd_sc_hd__and3_1
XFILLER_0_4_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11030_ _02261_ _02262_ _02263_ VGND VGND VPWR VPWR _02264_ sky130_fd_sc_hd__nand3_4
X_12981_ _04388_ _04389_ _04385_ VGND VGND VPWR VPWR _04391_ sky130_fd_sc_hd__a21o_1
X_14720_ _06283_ _06285_ VGND VGND VPWR VPWR _06286_ sky130_fd_sc_hd__xnor2_2
X_11932_ _03159_ _03235_ VGND VGND VPWR VPWR _03245_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14651_ _05896_ _05897_ VGND VGND VPWR VPWR _06210_ sky130_fd_sc_hd__xnor2_1
X_11863_ _03168_ _03169_ VGND VGND VPWR VPWR _03171_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_24_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10814_ _02038_ _02039_ net802 net355 VGND VGND VPWR VPWR _02040_ sky130_fd_sc_hd__o211a_1
X_13602_ _05065_ _05066_ VGND VGND VPWR VPWR _05067_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_39_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14582_ net196 net570 VGND VGND VPWR VPWR _06134_ sky130_fd_sc_hd__nand2_1
X_11794_ _03088_ _03093_ _03095_ VGND VGND VPWR VPWR _03096_ sky130_fd_sc_hd__nand3_1
XFILLER_0_138_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16321_ clknet_4_7_0_clk _00034_ net336 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dfrtp_1
X_10745_ net779 net787 net379 net370 VGND VGND VPWR VPWR _01971_ sky130_fd_sc_hd__and4_1
X_13533_ net613 net301 _04989_ _04990_ VGND VGND VPWR VPWR _04993_ sky130_fd_sc_hd__nand4_2
XFILLER_0_82_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16252_ _07951_ _07952_ VGND VGND VPWR VPWR _07953_ sky130_fd_sc_hd__nor2_1
X_13464_ _04914_ _04915_ _04911_ VGND VGND VPWR VPWR _04918_ sky130_fd_sc_hd__a21o_1
XFILLER_0_137_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10676_ _01868_ _01869_ _01863_ VGND VGND VPWR VPWR _01902_ sky130_fd_sc_hd__a21bo_1
X_15203_ _06811_ _06812_ VGND VGND VPWR VPWR _06814_ sky130_fd_sc_hd__xnor2_2
X_12415_ _03731_ _03729_ _03732_ VGND VGND VPWR VPWR _03770_ sky130_fd_sc_hd__and3_1
X_16183_ _07878_ _07790_ VGND VGND VPWR VPWR _07880_ sky130_fd_sc_hd__or2_1
X_13395_ _04758_ _04842_ VGND VGND VPWR VPWR _04843_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_51_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15134_ net238 net633 VGND VGND VPWR VPWR _06739_ sky130_fd_sc_hd__nand2_1
X_12346_ net328 net243 net743 net753 VGND VGND VPWR VPWR _03694_ sky130_fd_sc_hd__and4_1
XFILLER_0_50_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15065_ _06660_ net817 _06625_ VGND VGND VPWR VPWR _06664_ sky130_fd_sc_hd__o21ai_2
X_12277_ _03249_ _03253_ VGND VGND VPWR VPWR _03620_ sky130_fd_sc_hd__nor2_1
X_14016_ net230 net288 net279 net148 VGND VGND VPWR VPWR _05518_ sky130_fd_sc_hd__and4_1
X_11228_ _02477_ _02478_ _02390_ _02372_ VGND VGND VPWR VPWR _02480_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_65_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11159_ _02402_ _02403_ VGND VGND VPWR VPWR _02404_ sky130_fd_sc_hd__xor2_1
X_15967_ _07566_ _07626_ _07643_ VGND VGND VPWR VPWR _07645_ sky130_fd_sc_hd__and3_1
X_14918_ _06062_ _06070_ VGND VGND VPWR VPWR _06503_ sky130_fd_sc_hd__and2_1
X_15898_ _07549_ _07481_ _07568_ VGND VGND VPWR VPWR _07570_ sky130_fd_sc_hd__nor3_1
XFILLER_0_78_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14849_ _06386_ _06409_ _06427_ VGND VGND VPWR VPWR _06428_ sky130_fd_sc_hd__nand3_1
XFILLER_0_147_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08370_ _04535_ _04589_ _04545_ VGND VGND VPWR VPWR _04633_ sky130_fd_sc_hd__nand3_1
XFILLER_0_14_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout403 net404 VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_10_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout414 net421 VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__clkbuf_4
Xfanout425 net431 VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__clkbuf_4
Xfanout436 net437 VGND VGND VPWR VPWR net436 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_39_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09824_ _01093_ _01094_ VGND VGND VPWR VPWR _01095_ sky130_fd_sc_hd__xor2_1
Xfanout447 net448 VGND VGND VPWR VPWR net447 sky130_fd_sc_hd__clkbuf_2
Xfanout458 net459 VGND VGND VPWR VPWR net458 sky130_fd_sc_hd__clkbuf_4
Xfanout469 net472 VGND VGND VPWR VPWR net469 sky130_fd_sc_hd__clkbuf_4
X_09755_ _01009_ _01026_ VGND VGND VPWR VPWR _01027_ sky130_fd_sc_hd__nand2_2
X_08706_ _07889_ _07995_ _07994_ VGND VGND VPWR VPWR _08018_ sky130_fd_sc_hd__nand3_1
X_09686_ _00865_ _00901_ _00957_ _00958_ VGND VGND VPWR VPWR _00959_ sky130_fd_sc_hd__o211a_1
XFILLER_0_69_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08637_ net598 net408 net397 net606 VGND VGND VPWR VPWR _07543_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_139_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08568_ _05579_ _05688_ _05677_ VGND VGND VPWR VPWR _06791_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_138_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08499_ net578 net591 net407 net396 VGND VGND VPWR VPWR _06036_ sky130_fd_sc_hd__and4_1
XFILLER_0_9_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10530_ _01745_ _01746_ _01755_ VGND VGND VPWR VPWR _01756_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_18_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10461_ _01635_ _01639_ _01640_ _01644_ VGND VGND VPWR VPWR _01687_ sky130_fd_sc_hd__a22o_1
X_12200_ _03534_ _03531_ _03535_ VGND VGND VPWR VPWR _03536_ sky130_fd_sc_hd__a21o_1
X_13180_ net242 net143 VGND VGND VPWR VPWR _04608_ sky130_fd_sc_hd__nand2_1
X_10392_ net761 net362 VGND VGND VPWR VPWR _01618_ sky130_fd_sc_hd__nand2_1
XFILLER_0_103_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12131_ _03321_ _03342_ _03341_ VGND VGND VPWR VPWR _03462_ sky130_fd_sc_hd__a21oi_2
X_12062_ _03286_ _03302_ _03303_ VGND VGND VPWR VPWR _03387_ sky130_fd_sc_hd__and3_1
X_11013_ _02236_ _02244_ VGND VGND VPWR VPWR _02246_ sky130_fd_sc_hd__xor2_2
X_15821_ _07464_ _07484_ _07485_ VGND VGND VPWR VPWR _07486_ sky130_fd_sc_hd__and3_1
XFILLER_0_126_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15752_ _07398_ _07399_ _07410_ VGND VGND VPWR VPWR _07411_ sky130_fd_sc_hd__nand3_1
XFILLER_0_99_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12964_ _04369_ _04370_ _04372_ VGND VGND VPWR VPWR _04373_ sky130_fd_sc_hd__nand3_1
X_14703_ _06264_ _06265_ _06260_ VGND VGND VPWR VPWR _06268_ sky130_fd_sc_hd__a21o_1
XFILLER_0_99_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11915_ _03226_ _03151_ _03227_ VGND VGND VPWR VPWR _03228_ sky130_fd_sc_hd__a21o_1
X_15683_ _07334_ _07335_ VGND VGND VPWR VPWR _07337_ sky130_fd_sc_hd__xnor2_1
X_12895_ net225 net430 VGND VGND VPWR VPWR _04298_ sky130_fd_sc_hd__nand2_1
X_14634_ net160 net309 net607 net702 VGND VGND VPWR VPWR _06192_ sky130_fd_sc_hd__and4_1
XFILLER_0_142_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11846_ _03036_ _03034_ VGND VGND VPWR VPWR _03153_ sky130_fd_sc_hd__and2b_1
XFILLER_0_145_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14565_ net819 _06114_ _06050_ _06035_ VGND VGND VPWR VPWR _06116_ sky130_fd_sc_hd__a211o_4
X_11777_ _02891_ VGND VGND VPWR VPWR _03078_ sky130_fd_sc_hd__inv_2
X_16304_ clknet_4_4_0_clk _00017_ net337 VGND VGND VPWR VPWR Q_cos\[17\] sky130_fd_sc_hd__dfrtp_1
X_10728_ _01952_ _01953_ VGND VGND VPWR VPWR _01954_ sky130_fd_sc_hd__or2_1
X_13516_ _04867_ _04873_ VGND VGND VPWR VPWR _04974_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14496_ _05901_ _06039_ VGND VGND VPWR VPWR _06040_ sky130_fd_sc_hd__and2_1
XFILLER_0_82_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16235_ _07932_ _07935_ VGND VGND VPWR VPWR _07936_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_36_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10659_ _01863_ _01869_ _01868_ VGND VGND VPWR VPWR _01885_ sky130_fd_sc_hd__a21o_1
X_13447_ net705 net301 VGND VGND VPWR VPWR _04899_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16166_ _07853_ _07860_ VGND VGND VPWR VPWR _07861_ sky130_fd_sc_hd__xnor2_1
X_13378_ _04823_ _04716_ net225 VGND VGND VPWR VPWR _04824_ sky130_fd_sc_hd__mux2_2
XFILLER_0_23_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15117_ _06610_ _06612_ _06611_ VGND VGND VPWR VPWR _06720_ sky130_fd_sc_hd__a21bo_1
X_12329_ _03625_ _03675_ VGND VGND VPWR VPWR _03676_ sky130_fd_sc_hd__xnor2_1
X_16097_ _07783_ _07785_ VGND VGND VPWR VPWR _07786_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_121_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15048_ net238 net642 net632 net323 VGND VGND VPWR VPWR _06645_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_76_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09540_ _00666_ _00729_ _00727_ VGND VGND VPWR VPWR _00815_ sky130_fd_sc_hd__o21a_1
X_09471_ _00692_ _00699_ VGND VGND VPWR VPWR _00746_ sky130_fd_sc_hd__nand2_1
X_08422_ _05134_ _05144_ _05188_ VGND VGND VPWR VPWR _05199_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08353_ _04053_ _04064_ _04415_ _04426_ VGND VGND VPWR VPWR _04447_ sky130_fd_sc_hd__a22o_1
XFILLER_0_18_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08284_ net542 net378 net369 net551 VGND VGND VPWR VPWR _03691_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_128_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout200 net201 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__clkbuf_4
Xfanout211 net219 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__buf_8
Xfanout222 net226 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__buf_2
XFILLER_0_10_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout233 net236 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__clkbuf_4
Xfanout244 net245 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__clkbuf_2
Xfanout255 net260 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_5_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout266 net269 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__clkbuf_2
X_09807_ net654 net465 VGND VGND VPWR VPWR _01078_ sky130_fd_sc_hd__nand2_1
Xfanout277 net278 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__clkbuf_4
Xfanout288 net290 VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__clkbuf_4
Xfanout299 net61 VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__buf_4
X_09738_ _00903_ _00920_ _00919_ VGND VGND VPWR VPWR _01010_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_19_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09669_ net680 net689 net455 net446 VGND VGND VPWR VPWR _00942_ sky130_fd_sc_hd__and4_1
XFILLER_0_69_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11700_ _02934_ _02936_ VGND VGND VPWR VPWR _02993_ sky130_fd_sc_hd__nand2_1
X_12680_ net189 net179 net754 net762 VGND VGND VPWR VPWR _04061_ sky130_fd_sc_hd__and4_1
X_11631_ _02915_ _02917_ VGND VGND VPWR VPWR _02918_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_37_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_145_Right_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14350_ net300 net601 _05877_ _05878_ VGND VGND VPWR VPWR _05879_ sky130_fd_sc_hd__a31o_1
XFILLER_0_64_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11562_ _02840_ _02841_ _02842_ VGND VGND VPWR VPWR _02843_ sky130_fd_sc_hd__and3_1
XFILLER_0_80_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10513_ net320 net529 net935 net707 VGND VGND VPWR VPWR _01739_ sky130_fd_sc_hd__a22o_1
X_13301_ _04738_ _04739_ VGND VGND VPWR VPWR _04740_ sky130_fd_sc_hd__and2_1
XFILLER_0_80_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14281_ _05803_ _05804_ VGND VGND VPWR VPWR _05805_ sky130_fd_sc_hd__nor2_1
XFILLER_0_123_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11493_ _02762_ _02767_ VGND VGND VPWR VPWR _02769_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_150_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16020_ _07692_ _07698_ _07701_ VGND VGND VPWR VPWR _07702_ sky130_fd_sc_hd__o21ai_1
X_13232_ _04662_ _04663_ VGND VGND VPWR VPWR _04664_ sky130_fd_sc_hd__xnor2_1
X_10444_ _01618_ _01620_ _01619_ VGND VGND VPWR VPWR _01670_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_150_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13163_ _04493_ _04511_ _04512_ VGND VGND VPWR VPWR _04590_ sky130_fd_sc_hd__nand3_2
XFILLER_0_150_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10375_ Q_cos\[16\] VGND VGND VPWR VPWR _01604_ sky130_fd_sc_hd__inv_2
XFILLER_0_103_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12114_ net792 net495 _03364_ VGND VGND VPWR VPWR _03444_ sky130_fd_sc_hd__a21oi_1
X_13094_ _04511_ _04512_ _04493_ VGND VGND VPWR VPWR _04515_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_20_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12045_ _03362_ _03273_ _03367_ VGND VGND VPWR VPWR _03369_ sky130_fd_sc_hd__nor3_1
X_15804_ net286 net656 net664 net277 VGND VGND VPWR VPWR _07468_ sky130_fd_sc_hd__a22oi_2
X_13996_ _05455_ _05454_ VGND VGND VPWR VPWR _05496_ sky130_fd_sc_hd__and2b_1
X_15735_ _07384_ _07392_ VGND VGND VPWR VPWR _07393_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_62_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12947_ net947 _04278_ _04353_ VGND VGND VPWR VPWR _04354_ sky130_fd_sc_hd__a21oi_1
X_15666_ _07298_ _07299_ _07316_ _07317_ VGND VGND VPWR VPWR _07318_ sky130_fd_sc_hd__o211a_1
XFILLER_0_87_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12878_ _04276_ _04277_ _04256_ _04257_ VGND VGND VPWR VPWR _04279_ sky130_fd_sc_hd__a211o_1
XFILLER_0_68_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14617_ _05931_ _05928_ _05930_ VGND VGND VPWR VPWR _06173_ sky130_fd_sc_hd__nand3_1
XFILLER_0_8_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11829_ net703 net461 net451 net711 VGND VGND VPWR VPWR _03134_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_145_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15597_ net287 net278 net683 net690 VGND VGND VPWR VPWR _07243_ sky130_fd_sc_hd__and4_1
X_14548_ _06094_ _06095_ _06096_ VGND VGND VPWR VPWR _06097_ sky130_fd_sc_hd__or3_4
XPHY_EDGE_ROW_112_Right_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14479_ net292 net594 net609 net282 VGND VGND VPWR VPWR _06021_ sky130_fd_sc_hd__a22o_1
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16218_ _07801_ _07840_ _07793_ VGND VGND VPWR VPWR _07917_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_125_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16149_ _07706_ _07841_ VGND VGND VPWR VPWR _07842_ sky130_fd_sc_hd__xnor2_1
X_08971_ net403 _00250_ _00251_ VGND VGND VPWR VPWR _00252_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09523_ _00670_ _00675_ VGND VGND VPWR VPWR _00798_ sky130_fd_sc_hd__and2b_1
XFILLER_0_94_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09454_ _00666_ _00729_ VGND VGND VPWR VPWR _00730_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_149_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08405_ _05003_ VGND VGND VPWR VPWR _05014_ sky130_fd_sc_hd__inv_2
X_09385_ Q_cos\[7\] _00660_ _00661_ VGND VGND VPWR VPWR _00662_ sky130_fd_sc_hd__mux2_1
XFILLER_0_148_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08336_ net650 net659 net521 net433 VGND VGND VPWR VPWR _04262_ sky130_fd_sc_hd__and4_1
XFILLER_0_19_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08267_ _03116_ _03127_ net902 VGND VGND VPWR VPWR _03507_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_7_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08198_ net567 net360 VGND VGND VPWR VPWR _02757_ sky130_fd_sc_hd__nand2_1
XFILLER_0_132_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10160_ _01417_ _01418_ VGND VGND VPWR VPWR _01419_ sky130_fd_sc_hd__xnor2_2
X_10091_ _01353_ _01356_ VGND VGND VPWR VPWR _01357_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13850_ _05335_ _05336_ VGND VGND VPWR VPWR _05337_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12801_ net191 net180 net725 net736 VGND VGND VPWR VPWR _04194_ sky130_fd_sc_hd__and4_1
X_10993_ _01773_ _01774_ _01775_ VGND VGND VPWR VPWR _02224_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_96_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13781_ _05260_ _05261_ VGND VGND VPWR VPWR _05262_ sky130_fd_sc_hd__nor2_2
XFILLER_0_96_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15520_ _07152_ _07156_ _07158_ VGND VGND VPWR VPWR _07159_ sky130_fd_sc_hd__nand3_1
XFILLER_0_85_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12732_ _04063_ _04069_ VGND VGND VPWR VPWR _04118_ sky130_fd_sc_hd__or2b_1
XFILLER_0_123_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15451_ _06993_ _07083_ VGND VGND VPWR VPWR _07084_ sky130_fd_sc_hd__xnor2_1
X_12663_ net224 net710 VGND VGND VPWR VPWR _04043_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14402_ _05868_ _05869_ VGND VGND VPWR VPWR _05936_ sky130_fd_sc_hd__xnor2_1
X_11614_ _02806_ _02826_ _02899_ VGND VGND VPWR VPWR _02900_ sky130_fd_sc_hd__a21o_1
X_15382_ _07006_ _07007_ VGND VGND VPWR VPWR _07008_ sky130_fd_sc_hd__xor2_2
XFILLER_0_65_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12594_ _03962_ _03964_ _03963_ VGND VGND VPWR VPWR _03967_ sky130_fd_sc_hd__a21o_1
XFILLER_0_52_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14333_ _05858_ _05859_ VGND VGND VPWR VPWR _05861_ sky130_fd_sc_hd__nor2_1
X_11545_ _02823_ _02824_ VGND VGND VPWR VPWR _02825_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_52_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11476_ net705 net495 VGND VGND VPWR VPWR _02750_ sky130_fd_sc_hd__and2_1
X_14264_ _05784_ _05786_ VGND VGND VPWR VPWR _05787_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16003_ _07582_ _07607_ _07681_ _07682_ VGND VGND VPWR VPWR _07685_ sky130_fd_sc_hd__o211a_1
X_10427_ net803 net490 VGND VGND VPWR VPWR _01653_ sky130_fd_sc_hd__nand2_1
X_13215_ _04643_ _04646_ VGND VGND VPWR VPWR _04647_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_110_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14195_ _05643_ _05646_ _05711_ VGND VGND VPWR VPWR _05712_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_20_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10358_ _01589_ VGND VGND VPWR VPWR _00052_ sky130_fd_sc_hd__clkbuf_1
X_13146_ net293 _04569_ _04570_ VGND VGND VPWR VPWR _04571_ sky130_fd_sc_hd__a21bo_1
X_13077_ net215 _04494_ _04495_ VGND VGND VPWR VPWR _04496_ sky130_fd_sc_hd__a21bo_1
X_10289_ net922 _01529_ net133 VGND VGND VPWR VPWR _01530_ sky130_fd_sc_hd__mux2_1
XFILLER_0_57_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12028_ _03348_ _03349_ VGND VGND VPWR VPWR _03350_ sky130_fd_sc_hd__nand2_4
XFILLER_0_73_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13979_ _05407_ _05477_ VGND VGND VPWR VPWR _05478_ sky130_fd_sc_hd__xnor2_2
X_15718_ _07373_ _07370_ _07363_ VGND VGND VPWR VPWR _07374_ sky130_fd_sc_hd__o21a_1
XFILLER_0_48_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15649_ _07246_ _07254_ VGND VGND VPWR VPWR _07299_ sky130_fd_sc_hd__and2_1
XFILLER_0_91_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09170_ _00446_ _00447_ _00448_ VGND VGND VPWR VPWR _00449_ sky130_fd_sc_hd__and3_1
XFILLER_0_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_840 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08954_ _00216_ _00233_ _00234_ VGND VGND VPWR VPWR _00235_ sky130_fd_sc_hd__and3_1
X_08885_ _00148_ _00165_ _00166_ VGND VGND VPWR VPWR _00167_ sky130_fd_sc_hd__and3_1
XFILLER_0_138_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09506_ _00779_ _00762_ _00763_ VGND VGND VPWR VPWR _00781_ sky130_fd_sc_hd__nor3_1
XFILLER_0_2_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09437_ _00711_ _00712_ VGND VGND VPWR VPWR _00713_ sky130_fd_sc_hd__nor2_1
XFILLER_0_66_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09368_ _00551_ _00553_ VGND VGND VPWR VPWR _00645_ sky130_fd_sc_hd__nor2_1
XFILLER_0_62_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08319_ _03637_ _03648_ _03745_ VGND VGND VPWR VPWR _04075_ sky130_fd_sc_hd__nand3_2
XFILLER_0_35_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09299_ net546 net466 _00509_ _00508_ VGND VGND VPWR VPWR _00576_ sky130_fd_sc_hd__a31o_1
XANTENNA_60 net768 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11330_ _02475_ _02477_ _02589_ _02590_ VGND VGND VPWR VPWR _02591_ sky130_fd_sc_hd__a211o_1
XFILLER_0_62_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11261_ _02512_ _02513_ _02514_ VGND VGND VPWR VPWR _02515_ sky130_fd_sc_hd__nand3_1
XFILLER_0_104_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10212_ _01453_ _01459_ _01462_ VGND VGND VPWR VPWR _01464_ sky130_fd_sc_hd__o21ai_1
X_13000_ _04409_ _04410_ _04411_ VGND VGND VPWR VPWR _04412_ sky130_fd_sc_hd__nand3_4
X_11192_ net426 net386 net376 net515 VGND VGND VPWR VPWR _02440_ sky130_fd_sc_hd__a22o_1
X_10143_ Q_sin\[4\] D_cos\[4\] VGND VGND VPWR VPWR _01404_ sky130_fd_sc_hd__or2b_1
X_10074_ _01235_ _01233_ _01286_ VGND VGND VPWR VPWR _01341_ sky130_fd_sc_hd__o21ai_1
X_14951_ net195 net684 VGND VGND VPWR VPWR _06539_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13902_ _05307_ _05310_ _05393_ VGND VGND VPWR VPWR _05394_ sky130_fd_sc_hd__o21a_1
X_14882_ _06371_ _06461_ VGND VGND VPWR VPWR _06464_ sky130_fd_sc_hd__nand2_1
X_13833_ _05298_ _05281_ VGND VGND VPWR VPWR _05319_ sky130_fd_sc_hd__and2b_1
XFILLER_0_134_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13764_ net611 net271 VGND VGND VPWR VPWR _05244_ sky130_fd_sc_hd__nand2_1
X_10976_ _02203_ _02204_ VGND VGND VPWR VPWR _02205_ sky130_fd_sc_hd__nand2_1
X_15503_ net210 net200 net623 VGND VGND VPWR VPWR _07141_ sky130_fd_sc_hd__and3_2
XFILLER_0_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12715_ _04095_ _04098_ _04096_ VGND VGND VPWR VPWR _04100_ sky130_fd_sc_hd__a21o_1
X_13695_ net174 net143 net798 net933 VGND VGND VPWR VPWR _05169_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_66_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15434_ _06952_ _06964_ _07065_ VGND VGND VPWR VPWR _07066_ sky130_fd_sc_hd__o21a_1
X_12646_ _03986_ VGND VGND VPWR VPWR _04024_ sky130_fd_sc_hd__inv_2
XFILLER_0_38_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_143_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15365_ Q_sin\[5\] _06990_ _05626_ VGND VGND VPWR VPWR _06991_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12577_ _03935_ _03946_ _03936_ VGND VGND VPWR VPWR _03948_ sky130_fd_sc_hd__and3_1
XFILLER_0_25_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14316_ _05841_ _05842_ VGND VGND VPWR VPWR _05843_ sky130_fd_sc_hd__xor2_1
XFILLER_0_80_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11528_ _02733_ _02734_ _02805_ VGND VGND VPWR VPWR _02806_ sky130_fd_sc_hd__a21o_1
X_15296_ _06912_ _06914_ VGND VGND VPWR VPWR _06915_ sky130_fd_sc_hd__xor2_2
XFILLER_0_7_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14247_ _05726_ _05729_ _05767_ VGND VGND VPWR VPWR _05768_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_0_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11459_ _02611_ _02617_ VGND VGND VPWR VPWR _02731_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14178_ _05681_ _05680_ VGND VGND VPWR VPWR _05693_ sky130_fd_sc_hd__or2b_1
X_13129_ _04547_ _04551_ VGND VGND VPWR VPWR _04552_ sky130_fd_sc_hd__xor2_1
XFILLER_0_84_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08670_ _07662_ _07651_ VGND VGND VPWR VPWR _07900_ sky130_fd_sc_hd__and2b_1
XFILLER_0_108_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09222_ _00497_ _00499_ VGND VGND VPWR VPWR _00500_ sky130_fd_sc_hd__xor2_2
XFILLER_0_118_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09153_ _00413_ _00431_ VGND VGND VPWR VPWR _00432_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_146_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09084_ _00361_ _00362_ _00363_ VGND VGND VPWR VPWR _00364_ sky130_fd_sc_hd__nand3_1
XFILLER_0_71_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09986_ _01188_ _01190_ _01253_ VGND VGND VPWR VPWR _01254_ sky130_fd_sc_hd__o21ai_1
X_08937_ net564 net478 VGND VGND VPWR VPWR _00218_ sky130_fd_sc_hd__and2_1
XFILLER_0_99_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08868_ net659 net402 net393 net666 VGND VGND VPWR VPWR _00150_ sky130_fd_sc_hd__a22o_1
X_08799_ _08076_ _08108_ net866 VGND VGND VPWR VPWR _08110_ sky130_fd_sc_hd__nor3_4
X_10830_ _02054_ _02055_ VGND VGND VPWR VPWR _02056_ sky130_fd_sc_hd__and2b_1
XFILLER_0_39_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10761_ _01981_ _01982_ _01986_ VGND VGND VPWR VPWR _01987_ sky130_fd_sc_hd__a21o_1
XFILLER_0_94_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12500_ _03819_ _03823_ VGND VGND VPWR VPWR _03863_ sky130_fd_sc_hd__nor2_1
X_10692_ net803 net499 _01648_ _01649_ VGND VGND VPWR VPWR _01918_ sky130_fd_sc_hd__o2bb2a_1
X_13480_ _04816_ _04828_ _04934_ VGND VGND VPWR VPWR _04935_ sky130_fd_sc_hd__o21a_1
XFILLER_0_47_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12431_ _03739_ _03741_ _03740_ VGND VGND VPWR VPWR _03787_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_125_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15150_ net173 net685 _06754_ _06755_ VGND VGND VPWR VPWR _06756_ sky130_fd_sc_hd__a22o_1
X_12362_ net217 net207 net772 net781 VGND VGND VPWR VPWR _03711_ sky130_fd_sc_hd__and4_1
XFILLER_0_35_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14101_ _05608_ _05609_ VGND VGND VPWR VPWR _05610_ sky130_fd_sc_hd__or2_1
X_11313_ net756 net765 net462 net452 VGND VGND VPWR VPWR _02573_ sky130_fd_sc_hd__and4_1
XFILLER_0_50_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15081_ _06680_ VGND VGND VPWR VPWR _00098_ sky130_fd_sc_hd__clkbuf_1
X_12293_ _03552_ _03580_ VGND VGND VPWR VPWR _03638_ sky130_fd_sc_hd__or2_1
XFILLER_0_132_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11244_ _02388_ _02484_ _02483_ VGND VGND VPWR VPWR _02497_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_120_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14032_ _05431_ _05435_ _05439_ VGND VGND VPWR VPWR _05535_ sky130_fd_sc_hd__a21o_1
XFILLER_0_31_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11175_ net722 net509 VGND VGND VPWR VPWR _02422_ sky130_fd_sc_hd__and2_1
X_10126_ _01389_ VGND VGND VPWR VPWR _00020_ sky130_fd_sc_hd__clkbuf_1
X_15983_ _07659_ _07660_ _07661_ VGND VGND VPWR VPWR _07663_ sky130_fd_sc_hd__o21a_1
X_10057_ _01305_ _01323_ VGND VGND VPWR VPWR _01324_ sky130_fd_sc_hd__and2_1
X_14934_ _06517_ _06518_ _06510_ VGND VGND VPWR VPWR _06521_ sky130_fd_sc_hd__a21o_1
XFILLER_0_145_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14865_ net325 net240 net608 net700 VGND VGND VPWR VPWR _06446_ sky130_fd_sc_hd__nand4_1
X_13816_ _05279_ _05299_ VGND VGND VPWR VPWR _05301_ sky130_fd_sc_hd__or2_1
X_14796_ _06330_ _06365_ VGND VGND VPWR VPWR _06370_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13747_ _04846_ _04951_ _05045_ _05136_ VGND VGND VPWR VPWR _05226_ sky130_fd_sc_hd__nand4_2
X_10959_ net912 _00187_ VGND VGND VPWR VPWR _02188_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13678_ _05148_ _05149_ VGND VGND VPWR VPWR _05150_ sky130_fd_sc_hd__xnor2_1
X_15417_ _07041_ _07045_ _07046_ VGND VGND VPWR VPWR _07047_ sky130_fd_sc_hd__and3_1
X_12629_ _03991_ _03992_ _04004_ VGND VGND VPWR VPWR _04005_ sky130_fd_sc_hd__a21oi_2
X_16397_ clknet_4_4_0_clk _00110_ net337 VGND VGND VPWR VPWR Q_sin\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_143_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15348_ _06970_ _06971_ VGND VGND VPWR VPWR _06972_ sky130_fd_sc_hd__or2b_1
XFILLER_0_85_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold105 Q_sin\[11\] VGND VGND VPWR VPWR net911 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_111_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold116 net112 VGND VGND VPWR VPWR net922 sky130_fd_sc_hd__dlygate4sd3_1
X_15279_ _06793_ _06883_ _06895_ VGND VGND VPWR VPWR _06896_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_110_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09840_ _00969_ _00970_ _01040_ VGND VGND VPWR VPWR _01111_ sky130_fd_sc_hd__or3_1
Xfanout607 net608 VGND VGND VPWR VPWR net607 sky130_fd_sc_hd__clkbuf_4
Xfanout618 net3 VGND VGND VPWR VPWR net618 sky130_fd_sc_hd__buf_2
Xfanout629 net634 VGND VGND VPWR VPWR net629 sky130_fd_sc_hd__buf_2
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09771_ _01042_ VGND VGND VPWR VPWR _00012_ sky130_fd_sc_hd__clkbuf_1
X_08722_ _08033_ VGND VGND VPWR VPWR _00000_ sky130_fd_sc_hd__clkbuf_1
X_08653_ _07705_ VGND VGND VPWR VPWR _07716_ sky130_fd_sc_hd__inv_2
XFILLER_0_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08584_ _06868_ _06890_ _06944_ _06955_ VGND VGND VPWR VPWR _06966_ sky130_fd_sc_hd__o211a_1
XFILLER_0_48_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09205_ _00405_ _00407_ VGND VGND VPWR VPWR _00483_ sky130_fd_sc_hd__or2_1
XFILLER_0_107_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09136_ _00339_ _00346_ _00414_ VGND VGND VPWR VPWR _00415_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_134_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_844 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09067_ _00339_ _00346_ VGND VGND VPWR VPWR _00347_ sky130_fd_sc_hd__xor2_1
XFILLER_0_71_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09969_ net484 net474 VGND VGND VPWR VPWR _01237_ sky130_fd_sc_hd__or2_2
X_12980_ _04385_ _04388_ _04389_ VGND VGND VPWR VPWR _04390_ sky130_fd_sc_hd__and3_1
X_11931_ _03159_ _03235_ VGND VGND VPWR VPWR _03244_ sky130_fd_sc_hd__nand2_1
X_14650_ _06182_ _06207_ _06208_ VGND VGND VPWR VPWR _06209_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11862_ net511 net468 VGND VGND VPWR VPWR _03169_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13601_ net738 net250 VGND VGND VPWR VPWR _05066_ sky130_fd_sc_hd__nand2_1
X_10813_ _02031_ _02032_ VGND VGND VPWR VPWR _02039_ sky130_fd_sc_hd__and2_1
X_14581_ _06131_ _06132_ VGND VGND VPWR VPWR _06133_ sky130_fd_sc_hd__and2b_1
XFILLER_0_138_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11793_ _03091_ _03092_ _02994_ VGND VGND VPWR VPWR _03095_ sky130_fd_sc_hd__a21o_1
X_16320_ clknet_4_5_0_clk _00033_ net335 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_82_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13532_ net612 net301 _04989_ _04990_ VGND VGND VPWR VPWR _04991_ sky130_fd_sc_hd__a22o_1
X_10744_ net777 net379 net370 net787 VGND VGND VPWR VPWR _01970_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_131_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16251_ _07935_ _07932_ VGND VGND VPWR VPWR _07952_ sky130_fd_sc_hd__and2b_1
X_13463_ _04911_ _04914_ _04915_ VGND VGND VPWR VPWR _04917_ sky130_fd_sc_hd__and3_1
X_10675_ _01836_ _01833_ _01835_ VGND VGND VPWR VPWR _01901_ sky130_fd_sc_hd__nand3_2
XFILLER_0_125_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15202_ _04537_ net601 VGND VGND VPWR VPWR _06812_ sky130_fd_sc_hd__nor2_1
X_12414_ _03727_ _03737_ _03766_ _03768_ VGND VGND VPWR VPWR _03769_ sky130_fd_sc_hd__o211a_1
XFILLER_0_23_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16182_ _07788_ _07772_ VGND VGND VPWR VPWR _07878_ sky130_fd_sc_hd__and2b_1
XFILLER_0_106_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13394_ _04760_ _04841_ VGND VGND VPWR VPWR _04842_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_62_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclone94 net545 VGND VGND VPWR VPWR net900 sky130_fd_sc_hd__buf_4
X_15133_ _06644_ _06645_ net887 VGND VGND VPWR VPWR _06738_ sky130_fd_sc_hd__nor3_1
XFILLER_0_106_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12345_ net328 net743 net753 net243 VGND VGND VPWR VPWR _03693_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_121_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15064_ _06625_ _06660_ _06662_ VGND VGND VPWR VPWR _06663_ sky130_fd_sc_hd__or3_4
X_12276_ _03595_ _03596_ _03617_ VGND VGND VPWR VPWR _03619_ sky130_fd_sc_hd__nand3_1
X_14015_ net230 net279 net148 net288 VGND VGND VPWR VPWR _05517_ sky130_fd_sc_hd__a22oi_1
X_11227_ _02390_ _02372_ _02477_ _02478_ VGND VGND VPWR VPWR _02479_ sky130_fd_sc_hd__o211a_1
X_11158_ _02199_ _02298_ _02297_ VGND VGND VPWR VPWR _02403_ sky130_fd_sc_hd__a21boi_1
X_10109_ _01361_ _01374_ VGND VGND VPWR VPWR _01375_ sky130_fd_sc_hd__xnor2_1
X_15966_ _07566_ _07626_ _07643_ VGND VGND VPWR VPWR _07644_ sky130_fd_sc_hd__a21oi_1
X_11089_ _02307_ _02326_ _02327_ VGND VGND VPWR VPWR _02328_ sky130_fd_sc_hd__and3_1
X_14917_ _06068_ _06067_ VGND VGND VPWR VPWR _06502_ sky130_fd_sc_hd__and2b_1
X_15897_ _07549_ _07481_ _07568_ VGND VGND VPWR VPWR _07569_ sky130_fd_sc_hd__o21a_1
XFILLER_0_77_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14848_ _06412_ _06414_ _06418_ _06426_ VGND VGND VPWR VPWR _06427_ sky130_fd_sc_hd__a31o_1
XFILLER_0_58_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14779_ _06334_ _06350_ VGND VGND VPWR VPWR _06351_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout404 net406 VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__buf_2
Xfanout415 net421 VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_39_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout426 net428 VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__buf_4
X_09823_ _00998_ _01001_ _01004_ VGND VGND VPWR VPWR _01094_ sky130_fd_sc_hd__a21boi_1
Xfanout437 net49 VGND VGND VPWR VPWR net437 sky130_fd_sc_hd__clkbuf_4
Xfanout448 net454 VGND VGND VPWR VPWR net448 sky130_fd_sc_hd__buf_2
Xfanout459 net464 VGND VGND VPWR VPWR net459 sky130_fd_sc_hd__clkbuf_4
X_09754_ _01010_ _01025_ VGND VGND VPWR VPWR _01026_ sky130_fd_sc_hd__xnor2_1
X_08705_ _07995_ _07994_ _07889_ VGND VGND VPWR VPWR _08017_ sky130_fd_sc_hd__a21o_1
X_09685_ _00935_ _00956_ VGND VGND VPWR VPWR _00958_ sky130_fd_sc_hd__or2_1
XFILLER_0_146_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_126_Right_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08636_ net598 net606 net408 net397 VGND VGND VPWR VPWR _07532_ sky130_fd_sc_hd__and4_1
XFILLER_0_49_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08567_ _06759_ _06770_ VGND VGND VPWR VPWR _06781_ sky130_fd_sc_hd__nor2_1
XFILLER_0_138_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08498_ net578 net407 net396 net591 VGND VGND VPWR VPWR _06025_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_91_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10460_ _01669_ _01672_ _01685_ VGND VGND VPWR VPWR _01686_ sky130_fd_sc_hd__a21o_1
XFILLER_0_51_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09119_ net564 net574 net458 net449 VGND VGND VPWR VPWR _00398_ sky130_fd_sc_hd__and4_1
X_10391_ _01614_ _01616_ VGND VGND VPWR VPWR _01617_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12130_ _03459_ _03460_ VGND VGND VPWR VPWR _03461_ sky130_fd_sc_hd__and2b_1
XFILLER_0_60_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12061_ _03384_ _03385_ VGND VGND VPWR VPWR _03386_ sky130_fd_sc_hd__and2b_1
XFILLER_0_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11012_ _02242_ _02243_ VGND VGND VPWR VPWR _02244_ sky130_fd_sc_hd__and2b_1
X_15820_ _07465_ _07467_ _07483_ VGND VGND VPWR VPWR _07485_ sky130_fd_sc_hd__nand3_1
X_15751_ _07282_ _07409_ VGND VGND VPWR VPWR _07410_ sky130_fd_sc_hd__xnor2_1
X_12963_ _04267_ _04268_ _04269_ VGND VGND VPWR VPWR _04372_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_87_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14702_ _06260_ _06264_ _06265_ VGND VGND VPWR VPWR _06266_ sky130_fd_sc_hd__nand3_1
XFILLER_0_59_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11914_ _03125_ _03128_ VGND VGND VPWR VPWR _03227_ sky130_fd_sc_hd__nor2_1
X_15682_ net248 net547 VGND VGND VPWR VPWR _07335_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12894_ _04292_ _04296_ VGND VGND VPWR VPWR _04297_ sky130_fd_sc_hd__xnor2_2
X_14633_ _06169_ _06164_ VGND VGND VPWR VPWR _06191_ sky130_fd_sc_hd__or2b_1
X_11845_ _03129_ _03151_ VGND VGND VPWR VPWR _03152_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_67_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14564_ _06050_ _06035_ net819 _06114_ VGND VGND VPWR VPWR _06115_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_67_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11776_ _02897_ _02895_ VGND VGND VPWR VPWR _03077_ sky130_fd_sc_hd__nand2_1
XFILLER_0_82_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16303_ clknet_4_0_0_clk _00016_ net334 VGND VGND VPWR VPWR Q_cos\[16\] sky130_fd_sc_hd__dfrtp_1
X_13515_ _04971_ _04972_ VGND VGND VPWR VPWR _04973_ sky130_fd_sc_hd__xor2_2
XFILLER_0_126_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10727_ _01853_ _01850_ _01852_ VGND VGND VPWR VPWR _01953_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_137_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14495_ _05881_ _05886_ _05900_ VGND VGND VPWR VPWR _06039_ sky130_fd_sc_hd__or3_1
X_16234_ _07850_ _07872_ _07934_ VGND VGND VPWR VPWR _07935_ sky130_fd_sc_hd__a21oi_1
X_13446_ net514 net612 net161 net312 VGND VGND VPWR VPWR _04898_ sky130_fd_sc_hd__nand4_1
XFILLER_0_3_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10658_ _01877_ _01882_ _01883_ VGND VGND VPWR VPWR _01884_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_35_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16165_ _07858_ _07859_ VGND VGND VPWR VPWR _07860_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_141_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13377_ net327 net242 net799 VGND VGND VPWR VPWR _04823_ sky130_fd_sc_hd__and3_1
X_10589_ _01812_ _01813_ _01795_ VGND VGND VPWR VPWR _01815_ sky130_fd_sc_hd__a21oi_2
X_15116_ _06717_ _06714_ _06716_ VGND VGND VPWR VPWR _06719_ sky130_fd_sc_hd__nand3_1
X_12328_ _03673_ _03674_ VGND VGND VPWR VPWR _03675_ sky130_fd_sc_hd__xor2_1
X_16096_ _07715_ _07784_ VGND VGND VPWR VPWR _07785_ sky130_fd_sc_hd__nor2_1
XFILLER_0_50_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15047_ net220 net652 VGND VGND VPWR VPWR _06644_ sky130_fd_sc_hd__nand2_1
X_12259_ net227 net443 VGND VGND VPWR VPWR _03600_ sky130_fd_sc_hd__nand2_1
X_15949_ _07598_ _07599_ _07624_ VGND VGND VPWR VPWR _07625_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_92_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09470_ _00693_ _00698_ VGND VGND VPWR VPWR _00745_ sky130_fd_sc_hd__nand2_1
XFILLER_0_116_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08421_ _05155_ _05166_ _05177_ VGND VGND VPWR VPWR _05188_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_148_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08352_ _04053_ net881 net813 _04426_ VGND VGND VPWR VPWR _04437_ sky130_fd_sc_hd__nand4_4
XFILLER_0_74_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08283_ net558 net360 VGND VGND VPWR VPWR _03680_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout201 net209 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__buf_6
Xfanout212 net213 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__clkbuf_4
Xfanout223 net226 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__buf_2
Xfanout234 net236 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__clkbuf_4
Xfanout245 net246 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__buf_2
Xfanout256 net259 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__clkbuf_2
X_09806_ net645 net635 net483 net473 VGND VGND VPWR VPWR _01077_ sky130_fd_sc_hd__and4_1
Xfanout267 net269 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__clkbuf_4
Xfanout278 net281 VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__buf_4
Xfanout289 net290 VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__buf_2
X_09737_ _00948_ _00951_ _01008_ VGND VGND VPWR VPWR _01009_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_97_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09668_ net680 net455 net446 net689 VGND VGND VPWR VPWR _00941_ sky130_fd_sc_hd__a22oi_2
X_08619_ _07140_ _07096_ VGND VGND VPWR VPWR _07347_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09599_ net538 net441 VGND VGND VPWR VPWR _00873_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11630_ _02817_ _02818_ _02916_ VGND VGND VPWR VPWR _02917_ sky130_fd_sc_hd__o21a_1
XFILLER_0_108_802 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11561_ _02748_ _02750_ _02749_ VGND VGND VPWR VPWR _02842_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_108_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13300_ _04736_ _04737_ _04673_ VGND VGND VPWR VPWR _04739_ sky130_fd_sc_hd__a21o_1
X_10512_ net320 net707 net529 net935 VGND VGND VPWR VPWR _01738_ sky130_fd_sc_hd__and4_1
XFILLER_0_135_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14280_ _05751_ _05802_ VGND VGND VPWR VPWR _05804_ sky130_fd_sc_hd__nor2_1
X_11492_ _02765_ _02766_ VGND VGND VPWR VPWR _02767_ sky130_fd_sc_hd__nand2_1
XFILLER_0_150_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13231_ _04548_ _04549_ _04551_ _04547_ VGND VGND VPWR VPWR _04663_ sky130_fd_sc_hd__o22a_1
X_10443_ _01663_ _01668_ VGND VGND VPWR VPWR _01669_ sky130_fd_sc_hd__or2b_1
XFILLER_0_123_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13162_ _04586_ _04587_ VGND VGND VPWR VPWR _04588_ sky130_fd_sc_hd__or2_1
X_10374_ _01601_ _01602_ VGND VGND VPWR VPWR _01603_ sky130_fd_sc_hd__nand2_1
XFILLER_0_103_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12113_ _03363_ _03364_ _03270_ VGND VGND VPWR VPWR _03443_ sky130_fd_sc_hd__a21o_1
X_13093_ _04493_ _04511_ _04512_ VGND VGND VPWR VPWR _04514_ sky130_fd_sc_hd__and3_1
XFILLER_0_20_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12044_ _03362_ _03273_ _03367_ VGND VGND VPWR VPWR _03368_ sky130_fd_sc_hd__o21a_1
Xfanout790 net791 VGND VGND VPWR VPWR net790 sky130_fd_sc_hd__buf_2
X_15803_ _07400_ _07408_ VGND VGND VPWR VPWR _07467_ sky130_fd_sc_hd__or2b_1
X_13995_ _05447_ _05453_ VGND VGND VPWR VPWR _05495_ sky130_fd_sc_hd__and2b_1
X_15734_ _07389_ _07391_ VGND VGND VPWR VPWR _07392_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_87_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12946_ _04351_ _04352_ VGND VGND VPWR VPWR _04353_ sky130_fd_sc_hd__nand2_1
X_15665_ _07300_ _07232_ _07315_ VGND VGND VPWR VPWR _07317_ sky130_fd_sc_hd__nand3_1
XFILLER_0_87_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12877_ _04256_ _04257_ _04276_ _04277_ VGND VGND VPWR VPWR _04278_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_141_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14616_ _06156_ _06170_ _06171_ VGND VGND VPWR VPWR _06172_ sky130_fd_sc_hd__nand3_2
X_11828_ net703 net468 _03014_ _03013_ VGND VGND VPWR VPWR _03133_ sky130_fd_sc_hd__a31o_1
X_15596_ net287 net683 net689 net278 VGND VGND VPWR VPWR _07242_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_28_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14547_ net322 net901 net660 net237 VGND VGND VPWR VPWR _06096_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_55_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11759_ _03056_ _03057_ VGND VGND VPWR VPWR _03058_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_125_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14478_ net273 net697 VGND VGND VPWR VPWR _06020_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16217_ _07653_ _07843_ _07649_ VGND VGND VPWR VPWR _07916_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_113_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13429_ _04771_ _04773_ _04878_ VGND VGND VPWR VPWR _04879_ sky130_fd_sc_hd__a21o_1
XFILLER_0_140_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16148_ _07801_ _07840_ VGND VGND VPWR VPWR _07841_ sky130_fd_sc_hd__xor2_1
XFILLER_0_12_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08970_ net641 net413 net403 net839 VGND VGND VPWR VPWR _00251_ sky130_fd_sc_hd__a22o_1
X_16079_ _07766_ VGND VGND VPWR VPWR _00110_ sky130_fd_sc_hd__clkbuf_1
Xinput1 D[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_1
X_09522_ _00795_ _00796_ VGND VGND VPWR VPWR _00797_ sky130_fd_sc_hd__xor2_1
XFILLER_0_149_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09453_ _00727_ _00728_ VGND VGND VPWR VPWR _00729_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08404_ _04970_ _04981_ _04992_ VGND VGND VPWR VPWR _05003_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_47_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09384_ _02170_ VGND VGND VPWR VPWR _00661_ sky130_fd_sc_hd__buf_4
X_08335_ net667 net421 VGND VGND VPWR VPWR _04251_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08266_ _03464_ _03474_ _03485_ VGND VGND VPWR VPWR _03496_ sky130_fd_sc_hd__or3_4
XFILLER_0_6_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08197_ _02713_ _02735_ VGND VGND VPWR VPWR _02746_ sky130_fd_sc_hd__nor2_1
XFILLER_0_116_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10090_ _01354_ _01355_ VGND VGND VPWR VPWR _01356_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12800_ net191 net725 net736 net180 VGND VGND VPWR VPWR _04193_ sky130_fd_sc_hd__a22oi_1
X_13780_ net933 net174 net795 VGND VGND VPWR VPWR _05261_ sky130_fd_sc_hd__o21ai_1
X_10992_ _02218_ _02219_ _02220_ VGND VGND VPWR VPWR _02222_ sky130_fd_sc_hd__nand3_1
X_12731_ _04027_ _04035_ VGND VGND VPWR VPWR _04117_ sky130_fd_sc_hd__or2b_1
XFILLER_0_139_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15450_ _07081_ _07082_ VGND VGND VPWR VPWR _07083_ sky130_fd_sc_hd__and2_1
X_12662_ net328 net243 net516 net617 VGND VGND VPWR VPWR _04041_ sky130_fd_sc_hd__and4_1
X_14401_ _05920_ _05933_ _05932_ VGND VGND VPWR VPWR _05935_ sky130_fd_sc_hd__a21o_1
XFILLER_0_65_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11613_ _02809_ _02825_ VGND VGND VPWR VPWR _02899_ sky130_fd_sc_hd__and2b_1
XFILLER_0_139_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15381_ net565 _06903_ _06905_ _06906_ VGND VGND VPWR VPWR _07007_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_53_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12593_ _03962_ _03963_ _03964_ VGND VGND VPWR VPWR _03966_ sky130_fd_sc_hd__nand3_1
XFILLER_0_93_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14332_ net188 net559 net571 net178 VGND VGND VPWR VPWR _05859_ sky130_fd_sc_hd__a22oi_1
X_11544_ net756 net937 VGND VGND VPWR VPWR _02824_ sky130_fd_sc_hd__nor2_1
XFILLER_0_80_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14263_ net314 _04539_ VGND VGND VPWR VPWR _05786_ sky130_fd_sc_hd__nor2_1
XFILLER_0_122_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11475_ net513 net612 net350 net502 VGND VGND VPWR VPWR _02749_ sky130_fd_sc_hd__nand4_1
XFILLER_0_21_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16002_ _07681_ _07682_ _07582_ _07607_ VGND VGND VPWR VPWR _07683_ sky130_fd_sc_hd__a211oi_1
X_13214_ _04436_ _04532_ _04645_ VGND VGND VPWR VPWR _04646_ sky130_fd_sc_hd__o21ai_1
X_10426_ _01638_ _01647_ _01651_ VGND VGND VPWR VPWR _01652_ sky130_fd_sc_hd__or3_1
X_14194_ _05647_ _05648_ VGND VGND VPWR VPWR _05711_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13145_ net731 net301 net293 net739 VGND VGND VPWR VPWR _04570_ sky130_fd_sc_hd__a22o_1
X_10357_ net925 _01588_ net129 VGND VGND VPWR VPWR _01589_ sky130_fd_sc_hd__mux2_1
X_13076_ net321 net215 net205 net427 VGND VGND VPWR VPWR _04495_ sky130_fd_sc_hd__a22o_1
X_10288_ _01527_ _01528_ VGND VGND VPWR VPWR _01529_ sky130_fd_sc_hd__xnor2_1
X_12027_ _02991_ _03253_ VGND VGND VPWR VPWR _03349_ sky130_fd_sc_hd__nand2_2
XFILLER_0_73_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13978_ _05408_ _05476_ VGND VGND VPWR VPWR _05477_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_87_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15717_ _07365_ VGND VGND VPWR VPWR _07373_ sky130_fd_sc_hd__inv_2
X_12929_ _04331_ _04332_ VGND VGND VPWR VPWR _04335_ sky130_fd_sc_hd__or2_1
X_15648_ _07252_ _07253_ VGND VGND VPWR VPWR _07298_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_1_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_118_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_38_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15579_ _07155_ _07154_ _07153_ VGND VGND VPWR VPWR _07223_ sky130_fd_sc_hd__and3b_1
XFILLER_0_7_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08953_ _00231_ _00232_ _00217_ VGND VGND VPWR VPWR _00234_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_47_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08884_ _00162_ _00163_ _00164_ VGND VGND VPWR VPWR _00166_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_644 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09505_ _00762_ _00763_ _00779_ VGND VGND VPWR VPWR _00780_ sky130_fd_sc_hd__o21a_1
XFILLER_0_149_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09436_ net655 net663 net347 net500 VGND VGND VPWR VPWR _00712_ sky130_fd_sc_hd__and4_1
XFILLER_0_93_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09367_ _00551_ _00553_ VGND VGND VPWR VPWR _00644_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08318_ _04031_ _04042_ _03833_ _03844_ VGND VGND VPWR VPWR _04064_ sky130_fd_sc_hd__a211o_1
XFILLER_0_74_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09298_ _00505_ _00522_ _00574_ VGND VGND VPWR VPWR _00575_ sky130_fd_sc_hd__a21oi_1
XANTENNA_50 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_61 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08249_ net536 net417 VGND VGND VPWR VPWR _03312_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11260_ _02422_ _02420_ _02421_ VGND VGND VPWR VPWR _02514_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_105_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10211_ _01453_ _01459_ _01462_ VGND VGND VPWR VPWR _01463_ sky130_fd_sc_hd__or3_1
X_11191_ net515 net386 _02346_ _02438_ VGND VGND VPWR VPWR _02439_ sky130_fd_sc_hd__a31o_1
X_10142_ D_cos\[4\] Q_sin\[4\] VGND VGND VPWR VPWR _01403_ sky130_fd_sc_hd__or2b_1
X_10073_ _01109_ _01174_ _01232_ _01287_ VGND VGND VPWR VPWR _01340_ sky130_fd_sc_hd__or4_1
X_14950_ _06528_ _06537_ VGND VGND VPWR VPWR _06538_ sky130_fd_sc_hd__xor2_2
X_13901_ _05304_ _05306_ VGND VGND VPWR VPWR _05393_ sky130_fd_sc_hd__nand2_1
X_14881_ _06461_ _06462_ VGND VGND VPWR VPWR _06463_ sky130_fd_sc_hd__or2_1
X_13832_ _05317_ VGND VGND VPWR VPWR _00087_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_134_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13763_ _05240_ _05241_ VGND VGND VPWR VPWR _05243_ sky130_fd_sc_hd__nor2_1
X_10975_ _02195_ _02202_ VGND VGND VPWR VPWR _02204_ sky130_fd_sc_hd__or2_1
XFILLER_0_97_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15502_ _07137_ _07138_ VGND VGND VPWR VPWR _07139_ sky130_fd_sc_hd__nor2_1
XFILLER_0_85_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12714_ _04095_ _04096_ _04098_ VGND VGND VPWR VPWR _04099_ sky130_fd_sc_hd__nand3_4
X_13694_ net194 _05006_ _05086_ VGND VGND VPWR VPWR _05168_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_84_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15433_ _06962_ _06963_ VGND VGND VPWR VPWR _07065_ sky130_fd_sc_hd__or2b_1
XFILLER_0_84_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12645_ _03911_ _04000_ VGND VGND VPWR VPWR _04023_ sky130_fd_sc_hd__and2_1
XFILLER_0_150_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15364_ _06981_ _06989_ VGND VGND VPWR VPWR _06990_ sky130_fd_sc_hd__xor2_1
X_12576_ _03935_ _03936_ _03946_ VGND VGND VPWR VPWR _03947_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_80_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14315_ net263 net10 VGND VGND VPWR VPWR _05842_ sky130_fd_sc_hd__nand2_1
XFILLER_0_142_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11527_ _02730_ _02732_ VGND VGND VPWR VPWR _02805_ sky130_fd_sc_hd__nor2_1
XFILLER_0_108_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15295_ _06804_ _06805_ _06913_ VGND VGND VPWR VPWR _06914_ sky130_fd_sc_hd__a21o_1
XFILLER_0_135_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14246_ net422 _04540_ _05730_ VGND VGND VPWR VPWR _05767_ sky130_fd_sc_hd__or3_1
X_11458_ _02727_ _02729_ VGND VGND VPWR VPWR _02730_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_1_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10409_ _01631_ _01634_ VGND VGND VPWR VPWR _01635_ sky130_fd_sc_hd__xnor2_1
X_14177_ _05683_ _05686_ _05691_ VGND VGND VPWR VPWR _05692_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_110_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11389_ _02531_ _02533_ VGND VGND VPWR VPWR _02655_ sky130_fd_sc_hd__nand2_2
X_13128_ _04548_ _04549_ _04550_ VGND VGND VPWR VPWR _04551_ sky130_fd_sc_hd__o21ai_1
X_13059_ _04459_ _04474_ _04475_ VGND VGND VPWR VPWR _04476_ sky130_fd_sc_hd__nand3_1
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09221_ _00402_ _00404_ _00498_ VGND VGND VPWR VPWR _00499_ sky130_fd_sc_hd__a21o_1
XFILLER_0_63_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09152_ _00415_ _00430_ VGND VGND VPWR VPWR _00431_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_56_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09083_ _00253_ net877 _00259_ VGND VGND VPWR VPWR _00363_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_114_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput70 sin[2] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_4_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_55_Left_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09985_ _01191_ _01192_ VGND VGND VPWR VPWR _01253_ sky130_fd_sc_hd__or2_1
XFILLER_0_58_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08936_ _00139_ _00146_ _00145_ VGND VGND VPWR VPWR _00217_ sky130_fd_sc_hd__a21o_1
X_08867_ net659 net667 net392 VGND VGND VPWR VPWR _00149_ sky130_fd_sc_hd__and3_1
XFILLER_0_98_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08798_ _08106_ _08107_ _04371_ _08077_ VGND VGND VPWR VPWR _08109_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_64_Left_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10760_ _01983_ _01984_ _01985_ VGND VGND VPWR VPWR _01986_ sky130_fd_sc_hd__o21bai_1
X_09419_ net640 net630 net373 net364 VGND VGND VPWR VPWR _00695_ sky130_fd_sc_hd__and4_1
XFILLER_0_66_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10691_ net787 net803 net354 net508 VGND VGND VPWR VPWR _01917_ sky130_fd_sc_hd__and4_1
XFILLER_0_35_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12430_ _03780_ _03785_ VGND VGND VPWR VPWR _03786_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_63_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12361_ _03702_ _03708_ _03707_ VGND VGND VPWR VPWR _03710_ sky130_fd_sc_hd__a21o_1
X_14100_ _05607_ _05591_ VGND VGND VPWR VPWR _05609_ sky130_fd_sc_hd__and2b_1
XFILLER_0_62_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11312_ net765 net452 VGND VGND VPWR VPWR _02571_ sky130_fd_sc_hd__nand2_1
X_15080_ Q_sin\[2\] _06679_ _05626_ VGND VGND VPWR VPWR _06680_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_73_Left_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12292_ _03634_ _03635_ VGND VGND VPWR VPWR _03636_ sky130_fd_sc_hd__nor2_1
XFILLER_0_105_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14031_ _05510_ _05533_ VGND VGND VPWR VPWR _05534_ sky130_fd_sc_hd__xnor2_1
X_11243_ _02495_ VGND VGND VPWR VPWR _00061_ sky130_fd_sc_hd__clkbuf_1
X_11174_ net707 net715 net359 net353 VGND VGND VPWR VPWR _02421_ sky130_fd_sc_hd__nand4_2
X_10125_ net89 _01388_ net135 VGND VGND VPWR VPWR _01389_ sky130_fd_sc_hd__mux2_1
X_15982_ net270 net656 VGND VGND VPWR VPWR _07661_ sky130_fd_sc_hd__nand2_1
X_10056_ _01321_ _01322_ VGND VGND VPWR VPWR _01323_ sky130_fd_sc_hd__xnor2_1
X_14933_ _06510_ _06517_ _06518_ VGND VGND VPWR VPWR _06520_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_82_Left_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14864_ net222 net600 VGND VGND VPWR VPWR _06445_ sky130_fd_sc_hd__or2_1
X_13815_ _05279_ _05299_ VGND VGND VPWR VPWR _05300_ sky130_fd_sc_hd__nand2_1
X_14795_ _06321_ _06367_ _06368_ VGND VGND VPWR VPWR _06369_ sky130_fd_sc_hd__and3_1
X_13746_ _05223_ _05224_ VGND VGND VPWR VPWR _05225_ sky130_fd_sc_hd__nand2_2
X_10958_ _01958_ _02186_ VGND VGND VPWR VPWR _02187_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_128_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13677_ net704 net271 VGND VGND VPWR VPWR _05149_ sky130_fd_sc_hd__nand2_1
X_10889_ net761 net802 net527 net401 VGND VGND VPWR VPWR _02115_ sky130_fd_sc_hd__and4_1
X_15416_ net165 net668 _07043_ _07044_ VGND VGND VPWR VPWR _07046_ sky130_fd_sc_hd__nand4_1
X_12628_ _04002_ _04003_ VGND VGND VPWR VPWR _04004_ sky130_fd_sc_hd__nor2_1
X_16396_ clknet_4_6_0_clk _00109_ net338 VGND VGND VPWR VPWR Q_sin\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_65_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15347_ _06873_ _06875_ _06969_ VGND VGND VPWR VPWR _06971_ sky130_fd_sc_hd__nand3_1
XFILLER_0_108_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_91_Left_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12559_ net198 net755 VGND VGND VPWR VPWR _03928_ sky130_fd_sc_hd__nand2_1
XFILLER_0_102_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15278_ _06881_ _06882_ VGND VGND VPWR VPWR _06895_ sky130_fd_sc_hd__and2b_1
Xhold106 D_cos\[0\] VGND VGND VPWR VPWR net912 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_79_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold117 net99 VGND VGND VPWR VPWR net923 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14229_ _05692_ _05748_ VGND VGND VPWR VPWR _05749_ sky130_fd_sc_hd__xnor2_1
Xfanout608 net609 VGND VGND VPWR VPWR net608 sky130_fd_sc_hd__clkbuf_2
Xfanout619 net625 VGND VGND VPWR VPWR net619 sky130_fd_sc_hd__buf_2
XFILLER_0_95_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_107_Right_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09770_ Q_cos\[12\] _01041_ _00661_ VGND VGND VPWR VPWR _01042_ sky130_fd_sc_hd__mux2_1
X_08721_ Q_cos\[0\] _08032_ _02181_ VGND VGND VPWR VPWR _08033_ sky130_fd_sc_hd__mux2_1
X_08652_ _07532_ _07553_ net701 net378 VGND VGND VPWR VPWR _07705_ sky130_fd_sc_hd__o211a_1
XFILLER_0_135_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08583_ _06922_ _06933_ _06759_ VGND VGND VPWR VPWR _06955_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_135_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09204_ _00394_ _00411_ _00481_ VGND VGND VPWR VPWR _00482_ sky130_fd_sc_hd__a21o_1
XFILLER_0_146_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09135_ _00340_ _00345_ VGND VGND VPWR VPWR _00414_ sky130_fd_sc_hd__and2_1
XFILLER_0_45_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09066_ _00340_ _00345_ VGND VGND VPWR VPWR _00346_ sky130_fd_sc_hd__xor2_2
XFILLER_0_102_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_139_Left_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09968_ _01205_ _01206_ _01198_ VGND VGND VPWR VPWR _01236_ sky130_fd_sc_hd__o21ai_1
X_08919_ net583 net469 VGND VGND VPWR VPWR _00200_ sky130_fd_sc_hd__nand2_1
X_09899_ _01045_ _01065_ _01063_ VGND VGND VPWR VPWR _01169_ sky130_fd_sc_hd__a21oi_2
X_11930_ _03243_ VGND VGND VPWR VPWR _00069_ sky130_fd_sc_hd__clkbuf_1
X_11861_ _03166_ _03167_ VGND VGND VPWR VPWR _03168_ sky130_fd_sc_hd__nor2_1
XFILLER_0_24_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13600_ _05063_ _05064_ VGND VGND VPWR VPWR _05065_ sky130_fd_sc_hd__nor2_1
X_10812_ _02028_ _02030_ VGND VGND VPWR VPWR _02038_ sky130_fd_sc_hd__and2_1
X_14580_ net213 net552 net561 net203 VGND VGND VPWR VPWR _06132_ sky130_fd_sc_hd__a22o_1
XFILLER_0_67_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11792_ _02994_ _03091_ _03092_ VGND VGND VPWR VPWR _03093_ sky130_fd_sc_hd__nand3_1
XFILLER_0_95_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13531_ net427 net513 net157 net306 VGND VGND VPWR VPWR _04990_ sky130_fd_sc_hd__nand4_2
XFILLER_0_27_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10743_ net803 net362 VGND VGND VPWR VPWR _01969_ sky130_fd_sc_hd__nand2_1
XFILLER_0_94_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16250_ _07931_ _07930_ VGND VGND VPWR VPWR _07951_ sky130_fd_sc_hd__and2b_1
XFILLER_0_125_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13462_ net427 net168 _04912_ _04913_ VGND VGND VPWR VPWR _04915_ sky130_fd_sc_hd__nand4_2
XFILLER_0_82_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10674_ _01886_ _01887_ _01899_ VGND VGND VPWR VPWR _01900_ sky130_fd_sc_hd__nand3_1
X_15201_ _06809_ _06810_ VGND VGND VPWR VPWR _06811_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12413_ _03764_ _03765_ _03746_ VGND VGND VPWR VPWR _03768_ sky130_fd_sc_hd__o21ai_1
X_16181_ _07809_ _07812_ _07874_ _07875_ VGND VGND VPWR VPWR _07877_ sky130_fd_sc_hd__a211o_1
X_13393_ _04838_ _04839_ VGND VGND VPWR VPWR _04841_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_62_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15132_ _06732_ _06735_ VGND VGND VPWR VPWR _06736_ sky130_fd_sc_hd__xnor2_1
X_12344_ net223 net763 VGND VGND VPWR VPWR _03692_ sky130_fd_sc_hd__nand2_1
XFILLER_0_62_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15063_ _06658_ _06659_ _06557_ _06626_ VGND VGND VPWR VPWR _06662_ sky130_fd_sc_hd__o211a_1
X_12275_ _03595_ _03596_ _03617_ VGND VGND VPWR VPWR _03618_ sky130_fd_sc_hd__a21o_1
X_14014_ _05515_ VGND VGND VPWR VPWR _05516_ sky130_fd_sc_hd__buf_2
X_11226_ _02475_ _02476_ _02410_ VGND VGND VPWR VPWR _02478_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11157_ _02400_ _02401_ VGND VGND VPWR VPWR _02402_ sky130_fd_sc_hd__xnor2_1
X_10108_ _01366_ _01373_ VGND VGND VPWR VPWR _01374_ sky130_fd_sc_hd__xnor2_1
X_15965_ _07641_ _07642_ VGND VGND VPWR VPWR _07643_ sky130_fd_sc_hd__xnor2_1
X_11088_ _02324_ _02325_ _02308_ VGND VGND VPWR VPWR _02327_ sky130_fd_sc_hd__a21o_1
X_10039_ _01267_ _01266_ VGND VGND VPWR VPWR _01306_ sky130_fd_sc_hd__and2b_1
X_14916_ _06499_ _06500_ VGND VGND VPWR VPWR _06501_ sky130_fd_sc_hd__nor2_1
X_15896_ _07566_ _07567_ VGND VGND VPWR VPWR _07568_ sky130_fd_sc_hd__and2_1
XFILLER_0_78_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14847_ _06419_ _06424_ _06425_ VGND VGND VPWR VPWR _06426_ sky130_fd_sc_hd__and3_1
X_14778_ net197 net605 VGND VGND VPWR VPWR _06350_ sky130_fd_sc_hd__nand2_1
XFILLER_0_105_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13729_ _05203_ _05204_ VGND VGND VPWR VPWR _05206_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16379_ clknet_4_7_0_clk _00092_ net336 VGND VGND VPWR VPWR D_sin\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_41_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout405 net406 VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__clkbuf_4
Xfanout416 net417 VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__buf_2
X_09822_ _01071_ _01092_ VGND VGND VPWR VPWR _01093_ sky130_fd_sc_hd__xnor2_1
Xfanout427 net428 VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout438 net439 VGND VGND VPWR VPWR net438 sky130_fd_sc_hd__clkbuf_4
Xfanout449 net454 VGND VGND VPWR VPWR net449 sky130_fd_sc_hd__clkbuf_4
X_09753_ _01023_ _01024_ VGND VGND VPWR VPWR _01025_ sky130_fd_sc_hd__xnor2_1
X_08704_ _08001_ _08010_ _08012_ _08015_ _08009_ VGND VGND VPWR VPWR _08016_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_146_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09684_ _00935_ _00956_ VGND VGND VPWR VPWR _00957_ sky130_fd_sc_hd__nand2_1
X_08635_ _07303_ _07292_ _07216_ VGND VGND VPWR VPWR _07521_ sky130_fd_sc_hd__a21o_1
X_08566_ _06715_ _06726_ _06748_ VGND VGND VPWR VPWR _06770_ sky130_fd_sc_hd__and3_1
XFILLER_0_77_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08497_ _05395_ _05882_ VGND VGND VPWR VPWR _06014_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_36_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09118_ net564 net458 net449 net574 VGND VGND VPWR VPWR _00397_ sky130_fd_sc_hd__a22oi_2
X_10390_ _01614_ _01615_ net743 net390 VGND VGND VPWR VPWR _01616_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_115_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09049_ _00225_ _00223_ _00224_ VGND VGND VPWR VPWR _00329_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_13_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12060_ _03380_ _03381_ _03383_ VGND VGND VPWR VPWR _03385_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11011_ _02240_ _02241_ _02237_ VGND VGND VPWR VPWR _02243_ sky130_fd_sc_hd__a21o_1
X_15750_ _07400_ _07408_ VGND VGND VPWR VPWR _07409_ sky130_fd_sc_hd__xnor2_1
X_12962_ _04366_ _04367_ _04368_ VGND VGND VPWR VPWR _04370_ sky130_fd_sc_hd__nand3_1
X_14701_ _06261_ _06263_ _06262_ VGND VGND VPWR VPWR _06265_ sky130_fd_sc_hd__a21o_1
X_11913_ _03125_ _03128_ VGND VGND VPWR VPWR _03226_ sky130_fd_sc_hd__nand2_1
X_15681_ _07332_ _07333_ VGND VGND VPWR VPWR _07334_ sky130_fd_sc_hd__nor2_1
X_12893_ _04293_ _04294_ VGND VGND VPWR VPWR _04296_ sky130_fd_sc_hd__nor2_1
X_14632_ _06158_ _06163_ VGND VGND VPWR VPWR _06189_ sky130_fd_sc_hd__or2b_1
X_11844_ _03131_ _03150_ VGND VGND VPWR VPWR _03151_ sky130_fd_sc_hd__xor2_1
XFILLER_0_129_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14563_ _06074_ _06075_ _06110_ net832 VGND VGND VPWR VPWR _06114_ sky130_fd_sc_hd__a22o_4
XFILLER_0_51_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11775_ _02189_ _02491_ _02704_ _03075_ VGND VGND VPWR VPWR _03076_ sky130_fd_sc_hd__or4_4
X_16302_ clknet_4_0_0_clk _00015_ net334 VGND VGND VPWR VPWR Q_cos\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_82_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10726_ _01853_ _01850_ _01852_ VGND VGND VPWR VPWR _01952_ sky130_fd_sc_hd__and3_1
XFILLER_0_83_756 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13514_ _04868_ _04871_ _04869_ VGND VGND VPWR VPWR _04972_ sky130_fd_sc_hd__o21ba_1
X_14494_ _06035_ _06034_ _05974_ _05971_ VGND VGND VPWR VPWR _06038_ sky130_fd_sc_hd__o211a_1
XFILLER_0_126_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16233_ _07852_ _07871_ VGND VGND VPWR VPWR _07934_ sky130_fd_sc_hd__and2_1
XFILLER_0_126_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13445_ net514 net161 net312 net612 VGND VGND VPWR VPWR _04897_ sky130_fd_sc_hd__a22o_1
X_10657_ _01871_ _01876_ _01872_ VGND VGND VPWR VPWR _01883_ sky130_fd_sc_hd__nand3_1
XFILLER_0_141_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16164_ net247 net657 VGND VGND VPWR VPWR _07859_ sky130_fd_sc_hd__nand2_1
X_13376_ _04820_ _04821_ VGND VGND VPWR VPWR _04822_ sky130_fd_sc_hd__xor2_2
XFILLER_0_51_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10588_ _01795_ _01812_ _01813_ VGND VGND VPWR VPWR _01814_ sky130_fd_sc_hd__and3_1
X_15115_ _06714_ _06716_ _06717_ VGND VGND VPWR VPWR _06718_ sky130_fd_sc_hd__a21o_1
X_12327_ net145 net443 VGND VGND VPWR VPWR _03674_ sky130_fd_sc_hd__nand2_1
X_16095_ _07718_ _07717_ VGND VGND VPWR VPWR _07784_ sky130_fd_sc_hd__and2b_1
XFILLER_0_121_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15046_ _06641_ _06642_ VGND VGND VPWR VPWR _06643_ sky130_fd_sc_hd__xnor2_2
X_12258_ _03569_ _03568_ VGND VGND VPWR VPWR _03599_ sky130_fd_sc_hd__and2b_1
XFILLER_0_121_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11209_ net151 net414 _02456_ _02457_ VGND VGND VPWR VPWR _02459_ sky130_fd_sc_hd__o2bb2a_1
X_12189_ _03459_ _03462_ _03460_ VGND VGND VPWR VPWR _03525_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_92_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15948_ _07593_ _07596_ VGND VGND VPWR VPWR _07624_ sky130_fd_sc_hd__or2_1
XFILLER_0_78_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15879_ _07479_ _07478_ VGND VGND VPWR VPWR _07549_ sky130_fd_sc_hd__and2b_1
X_08420_ net536 net543 net524 net437 VGND VGND VPWR VPWR _05177_ sky130_fd_sc_hd__and4_1
XFILLER_0_148_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08351_ _04393_ _04404_ _03637_ _04075_ VGND VGND VPWR VPWR _04426_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_46_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08282_ net875 _03246_ VGND VGND VPWR VPWR _03669_ sky130_fd_sc_hd__nor2_4
XFILLER_0_18_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_143_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout202 net203 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__clkbuf_4
Xfanout213 net219 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__clkbuf_4
Xfanout224 net226 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__buf_2
Xfanout235 net236 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__clkbuf_2
Xfanout246 net69 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__buf_6
X_09805_ net635 net483 net473 net645 VGND VGND VPWR VPWR _01076_ sky130_fd_sc_hd__a22oi_2
Xfanout257 net259 VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__clkbuf_4
Xfanout268 net269 VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__clkbuf_2
Xfanout279 net281 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__clkbuf_4
X_09736_ _00952_ _00953_ VGND VGND VPWR VPWR _01008_ sky130_fd_sc_hd__or2_1
XFILLER_0_97_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09667_ _00832_ _00835_ _00833_ VGND VGND VPWR VPWR _00940_ sky130_fd_sc_hd__o21ba_1
X_08618_ _07184_ _07194_ _07314_ VGND VGND VPWR VPWR _07336_ sky130_fd_sc_hd__nand3_1
X_09598_ _00870_ _00871_ VGND VGND VPWR VPWR _00872_ sky130_fd_sc_hd__nor2_1
XFILLER_0_49_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08549_ _06541_ _06563_ _06552_ VGND VGND VPWR VPWR _06584_ sky130_fd_sc_hd__a21o_1
XFILLER_0_65_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11560_ _02837_ _02838_ _02839_ VGND VGND VPWR VPWR _02841_ sky130_fd_sc_hd__nand3_1
XFILLER_0_119_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10511_ net715 net390 VGND VGND VPWR VPWR _01737_ sky130_fd_sc_hd__nand2_1
XFILLER_0_108_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11491_ net426 net358 _02763_ _02764_ VGND VGND VPWR VPWR _02766_ sky130_fd_sc_hd__nand4_2
XFILLER_0_45_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13230_ _04656_ _04661_ VGND VGND VPWR VPWR _04662_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_122_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10442_ _01664_ _01667_ VGND VGND VPWR VPWR _01668_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_122_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13161_ _04584_ _04585_ _04565_ VGND VGND VPWR VPWR _04587_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_21_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10373_ Q_cos\[17\] D_sin\[17\] VGND VGND VPWR VPWR _01602_ sky130_fd_sc_hd__or2b_1
XFILLER_0_131_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12112_ _03439_ _03440_ VGND VGND VPWR VPWR _03441_ sky130_fd_sc_hd__xnor2_1
X_13092_ _04508_ _04509_ _04510_ VGND VGND VPWR VPWR _04512_ sky130_fd_sc_hd__a21o_1
X_12043_ _03363_ _03365_ VGND VGND VPWR VPWR _03367_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_137_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout780 net782 VGND VGND VPWR VPWR net780 sky130_fd_sc_hd__buf_2
X_15802_ _07284_ _07407_ VGND VGND VPWR VPWR _07465_ sky130_fd_sc_hd__or2_1
Xfanout791 net11 VGND VGND VPWR VPWR net791 sky130_fd_sc_hd__clkbuf_2
X_13994_ _05491_ _05493_ VGND VGND VPWR VPWR _05494_ sky130_fd_sc_hd__xor2_1
XFILLER_0_1_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15733_ _07307_ _07310_ _07308_ VGND VGND VPWR VPWR _07391_ sky130_fd_sc_hd__o21ba_1
X_12945_ _04247_ _04350_ VGND VGND VPWR VPWR _04352_ sky130_fd_sc_hd__or2_1
X_15664_ _07300_ _07232_ _07315_ VGND VGND VPWR VPWR _07316_ sky130_fd_sc_hd__a21o_1
X_12876_ _04258_ _04259_ _04275_ VGND VGND VPWR VPWR _04277_ sky130_fd_sc_hd__nand3_2
XFILLER_0_68_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14615_ _06138_ _06155_ _06154_ VGND VGND VPWR VPWR _06171_ sky130_fd_sc_hd__a21o_1
X_11827_ _03028_ _03031_ VGND VGND VPWR VPWR _03132_ sky130_fd_sc_hd__nand2_1
X_15595_ _07150_ _07160_ _07159_ VGND VGND VPWR VPWR _07241_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_55_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14546_ net322 net237 net651 net660 VGND VGND VPWR VPWR _06095_ sky130_fd_sc_hd__and4_1
XFILLER_0_56_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11758_ net740 net937 VGND VGND VPWR VPWR _03057_ sky130_fd_sc_hd__nor2_1
XFILLER_0_102_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10709_ _01653_ _01655_ VGND VGND VPWR VPWR _01935_ sky130_fd_sc_hd__xnor2_1
X_14477_ _06012_ _06018_ VGND VGND VPWR VPWR _06019_ sky130_fd_sc_hd__xnor2_1
X_11689_ _02896_ _02981_ VGND VGND VPWR VPWR _02982_ sky130_fd_sc_hd__xnor2_1
X_16216_ _07891_ _07892_ _07913_ VGND VGND VPWR VPWR _07915_ sky130_fd_sc_hd__nand3_1
X_13428_ _04765_ _04770_ VGND VGND VPWR VPWR _04878_ sky130_fd_sc_hd__and2_1
XFILLER_0_141_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16147_ _07838_ _07839_ VGND VGND VPWR VPWR _07840_ sky130_fd_sc_hd__or2_1
X_13359_ _04801_ _04802_ VGND VGND VPWR VPWR _04803_ sky130_fd_sc_hd__nand2_1
XFILLER_0_140_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16078_ Q_sin\[14\] _07765_ _00186_ VGND VGND VPWR VPWR _07766_ sky130_fd_sc_hd__mux2_1
XFILLER_0_121_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15029_ _06621_ _06622_ _06602_ VGND VGND VPWR VPWR _06624_ sky130_fd_sc_hd__a21oi_1
Xinput2 D[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_2
X_09521_ _00671_ _00674_ _00672_ VGND VGND VPWR VPWR _00796_ sky130_fd_sc_hd__o21ba_1
X_09452_ _00724_ _00726_ VGND VGND VPWR VPWR _00728_ sky130_fd_sc_hd__nand2_1
XFILLER_0_148_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08403_ net578 net587 net377 net368 VGND VGND VPWR VPWR _04992_ sky130_fd_sc_hd__and4_1
XFILLER_0_143_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09383_ _00655_ _00659_ VGND VGND VPWR VPWR _00660_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_143_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08334_ _04196_ _04229_ VGND VGND VPWR VPWR _04240_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_46_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08265_ net659 net521 net433 net667 VGND VGND VPWR VPWR _03485_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08196_ _02713_ _02724_ net552 net387 VGND VGND VPWR VPWR _02735_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09719_ _00989_ _00990_ VGND VGND VPWR VPWR _00991_ sky130_fd_sc_hd__nor2_1
X_10991_ _02218_ _02219_ _02220_ VGND VGND VPWR VPWR _02221_ sky130_fd_sc_hd__a21o_1
X_12730_ _04034_ _04033_ VGND VGND VPWR VPWR _04116_ sky130_fd_sc_hd__or2b_1
X_12661_ _03977_ _03988_ _03978_ VGND VGND VPWR VPWR _04040_ sky130_fd_sc_hd__nand3_1
XFILLER_0_32_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14400_ _05920_ _05932_ _05933_ VGND VGND VPWR VPWR _05934_ sky130_fd_sc_hd__nand3_2
X_11612_ _02802_ _02887_ VGND VGND VPWR VPWR _02897_ sky130_fd_sc_hd__or2_1
X_15380_ _07000_ _07005_ VGND VGND VPWR VPWR _07006_ sky130_fd_sc_hd__xor2_2
X_12592_ net224 net718 _03959_ _03961_ VGND VGND VPWR VPWR _03964_ sky130_fd_sc_hd__a22o_1
XFILLER_0_92_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14331_ net188 net178 net559 net571 VGND VGND VPWR VPWR _05858_ sky130_fd_sc_hd__and4_1
X_11543_ _02819_ _02821_ VGND VGND VPWR VPWR _02823_ sky130_fd_sc_hd__xor2_4
XFILLER_0_107_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14262_ _05782_ _05783_ VGND VGND VPWR VPWR _05784_ sky130_fd_sc_hd__or2b_1
X_11474_ net513 net349 net502 net612 VGND VGND VPWR VPWR _02748_ sky130_fd_sc_hd__a22o_1
X_16001_ _07680_ _07647_ _07648_ VGND VGND VPWR VPWR _07682_ sky130_fd_sc_hd__or3_1
X_13213_ _04440_ _04432_ _04531_ VGND VGND VPWR VPWR _04645_ sky130_fd_sc_hd__a21o_1
X_10425_ _01648_ _01650_ VGND VGND VPWR VPWR _01651_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14193_ _05707_ _05708_ VGND VGND VPWR VPWR _05710_ sky130_fd_sc_hd__xor2_1
XFILLER_0_33_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13144_ net731 net739 net301 VGND VGND VPWR VPWR _04569_ sky130_fd_sc_hd__and3_1
XFILLER_0_150_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10356_ _01586_ _01587_ VGND VGND VPWR VPWR _01588_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13075_ net321 net427 net205 VGND VGND VPWR VPWR _04494_ sky130_fd_sc_hd__and3_1
X_10287_ _01519_ _01522_ _01520_ VGND VGND VPWR VPWR _01528_ sky130_fd_sc_hd__a21bo_1
X_12026_ _03347_ VGND VGND VPWR VPWR _03348_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_88_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13977_ _05474_ _05475_ VGND VGND VPWR VPWR _05476_ sky130_fd_sc_hd__xnor2_2
X_15716_ _07372_ VGND VGND VPWR VPWR _00105_ sky130_fd_sc_hd__clkbuf_1
X_12928_ _04161_ _04166_ _04244_ _04331_ VGND VGND VPWR VPWR _04334_ sky130_fd_sc_hd__a211o_1
XFILLER_0_69_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15647_ _07295_ _07296_ VGND VGND VPWR VPWR _07297_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12859_ _04191_ _04197_ VGND VGND VPWR VPWR _04258_ sky130_fd_sc_hd__or2b_1
XFILLER_0_146_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15578_ _07220_ _07221_ VGND VGND VPWR VPWR _07222_ sky130_fd_sc_hd__and2b_1
XFILLER_0_90_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14529_ _05994_ _05995_ _06005_ VGND VGND VPWR VPWR _06076_ sky130_fd_sc_hd__nand3_2
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08952_ _00217_ _00231_ _00232_ VGND VGND VPWR VPWR _00233_ sky130_fd_sc_hd__nand3_1
XFILLER_0_110_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_102_Left_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08883_ _00162_ _00163_ _00164_ VGND VGND VPWR VPWR _00165_ sky130_fd_sc_hd__nand3_4
XFILLER_0_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09504_ _00776_ _00778_ VGND VGND VPWR VPWR _00779_ sky130_fd_sc_hd__xnor2_1
X_09435_ net655 net347 net500 net663 VGND VGND VPWR VPWR _00711_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_66_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_111_Left_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09366_ _00591_ _00642_ VGND VGND VPWR VPWR _00643_ sky130_fd_sc_hd__xor2_1
XFILLER_0_93_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08317_ _03833_ _03844_ _04031_ _04042_ VGND VGND VPWR VPWR _04053_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_90_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09297_ _00506_ _00521_ VGND VGND VPWR VPWR _00574_ sky130_fd_sc_hd__nor2_1
XANTENNA_40 D_sin\[0\] VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_145_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_51 net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_62 net400 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08248_ _03170_ _03160_ _03149_ VGND VGND VPWR VPWR _03301_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_144_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08179_ _02299_ _02376_ net807 VGND VGND VPWR VPWR _02550_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_132_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10210_ _01460_ _01461_ VGND VGND VPWR VPWR _01462_ sky130_fd_sc_hd__nor2_1
X_11190_ net426 net142 net523 net395 VGND VGND VPWR VPWR _02438_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_120_Left_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10141_ net135 net927 _01401_ _01402_ VGND VGND VPWR VPWR _00022_ sky130_fd_sc_hd__o22a_1
X_10072_ _01337_ _01338_ VGND VGND VPWR VPWR _01339_ sky130_fd_sc_hd__nor2_1
XFILLER_0_100_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13900_ _05390_ _05391_ VGND VGND VPWR VPWR _05392_ sky130_fd_sc_hd__nor2_1
X_14880_ _06433_ _06457_ _06404_ _06460_ VGND VGND VPWR VPWR _06462_ sky130_fd_sc_hd__o2bb2a_1
X_13831_ D_sin\[10\] _05316_ _04752_ VGND VGND VPWR VPWR _05317_ sky130_fd_sc_hd__mux2_1
XFILLER_0_43_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10974_ _02195_ _02202_ VGND VGND VPWR VPWR _02203_ sky130_fd_sc_hd__nand2_1
X_13762_ net431 net512 net289 net280 VGND VGND VPWR VPWR _05241_ sky130_fd_sc_hd__and4_1
X_15501_ _07135_ _07136_ _07117_ VGND VGND VPWR VPWR _07138_ sky130_fd_sc_hd__a21oi_1
X_12713_ _04088_ _04089_ _04094_ VGND VGND VPWR VPWR _04098_ sky130_fd_sc_hd__a21o_1
XFILLER_0_84_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13693_ _05088_ _05092_ _05089_ VGND VGND VPWR VPWR _05167_ sky130_fd_sc_hd__o21ba_1
X_15432_ _07050_ _07062_ VGND VGND VPWR VPWR _07063_ sky130_fd_sc_hd__xor2_1
XFILLER_0_127_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12644_ _04018_ _04012_ _04013_ _04017_ VGND VGND VPWR VPWR _04022_ sky130_fd_sc_hd__nor4_1
XFILLER_0_150_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15363_ _06487_ _06983_ _06984_ _06987_ VGND VGND VPWR VPWR _06989_ sky130_fd_sc_hd__o211a_4
XFILLER_0_93_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12575_ _03944_ _03945_ VGND VGND VPWR VPWR _03946_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_25_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14314_ _05771_ _05773_ _05840_ VGND VGND VPWR VPWR _05841_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_25_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11526_ _02718_ _02737_ _02803_ VGND VGND VPWR VPWR _02804_ sky130_fd_sc_hd__a21o_1
XFILLER_0_136_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15294_ _06803_ _06797_ VGND VGND VPWR VPWR _06913_ sky130_fd_sc_hd__and2b_1
XFILLER_0_41_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11457_ _02728_ VGND VGND VPWR VPWR _02729_ sky130_fd_sc_hd__inv_2
X_14245_ _05764_ _05765_ VGND VGND VPWR VPWR _05766_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10408_ _01632_ _01633_ VGND VGND VPWR VPWR _01634_ sky130_fd_sc_hd__nor2_1
XFILLER_0_123_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14176_ _05690_ _05682_ VGND VGND VPWR VPWR _05691_ sky130_fd_sc_hd__nor2_1
X_11388_ _02537_ _02556_ _02557_ VGND VGND VPWR VPWR _02654_ sky130_fd_sc_hd__nand3_1
XFILLER_0_110_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10339_ _01563_ _01567_ _01571_ VGND VGND VPWR VPWR _01573_ sky130_fd_sc_hd__or3_1
X_13127_ net758 net274 net268 net766 VGND VGND VPWR VPWR _04550_ sky130_fd_sc_hd__a22o_1
X_13058_ _04472_ _04473_ _04464_ VGND VGND VPWR VPWR _04475_ sky130_fd_sc_hd__a21o_1
XFILLER_0_84_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12009_ net610 net444 VGND VGND VPWR VPWR _03329_ sky130_fd_sc_hd__nand2_1
XFILLER_0_88_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09220_ _00396_ _00401_ VGND VGND VPWR VPWR _00498_ sky130_fd_sc_hd__and2_1
XFILLER_0_146_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09151_ _00420_ _00429_ VGND VGND VPWR VPWR _00430_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_17_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09082_ _00359_ _00360_ _00352_ VGND VGND VPWR VPWR _00362_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput60 sin[10] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__buf_4
Xinput71 sin[3] VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_142_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09984_ _01250_ _01251_ VGND VGND VPWR VPWR _01252_ sky130_fd_sc_hd__and2b_1
X_08935_ _00129_ _00131_ VGND VGND VPWR VPWR _00216_ sky130_fd_sc_hd__nand2_1
X_08866_ _00139_ _00147_ VGND VGND VPWR VPWR _00148_ sky130_fd_sc_hd__xor2_2
XFILLER_0_99_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08797_ _04371_ _08077_ _08106_ _08107_ VGND VGND VPWR VPWR _08108_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_67_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09418_ net630 net373 net364 net640 VGND VGND VPWR VPWR _00694_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_48_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10690_ _01898_ _01894_ VGND VGND VPWR VPWR _01916_ sky130_fd_sc_hd__or2b_1
XFILLER_0_47_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09349_ net640 net373 net364 net650 VGND VGND VPWR VPWR _00626_ sky130_fd_sc_hd__a22o_1
XFILLER_0_63_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12360_ _03702_ _03707_ _03708_ VGND VGND VPWR VPWR _03709_ sky130_fd_sc_hd__nand3_1
XFILLER_0_63_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_742 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11311_ _02414_ _02416_ _02415_ net491 VGND VGND VPWR VPWR _02570_ sky130_fd_sc_hd__a22o_1
XFILLER_0_105_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12291_ _03633_ _03618_ _03619_ VGND VGND VPWR VPWR _03635_ sky130_fd_sc_hd__and3_1
XFILLER_0_22_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14030_ _05512_ _05532_ VGND VGND VPWR VPWR _05533_ sky130_fd_sc_hd__xnor2_1
X_11242_ D_cos\[3\] _02494_ _01379_ VGND VGND VPWR VPWR _02495_ sky130_fd_sc_hd__mux2_1
XFILLER_0_120_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11173_ net707 net361 net353 net715 VGND VGND VPWR VPWR _02420_ sky130_fd_sc_hd__a22o_1
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10124_ _01386_ _01387_ VGND VGND VPWR VPWR _01388_ sky130_fd_sc_hd__nor2_1
X_15981_ net286 net277 net647 net637 VGND VGND VPWR VPWR _07660_ sky130_fd_sc_hd__and4_1
X_10055_ net656 _00193_ VGND VGND VPWR VPWR _01322_ sky130_fd_sc_hd__nor2_1
X_14932_ _06514_ _06515_ _06516_ VGND VGND VPWR VPWR _06518_ sky130_fd_sc_hd__a21o_1
XFILLER_0_89_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14863_ _06440_ _06442_ VGND VGND VPWR VPWR _06444_ sky130_fd_sc_hd__nor2_1
X_13814_ _05281_ _05298_ VGND VGND VPWR VPWR _05299_ sky130_fd_sc_hd__xnor2_1
X_14794_ _06318_ _06320_ _06319_ VGND VGND VPWR VPWR _06368_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13745_ _05132_ _05222_ VGND VGND VPWR VPWR _05224_ sky130_fd_sc_hd__or2_1
X_10957_ _01950_ _01960_ _02007_ _02185_ VGND VGND VPWR VPWR _02186_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_45_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13676_ _05146_ _05147_ VGND VGND VPWR VPWR _05148_ sky130_fd_sc_hd__nor2_1
X_10888_ _02097_ _02113_ VGND VGND VPWR VPWR _02114_ sky130_fd_sc_hd__xor2_1
X_15415_ net165 net668 _07043_ _07044_ VGND VGND VPWR VPWR _07045_ sky130_fd_sc_hd__a22o_1
X_12627_ _03993_ _03994_ _04001_ VGND VGND VPWR VPWR _04003_ sky130_fd_sc_hd__and3_1
X_16395_ clknet_4_6_0_clk _00108_ net338 VGND VGND VPWR VPWR Q_sin\[12\] sky130_fd_sc_hd__dfrtp_1
X_15346_ _06873_ _06875_ _06969_ VGND VGND VPWR VPWR _06970_ sky130_fd_sc_hd__a21oi_1
X_12558_ _03925_ _03926_ VGND VGND VPWR VPWR _03927_ sky130_fd_sc_hd__and2b_1
XFILLER_0_14_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11509_ _02760_ _02785_ VGND VGND VPWR VPWR _02786_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_123_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15277_ _06886_ _06884_ VGND VGND VPWR VPWR _06894_ sky130_fd_sc_hd__and2b_1
Xhold107 D_cos\[14\] VGND VGND VPWR VPWR net913 sky130_fd_sc_hd__dlygate4sd3_1
X_12489_ net330 net245 net772 net780 VGND VGND VPWR VPWR _03851_ sky130_fd_sc_hd__and4_1
Xhold118 net116 VGND VGND VPWR VPWR net924 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_0_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14228_ _05693_ _05747_ VGND VGND VPWR VPWR _05748_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_111_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14159_ _05671_ _05651_ _05652_ VGND VGND VPWR VPWR _05673_ sky130_fd_sc_hd__or3_2
Xfanout609 net30 VGND VGND VPWR VPWR net609 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_95_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08720_ _06003_ _08031_ VGND VGND VPWR VPWR _08032_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_119_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08651_ _07510_ _07521_ _07673_ VGND VGND VPWR VPWR _07695_ sky130_fd_sc_hd__and3_1
X_08582_ _06922_ _06933_ _06759_ VGND VGND VPWR VPWR _06944_ sky130_fd_sc_hd__or3b_1
XFILLER_0_89_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09203_ _00395_ _00410_ VGND VGND VPWR VPWR _00481_ sky130_fd_sc_hd__nor2_1
XFILLER_0_63_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09134_ _00327_ _00328_ _00329_ _00332_ VGND VGND VPWR VPWR _00413_ sky130_fd_sc_hd__a31o_1
XFILLER_0_60_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09065_ _00343_ _00344_ VGND VGND VPWR VPWR _00345_ sky130_fd_sc_hd__xor2_2
XFILLER_0_44_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09967_ _01222_ _01223_ _01225_ VGND VGND VPWR VPWR _01235_ sky130_fd_sc_hd__and3_1
X_08918_ net593 net449 VGND VGND VPWR VPWR _00199_ sky130_fd_sc_hd__nand2_1
X_09898_ _01166_ _01167_ VGND VGND VPWR VPWR _01168_ sky130_fd_sc_hd__nor2_1
X_08849_ _00122_ _00129_ _00130_ VGND VGND VPWR VPWR _00131_ sky130_fd_sc_hd__nand3_2
X_11860_ net316 net423 net486 net476 VGND VGND VPWR VPWR _03167_ sky130_fd_sc_hd__and4_1
XFILLER_0_67_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10811_ _02026_ _02034_ _02035_ _02036_ VGND VGND VPWR VPWR _02037_ sky130_fd_sc_hd__a211oi_2
X_11791_ net796 _00851_ _03089_ _03090_ VGND VGND VPWR VPWR _03092_ sky130_fd_sc_hd__nand4_1
XFILLER_0_39_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13530_ net427 net157 net306 net513 VGND VGND VPWR VPWR _04989_ sky130_fd_sc_hd__a22o_1
X_10742_ _01965_ _01967_ VGND VGND VPWR VPWR _01968_ sky130_fd_sc_hd__or2b_1
XFILLER_0_94_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10673_ _01894_ _01898_ VGND VGND VPWR VPWR _01899_ sky130_fd_sc_hd__xnor2_1
X_13461_ net427 net168 _04912_ _04913_ VGND VGND VPWR VPWR _04914_ sky130_fd_sc_hd__a22o_1
XFILLER_0_137_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15200_ _06806_ _06808_ VGND VGND VPWR VPWR _06810_ sky130_fd_sc_hd__nor2_1
X_12412_ _03746_ _03764_ _03765_ VGND VGND VPWR VPWR _03766_ sky130_fd_sc_hd__or3_1
XFILLER_0_35_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16180_ _07874_ _07875_ _07809_ _07812_ VGND VGND VPWR VPWR _07876_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_106_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13392_ _04736_ _04738_ VGND VGND VPWR VPWR _04839_ sky130_fd_sc_hd__and2_1
X_15131_ net652 _06733_ _06734_ VGND VGND VPWR VPWR _06735_ sky130_fd_sc_hd__a21bo_1
X_12343_ _03690_ VGND VGND VPWR VPWR _00076_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_133_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15062_ _06557_ _06626_ _06658_ _06659_ VGND VGND VPWR VPWR _06660_ sky130_fd_sc_hd__a211oi_4
X_12274_ _03598_ _03616_ VGND VGND VPWR VPWR _03617_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_50_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11225_ _02410_ _02475_ _02476_ VGND VGND VPWR VPWR _02477_ sky130_fd_sc_hd__nand3_2
X_14013_ _05410_ _05513_ VGND VGND VPWR VPWR _05515_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11156_ net801 net444 _02294_ _02293_ VGND VGND VPWR VPWR _02401_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_4_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10107_ _01367_ _01372_ VGND VGND VPWR VPWR _01373_ sky130_fd_sc_hd__xnor2_1
X_15964_ _04881_ net690 VGND VGND VPWR VPWR _07642_ sky130_fd_sc_hd__or2_1
X_11087_ _02308_ _02324_ _02325_ VGND VGND VPWR VPWR _02326_ sky130_fd_sc_hd__nand3_1
X_10038_ _01075_ _01242_ _01244_ VGND VGND VPWR VPWR _01305_ sky130_fd_sc_hd__a21bo_1
X_14915_ _06072_ _06074_ _06498_ VGND VGND VPWR VPWR _06500_ sky130_fd_sc_hd__and3_1
X_15895_ _07550_ _07493_ _07565_ VGND VGND VPWR VPWR _07567_ sky130_fd_sc_hd__or3b_1
X_14846_ _06412_ _06414_ _06418_ VGND VGND VPWR VPWR _06425_ sky130_fd_sc_hd__a21o_1
XFILLER_0_105_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14777_ _06342_ _06343_ _06348_ VGND VGND VPWR VPWR _06349_ sky130_fd_sc_hd__nand3_2
X_11989_ _03200_ _03223_ VGND VGND VPWR VPWR _03308_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13728_ _05203_ _05204_ VGND VGND VPWR VPWR _05205_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13659_ _05126_ _05129_ VGND VGND VPWR VPWR _05130_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_116_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_140_Right_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16378_ clknet_4_6_0_clk _00091_ net338 VGND VGND VPWR VPWR D_sin\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_53_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15329_ _06949_ _06950_ VGND VGND VPWR VPWR _06951_ sky130_fd_sc_hd__and2b_1
XFILLER_0_112_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout406 net51 VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__buf_6
XFILLER_0_10_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09821_ _01073_ _01091_ VGND VGND VPWR VPWR _01092_ sky130_fd_sc_hd__xnor2_1
Xfanout417 net421 VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__clkbuf_2
Xfanout428 net430 VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__buf_2
Xfanout439 net440 VGND VGND VPWR VPWR net439 sky130_fd_sc_hd__clkbuf_2
X_09752_ net530 _00191_ VGND VGND VPWR VPWR _01024_ sky130_fd_sc_hd__or2_1
X_08703_ _07608_ _08013_ _08014_ VGND VGND VPWR VPWR _08015_ sky130_fd_sc_hd__a21oi_1
X_09683_ _00937_ _00955_ VGND VGND VPWR VPWR _00956_ sky130_fd_sc_hd__xnor2_1
X_08634_ _07303_ _07216_ _07292_ VGND VGND VPWR VPWR _07510_ sky130_fd_sc_hd__nand3_1
XFILLER_0_55_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08565_ _06715_ _06726_ _06748_ VGND VGND VPWR VPWR _06759_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_76_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08496_ _05992_ VGND VGND VPWR VPWR _06003_ sky130_fd_sc_hd__inv_2
XFILLER_0_64_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09117_ net573 net469 _00320_ _00319_ net478 VGND VGND VPWR VPWR _00396_ sky130_fd_sc_hd__a32o_1
XFILLER_0_143_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09048_ _00324_ _00325_ _00326_ VGND VGND VPWR VPWR _00328_ sky130_fd_sc_hd__nand3_1
XFILLER_0_103_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11010_ _02237_ _02240_ _02241_ VGND VGND VPWR VPWR _02242_ sky130_fd_sc_hd__and3_1
XFILLER_0_99_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12961_ _04366_ _04367_ _04368_ VGND VGND VPWR VPWR _04369_ sky130_fd_sc_hd__a21o_1
X_14700_ _06261_ _06262_ _06263_ VGND VGND VPWR VPWR _06264_ sky130_fd_sc_hd__nand3_1
X_11912_ _03222_ _03223_ VGND VGND VPWR VPWR _03224_ sky130_fd_sc_hd__nand2_1
X_15680_ net262 net253 net531 net539 VGND VGND VPWR VPWR _07333_ sky130_fd_sc_hd__and4_1
X_12892_ net517 net215 net205 net615 VGND VGND VPWR VPWR _04294_ sky130_fd_sc_hd__a22oi_2
X_14631_ _06186_ _06185_ _06172_ _06156_ VGND VGND VPWR VPWR _06188_ sky130_fd_sc_hd__o211a_1
X_11843_ _03132_ _03148_ VGND VGND VPWR VPWR _03150_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_68_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14562_ _06074_ _06075_ _06110_ _06111_ VGND VGND VPWR VPWR _06112_ sky130_fd_sc_hd__nand4_4
X_11774_ _02702_ _02797_ _03074_ VGND VGND VPWR VPWR _03075_ sky130_fd_sc_hd__or3b_1
X_16301_ clknet_4_0_0_clk _00014_ net334 VGND VGND VPWR VPWR Q_cos\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_27_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13513_ _04964_ _04969_ VGND VGND VPWR VPWR _04971_ sky130_fd_sc_hd__xor2_2
X_10725_ _01946_ _01948_ VGND VGND VPWR VPWR _01951_ sky130_fd_sc_hd__or2_1
X_14493_ _05971_ _05974_ _06034_ _06035_ VGND VGND VPWR VPWR _06037_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_129_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16232_ _07930_ _07931_ VGND VGND VPWR VPWR _07932_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_126_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13444_ _04893_ _04895_ VGND VGND VPWR VPWR _04896_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_24_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10656_ _01878_ _01881_ VGND VGND VPWR VPWR _01882_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_70_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16163_ _07855_ _07856_ VGND VGND VPWR VPWR _07858_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10587_ _01809_ _01810_ _01811_ VGND VGND VPWR VPWR _01813_ sky130_fd_sc_hd__a21o_1
X_13375_ net234 net194 VGND VGND VPWR VPWR _04821_ sky130_fd_sc_hd__nand2_1
XFILLER_0_106_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15114_ net308 net540 VGND VGND VPWR VPWR _06717_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12326_ net792 net467 _01237_ _03499_ VGND VGND VPWR VPWR _03673_ sky130_fd_sc_hd__a31o_1
XFILLER_0_121_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16094_ _07780_ _07782_ VGND VGND VPWR VPWR _07783_ sky130_fd_sc_hd__xor2_2
XFILLER_0_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15045_ net195 net676 VGND VGND VPWR VPWR _06642_ sky130_fd_sc_hd__and2_1
X_12257_ _03354_ _03544_ _03597_ VGND VGND VPWR VPWR _03598_ sky130_fd_sc_hd__a21o_1
XFILLER_0_76_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11208_ _02456_ _02457_ net151 net414 VGND VGND VPWR VPWR _02458_ sky130_fd_sc_hd__and4bb_2
X_12188_ _03521_ _03523_ VGND VGND VPWR VPWR _03524_ sky130_fd_sc_hd__xnor2_2
X_11139_ _02282_ _02382_ VGND VGND VPWR VPWR _02383_ sky130_fd_sc_hd__xor2_1
X_15947_ _07613_ _07611_ VGND VGND VPWR VPWR _07623_ sky130_fd_sc_hd__and2b_1
X_15878_ _07537_ _07535_ VGND VGND VPWR VPWR _07548_ sky130_fd_sc_hd__and2b_1
X_14829_ _06321_ _06368_ _06367_ VGND VGND VPWR VPWR _06406_ sky130_fd_sc_hd__a21o_1
X_08350_ _03637_ _04075_ _04393_ _04404_ VGND VGND VPWR VPWR _04415_ sky130_fd_sc_hd__a211o_1
XFILLER_0_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08281_ _02757_ _02779_ _02768_ VGND VGND VPWR VPWR _03658_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_74_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_870 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout203 net209 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__clkbuf_4
Xfanout214 net219 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout225 net226 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__clkbuf_4
Xfanout236 net7 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__clkbuf_4
X_09804_ _01074_ VGND VGND VPWR VPWR _01075_ sky130_fd_sc_hd__inv_2
Xfanout247 net248 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout258 net259 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__clkbuf_2
Xfanout269 net65 VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__buf_6
X_09735_ _01005_ _00932_ _01003_ _01004_ VGND VGND VPWR VPWR _01007_ sky130_fd_sc_hd__o211ai_4
X_09666_ _00938_ _00847_ VGND VGND VPWR VPWR _00939_ sky130_fd_sc_hd__or2_1
X_08617_ _07184_ _07194_ _07314_ VGND VGND VPWR VPWR _07325_ sky130_fd_sc_hd__and3_1
X_09597_ net689 net530 net456 net447 VGND VGND VPWR VPWR _00871_ sky130_fd_sc_hd__and4_1
X_08548_ _06541_ _06552_ _06563_ VGND VGND VPWR VPWR _06574_ sky130_fd_sc_hd__nand3_2
XFILLER_0_37_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08479_ _05720_ _05709_ _05698_ _05579_ VGND VGND VPWR VPWR _05817_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_64_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10510_ _01732_ _01734_ _01733_ VGND VGND VPWR VPWR _01736_ sky130_fd_sc_hd__a21o_1
X_11490_ net426 net359 _02763_ _02764_ VGND VGND VPWR VPWR _02765_ sky130_fd_sc_hd__a22o_1
XFILLER_0_134_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10441_ _01665_ _01666_ VGND VGND VPWR VPWR _01667_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10372_ D_sin\[17\] Q_cos\[17\] VGND VGND VPWR VPWR _01601_ sky130_fd_sc_hd__or2b_1
X_13160_ _04565_ _04584_ _04585_ VGND VGND VPWR VPWR _04586_ sky130_fd_sc_hd__and3_1
X_12111_ net227 net467 VGND VGND VPWR VPWR _03440_ sky130_fd_sc_hd__nand2_1
X_13091_ _04508_ _04509_ _04510_ VGND VGND VPWR VPWR _04511_ sky130_fd_sc_hd__nand3_4
XFILLER_0_20_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12042_ _03270_ _03364_ VGND VGND VPWR VPWR _03365_ sky130_fd_sc_hd__and2b_1
X_15801_ _07384_ _07392_ _07463_ VGND VGND VPWR VPWR _07464_ sky130_fd_sc_hd__a21o_1
Xfanout770 net771 VGND VGND VPWR VPWR net770 sky130_fd_sc_hd__clkbuf_2
Xfanout781 net782 VGND VGND VPWR VPWR net781 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout792 net794 VGND VGND VPWR VPWR net792 sky130_fd_sc_hd__buf_2
X_13993_ _05448_ _05452_ _05450_ VGND VGND VPWR VPWR _05493_ sky130_fd_sc_hd__o21ba_1
X_15732_ _07387_ _07388_ VGND VGND VPWR VPWR _07389_ sky130_fd_sc_hd__xnor2_1
X_12944_ _04247_ _04350_ VGND VGND VPWR VPWR _04351_ sky130_fd_sc_hd__nand2_1
XFILLER_0_88_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15663_ _07306_ _07313_ VGND VGND VPWR VPWR _07315_ sky130_fd_sc_hd__xnor2_1
X_12875_ _04258_ _04259_ _04275_ VGND VGND VPWR VPWR _04276_ sky130_fd_sc_hd__a21o_1
X_14614_ _06164_ _06169_ VGND VGND VPWR VPWR _06170_ sky130_fd_sc_hd__xnor2_2
X_11826_ net740 _00192_ _03056_ _03130_ VGND VGND VPWR VPWR _03131_ sky130_fd_sc_hd__o31ai_2
X_15594_ _07131_ _07133_ VGND VGND VPWR VPWR _07240_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14545_ net220 net669 VGND VGND VPWR VPWR _06094_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11757_ _03053_ _03055_ VGND VGND VPWR VPWR _03056_ sky130_fd_sc_hd__xor2_2
XFILLER_0_138_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10708_ _01909_ _01932_ _01933_ VGND VGND VPWR VPWR _01934_ sky130_fd_sc_hd__a21oi_1
X_14476_ _06013_ _06017_ VGND VGND VPWR VPWR _06018_ sky130_fd_sc_hd__xnor2_1
X_11688_ _02897_ _02980_ VGND VGND VPWR VPWR _02981_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_71_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16215_ _07891_ _07892_ _07913_ VGND VGND VPWR VPWR _07914_ sky130_fd_sc_hd__a21o_1
XFILLER_0_11_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13427_ _04874_ _04876_ VGND VGND VPWR VPWR _04877_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_23_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10639_ net709 net741 net527 net399 VGND VGND VPWR VPWR _01865_ sky130_fd_sc_hd__and4_1
XFILLER_0_11_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16146_ net270 net628 _07837_ VGND VGND VPWR VPWR _07839_ sky130_fd_sc_hd__and3_1
X_13358_ _04798_ _04799_ _04800_ VGND VGND VPWR VPWR _04802_ sky130_fd_sc_hd__a21o_1
X_12309_ _03654_ VGND VGND VPWR VPWR _00075_ sky130_fd_sc_hd__clkbuf_1
X_16077_ _07702_ _07764_ VGND VGND VPWR VPWR _07765_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_121_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13289_ _04724_ _04725_ _04726_ VGND VGND VPWR VPWR _04727_ sky130_fd_sc_hd__nand3_1
X_15028_ _06602_ _06621_ _06622_ VGND VGND VPWR VPWR _06623_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput3 D[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_1
X_09520_ _00789_ _00794_ VGND VGND VPWR VPWR _00795_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_36_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09451_ _00724_ _00726_ VGND VGND VPWR VPWR _00727_ sky130_fd_sc_hd__or2_1
XFILLER_0_149_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08402_ net577 net377 net368 net587 VGND VGND VPWR VPWR _04981_ sky130_fd_sc_hd__a22oi_1
X_09382_ _00657_ _00658_ VGND VGND VPWR VPWR _00659_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08333_ _04207_ _04218_ VGND VGND VPWR VPWR _04229_ sky130_fd_sc_hd__nor2_1
XFILLER_0_117_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08264_ net677 net413 VGND VGND VPWR VPWR _03474_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08195_ net536 net409 net398 net544 VGND VGND VPWR VPWR _02724_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_116_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09718_ net635 net493 _00986_ _00988_ VGND VGND VPWR VPWR _00990_ sky130_fd_sc_hd__and4_1
X_10990_ net747 net499 VGND VGND VPWR VPWR _02220_ sky130_fd_sc_hd__and2_1
XFILLER_0_96_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09649_ _00919_ _00920_ _00903_ VGND VGND VPWR VPWR _00922_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_69_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12660_ _04023_ _04037_ _04038_ VGND VGND VPWR VPWR _04039_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_93_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11611_ _02890_ _02892_ _02895_ VGND VGND VPWR VPWR _02896_ sky130_fd_sc_hd__o21a_1
XFILLER_0_38_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12591_ _03918_ _03919_ _03917_ VGND VGND VPWR VPWR _03963_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_108_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14330_ net169 net581 VGND VGND VPWR VPWR _05857_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11542_ _02727_ _02729_ _02820_ VGND VGND VPWR VPWR _02821_ sky130_fd_sc_hd__a21o_1
XFILLER_0_52_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14261_ _05722_ _05725_ _05781_ VGND VGND VPWR VPWR _05783_ sky130_fd_sc_hd__a21o_1
X_11473_ _02744_ _02745_ VGND VGND VPWR VPWR _02747_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_107_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16000_ _07647_ _07648_ _07680_ VGND VGND VPWR VPWR _07681_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_123_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13212_ _04641_ _04642_ VGND VGND VPWR VPWR _04643_ sky130_fd_sc_hd__or2_1
XFILLER_0_150_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10424_ _01648_ _01649_ net803 net498 VGND VGND VPWR VPWR _01650_ sky130_fd_sc_hd__and4bb_1
X_14192_ _05510_ _05665_ _05507_ VGND VGND VPWR VPWR _05708_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_104_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13143_ net750 net283 VGND VGND VPWR VPWR _04568_ sky130_fd_sc_hd__and2_1
X_10355_ _01576_ _01582_ _01585_ VGND VGND VPWR VPWR _01587_ sky130_fd_sc_hd__nor3_1
XFILLER_0_103_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10286_ _01525_ _01526_ VGND VGND VPWR VPWR _01527_ sky130_fd_sc_hd__nand2_1
X_13074_ _04483_ _04492_ VGND VGND VPWR VPWR _04493_ sky130_fd_sc_hd__xor2_2
XFILLER_0_20_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12025_ _03249_ _03253_ VGND VGND VPWR VPWR _03347_ sky130_fd_sc_hd__or2_1
X_13976_ _05388_ _05390_ VGND VGND VPWR VPWR _05475_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15715_ Q_sin\[9\] _07371_ _00186_ VGND VGND VPWR VPWR _07372_ sky130_fd_sc_hd__mux2_1
X_12927_ _04331_ _04332_ VGND VGND VPWR VPWR _04333_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15646_ _07222_ _07234_ _07220_ VGND VGND VPWR VPWR _07296_ sky130_fd_sc_hd__a21o_1
X_12858_ _04213_ _04220_ VGND VGND VPWR VPWR _04257_ sky130_fd_sc_hd__and2_1
XFILLER_0_84_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11809_ net316 net496 _03110_ _03111_ VGND VGND VPWR VPWR _03112_ sky130_fd_sc_hd__a22o_1
XFILLER_0_145_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15577_ _07060_ _07215_ _07219_ VGND VGND VPWR VPWR _07221_ sky130_fd_sc_hd__or3_1
X_12789_ net216 net617 net708 net206 VGND VGND VPWR VPWR _04181_ sky130_fd_sc_hd__a22oi_2
X_14528_ _06072_ _06073_ _06051_ _06052_ VGND VGND VPWR VPWR _06075_ sky130_fd_sc_hd__a211o_4
XFILLER_0_4_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14459_ net188 net542 net550 net178 VGND VGND VPWR VPWR _05999_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_71_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16129_ _07819_ _07820_ VGND VGND VPWR VPWR _07821_ sky130_fd_sc_hd__xor2_1
X_08951_ _00229_ _00230_ _00222_ VGND VGND VPWR VPWR _00232_ sky130_fd_sc_hd__a21o_1
X_08882_ _08092_ net867 _08099_ VGND VGND VPWR VPWR _00164_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_138_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09503_ _00691_ _00700_ _00777_ VGND VGND VPWR VPWR _00778_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_79_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09434_ _00708_ _00709_ VGND VGND VPWR VPWR _00710_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_87_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09365_ _00639_ _00641_ VGND VGND VPWR VPWR _00642_ sky130_fd_sc_hd__xor2_1
XFILLER_0_93_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08316_ _03855_ _03866_ _04020_ VGND VGND VPWR VPWR _04042_ sky130_fd_sc_hd__nand3_2
XFILLER_0_75_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09296_ net583 _00192_ _00500_ _00572_ VGND VGND VPWR VPWR _00573_ sky130_fd_sc_hd__o31ai_2
XANTENNA_30 net556 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_35_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_41 state VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_52 net307 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_63 net518 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_144_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08247_ _03170_ _03149_ _03160_ VGND VGND VPWR VPWR _03290_ sky130_fd_sc_hd__or3_1
XFILLER_0_62_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08178_ _02485_ _02528_ VGND VGND VPWR VPWR _02539_ sky130_fd_sc_hd__xnor2_1
X_10140_ _01397_ _01400_ net135 VGND VGND VPWR VPWR _01402_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_112_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10071_ _01290_ _01336_ VGND VGND VPWR VPWR _01338_ sky130_fd_sc_hd__nor2_1
X_13830_ _05233_ _05315_ VGND VGND VPWR VPWR _05316_ sky130_fd_sc_hd__xnor2_4
X_13761_ net431 net289 net280 net512 VGND VGND VPWR VPWR _05240_ sky130_fd_sc_hd__a22oi_2
X_10973_ _02196_ _02200_ VGND VGND VPWR VPWR _02202_ sky130_fd_sc_hd__xnor2_1
X_15500_ _07117_ _07135_ _07136_ VGND VGND VPWR VPWR _07137_ sky130_fd_sc_hd__and3_1
X_12712_ _04049_ _04055_ _04048_ VGND VGND VPWR VPWR _04096_ sky130_fd_sc_hd__a21bo_1
X_13692_ _04930_ _05082_ _05164_ VGND VGND VPWR VPWR _05165_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_38_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15431_ _07059_ _07061_ VGND VGND VPWR VPWR _07062_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12643_ _03879_ _03906_ _04016_ _04019_ VGND VGND VPWR VPWR _04021_ sky130_fd_sc_hd__o211a_1
XFILLER_0_38_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15362_ _06783_ _06985_ _06986_ VGND VGND VPWR VPWR _06987_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_93_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12574_ _03781_ _03783_ _03782_ VGND VGND VPWR VPWR _03945_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_136_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14313_ net263 net148 _05772_ VGND VGND VPWR VPWR _05840_ sky130_fd_sc_hd__nand3_1
X_11525_ _02736_ _02719_ VGND VGND VPWR VPWR _02803_ sky130_fd_sc_hd__and2b_1
X_15293_ _06908_ _06910_ VGND VGND VPWR VPWR _06912_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_80_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14244_ _05507_ _05706_ _05762_ VGND VGND VPWR VPWR _05765_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_7_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11456_ _02612_ _02616_ _02613_ VGND VGND VPWR VPWR _02728_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_34_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10407_ net761 net354 net507 net771 VGND VGND VPWR VPWR _01633_ sky130_fd_sc_hd__a22oi_2
X_14175_ _05628_ VGND VGND VPWR VPWR _05690_ sky130_fd_sc_hd__inv_2
XFILLER_0_1_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11387_ _02651_ _02652_ VGND VGND VPWR VPWR _02653_ sky130_fd_sc_hd__nor2_1
XFILLER_0_104_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13126_ net758 net268 VGND VGND VPWR VPWR _04549_ sky130_fd_sc_hd__nand2_1
X_10338_ _01563_ _01567_ _01571_ VGND VGND VPWR VPWR _01572_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_103_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13057_ _04464_ _04472_ _04473_ VGND VGND VPWR VPWR _04474_ sky130_fd_sc_hd__nand3_1
X_10269_ Q_cos\[3\] D_sin\[3\] VGND VGND VPWR VPWR _01512_ sky130_fd_sc_hd__or2b_1
XFILLER_0_84_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12008_ _03326_ _03327_ VGND VGND VPWR VPWR _03328_ sky130_fd_sc_hd__nor2_1
XFILLER_0_108_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13959_ _05454_ _05455_ VGND VGND VPWR VPWR _05456_ sky130_fd_sc_hd__xor2_1
XFILLER_0_76_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15629_ _07277_ VGND VGND VPWR VPWR _00104_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_118_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09150_ _00427_ _00428_ VGND VGND VPWR VPWR _00429_ sky130_fd_sc_hd__and2b_1
XFILLER_0_84_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09081_ _00352_ _00359_ _00360_ VGND VGND VPWR VPWR _00361_ sky130_fd_sc_hd__nand3_1
XFILLER_0_140_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput50 cos[2] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_1
Xinput61 sin[11] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_142_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput72 sin[4] VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__buf_1
XFILLER_0_12_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09983_ _01069_ _01211_ _01249_ VGND VGND VPWR VPWR _01251_ sky130_fd_sc_hd__a21o_1
XFILLER_0_149_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08934_ _00137_ _00169_ _00170_ VGND VGND VPWR VPWR _00215_ sky130_fd_sc_hd__nor3_1
XFILLER_0_58_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08865_ _00145_ _00146_ VGND VGND VPWR VPWR _00147_ sky130_fd_sc_hd__and2b_1
X_08796_ _08104_ net859 _08087_ VGND VGND VPWR VPWR _08107_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_79_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09417_ _00614_ _00617_ VGND VGND VPWR VPWR _00693_ sky130_fd_sc_hd__nand2_1
XFILLER_0_137_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09348_ _00536_ _00538_ _00537_ VGND VGND VPWR VPWR _00625_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_63_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09279_ _00412_ _00461_ _00556_ VGND VGND VPWR VPWR _00557_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_117_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11310_ _02413_ _02428_ _02429_ _02433_ VGND VGND VPWR VPWR _02569_ sky130_fd_sc_hd__a31o_1
X_12290_ _03618_ _03619_ _03633_ VGND VGND VPWR VPWR _03634_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_50_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11241_ _02490_ _02493_ VGND VGND VPWR VPWR _02494_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_120_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11172_ _02414_ _02417_ VGND VGND VPWR VPWR _02418_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_101_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10123_ _01384_ _01385_ _01382_ VGND VGND VPWR VPWR _01387_ sky130_fd_sc_hd__a21oi_1
X_15980_ net277 net647 net637 net286 VGND VGND VPWR VPWR _07659_ sky130_fd_sc_hd__a22oi_2
X_10054_ _01319_ _01320_ VGND VGND VPWR VPWR _01321_ sky130_fd_sc_hd__nand2_1
X_14931_ _06514_ _06515_ _06516_ VGND VGND VPWR VPWR _06517_ sky130_fd_sc_hd__nand3_1
X_14862_ net213 net700 _06439_ _06441_ VGND VGND VPWR VPWR _06442_ sky130_fd_sc_hd__and4_1
XFILLER_0_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13813_ _05295_ _05296_ VGND VGND VPWR VPWR _05298_ sky130_fd_sc_hd__xnor2_1
X_14793_ _06330_ _06364_ _06365_ VGND VGND VPWR VPWR _06367_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_121_Right_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13744_ _05132_ _05222_ VGND VGND VPWR VPWR _05223_ sky130_fd_sc_hd__nand2_1
X_10956_ _02087_ _02180_ _01960_ _02184_ _01950_ VGND VGND VPWR VPWR _02185_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_39_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13675_ net519 net611 net289 net280 VGND VGND VPWR VPWR _05147_ sky130_fd_sc_hd__and4_1
X_10887_ _02109_ _02112_ VGND VGND VPWR VPWR _02113_ sky130_fd_sc_hd__xor2_1
X_15414_ net183 net173 net651 net660 VGND VGND VPWR VPWR _07044_ sky130_fd_sc_hd__nand4_1
XFILLER_0_128_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12626_ _03993_ _03994_ _04001_ VGND VGND VPWR VPWR _04002_ sky130_fd_sc_hd__a21oi_1
X_16394_ clknet_4_1_0_clk _00107_ net339 VGND VGND VPWR VPWR Q_sin\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_53_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15345_ _06941_ _06968_ VGND VGND VPWR VPWR _06969_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_108_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12557_ net217 net737 net745 net207 VGND VGND VPWR VPWR _03926_ sky130_fd_sc_hd__a22o_1
XFILLER_0_53_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11508_ _02783_ _02784_ VGND VGND VPWR VPWR _02785_ sky130_fd_sc_hd__xor2_2
X_15276_ _00187_ _06891_ _06892_ _06893_ VGND VGND VPWR VPWR _00100_ sky130_fd_sc_hd__a31oi_1
X_12488_ net330 net772 net780 net245 VGND VGND VPWR VPWR _03850_ sky130_fd_sc_hd__a22o_1
XFILLER_0_22_730 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold108 Q_cos\[17\] VGND VGND VPWR VPWR net914 sky130_fd_sc_hd__dlygate4sd3_1
Xhold119 net103 VGND VGND VPWR VPWR net925 sky130_fd_sc_hd__dlygate4sd3_1
X_14227_ _05745_ _05746_ VGND VGND VPWR VPWR _05747_ sky130_fd_sc_hd__xnor2_1
X_11439_ _02707_ _02708_ _02702_ VGND VGND VPWR VPWR _02710_ sky130_fd_sc_hd__a21o_1
XFILLER_0_110_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14158_ _05651_ _05652_ _05671_ VGND VGND VPWR VPWR _05672_ sky130_fd_sc_hd__o21ai_1
X_13109_ _04529_ _04530_ VGND VGND VPWR VPWR _04531_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14089_ net230 net271 VGND VGND VPWR VPWR _05597_ sky130_fd_sc_hd__nand2_1
X_08650_ _07510_ _07521_ _07673_ VGND VGND VPWR VPWR _07684_ sky130_fd_sc_hd__nand3_1
X_08581_ _06911_ _06900_ _06835_ _06813_ VGND VGND VPWR VPWR _06933_ sky130_fd_sc_hd__o211a_1
XFILLER_0_44_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09202_ _00390_ _00465_ VGND VGND VPWR VPWR _00480_ sky130_fd_sc_hd__or2b_1
XFILLER_0_17_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09133_ _00394_ _00411_ VGND VGND VPWR VPWR _00412_ sky130_fd_sc_hd__xor2_1
XFILLER_0_56_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09064_ net684 net357 VGND VGND VPWR VPWR _00344_ sky130_fd_sc_hd__nand2_1
XFILLER_0_71_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09966_ _01232_ _01229_ _01233_ VGND VGND VPWR VPWR _01234_ sky130_fd_sc_hd__o21bai_1
X_08917_ net488 _00118_ _00121_ _00119_ VGND VGND VPWR VPWR _00198_ sky130_fd_sc_hd__a22o_1
X_09897_ _01165_ _01097_ _01163_ _01164_ VGND VGND VPWR VPWR _01167_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_85_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08848_ _00126_ _00127_ _00128_ VGND VGND VPWR VPWR _00130_ sky130_fd_sc_hd__a21o_1
X_08779_ net667 net404 net393 net677 VGND VGND VPWR VPWR _08090_ sky130_fd_sc_hd__a22oi_2
X_10810_ _01993_ _01994_ _01995_ VGND VGND VPWR VPWR _02036_ sky130_fd_sc_hd__and3_1
X_11790_ net796 _00851_ _03089_ _03090_ VGND VGND VPWR VPWR _03091_ sky130_fd_sc_hd__a31o_1
XFILLER_0_39_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10741_ _01895_ _01966_ VGND VGND VPWR VPWR _01967_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_137_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13460_ net234 net319 net933 net174 VGND VGND VPWR VPWR _04913_ sky130_fd_sc_hd__nand4_2
XFILLER_0_36_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10672_ _01895_ _01896_ _01897_ VGND VGND VPWR VPWR _01898_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_63_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12411_ _03762_ _03763_ _03747_ VGND VGND VPWR VPWR _03765_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_125_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13391_ _04784_ _04837_ VGND VGND VPWR VPWR _04838_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15130_ net210 net652 net643 net220 VGND VGND VPWR VPWR _06734_ sky130_fd_sc_hd__a22o_1
XFILLER_0_105_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12342_ D_cos\[18\] _03689_ _03242_ VGND VGND VPWR VPWR _03690_ sky130_fd_sc_hd__mux2_1
XFILLER_0_106_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15061_ _06656_ _06657_ _06637_ VGND VGND VPWR VPWR _06659_ sky130_fd_sc_hd__a21oi_2
X_12273_ _03613_ _03614_ VGND VGND VPWR VPWR _03616_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_105_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14012_ _05349_ _05432_ VGND VGND VPWR VPWR _05513_ sky130_fd_sc_hd__nor2_1
X_11224_ _02472_ _02473_ _02366_ _02411_ VGND VGND VPWR VPWR _02476_ sky130_fd_sc_hd__a211o_1
XFILLER_0_121_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11155_ _02392_ _02399_ VGND VGND VPWR VPWR _02400_ sky130_fd_sc_hd__xor2_1
XFILLER_0_101_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10106_ _01370_ _01371_ VGND VGND VPWR VPWR _01372_ sky130_fd_sc_hd__xnor2_1
X_15963_ _07636_ _07639_ VGND VGND VPWR VPWR _07641_ sky130_fd_sc_hd__xnor2_1
X_11086_ _02322_ _02323_ _02314_ VGND VGND VPWR VPWR _02325_ sky130_fd_sc_hd__a21o_1
X_10037_ _01268_ _01270_ _01274_ VGND VGND VPWR VPWR _01304_ sky130_fd_sc_hd__o21ai_2
X_14914_ _06072_ _06074_ _06498_ VGND VGND VPWR VPWR _06499_ sky130_fd_sc_hd__a21oi_2
X_15894_ _07550_ _07493_ _07565_ VGND VGND VPWR VPWR _07566_ sky130_fd_sc_hd__o21bai_1
X_14845_ _06422_ _06423_ VGND VGND VPWR VPWR _06424_ sky130_fd_sc_hd__nor2_1
XFILLER_0_98_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14776_ _06345_ _06346_ _06347_ VGND VGND VPWR VPWR _06348_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_86_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11988_ _03283_ _03306_ VGND VGND VPWR VPWR _03307_ sky130_fd_sc_hd__xnor2_2
X_13727_ net739 _04537_ VGND VGND VPWR VPWR _05204_ sky130_fd_sc_hd__or2_1
X_10939_ _02076_ _02165_ VGND VGND VPWR VPWR _02166_ sky130_fd_sc_hd__and2_1
XFILLER_0_86_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13658_ _04980_ _05127_ _05128_ VGND VGND VPWR VPWR _05129_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_73_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12609_ net171 net773 _03980_ _03981_ VGND VGND VPWR VPWR _03983_ sky130_fd_sc_hd__a22o_1
XFILLER_0_6_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16377_ clknet_4_1_0_clk _00090_ net332 VGND VGND VPWR VPWR D_sin\[13\] sky130_fd_sc_hd__dfrtp_1
X_13589_ _05046_ _05048_ _05045_ VGND VGND VPWR VPWR _05053_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_143_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15328_ _06947_ _06948_ _06943_ VGND VGND VPWR VPWR _06950_ sky130_fd_sc_hd__a21o_1
X_15259_ _06840_ _06873_ _06874_ VGND VGND VPWR VPWR _06875_ sky130_fd_sc_hd__nand3_2
XFILLER_0_112_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout407 net408 VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__buf_2
X_09820_ _01075_ _01090_ VGND VGND VPWR VPWR _01091_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_111_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout418 net419 VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__buf_4
XFILLER_0_39_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout429 net430 VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__buf_6
X_09751_ _01019_ _01022_ VGND VGND VPWR VPWR _01023_ sky130_fd_sc_hd__xnor2_2
X_08702_ net606 net701 net525 net436 VGND VGND VPWR VPWR _08014_ sky130_fd_sc_hd__nand4_1
X_09682_ _00939_ _00954_ VGND VGND VPWR VPWR _00955_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_146_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08633_ _07064_ _07434_ _07466_ _06966_ VGND VGND VPWR VPWR _07499_ sky130_fd_sc_hd__a31o_1
XFILLER_0_77_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08564_ _04861_ _06737_ VGND VGND VPWR VPWR _06748_ sky130_fd_sc_hd__or2_1
XFILLER_0_89_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08495_ _04851_ _05981_ VGND VGND VPWR VPWR _05992_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_77_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09116_ _00317_ _00336_ _00334_ VGND VGND VPWR VPWR _00395_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_134_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09047_ _00324_ _00325_ _00326_ VGND VGND VPWR VPWR _00327_ sky130_fd_sc_hd__a21o_1
XFILLER_0_142_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09949_ _01216_ _01217_ _01161_ _01164_ VGND VGND VPWR VPWR _01218_ sky130_fd_sc_hd__a211oi_1
X_12960_ net749 net302 VGND VGND VPWR VPWR _04368_ sky130_fd_sc_hd__and2_1
X_11911_ _03199_ _03200_ _03221_ VGND VGND VPWR VPWR _03223_ sky130_fd_sc_hd__nand3_1
X_12891_ net517 net214 net205 net614 VGND VGND VPWR VPWR _04293_ sky130_fd_sc_hd__and4_1
X_14630_ _06156_ _06172_ _06185_ _06186_ VGND VGND VPWR VPWR _06187_ sky130_fd_sc_hd__a211oi_4
X_11842_ _03146_ _03147_ VGND VGND VPWR VPWR _03148_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_67_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14561_ _06108_ _06109_ _05994_ _06076_ VGND VGND VPWR VPWR _06111_ sky130_fd_sc_hd__o211ai_2
X_11773_ _02890_ _02981_ VGND VGND VPWR VPWR _03074_ sky130_fd_sc_hd__and2b_1
XFILLER_0_83_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16300_ clknet_4_0_0_clk _00013_ net332 VGND VGND VPWR VPWR Q_cos\[13\] sky130_fd_sc_hd__dfrtp_1
X_13512_ _04967_ _04968_ VGND VGND VPWR VPWR _04969_ sky130_fd_sc_hd__nor2_1
XFILLER_0_82_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10724_ _01940_ _01942_ _01948_ _01949_ VGND VGND VPWR VPWR _01950_ sky130_fd_sc_hd__a211o_1
X_14492_ _06033_ _06008_ _06009_ _06032_ VGND VGND VPWR VPWR _06035_ sky130_fd_sc_hd__and4_4
XFILLER_0_138_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16231_ _07847_ _07875_ VGND VGND VPWR VPWR _07931_ sky130_fd_sc_hd__nor2_1
X_13443_ net731 net275 VGND VGND VPWR VPWR _04895_ sky130_fd_sc_hd__nand2_1
X_10655_ _01879_ _01880_ VGND VGND VPWR VPWR _01881_ sky130_fd_sc_hd__nor2_1
X_16162_ net262 net253 net648 net638 VGND VGND VPWR VPWR _07856_ sky130_fd_sc_hd__and4_1
X_13374_ net144 _04817_ _04819_ VGND VGND VPWR VPWR _04820_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_35_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10586_ _01809_ _01810_ _01811_ VGND VGND VPWR VPWR _01812_ sky130_fd_sc_hd__nand3_4
XFILLER_0_50_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15113_ net166 net159 net693 net532 VGND VGND VPWR VPWR _06716_ sky130_fd_sc_hd__nand4_1
X_12325_ _03620_ _03629_ _03349_ VGND VGND VPWR VPWR _03672_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_11_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16093_ _07709_ _07712_ _07710_ VGND VGND VPWR VPWR _07782_ sky130_fd_sc_hd__o21ba_1
X_15044_ net661 _06638_ _06640_ VGND VGND VPWR VPWR _06641_ sky130_fd_sc_hd__a21bo_1
X_12256_ _03538_ _03545_ VGND VGND VPWR VPWR _03597_ sky130_fd_sc_hd__and2_1
X_11207_ net233 net406 net48 VGND VGND VPWR VPWR _02457_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_79_Left_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12187_ _03522_ _03434_ VGND VGND VPWR VPWR _03523_ sky130_fd_sc_hd__nand2_1
X_11138_ _02379_ _02381_ VGND VGND VPWR VPWR _02382_ sky130_fd_sc_hd__xnor2_1
X_15946_ _07609_ _07610_ VGND VGND VPWR VPWR _07622_ sky130_fd_sc_hd__and2b_1
X_11069_ _02203_ _02305_ VGND VGND VPWR VPWR _02306_ sky130_fd_sc_hd__xor2_1
XFILLER_0_92_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15877_ _07539_ _07542_ _07546_ VGND VGND VPWR VPWR _07547_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_116_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14828_ _06371_ _06404_ VGND VGND VPWR VPWR _06405_ sky130_fd_sc_hd__and2_1
XFILLER_0_148_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14759_ _06326_ _06327_ _06318_ _06321_ VGND VGND VPWR VPWR _06329_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_74_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08280_ _03604_ _03626_ _03615_ VGND VGND VPWR VPWR _03648_ sky130_fd_sc_hd__a21o_1
XFILLER_0_27_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout204 net835 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__clkbuf_4
Xfanout215 net219 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__buf_2
Xfanout226 net70 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__buf_12
X_09803_ _00926_ _00999_ _00979_ VGND VGND VPWR VPWR _01074_ sky130_fd_sc_hd__a21boi_4
Xfanout237 net69 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__buf_4
Xfanout248 net67 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__buf_4
Xfanout259 net260 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__clkbuf_4
X_09734_ _01003_ _01004_ _01005_ _00932_ VGND VGND VPWR VPWR _01006_ sky130_fd_sc_hd__a211o_1
X_09665_ _00830_ _00831_ _00844_ VGND VGND VPWR VPWR _00938_ sky130_fd_sc_hd__a21oi_1
X_08616_ _07216_ _07292_ _07303_ VGND VGND VPWR VPWR _07314_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_96_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09596_ net689 net456 net447 net530 VGND VGND VPWR VPWR _00870_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_82_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08547_ _05547_ _05536_ _05460_ VGND VGND VPWR VPWR _06563_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08478_ _05785_ _05796_ VGND VGND VPWR VPWR _05807_ sky130_fd_sc_hd__nor2_1
XFILLER_0_92_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10440_ net733 net381 net371 net741 VGND VGND VPWR VPWR _01666_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_32_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10371_ net129 _01598_ _01599_ _01600_ VGND VGND VPWR VPWR _00054_ sky130_fd_sc_hd__a31o_1
XFILLER_0_131_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12110_ _03437_ _03438_ VGND VGND VPWR VPWR _03439_ sky130_fd_sc_hd__nor2_1
XFILLER_0_130_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13090_ _04399_ _04408_ _04407_ VGND VGND VPWR VPWR _04510_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_131_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12041_ net349 net502 net792 VGND VGND VPWR VPWR _03364_ sky130_fd_sc_hd__o21a_1
XFILLER_0_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout760 net761 VGND VGND VPWR VPWR net760 sky130_fd_sc_hd__clkbuf_4
X_15800_ _07391_ _07389_ VGND VGND VPWR VPWR _07463_ sky130_fd_sc_hd__and2b_1
Xfanout771 net13 VGND VGND VPWR VPWR net771 sky130_fd_sc_hd__buf_2
Xfanout782 net12 VGND VGND VPWR VPWR net782 sky130_fd_sc_hd__buf_2
X_13992_ _05485_ _05490_ VGND VGND VPWR VPWR _05491_ sky130_fd_sc_hd__xnor2_1
Xfanout793 net794 VGND VGND VPWR VPWR net793 sky130_fd_sc_hd__dlymetal6s2s_1
X_15731_ net936 net657 VGND VGND VPWR VPWR _07388_ sky130_fd_sc_hd__nand2_1
X_12943_ _04347_ _04348_ VGND VGND VPWR VPWR _04350_ sky130_fd_sc_hd__nor2_1
XFILLER_0_87_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15662_ _07311_ _07312_ VGND VGND VPWR VPWR _07313_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_62_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12874_ _04266_ _04274_ VGND VGND VPWR VPWR _04275_ sky130_fd_sc_hd__xnor2_1
X_14613_ _06165_ _06166_ _06167_ VGND VGND VPWR VPWR _06169_ sky130_fd_sc_hd__o21ba_1
X_11825_ _03053_ _03055_ VGND VGND VPWR VPWR _03130_ sky130_fd_sc_hd__or2b_1
X_15593_ _07235_ _07237_ VGND VGND VPWR VPWR _07239_ sky130_fd_sc_hd__xnor2_2
X_14544_ _06088_ _06092_ VGND VGND VPWR VPWR _06093_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_95_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11756_ _02912_ _02914_ _03054_ VGND VGND VPWR VPWR _03055_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_28_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10707_ _01906_ _01908_ VGND VGND VPWR VPWR _01933_ sky130_fd_sc_hd__and2_1
XFILLER_0_127_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14475_ _06015_ _06016_ VGND VGND VPWR VPWR _06017_ sky130_fd_sc_hd__nor2_1
X_11687_ _02977_ _02979_ VGND VGND VPWR VPWR _02980_ sky130_fd_sc_hd__xor2_2
XFILLER_0_11_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16214_ _07894_ _07912_ VGND VGND VPWR VPWR _07913_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_102_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13426_ _04875_ VGND VGND VPWR VPWR _04876_ sky130_fd_sc_hd__inv_2
XFILLER_0_125_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10638_ net709 net527 net399 net741 VGND VGND VPWR VPWR _01864_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_107_871 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16145_ net270 net628 _07837_ VGND VGND VPWR VPWR _07838_ sky130_fd_sc_hd__a21oi_1
X_13357_ _04798_ _04799_ _04800_ VGND VGND VPWR VPWR _04801_ sky130_fd_sc_hd__nand3_1
X_10569_ _01786_ _01794_ VGND VGND VPWR VPWR _01795_ sky130_fd_sc_hd__xor2_2
XFILLER_0_23_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12308_ D_cos\[17\] _03653_ _03242_ VGND VGND VPWR VPWR _03654_ sky130_fd_sc_hd__mux2_1
X_16076_ _07689_ _07763_ VGND VGND VPWR VPWR _07764_ sky130_fd_sc_hd__xor2_2
XFILLER_0_87_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13288_ _04606_ _04615_ _04614_ VGND VGND VPWR VPWR _04726_ sky130_fd_sc_hd__a21bo_1
X_15027_ _06619_ _06620_ _06603_ VGND VGND VPWR VPWR _06622_ sky130_fd_sc_hd__a21o_1
X_12239_ _03553_ _03578_ VGND VGND VPWR VPWR _03579_ sky130_fd_sc_hd__nor2_1
Xinput4 D[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_1
X_15929_ _07602_ _07603_ VGND VGND VPWR VPWR _07604_ sky130_fd_sc_hd__nor2_1
X_09450_ _00591_ _00642_ _00725_ VGND VGND VPWR VPWR _00726_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_149_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08401_ net595 net363 VGND VGND VPWR VPWR _04970_ sky130_fd_sc_hd__nand2_1
X_09381_ _00480_ _00478_ _00564_ VGND VGND VPWR VPWR _00658_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_148_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08332_ net677 net404 net393 net686 VGND VGND VPWR VPWR _04218_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_19_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08263_ net658 net667 net521 net433 VGND VGND VPWR VPWR _03464_ sky130_fd_sc_hd__and4_1
XFILLER_0_27_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08194_ net536 net544 net409 net398 VGND VGND VPWR VPWR _02713_ sky130_fd_sc_hd__and4_1
XFILLER_0_132_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09717_ net635 net493 _00986_ _00988_ VGND VGND VPWR VPWR _00989_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_69_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09648_ _00903_ _00919_ _00920_ VGND VGND VPWR VPWR _00921_ sky130_fd_sc_hd__and3_1
X_09579_ _00852_ VGND VGND VPWR VPWR _00853_ sky130_fd_sc_hd__buf_2
XFILLER_0_38_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11610_ _02794_ _02889_ VGND VGND VPWR VPWR _02895_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12590_ _03959_ _03960_ _03961_ VGND VGND VPWR VPWR _03962_ sky130_fd_sc_hd__nand3_1
XFILLER_0_65_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11541_ _02720_ _02726_ VGND VGND VPWR VPWR _02820_ sky130_fd_sc_hd__and2_1
XFILLER_0_147_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14260_ _05722_ _05725_ _05781_ VGND VGND VPWR VPWR _05782_ sky130_fd_sc_hd__and3_1
X_11472_ net729 net470 VGND VGND VPWR VPWR _02745_ sky130_fd_sc_hd__nand2_1
XFILLER_0_135_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13211_ _04639_ _04640_ _04536_ VGND VGND VPWR VPWR _04642_ sky130_fd_sc_hd__a21boi_2
X_10423_ net779 net354 net508 net787 VGND VGND VPWR VPWR _01649_ sky130_fd_sc_hd__a22oi_1
X_14191_ _05705_ _05706_ VGND VGND VPWR VPWR _05707_ sky130_fd_sc_hd__nor2_1
XFILLER_0_150_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13142_ _04483_ _04490_ _04489_ VGND VGND VPWR VPWR _04566_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10354_ _01576_ _01582_ _01585_ VGND VGND VPWR VPWR _01586_ sky130_fd_sc_hd__o21a_1
X_13073_ _04489_ _04490_ VGND VGND VPWR VPWR _04492_ sky130_fd_sc_hd__and2b_1
X_10285_ Q_cos\[5\] D_sin\[5\] VGND VGND VPWR VPWR _01526_ sky130_fd_sc_hd__or2b_1
X_12024_ _03321_ _03343_ VGND VGND VPWR VPWR _03346_ sky130_fd_sc_hd__or2_1
Xfanout590 net591 VGND VGND VPWR VPWR net590 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_73_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13975_ _05470_ _05473_ VGND VGND VPWR VPWR _05474_ sky130_fd_sc_hd__xnor2_2
X_15714_ _07365_ _07370_ VGND VGND VPWR VPWR _07371_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_87_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12926_ _04242_ _04243_ VGND VGND VPWR VPWR _04332_ sky130_fd_sc_hd__or2_1
XFILLER_0_88_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15645_ _07282_ _07294_ VGND VGND VPWR VPWR _07295_ sky130_fd_sc_hd__xor2_1
X_12857_ _04206_ _04212_ VGND VGND VPWR VPWR _04256_ sky130_fd_sc_hd__and2b_1
XFILLER_0_68_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11808_ net229 net147 net349 net502 VGND VGND VPWR VPWR _03111_ sky130_fd_sc_hd__nand4_2
XFILLER_0_56_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15576_ _07060_ _07215_ _07219_ VGND VGND VPWR VPWR _07220_ sky130_fd_sc_hd__o21a_1
X_12788_ net216 net206 net617 net708 VGND VGND VPWR VPWR _04180_ sky130_fd_sc_hd__and4_1
XFILLER_0_139_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14527_ _06051_ _06052_ _06072_ _06073_ VGND VGND VPWR VPWR _06074_ sky130_fd_sc_hd__o211ai_4
X_11739_ _02945_ _02967_ _03035_ VGND VGND VPWR VPWR _03036_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_126_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14458_ net169 net559 VGND VGND VPWR VPWR _05998_ sky130_fd_sc_hd__nand2_1
X_13409_ _04755_ _04843_ VGND VGND VPWR VPWR _04857_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14389_ net222 net537 _05909_ _05908_ VGND VGND VPWR VPWR _05922_ sky130_fd_sc_hd__a22o_1
XFILLER_0_141_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16128_ _07756_ _07759_ _07757_ VGND VGND VPWR VPWR _07820_ sky130_fd_sc_hd__o21ba_1
X_08950_ _00222_ _00229_ _00230_ VGND VGND VPWR VPWR _00231_ sky130_fd_sc_hd__nand3_2
X_16059_ _07706_ _07744_ VGND VGND VPWR VPWR _07745_ sky130_fd_sc_hd__xnor2_1
X_08881_ _00160_ _00161_ _00153_ VGND VGND VPWR VPWR _00163_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_135_Right_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_16_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09502_ _00687_ _00690_ VGND VGND VPWR VPWR _00777_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09433_ net530 net466 VGND VGND VPWR VPWR _00709_ sky130_fd_sc_hd__nand2_1
XFILLER_0_63_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09364_ _00523_ _00550_ _00640_ VGND VGND VPWR VPWR _00641_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_59_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08315_ _03855_ _03866_ _04020_ VGND VGND VPWR VPWR _04031_ sky130_fd_sc_hd__a21o_1
XFILLER_0_74_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09295_ _00497_ _00499_ VGND VGND VPWR VPWR _00572_ sky130_fd_sc_hd__or2b_1
XANTENNA_20 net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_31 net586 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_42 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08246_ _03203_ net848 _03268_ VGND VGND VPWR VPWR _03279_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_25_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_53 net401 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_145_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08177_ _02517_ VGND VGND VPWR VPWR _02528_ sky130_fd_sc_hd__inv_2
XFILLER_0_15_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10070_ _01290_ _01336_ VGND VGND VPWR VPWR _01337_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_102_Right_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_34_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13760_ _05167_ _05174_ VGND VGND VPWR VPWR _05239_ sky130_fd_sc_hd__or2b_1
X_10972_ _02197_ _02199_ VGND VGND VPWR VPWR _02200_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12711_ _04088_ _04089_ _04094_ VGND VGND VPWR VPWR _04095_ sky130_fd_sc_hd__nand3_2
X_13691_ _05012_ _04921_ _05081_ VGND VGND VPWR VPWR _05164_ sky130_fd_sc_hd__and3_1
XFILLER_0_84_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15430_ _06958_ _06961_ _07060_ VGND VGND VPWR VPWR _07061_ sky130_fd_sc_hd__a21oi_1
X_12642_ _04012_ _04013_ _04017_ _04018_ VGND VGND VPWR VPWR _04019_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_38_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15361_ _06790_ _06887_ VGND VGND VPWR VPWR _06986_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_43_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12573_ _03937_ _03942_ VGND VGND VPWR VPWR _03944_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_26_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11524_ _02716_ _02792_ _02801_ VGND VGND VPWR VPWR _02802_ sky130_fd_sc_hd__a21oi_2
X_14312_ _05662_ _05756_ _05653_ VGND VGND VPWR VPWR _05838_ sky130_fd_sc_hd__o21ba_1
X_15292_ _06909_ VGND VGND VPWR VPWR _06910_ sky130_fd_sc_hd__inv_2
XFILLER_0_80_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14243_ _05507_ _05706_ _05762_ VGND VGND VPWR VPWR _05764_ sky130_fd_sc_hd__nor3b_1
XFILLER_0_150_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11455_ _02720_ _02726_ VGND VGND VPWR VPWR _02727_ sky130_fd_sc_hd__xor2_2
XFILLER_0_1_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10406_ net761 net771 net354 net507 VGND VGND VPWR VPWR _01632_ sky130_fd_sc_hd__and4_1
X_14174_ _05689_ VGND VGND VPWR VPWR _00092_ sky130_fd_sc_hd__clkbuf_1
X_11386_ _02649_ _02650_ _02630_ VGND VGND VPWR VPWR _02652_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_110_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13125_ net766 net274 VGND VGND VPWR VPWR _04548_ sky130_fd_sc_hd__nand2_1
X_10337_ _01569_ _01570_ VGND VGND VPWR VPWR _01571_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13056_ _04468_ _04470_ _04471_ VGND VGND VPWR VPWR _04473_ sky130_fd_sc_hd__a21o_1
X_10268_ D_sin\[3\] Q_cos\[3\] VGND VGND VPWR VPWR _01511_ sky130_fd_sc_hd__or2b_1
X_12007_ net423 net511 net460 net450 VGND VGND VPWR VPWR _03327_ sky130_fd_sc_hd__and4_1
X_10199_ net130 _01445_ _01452_ VGND VGND VPWR VPWR _00030_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_108_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13958_ _05368_ _05371_ _05369_ VGND VGND VPWR VPWR _05455_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_88_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12909_ _04310_ _04311_ _04291_ VGND VGND VPWR VPWR _04313_ sky130_fd_sc_hd__a21oi_2
X_13889_ _05376_ _05379_ VGND VGND VPWR VPWR _05380_ sky130_fd_sc_hd__xnor2_2
X_15628_ Q_sin\[8\] _07276_ _00186_ VGND VGND VPWR VPWR _07277_ sky130_fd_sc_hd__mux2_1
XFILLER_0_124_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15559_ _07199_ _07200_ VGND VGND VPWR VPWR _07201_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_44_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09080_ _00357_ _00358_ _00255_ _00353_ VGND VGND VPWR VPWR _00360_ sky130_fd_sc_hd__a211o_1
XFILLER_0_4_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput40 cos[10] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput51 cos[3] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_4
Xinput62 sin[12] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__buf_4
XFILLER_0_4_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput73 sin[5] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_141_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09982_ _01069_ _01211_ _01249_ VGND VGND VPWR VPWR _01250_ sky130_fd_sc_hd__and3_1
X_08933_ _00212_ _00213_ VGND VGND VPWR VPWR _00214_ sky130_fd_sc_hd__xor2_1
XFILLER_0_58_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08864_ _00143_ _00144_ _00140_ VGND VGND VPWR VPWR _00146_ sky130_fd_sc_hd__a21o_1
X_08795_ _08087_ _08104_ _08105_ VGND VGND VPWR VPWR _08106_ sky130_fd_sc_hd__and3_1
XFILLER_0_74_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09416_ _00627_ _00629_ VGND VGND VPWR VPWR _00692_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09347_ _00527_ _00529_ VGND VGND VPWR VPWR _00624_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09278_ _00459_ _00460_ VGND VGND VPWR VPWR _00556_ sky130_fd_sc_hd__and2b_1
XFILLER_0_117_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08229_ _03073_ _03083_ VGND VGND VPWR VPWR _03094_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11240_ _02189_ _02491_ _02492_ VGND VGND VPWR VPWR _02493_ sky130_fd_sc_hd__o21a_1
XFILLER_0_105_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11171_ net491 _02415_ _02416_ VGND VGND VPWR VPWR _02417_ sky130_fd_sc_hd__a21bo_1
X_10122_ _01382_ _01384_ _01385_ VGND VGND VPWR VPWR _01386_ sky130_fd_sc_hd__and3_1
X_10053_ _01265_ _01306_ _01318_ VGND VGND VPWR VPWR _01320_ sky130_fd_sc_hd__o21bai_1
X_14930_ _06063_ _06064_ _06065_ VGND VGND VPWR VPWR _06516_ sky130_fd_sc_hd__o21bai_1
X_14861_ _06417_ _06435_ _06438_ VGND VGND VPWR VPWR _06441_ sky130_fd_sc_hd__a21o_1
X_13812_ net729 _04881_ VGND VGND VPWR VPWR _05296_ sky130_fd_sc_hd__or2_1
X_14792_ _06296_ _06302_ _06301_ VGND VGND VPWR VPWR _06365_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_98_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10955_ _02007_ _02183_ VGND VGND VPWR VPWR _02184_ sky130_fd_sc_hd__nor2_1
X_13743_ _05219_ _05220_ VGND VGND VPWR VPWR _05222_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_51_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10886_ _02110_ _02111_ VGND VGND VPWR VPWR _02112_ sky130_fd_sc_hd__nand2_1
X_13674_ net519 net289 net280 net611 VGND VGND VPWR VPWR _05146_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_54_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15413_ net183 net651 net660 net173 VGND VGND VPWR VPWR _07043_ sky130_fd_sc_hd__a22o_1
X_12625_ _03911_ _04000_ VGND VGND VPWR VPWR _04001_ sky130_fd_sc_hd__xnor2_1
X_16393_ clknet_4_1_0_clk _00106_ net338 VGND VGND VPWR VPWR Q_sin\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_81_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15344_ _06965_ _06967_ VGND VGND VPWR VPWR _06968_ sky130_fd_sc_hd__xnor2_1
X_12556_ net217 net207 net735 net745 VGND VGND VPWR VPWR _03925_ sky130_fd_sc_hd__and4_1
XFILLER_0_53_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11507_ _02664_ _02682_ _02680_ VGND VGND VPWR VPWR _02784_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_13_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15275_ net908 _02181_ VGND VGND VPWR VPWR _06893_ sky130_fd_sc_hd__nor2_1
X_12487_ _03832_ _03848_ VGND VGND VPWR VPWR _03849_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold109 net100 VGND VGND VPWR VPWR net915 sky130_fd_sc_hd__dlygate4sd3_1
X_11438_ _02702_ _02707_ _02708_ VGND VGND VPWR VPWR _02709_ sky130_fd_sc_hd__and3_1
X_14226_ _05678_ _05679_ _05676_ VGND VGND VPWR VPWR _05746_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_21_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_60_Left_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14157_ _05669_ _05670_ VGND VGND VPWR VPWR _05671_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11369_ net722 net732 net491 net480 VGND VGND VPWR VPWR _02633_ sky130_fd_sc_hd__and4_1
XFILLER_0_95_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13108_ _04425_ _04428_ VGND VGND VPWR VPWR _04530_ sky130_fd_sc_hd__nand2_1
X_14088_ _05594_ _05595_ VGND VGND VPWR VPWR _05596_ sky130_fd_sc_hd__nor2_1
X_13039_ _04377_ _04379_ _04452_ VGND VGND VPWR VPWR _04454_ sky130_fd_sc_hd__a21oi_1
X_08580_ _06813_ _06835_ _06900_ _06911_ VGND VGND VPWR VPWR _06922_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_135_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09201_ _00468_ _00475_ _00478_ VGND VGND VPWR VPWR _00479_ sky130_fd_sc_hd__o21a_1
XFILLER_0_8_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09132_ _00395_ _00410_ VGND VGND VPWR VPWR _00411_ sky130_fd_sc_hd__xor2_1
XFILLER_0_44_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09063_ _00341_ _00342_ VGND VGND VPWR VPWR _00343_ sky130_fd_sc_hd__nand2_2
XFILLER_0_114_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09965_ _01171_ _01226_ VGND VGND VPWR VPWR _01233_ sky130_fd_sc_hd__and2b_1
X_08916_ _00117_ _00131_ _00132_ _00135_ VGND VGND VPWR VPWR _00197_ sky130_fd_sc_hd__a31o_1
X_09896_ _01163_ _01164_ _01165_ _01097_ VGND VGND VPWR VPWR _01166_ sky130_fd_sc_hd__o211a_1
XFILLER_0_85_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08847_ _00126_ _00127_ _00128_ VGND VGND VPWR VPWR _00129_ sky130_fd_sc_hd__nand3_2
X_08778_ net667 net677 net404 net393 VGND VGND VPWR VPWR _08089_ sky130_fd_sc_hd__and4_1
XFILLER_0_94_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10740_ _01897_ _01896_ VGND VGND VPWR VPWR _01966_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10671_ net769 net777 net380 net371 VGND VGND VPWR VPWR _01897_ sky130_fd_sc_hd__and4_1
XFILLER_0_138_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12410_ _03747_ _03762_ _03763_ VGND VGND VPWR VPWR _03764_ sky130_fd_sc_hd__and3_1
XFILLER_0_35_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13390_ _04835_ _04836_ VGND VGND VPWR VPWR _04837_ sky130_fd_sc_hd__xnor2_1
X_12341_ _03655_ _03688_ VGND VGND VPWR VPWR _03689_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_63_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15060_ _06637_ _06656_ _06657_ VGND VGND VPWR VPWR _06658_ sky130_fd_sc_hd__and3_1
X_12272_ net313 _00193_ VGND VGND VPWR VPWR _03614_ sky130_fd_sc_hd__nor2_1
XFILLER_0_105_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14011_ _05415_ _05423_ _05511_ VGND VGND VPWR VPWR _05512_ sky130_fd_sc_hd__a21oi_1
X_11223_ _02366_ net127 _02472_ _02473_ VGND VGND VPWR VPWR _02475_ sky130_fd_sc_hd__o211ai_4
X_11154_ _02393_ _02398_ VGND VGND VPWR VPWR _02399_ sky130_fd_sc_hd__xor2_1
X_10105_ _01075_ _01295_ _01297_ VGND VGND VPWR VPWR _01371_ sky130_fd_sc_hd__a21oi_1
X_15962_ _07637_ _07638_ VGND VGND VPWR VPWR _07639_ sky130_fd_sc_hd__nor2_1
X_11085_ _02314_ _02322_ _02323_ VGND VGND VPWR VPWR _02324_ sky130_fd_sc_hd__nand3_2
X_10036_ _01301_ _01302_ VGND VGND VPWR VPWR _01303_ sky130_fd_sc_hd__nor2_1
X_14913_ _06495_ _06496_ VGND VGND VPWR VPWR _06498_ sky130_fd_sc_hd__nand2_1
X_15893_ _07556_ _07563_ VGND VGND VPWR VPWR _07565_ sky130_fd_sc_hd__xnor2_1
X_14844_ net219 net203 net605 net700 VGND VGND VPWR VPWR _06423_ sky130_fd_sc_hd__and4_1
XFILLER_0_81_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14775_ net324 net239 net570 net579 VGND VGND VPWR VPWR _06347_ sky130_fd_sc_hd__nand4_1
XFILLER_0_14_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11987_ _03285_ _03305_ VGND VGND VPWR VPWR _03306_ sky130_fd_sc_hd__xor2_2
XFILLER_0_105_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13726_ _05200_ _05202_ VGND VGND VPWR VPWR _05203_ sky130_fd_sc_hd__xnor2_1
X_10938_ _02068_ _02075_ _02074_ VGND VGND VPWR VPWR _02165_ sky130_fd_sc_hd__a21o_1
XFILLER_0_105_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10869_ _02091_ _02094_ net802 net379 VGND VGND VPWR VPWR _02095_ sky130_fd_sc_hd__o211a_1
X_13657_ _05031_ _05033_ VGND VGND VPWR VPWR _05128_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12608_ net171 net773 _03980_ _03981_ VGND VGND VPWR VPWR _03982_ sky130_fd_sc_hd__and4_1
X_16376_ clknet_4_0_0_clk _00089_ net332 VGND VGND VPWR VPWR D_sin\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_42_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13588_ _04954_ _05044_ VGND VGND VPWR VPWR _05052_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15327_ _06943_ _06947_ _06948_ VGND VGND VPWR VPWR _06949_ sky130_fd_sc_hd__and3_1
XFILLER_0_54_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12539_ _03878_ _03880_ _03905_ VGND VGND VPWR VPWR _03906_ sky130_fd_sc_hd__o21a_1
XFILLER_0_124_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15258_ _06871_ _06872_ _06750_ net893 VGND VGND VPWR VPWR _06874_ sky130_fd_sc_hd__a211o_1
XFILLER_0_112_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14209_ _05634_ _05640_ VGND VGND VPWR VPWR _05727_ sky130_fd_sc_hd__and2b_1
XFILLER_0_22_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15189_ net265 net575 net584 net932 VGND VGND VPWR VPWR _06798_ sky130_fd_sc_hd__a22oi_1
Xfanout408 net409 VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_1_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout419 net420 VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__buf_4
XFILLER_0_10_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09750_ _01020_ _01021_ VGND VGND VPWR VPWR _01022_ sky130_fd_sc_hd__nor2_1
X_08701_ net598 net416 VGND VGND VPWR VPWR _08013_ sky130_fd_sc_hd__or2_1
X_09681_ _00952_ _00953_ VGND VGND VPWR VPWR _00954_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_146_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08632_ _06014_ _06966_ _07031_ _07053_ _07477_ VGND VGND VPWR VPWR _07488_ sky130_fd_sc_hd__a32o_1
XFILLER_0_96_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08563_ net603 net352 net505 net699 VGND VGND VPWR VPWR _06737_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_49_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08494_ _05893_ _05959_ _05970_ VGND VGND VPWR VPWR _05981_ sky130_fd_sc_hd__o21a_1
XFILLER_0_37_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09115_ _00310_ _00312_ _00393_ VGND VGND VPWR VPWR _00394_ sky130_fd_sc_hd__a21o_1
XFILLER_0_60_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09046_ net540 net497 VGND VGND VPWR VPWR _00326_ sky130_fd_sc_hd__and2_1
XFILLER_0_115_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_8_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09948_ _01215_ _01195_ _01196_ VGND VGND VPWR VPWR _01217_ sky130_fd_sc_hd__nand3_2
X_09879_ _01147_ _01148_ VGND VGND VPWR VPWR _01149_ sky130_fd_sc_hd__xnor2_1
X_11910_ _03199_ _03200_ _03221_ VGND VGND VPWR VPWR _03222_ sky130_fd_sc_hd__a21o_1
X_12890_ net199 net708 VGND VGND VPWR VPWR _04292_ sky130_fd_sc_hd__nand2_1
X_11841_ net732 _00191_ VGND VGND VPWR VPWR _03147_ sky130_fd_sc_hd__or2_1
X_14560_ _05994_ _06076_ _06108_ _06109_ VGND VGND VPWR VPWR _06110_ sky130_fd_sc_hd__a211o_4
X_11772_ _03070_ _03071_ VGND VGND VPWR VPWR _03072_ sky130_fd_sc_hd__or2_1
X_10723_ _01946_ _01947_ _01943_ _01944_ VGND VGND VPWR VPWR _01949_ sky130_fd_sc_hd__o211a_1
X_13511_ _04965_ _04966_ net748 net250 VGND VGND VPWR VPWR _04968_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_137_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14491_ _06008_ _06009_ _06032_ _06033_ VGND VGND VPWR VPWR _06034_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_95_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16230_ _07928_ _07929_ VGND VGND VPWR VPWR _07930_ sky130_fd_sc_hd__nor2_1
X_10654_ net717 net751 net527 net399 VGND VGND VPWR VPWR _01880_ sky130_fd_sc_hd__and4_1
X_13442_ _04891_ _04892_ VGND VGND VPWR VPWR _04893_ sky130_fd_sc_hd__nor2_1
XFILLER_0_63_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16161_ net253 net648 _07854_ VGND VGND VPWR VPWR _07855_ sky130_fd_sc_hd__a21boi_1
X_13373_ net204 net152 net143 net214 VGND VGND VPWR VPWR _04819_ sky130_fd_sc_hd__a22o_1
XFILLER_0_141_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10585_ _01736_ _01741_ _01735_ VGND VGND VPWR VPWR _01811_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_24_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15112_ net166 net693 net532 net159 VGND VGND VPWR VPWR _06714_ sky130_fd_sc_hd__a22o_1
X_12324_ _03598_ _03616_ _03618_ VGND VGND VPWR VPWR _03671_ sky130_fd_sc_hd__a21bo_1
X_16092_ _07773_ _07779_ VGND VGND VPWR VPWR _07780_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_133_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15043_ net210 net661 net668 net200 VGND VGND VPWR VPWR _06640_ sky130_fd_sc_hd__a22o_1
X_12255_ net422 _00193_ _03574_ VGND VGND VPWR VPWR _03596_ sky130_fd_sc_hd__or3_1
X_11206_ net233 net406 net48 VGND VGND VPWR VPWR _02456_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_121_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12186_ _03432_ _03412_ VGND VGND VPWR VPWR _03522_ sky130_fd_sc_hd__or2b_1
X_11137_ _02380_ _02280_ VGND VGND VPWR VPWR _02381_ sky130_fd_sc_hd__nor2_1
X_15945_ _07614_ _07615_ VGND VGND VPWR VPWR _07621_ sky130_fd_sc_hd__and2b_1
X_11068_ _02303_ _02304_ VGND VGND VPWR VPWR _02305_ sky130_fd_sc_hd__or2b_1
XFILLER_0_92_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10019_ _01235_ _01286_ VGND VGND VPWR VPWR _01287_ sky130_fd_sc_hd__xnor2_1
X_15876_ _07460_ _07538_ VGND VGND VPWR VPWR _07546_ sky130_fd_sc_hd__nand2_1
X_14827_ _06397_ _06401_ _06402_ _06403_ VGND VGND VPWR VPWR _06404_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_58_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14758_ _06318_ _06321_ _06326_ _06327_ VGND VGND VPWR VPWR _06328_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_132_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13709_ _05099_ _05120_ _05100_ VGND VGND VPWR VPWR _05184_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_58_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14689_ _06246_ _06247_ _06251_ VGND VGND VPWR VPWR _06252_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16359_ clknet_4_6_0_clk _00072_ net336 VGND VGND VPWR VPWR D_cos\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_42_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout205 net834 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__clkbuf_2
Xfanout216 net218 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__clkbuf_4
X_09802_ _00985_ _00993_ _01072_ VGND VGND VPWR VPWR _01073_ sky130_fd_sc_hd__a21o_1
Xfanout227 net229 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__clkbuf_4
Xfanout238 net69 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__clkbuf_2
Xfanout249 net67 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_5_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09733_ _00928_ _00929_ VGND VGND VPWR VPWR _01005_ sky130_fd_sc_hd__and2_1
X_09664_ _00881_ _00882_ _00936_ VGND VGND VPWR VPWR _00937_ sky130_fd_sc_hd__o21ai_1
X_08615_ _07227_ _07238_ _07281_ VGND VGND VPWR VPWR _07303_ sky130_fd_sc_hd__nand3_1
X_09595_ _00747_ _00750_ _00748_ VGND VGND VPWR VPWR _00869_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_49_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08546_ _06256_ _06311_ _06300_ VGND VGND VPWR VPWR _06552_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_65_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08477_ _05742_ _05752_ _05774_ VGND VGND VPWR VPWR _05796_ sky130_fd_sc_hd__and3_1
XFILLER_0_65_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_149_Right_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10370_ net129 net105 VGND VGND VPWR VPWR _01600_ sky130_fd_sc_hd__and2b_1
XFILLER_0_21_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09029_ _00205_ _00307_ _00308_ VGND VGND VPWR VPWR _00309_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_131_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12040_ net136 net495 VGND VGND VPWR VPWR _03363_ sky130_fd_sc_hd__nand2_1
Xfanout750 net15 VGND VGND VPWR VPWR net750 sky130_fd_sc_hd__buf_2
Xfanout761 net764 VGND VGND VPWR VPWR net761 sky130_fd_sc_hd__clkbuf_4
Xfanout772 net773 VGND VGND VPWR VPWR net772 sky130_fd_sc_hd__buf_2
Xfanout783 net784 VGND VGND VPWR VPWR net783 sky130_fd_sc_hd__buf_2
X_13991_ _05488_ _05489_ VGND VGND VPWR VPWR _05490_ sky130_fd_sc_hd__xnor2_1
Xfanout794 net795 VGND VGND VPWR VPWR net794 sky130_fd_sc_hd__buf_2
X_15730_ _07385_ _07386_ VGND VGND VPWR VPWR _07387_ sky130_fd_sc_hd__nor2_1
XFILLER_0_99_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12942_ _04344_ _04346_ _04261_ _04265_ VGND VGND VPWR VPWR _04348_ sky130_fd_sc_hd__a211oi_1
X_15661_ _07247_ _07251_ _07248_ VGND VGND VPWR VPWR _07312_ sky130_fd_sc_hd__o21ba_1
X_12873_ _04271_ _04272_ VGND VGND VPWR VPWR _04274_ sky130_fd_sc_hd__xnor2_1
X_14612_ net187 net177 net590 net599 VGND VGND VPWR VPWR _06167_ sky130_fd_sc_hd__and4_1
XFILLER_0_68_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11824_ _03125_ _03128_ VGND VGND VPWR VPWR _03129_ sky130_fd_sc_hd__xnor2_1
X_15592_ _07149_ _07163_ _07236_ VGND VGND VPWR VPWR _07237_ sky130_fd_sc_hd__a21o_1
X_14543_ _06089_ _06090_ VGND VGND VPWR VPWR _06092_ sky130_fd_sc_hd__nor2_1
XFILLER_0_68_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11755_ _02905_ _02911_ VGND VGND VPWR VPWR _03054_ sky130_fd_sc_hd__nand2_1
X_10706_ _01910_ VGND VGND VPWR VPWR _01932_ sky130_fd_sc_hd__inv_2
X_14474_ net160 net571 net576 net309 VGND VGND VPWR VPWR _06016_ sky130_fd_sc_hd__a22oi_2
X_11686_ _02804_ _02886_ _02978_ VGND VGND VPWR VPWR _02979_ sky130_fd_sc_hd__a21boi_2
X_16213_ _07909_ _07910_ VGND VGND VPWR VPWR _07912_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_64_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13425_ _04766_ _04769_ _04767_ VGND VGND VPWR VPWR _04875_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_114_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10637_ _01857_ _01861_ _01862_ VGND VGND VPWR VPWR _01863_ sky130_fd_sc_hd__nand3_1
XFILLER_0_141_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16144_ _07834_ _07836_ VGND VGND VPWR VPWR _07837_ sky130_fd_sc_hd__nor2_1
X_10568_ _01792_ _01793_ VGND VGND VPWR VPWR _01794_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_116_Right_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13356_ _04683_ _04685_ _04684_ VGND VGND VPWR VPWR _04800_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_11_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12307_ _03647_ _03652_ VGND VGND VPWR VPWR _03653_ sky130_fd_sc_hd__xor2_1
XFILLER_0_122_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16075_ _07761_ _07762_ VGND VGND VPWR VPWR _07763_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_87_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10499_ _01712_ _01723_ _01724_ VGND VGND VPWR VPWR _01725_ sky130_fd_sc_hd__nand3_4
X_13287_ _04722_ _04723_ _04714_ VGND VGND VPWR VPWR _04725_ sky130_fd_sc_hd__a21o_1
X_15026_ _06603_ _06619_ _06620_ VGND VGND VPWR VPWR _06621_ sky130_fd_sc_hd__nand3_1
X_12238_ _03555_ _03577_ VGND VGND VPWR VPWR _03578_ sky130_fd_sc_hd__xnor2_1
X_12169_ _03501_ _03502_ VGND VGND VPWR VPWR _03503_ sky130_fd_sc_hd__xor2_1
Xinput5 D[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
X_15928_ _07601_ _07600_ VGND VGND VPWR VPWR _07603_ sky130_fd_sc_hd__and2b_1
X_15859_ _07502_ _07503_ _07527_ VGND VGND VPWR VPWR _07528_ sky130_fd_sc_hd__a21o_1
XFILLER_0_148_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08400_ _04927_ _04949_ VGND VGND VPWR VPWR _04959_ sky130_fd_sc_hd__xor2_1
X_09380_ _00475_ _00656_ VGND VGND VPWR VPWR _00657_ sky130_fd_sc_hd__nor2_1
XFILLER_0_143_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08331_ net677 net686 net404 net393 VGND VGND VPWR VPWR _04207_ sky130_fd_sc_hd__and4_1
XFILLER_0_19_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08262_ _03420_ _03431_ _03442_ VGND VGND VPWR VPWR _03453_ sky130_fd_sc_hd__nand3_2
XFILLER_0_116_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08193_ _02692_ VGND VGND VPWR VPWR _02703_ sky130_fd_sc_hd__inv_2
XFILLER_0_116_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09716_ net626 _00987_ VGND VGND VPWR VPWR _00988_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_98_Left_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09647_ _00904_ _00905_ _00918_ VGND VGND VPWR VPWR _00920_ sky130_fd_sc_hd__nand3_1
X_09578_ _00769_ _00851_ net622 VGND VGND VPWR VPWR _00852_ sky130_fd_sc_hd__and3b_1
XFILLER_0_84_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08529_ net596 net388 _06047_ _06036_ VGND VGND VPWR VPWR _06366_ sky130_fd_sc_hd__a31o_1
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11540_ _02817_ _02818_ VGND VGND VPWR VPWR _02819_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_92_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11471_ _02742_ _02743_ VGND VGND VPWR VPWR _02744_ sky130_fd_sc_hd__nor2_1
XFILLER_0_61_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10422_ net779 net787 net354 net508 VGND VGND VPWR VPWR _01648_ sky130_fd_sc_hd__and4_1
X_13210_ _04536_ _04639_ _04640_ VGND VGND VPWR VPWR _04641_ sky130_fd_sc_hd__and3b_1
XFILLER_0_135_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14190_ _05510_ _05704_ VGND VGND VPWR VPWR _05706_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10353_ _01583_ _01584_ VGND VGND VPWR VPWR _01585_ sky130_fd_sc_hd__nor2_1
X_13141_ _04472_ _04474_ VGND VGND VPWR VPWR _04565_ sky130_fd_sc_hd__nand2_1
X_13072_ _04487_ _04488_ _04484_ VGND VGND VPWR VPWR _04490_ sky130_fd_sc_hd__a21o_1
X_10284_ D_sin\[5\] Q_cos\[5\] VGND VGND VPWR VPWR _01525_ sky130_fd_sc_hd__or2b_1
XFILLER_0_130_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12023_ _03321_ _03343_ VGND VGND VPWR VPWR _03345_ sky130_fd_sc_hd__nand2_1
Xfanout580 net581 VGND VGND VPWR VPWR net580 sky130_fd_sc_hd__clkbuf_2
Xfanout591 net32 VGND VGND VPWR VPWR net591 sky130_fd_sc_hd__clkbuf_2
X_13974_ _05364_ _05383_ _05472_ VGND VGND VPWR VPWR _05473_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_88_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15713_ _06989_ _07088_ _07366_ _07367_ _07368_ VGND VGND VPWR VPWR _07370_ sky130_fd_sc_hd__o311a_4
X_12925_ _04327_ _04330_ VGND VGND VPWR VPWR _04331_ sky130_fd_sc_hd__xnor2_1
X_15644_ _07283_ _07293_ VGND VGND VPWR VPWR _07294_ sky130_fd_sc_hd__xnor2_1
X_12856_ _04099_ _04169_ _04200_ net907 VGND VGND VPWR VPWR _04255_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_68_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_146_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11807_ net147 net349 net503 net229 VGND VGND VPWR VPWR _03110_ sky130_fd_sc_hd__a22o_1
X_15575_ _07052_ _07218_ VGND VGND VPWR VPWR _07219_ sky130_fd_sc_hd__xor2_1
XFILLER_0_139_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12787_ net199 net716 VGND VGND VPWR VPWR _04179_ sky130_fd_sc_hd__nand2_1
X_14526_ _06053_ _06054_ _06071_ VGND VGND VPWR VPWR _06073_ sky130_fd_sc_hd__nand3_2
X_11738_ _02941_ _02944_ VGND VGND VPWR VPWR _03035_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14457_ _05947_ _05950_ VGND VGND VPWR VPWR _05997_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11669_ _02837_ _02839_ _02838_ VGND VGND VPWR VPWR _02960_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_126_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13408_ _04856_ VGND VGND VPWR VPWR _00082_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_107_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14388_ _05909_ _05907_ _05908_ VGND VGND VPWR VPWR _05921_ sky130_fd_sc_hd__nand3_1
XFILLER_0_52_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16127_ _07817_ _07818_ VGND VGND VPWR VPWR _07819_ sky130_fd_sc_hd__xor2_1
XFILLER_0_106_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13339_ _04764_ _04780_ VGND VGND VPWR VPWR _04781_ sky130_fd_sc_hd__nor2_1
XFILLER_0_122_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16058_ _07740_ _07743_ VGND VGND VPWR VPWR _07744_ sky130_fd_sc_hd__xor2_1
X_15009_ _06517_ _06520_ VGND VGND VPWR VPWR _06602_ sky130_fd_sc_hd__nand2_1
X_08880_ _00153_ _00160_ _00161_ VGND VGND VPWR VPWR _00162_ sky130_fd_sc_hd__nand3_2
XFILLER_0_47_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09501_ _00766_ _00775_ VGND VGND VPWR VPWR _00776_ sky130_fd_sc_hd__xor2_1
X_09432_ _00706_ _00707_ VGND VGND VPWR VPWR _00708_ sky130_fd_sc_hd__nor2_1
XFILLER_0_66_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09363_ _00547_ _00549_ VGND VGND VPWR VPWR _00640_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08314_ _03932_ _04009_ VGND VGND VPWR VPWR _04020_ sky130_fd_sc_hd__xnor2_1
X_09294_ _00484_ _00503_ _00570_ VGND VGND VPWR VPWR _00571_ sky130_fd_sc_hd__a21o_1
XANTENNA_10 net73 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_90_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_21 net281 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_145_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_32 net691 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08245_ _03246_ _03257_ VGND VGND VPWR VPWR _03268_ sky130_fd_sc_hd__nor2_1
XANTENNA_43 net31 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_54 net421 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08176_ _02496_ _02506_ VGND VGND VPWR VPWR _02517_ sky130_fd_sc_hd__or2_1
XFILLER_0_42_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10971_ _01691_ _02198_ VGND VGND VPWR VPWR _02199_ sky130_fd_sc_hd__or2_1
X_12710_ _04092_ _04093_ VGND VGND VPWR VPWR _04094_ sky130_fd_sc_hd__nor2_2
X_13690_ _05160_ _05161_ _05141_ _05142_ VGND VGND VPWR VPWR _05163_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_84_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12641_ _03818_ _03874_ VGND VGND VPWR VPWR _04018_ sky130_fd_sc_hd__or2_1
XFILLER_0_127_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15360_ _06790_ _06887_ VGND VGND VPWR VPWR _06985_ sky130_fd_sc_hd__and2_1
XFILLER_0_93_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12572_ _03938_ _03941_ VGND VGND VPWR VPWR _03942_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_38_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14311_ _05754_ _05760_ _05758_ VGND VGND VPWR VPWR _05837_ sky130_fd_sc_hd__a21oi_1
X_11523_ _02789_ _02791_ VGND VGND VPWR VPWR _02801_ sky130_fd_sc_hd__nor2_1
X_15291_ _06798_ _06801_ _06799_ VGND VGND VPWR VPWR _06909_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_136_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14242_ _05510_ _05761_ VGND VGND VPWR VPWR _05762_ sky130_fd_sc_hd__xnor2_1
X_11454_ _02723_ _02725_ VGND VGND VPWR VPWR _02726_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_150_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10405_ net779 net498 VGND VGND VPWR VPWR _01631_ sky130_fd_sc_hd__nand2_1
X_14173_ D_sin\[15\] _05687_ _05626_ VGND VGND VPWR VPWR _05689_ sky130_fd_sc_hd__mux2_1
X_11385_ _02630_ _02649_ _02650_ VGND VGND VPWR VPWR _02651_ sky130_fd_sc_hd__and3_1
XFILLER_0_150_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13124_ net775 net258 VGND VGND VPWR VPWR _04547_ sky130_fd_sc_hd__nand2_1
X_10336_ D_sin\[12\] Q_cos\[12\] VGND VGND VPWR VPWR _01570_ sky130_fd_sc_hd__and2b_1
XFILLER_0_131_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_9_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_9_0_clk sky130_fd_sc_hd__clkbuf_8
X_10267_ net134 _01508_ _01509_ _01510_ VGND VGND VPWR VPWR _00040_ sky130_fd_sc_hd__a31o_1
X_13055_ _04468_ _04470_ _04471_ VGND VGND VPWR VPWR _04472_ sky130_fd_sc_hd__nand3_1
XFILLER_0_84_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12006_ net423 net460 net450 net511 VGND VGND VPWR VPWR _03326_ sky130_fd_sc_hd__a22oi_2
X_10198_ _01450_ _01451_ net131 VGND VGND VPWR VPWR _01452_ sky130_fd_sc_hd__or3b_1
XFILLER_0_17_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13957_ _05447_ _05453_ VGND VGND VPWR VPWR _05454_ sky130_fd_sc_hd__xnor2_1
X_12908_ _04291_ _04310_ _04311_ VGND VGND VPWR VPWR _04312_ sky130_fd_sc_hd__and3_1
XFILLER_0_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13888_ _05377_ _05378_ VGND VGND VPWR VPWR _05379_ sky130_fd_sc_hd__nor2_1
XFILLER_0_124_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15627_ _07188_ _07275_ VGND VGND VPWR VPWR _07276_ sky130_fd_sc_hd__xor2_1
XFILLER_0_57_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12839_ _04234_ _04235_ VGND VGND VPWR VPWR _04236_ sky130_fd_sc_hd__and2_1
XFILLER_0_146_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15558_ net248 net555 VGND VGND VPWR VPWR _07200_ sky130_fd_sc_hd__nand2_1
XFILLER_0_17_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14509_ _06004_ _05996_ VGND VGND VPWR VPWR _06054_ sky130_fd_sc_hd__or2b_1
XFILLER_0_140_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15489_ net156 net669 net673 net305 VGND VGND VPWR VPWR _07125_ sky130_fd_sc_hd__a22o_1
XFILLER_0_71_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput30 Q[1] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_140_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput41 cos[11] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_2
XFILLER_0_4_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput52 cos[4] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_141_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput63 sin[13] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_25_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput74 sin[6] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__buf_1
XFILLER_0_142_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09981_ _01247_ _01248_ VGND VGND VPWR VPWR _01249_ sky130_fd_sc_hd__or2_1
X_08932_ _08045_ _08135_ _08136_ VGND VGND VPWR VPWR _00213_ sky130_fd_sc_hd__and3_1
XFILLER_0_149_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08863_ _00140_ _00143_ _00144_ VGND VGND VPWR VPWR _00145_ sky130_fd_sc_hd__and3_1
X_08794_ _08101_ _08102_ _08103_ VGND VGND VPWR VPWR _08105_ sky130_fd_sc_hd__a21o_1
X_09415_ _00687_ _00690_ VGND VGND VPWR VPWR _00691_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_149_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09346_ _00618_ _00619_ _00621_ VGND VGND VPWR VPWR _00623_ sky130_fd_sc_hd__and3_1
XFILLER_0_90_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09277_ _00504_ _00554_ VGND VGND VPWR VPWR _00555_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_105_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08228_ _02996_ _03029_ _03062_ VGND VGND VPWR VPWR _03083_ sky130_fd_sc_hd__and3_1
XFILLER_0_31_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08159_ net568 net377 net368 net577 VGND VGND VPWR VPWR _02332_ sky130_fd_sc_hd__a22o_1
X_11170_ net732 net498 net491 net740 VGND VGND VPWR VPWR _02416_ sky130_fd_sc_hd__a22o_1
X_10121_ D_cos\[1\] Q_sin\[1\] VGND VGND VPWR VPWR _01385_ sky130_fd_sc_hd__or2b_1
XFILLER_0_100_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10052_ _01265_ _01306_ _01318_ VGND VGND VPWR VPWR _01319_ sky130_fd_sc_hd__or3b_1
X_14860_ _06439_ VGND VGND VPWR VPWR _06440_ sky130_fd_sc_hd__inv_2
XFILLER_0_89_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13811_ _05291_ _05294_ VGND VGND VPWR VPWR _05295_ sky130_fd_sc_hd__xnor2_1
X_14791_ _06337_ _06362_ _06363_ VGND VGND VPWR VPWR _06364_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_98_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13742_ _05216_ _05218_ VGND VGND VPWR VPWR _05220_ sky130_fd_sc_hd__nand2_1
X_10954_ _02182_ _02006_ VGND VGND VPWR VPWR _02183_ sky130_fd_sc_hd__nor2_1
XFILLER_0_97_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13673_ _05085_ _05094_ VGND VGND VPWR VPWR _05145_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10885_ _02065_ _02064_ _02058_ VGND VGND VPWR VPWR _02111_ sky130_fd_sc_hd__a21o_1
X_15412_ net193 net651 _06954_ _06953_ net633 VGND VGND VPWR VPWR _07041_ sky130_fd_sc_hd__a32o_1
X_12624_ _03997_ _03999_ VGND VGND VPWR VPWR _04000_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16392_ clknet_4_1_0_clk _00105_ net338 VGND VGND VPWR VPWR Q_sin\[9\] sky130_fd_sc_hd__dfrtp_1
X_15343_ _06851_ _06870_ _06869_ VGND VGND VPWR VPWR _06967_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_124_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12555_ _03920_ _03922_ _03923_ VGND VGND VPWR VPWR _03924_ sky130_fd_sc_hd__nand3_1
XFILLER_0_79_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11506_ _02770_ _02782_ VGND VGND VPWR VPWR _02783_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_41_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15274_ _06888_ _06889_ VGND VGND VPWR VPWR _06892_ sky130_fd_sc_hd__nand2_1
X_12486_ _03835_ _03834_ VGND VGND VPWR VPWR _03848_ sky130_fd_sc_hd__nor2_1
XFILLER_0_123_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14225_ _05743_ _05744_ VGND VGND VPWR VPWR _05745_ sky130_fd_sc_hd__or2_1
X_11437_ _02189_ _02491_ _02704_ VGND VGND VPWR VPWR _02708_ sky130_fd_sc_hd__or3_1
XFILLER_0_111_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14156_ _05667_ _05668_ VGND VGND VPWR VPWR _05670_ sky130_fd_sc_hd__nand2_1
X_11368_ net722 net491 net480 net732 VGND VGND VPWR VPWR _02632_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_0_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13107_ _04527_ _04528_ VGND VGND VPWR VPWR _04529_ sky130_fd_sc_hd__and2_1
X_10319_ Q_cos\[10\] D_sin\[10\] VGND VGND VPWR VPWR _01555_ sky130_fd_sc_hd__and2b_1
XFILLER_0_21_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14087_ net288 net279 net148 net138 VGND VGND VPWR VPWR _05595_ sky130_fd_sc_hd__and4_1
X_11299_ _02553_ _02554_ _02555_ VGND VGND VPWR VPWR _02557_ sky130_fd_sc_hd__a21o_1
X_13038_ _04377_ _04379_ _04452_ VGND VGND VPWR VPWR _04453_ sky130_fd_sc_hd__and3_1
XFILLER_0_119_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14989_ _06487_ _06579_ VGND VGND VPWR VPWR _06581_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09200_ _00387_ _00466_ VGND VGND VPWR VPWR _00478_ sky130_fd_sc_hd__nand2_1
XFILLER_0_146_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09131_ _00408_ _00409_ VGND VGND VPWR VPWR _00410_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09062_ net666 net675 net374 net365 VGND VGND VPWR VPWR _00342_ sky130_fd_sc_hd__nand4_2
XFILLER_0_115_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09964_ _01227_ VGND VGND VPWR VPWR _01232_ sky130_fd_sc_hd__inv_2
XFILLER_0_0_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08915_ _08108_ net885 _00171_ _00172_ VGND VGND VPWR VPWR _00196_ sky130_fd_sc_hd__o211a_1
X_09895_ _01093_ _01094_ VGND VGND VPWR VPWR _01165_ sky130_fd_sc_hd__or2_1
X_08846_ _08062_ _08064_ _08063_ VGND VGND VPWR VPWR _00128_ sky130_fd_sc_hd__a21bo_1
X_08777_ net684 net384 VGND VGND VPWR VPWR _08088_ sky130_fd_sc_hd__nand2_1
XFILLER_0_138_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10670_ net769 net380 net372 net777 VGND VGND VPWR VPWR _01896_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_75_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_137_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09329_ _00598_ _00604_ _00605_ VGND VGND VPWR VPWR _00606_ sky130_fd_sc_hd__nand3_1
XFILLER_0_118_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12340_ _03668_ _03687_ VGND VGND VPWR VPWR _03688_ sky130_fd_sc_hd__xnor2_1
Xclone66 net634 VGND VGND VPWR VPWR net872 sky130_fd_sc_hd__buf_4
XFILLER_0_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12271_ _03611_ _03612_ VGND VGND VPWR VPWR _03613_ sky130_fd_sc_hd__nand2_1
XFILLER_0_121_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14010_ _05421_ _05422_ VGND VGND VPWR VPWR _05511_ sky130_fd_sc_hd__and2_1
X_11222_ _02470_ _02471_ _02435_ VGND VGND VPWR VPWR _02473_ sky130_fd_sc_hd__o21ai_2
X_11153_ _02394_ _02395_ _02396_ VGND VGND VPWR VPWR _02398_ sky130_fd_sc_hd__o21ai_1
X_10104_ _01368_ _01369_ VGND VGND VPWR VPWR _01370_ sky130_fd_sc_hd__xnor2_1
X_15961_ _07592_ _07591_ VGND VGND VPWR VPWR _07638_ sky130_fd_sc_hd__and2b_1
X_11084_ _02318_ _02319_ _02320_ VGND VGND VPWR VPWR _02323_ sky130_fd_sc_hd__a21o_1
X_10035_ _01291_ _01248_ _01300_ VGND VGND VPWR VPWR _01302_ sky130_fd_sc_hd__o21a_1
X_14912_ _06043_ _06494_ VGND VGND VPWR VPWR _06496_ sky130_fd_sc_hd__or2_1
X_15892_ _07561_ _07562_ VGND VGND VPWR VPWR _07563_ sky130_fd_sc_hd__xor2_1
X_14843_ _06420_ VGND VGND VPWR VPWR _06422_ sky130_fd_sc_hd__inv_2
X_14774_ net324 net569 net579 net239 VGND VGND VPWR VPWR _06346_ sky130_fd_sc_hd__a22o_1
X_11986_ _03286_ _03304_ VGND VGND VPWR VPWR _03305_ sky130_fd_sc_hd__xnor2_2
X_13725_ _05069_ _05070_ _05201_ VGND VGND VPWR VPWR _05202_ sky130_fd_sc_hd__a21oi_1
X_10937_ _02097_ _02113_ _02163_ VGND VGND VPWR VPWR _02164_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_14_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13656_ _05031_ _05033_ VGND VGND VPWR VPWR _05127_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10868_ net802 net389 _02093_ VGND VGND VPWR VPWR _02094_ sky130_fd_sc_hd__and3_1
XFILLER_0_116_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12607_ net189 net754 net762 net179 VGND VGND VPWR VPWR _03981_ sky130_fd_sc_hd__a22o_1
X_16375_ clknet_4_3_0_clk _00088_ net332 VGND VGND VPWR VPWR D_sin\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_27_868 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13587_ _05051_ VGND VGND VPWR VPWR _00084_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_137_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10799_ _01990_ _01987_ _01989_ VGND VGND VPWR VPWR _02025_ sky130_fd_sc_hd__a21o_1
XFILLER_0_121_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15326_ net166 net676 _06945_ _06946_ VGND VGND VPWR VPWR _06948_ sky130_fd_sc_hd__nand4_1
X_12538_ _03862_ _03876_ _03904_ _03872_ VGND VGND VPWR VPWR _03905_ sky130_fd_sc_hd__o211a_1
XFILLER_0_121_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_124_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15257_ _06750_ net893 _06871_ _06872_ VGND VGND VPWR VPWR _06873_ sky130_fd_sc_hd__o211ai_4
X_12469_ _03827_ _03828_ VGND VGND VPWR VPWR _03829_ sky130_fd_sc_hd__xnor2_1
X_14208_ _05724_ _05725_ VGND VGND VPWR VPWR _05726_ sky130_fd_sc_hd__nand2_1
XFILLER_0_111_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15188_ _06709_ _06711_ _06710_ net563 VGND VGND VPWR VPWR _06797_ sky130_fd_sc_hd__a22o_1
XFILLER_0_39_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14139_ _05630_ _05650_ VGND VGND VPWR VPWR _05651_ sky130_fd_sc_hd__and2_1
Xfanout409 net51 VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__buf_2
XFILLER_0_10_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08700_ net701 net408 _08008_ VGND VGND VPWR VPWR _08012_ sky130_fd_sc_hd__a21o_1
X_09680_ net538 _00191_ VGND VGND VPWR VPWR _00953_ sky130_fd_sc_hd__or2_1
X_08631_ _07020_ _07075_ _07434_ _07466_ VGND VGND VPWR VPWR _07477_ sky130_fd_sc_hd__and4b_1
XFILLER_0_55_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08562_ _06519_ _06508_ VGND VGND VPWR VPWR _06726_ sky130_fd_sc_hd__or2b_1
XFILLER_0_147_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08493_ _05937_ _05948_ VGND VGND VPWR VPWR _05970_ sky130_fd_sc_hd__nand2_1
XFILLER_0_64_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09114_ _00306_ _00309_ VGND VGND VPWR VPWR _00393_ sky130_fd_sc_hd__nor2_1
XFILLER_0_143_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09045_ net694 net532 net348 net506 VGND VGND VPWR VPWR _00325_ sky130_fd_sc_hd__nand4_1
XFILLER_0_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_871 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09947_ _01195_ _01196_ _01215_ VGND VGND VPWR VPWR _01216_ sky130_fd_sc_hd__a21o_1
X_09878_ net645 net465 VGND VGND VPWR VPWR _01148_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08829_ _08137_ _08138_ VGND VGND VPWR VPWR _08139_ sky130_fd_sc_hd__xnor2_1
X_11840_ _03143_ _03145_ VGND VGND VPWR VPWR _03146_ sky130_fd_sc_hd__xor2_2
XFILLER_0_67_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11771_ _02984_ _03069_ VGND VGND VPWR VPWR _03071_ sky130_fd_sc_hd__nor2_1
X_13510_ net748 net250 _04965_ _04966_ VGND VGND VPWR VPWR _04967_ sky130_fd_sc_hd__o2bb2a_1
X_10722_ _01943_ _01944_ _01946_ _01947_ VGND VGND VPWR VPWR _01948_ sky130_fd_sc_hd__a211oi_2
X_14490_ _06030_ _06031_ _06028_ _06029_ VGND VGND VPWR VPWR _06033_ sky130_fd_sc_hd__o211ai_4
X_13441_ net714 net723 net295 net284 VGND VGND VPWR VPWR _04892_ sky130_fd_sc_hd__and4_1
XFILLER_0_138_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10653_ net717 net527 net399 net751 VGND VGND VPWR VPWR _01879_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_82_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16160_ net262 net638 VGND VGND VPWR VPWR _07854_ sky130_fd_sc_hd__nand2_1
XFILLER_0_106_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13372_ net214 net204 net152 VGND VGND VPWR VPWR _04817_ sky130_fd_sc_hd__and3_1
X_10584_ _01807_ _01808_ _01800_ VGND VGND VPWR VPWR _01810_ sky130_fd_sc_hd__a21o_1
XFILLER_0_50_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15111_ _06709_ _06712_ VGND VGND VPWR VPWR _06713_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_140_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12323_ _03632_ _03635_ VGND VGND VPWR VPWR _03670_ sky130_fd_sc_hd__or2_1
XFILLER_0_133_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16091_ _07777_ _07778_ VGND VGND VPWR VPWR _07779_ sky130_fd_sc_hd__nor2_1
XFILLER_0_23_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15042_ net210 net200 net668 VGND VGND VPWR VPWR _06638_ sky130_fd_sc_hd__and3_1
X_12254_ _03570_ _03573_ VGND VGND VPWR VPWR _03595_ sky130_fd_sc_hd__or2_1
X_11205_ _02449_ _02454_ VGND VGND VPWR VPWR _02455_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_76_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12185_ _03519_ _03520_ VGND VGND VPWR VPWR _03521_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_118_Left_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11136_ _02277_ VGND VGND VPWR VPWR _02380_ sky130_fd_sc_hd__inv_2
X_15944_ _07620_ VGND VGND VPWR VPWR _00108_ sky130_fd_sc_hd__clkbuf_1
X_11067_ _02229_ _02231_ _02302_ VGND VGND VPWR VPWR _02304_ sky130_fd_sc_hd__a21o_1
X_10018_ _01284_ _01285_ VGND VGND VPWR VPWR _01286_ sky130_fd_sc_hd__xnor2_1
X_15875_ next_state _07544_ _07545_ VGND VGND VPWR VPWR _00107_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_25_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14826_ _06337_ _06363_ _06362_ VGND VGND VPWR VPWR _06403_ sky130_fd_sc_hd__and3_1
XFILLER_0_98_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14757_ _06324_ _06325_ _06308_ VGND VGND VPWR VPWR _06327_ sky130_fd_sc_hd__a21oi_1
X_11969_ _03180_ _03183_ VGND VGND VPWR VPWR _03286_ sky130_fd_sc_hd__or2_1
XFILLER_0_86_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_127_Left_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13708_ _05181_ _05182_ VGND VGND VPWR VPWR _05183_ sky130_fd_sc_hd__or2_1
X_14688_ _06248_ _06249_ _06250_ VGND VGND VPWR VPWR _06251_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_128_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13639_ net712 net275 VGND VGND VPWR VPWR _05108_ sky130_fd_sc_hd__nand2_1
XFILLER_0_54_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16358_ clknet_4_7_0_clk _00071_ net338 VGND VGND VPWR VPWR D_cos\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_26_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15309_ net296 net532 VGND VGND VPWR VPWR _06929_ sky130_fd_sc_hd__and2_1
XFILLER_0_143_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16289_ clknet_4_14_0_clk _00002_ net344 VGND VGND VPWR VPWR Q_cos\[2\] sky130_fd_sc_hd__dfrtp_2
XFILLER_0_140_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_136_Left_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout206 net208 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__buf_4
X_09801_ _00991_ _00992_ VGND VGND VPWR VPWR _01072_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout217 net218 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__buf_2
XFILLER_0_5_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout228 net229 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_5_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout239 net241 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__clkbuf_4
X_09732_ _01002_ _00996_ _00997_ VGND VGND VPWR VPWR _01004_ sky130_fd_sc_hd__or3_2
X_09663_ _00877_ _00880_ VGND VGND VPWR VPWR _00936_ sky130_fd_sc_hd__or2_1
X_08614_ _07227_ _07238_ _07281_ VGND VGND VPWR VPWR _07292_ sky130_fd_sc_hd__a21o_1
X_09594_ _00867_ _00762_ VGND VGND VPWR VPWR _00868_ sky130_fd_sc_hd__or2_1
XFILLER_0_89_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_145_Left_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08545_ _05547_ _05460_ _05536_ VGND VGND VPWR VPWR _06541_ sky130_fd_sc_hd__nand3_1
XFILLER_0_119_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08476_ _05742_ _05752_ _05774_ VGND VGND VPWR VPWR _05785_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_49_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09028_ _00198_ _00204_ VGND VGND VPWR VPWR _00308_ sky130_fd_sc_hd__and2_1
XFILLER_0_32_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout740 net746 VGND VGND VPWR VPWR net740 sky130_fd_sc_hd__clkbuf_4
Xfanout751 net755 VGND VGND VPWR VPWR net751 sky130_fd_sc_hd__clkbuf_4
Xfanout762 net763 VGND VGND VPWR VPWR net762 sky130_fd_sc_hd__clkbuf_4
Xfanout773 net13 VGND VGND VPWR VPWR net773 sky130_fd_sc_hd__clkbuf_4
X_13990_ net611 net248 VGND VGND VPWR VPWR _05489_ sky130_fd_sc_hd__nand2_1
Xfanout784 net11 VGND VGND VPWR VPWR net784 sky130_fd_sc_hd__clkbuf_2
Xfanout795 net10 VGND VGND VPWR VPWR net795 sky130_fd_sc_hd__buf_4
X_12941_ _04261_ _04265_ _04344_ _04346_ VGND VGND VPWR VPWR _04347_ sky130_fd_sc_hd__o211a_1
XFILLER_0_88_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15660_ _07309_ _07310_ VGND VGND VPWR VPWR _07311_ sky130_fd_sc_hd__xnor2_1
X_12872_ _04208_ _04210_ _04209_ VGND VGND VPWR VPWR _04272_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_68_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14611_ net187 net590 net599 net177 VGND VGND VPWR VPWR _06166_ sky130_fd_sc_hd__a22oi_2
X_11823_ _03009_ _03033_ _03126_ VGND VGND VPWR VPWR _03128_ sky130_fd_sc_hd__o21a_1
X_15591_ _07148_ _07146_ VGND VGND VPWR VPWR _07236_ sky130_fd_sc_hd__and2b_1
XFILLER_0_28_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14542_ net211 net678 net684 net201 VGND VGND VPWR VPWR _06090_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_95_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11754_ _03049_ _03052_ VGND VGND VPWR VPWR _03053_ sky130_fd_sc_hd__xnor2_2
X_10705_ _01843_ _01929_ _01928_ _01904_ VGND VGND VPWR VPWR _01931_ sky130_fd_sc_hd__o211a_1
X_14473_ net159 net309 net571 net576 VGND VGND VPWR VPWR _06015_ sky130_fd_sc_hd__and4_1
X_11685_ _02885_ _02883_ VGND VGND VPWR VPWR _02978_ sky130_fd_sc_hd__or2b_1
XFILLER_0_83_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16212_ _04540_ net657 VGND VGND VPWR VPWR _07910_ sky130_fd_sc_hd__nor2_1
X_13424_ _04867_ _04873_ VGND VGND VPWR VPWR _04874_ sky130_fd_sc_hd__xor2_2
X_10636_ _01831_ _01830_ _01829_ VGND VGND VPWR VPWR _01862_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_11_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16143_ net287 net278 net619 VGND VGND VPWR VPWR _07836_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_3_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13355_ _04794_ _04795_ _04797_ VGND VGND VPWR VPWR _04799_ sky130_fd_sc_hd__nand3_1
X_10567_ _01790_ _01791_ _01787_ VGND VGND VPWR VPWR _01793_ sky130_fd_sc_hd__a21o_1
XFILLER_0_122_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12306_ _03403_ _03528_ _03649_ _03651_ VGND VGND VPWR VPWR _03652_ sky130_fd_sc_hd__a31o_1
X_16074_ _07683_ _07687_ _07685_ VGND VGND VPWR VPWR _07762_ sky130_fd_sc_hd__o21ba_1
X_13286_ _04714_ _04722_ _04723_ VGND VGND VPWR VPWR _04724_ sky130_fd_sc_hd__nand3_1
X_10498_ _01705_ _01706_ _01711_ VGND VGND VPWR VPWR _01724_ sky130_fd_sc_hd__a21o_1
X_15025_ _06616_ _06618_ _06609_ VGND VGND VPWR VPWR _06620_ sky130_fd_sc_hd__a21o_1
X_12237_ _03557_ _03576_ VGND VGND VPWR VPWR _03577_ sky130_fd_sc_hd__xnor2_1
X_12168_ net145 net467 VGND VGND VPWR VPWR _03502_ sky130_fd_sc_hd__nand2_1
X_11119_ _02358_ _02359_ _02360_ VGND VGND VPWR VPWR _02361_ sky130_fd_sc_hd__nand3_4
X_12099_ _03423_ _03426_ VGND VGND VPWR VPWR _03427_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_127_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput6 D[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_2
X_15927_ _07600_ _07601_ VGND VGND VPWR VPWR _07602_ sky130_fd_sc_hd__and2b_1
XFILLER_0_36_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15858_ _07504_ _07526_ VGND VGND VPWR VPWR _07527_ sky130_fd_sc_hd__xor2_1
XFILLER_0_143_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14809_ _06382_ _06383_ VGND VGND VPWR VPWR _06384_ sky130_fd_sc_hd__xnor2_1
X_15789_ _07450_ _07451_ VGND VGND VPWR VPWR _07452_ sky130_fd_sc_hd__xor2_1
XFILLER_0_86_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08330_ net693 net384 VGND VGND VPWR VPWR _04196_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08261_ _02822_ _02833_ VGND VGND VPWR VPWR _03442_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_15_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08192_ net858 _02681_ _02496_ VGND VGND VPWR VPWR _02692_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_42_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09715_ net620 net347 net500 VGND VGND VPWR VPWR _00987_ sky130_fd_sc_hd__and3_1
X_09646_ _00904_ _00905_ _00918_ VGND VGND VPWR VPWR _00919_ sky130_fd_sc_hd__a21o_1
XFILLER_0_96_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09577_ net375 net366 VGND VGND VPWR VPWR _00851_ sky130_fd_sc_hd__or2_4
XFILLER_0_78_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08528_ net603 net699 net377 net368 VGND VGND VPWR VPWR _06355_ sky130_fd_sc_hd__and4_1
XFILLER_0_38_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08459_ _04992_ _04981_ VGND VGND VPWR VPWR _05601_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11470_ net713 net722 net491 net480 VGND VGND VPWR VPWR _02743_ sky130_fd_sc_hd__and4_1
XFILLER_0_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10421_ net787 net498 _01636_ _01637_ VGND VGND VPWR VPWR _01647_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_104_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13140_ _04481_ _04516_ _04517_ VGND VGND VPWR VPWR _04564_ sky130_fd_sc_hd__nor3_2
X_10352_ D_sin\[14\] Q_cos\[14\] VGND VGND VPWR VPWR _01584_ sky130_fd_sc_hd__and2b_1
XFILLER_0_20_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13071_ _04484_ _04487_ _04488_ VGND VGND VPWR VPWR _04489_ sky130_fd_sc_hd__and3_1
X_10283_ _01524_ VGND VGND VPWR VPWR _00042_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_103_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12022_ _03341_ _03342_ VGND VGND VPWR VPWR _03343_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout570 net571 VGND VGND VPWR VPWR net570 sky130_fd_sc_hd__buf_2
Xfanout581 net582 VGND VGND VPWR VPWR net581 sky130_fd_sc_hd__buf_2
Xfanout592 net594 VGND VGND VPWR VPWR net592 sky130_fd_sc_hd__clkbuf_4
X_13973_ _05382_ _05366_ VGND VGND VPWR VPWR _05472_ sky130_fd_sc_hd__and2b_1
X_15712_ _07189_ _07187_ _07274_ VGND VGND VPWR VPWR _07368_ sky130_fd_sc_hd__a21bo_1
X_12924_ _04167_ _04242_ _04329_ VGND VGND VPWR VPWR _04330_ sky130_fd_sc_hd__o21a_1
XFILLER_0_69_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15643_ _07290_ _07291_ VGND VGND VPWR VPWR _07293_ sky130_fd_sc_hd__and2_1
X_12855_ _04252_ _04253_ VGND VGND VPWR VPWR _04254_ sky130_fd_sc_hd__nor2_1
X_11806_ _03107_ _03108_ VGND VGND VPWR VPWR _03109_ sky130_fd_sc_hd__xnor2_1
X_15574_ _07143_ _07217_ VGND VGND VPWR VPWR _07218_ sky130_fd_sc_hd__xor2_1
XFILLER_0_68_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12786_ _04173_ _04176_ _04175_ VGND VGND VPWR VPWR _04178_ sky130_fd_sc_hd__a21o_1
XFILLER_0_145_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14525_ _06053_ _06054_ _06071_ VGND VGND VPWR VPWR _06072_ sky130_fd_sc_hd__a21o_2
XFILLER_0_56_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11737_ _03009_ _03033_ VGND VGND VPWR VPWR _03034_ sky130_fd_sc_hd__xor2_1
XFILLER_0_126_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14456_ _05961_ _05963_ _05962_ VGND VGND VPWR VPWR _05996_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_4_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11668_ _02955_ _02956_ _02957_ VGND VGND VPWR VPWR _02959_ sky130_fd_sc_hd__nand3_1
XFILLER_0_24_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13407_ D_sin\[5\] _04855_ _04752_ VGND VGND VPWR VPWR _04856_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10619_ _01839_ _01843_ _01844_ _01728_ VGND VGND VPWR VPWR _01845_ sky130_fd_sc_hd__o211a_1
X_14387_ _05912_ _05913_ _05919_ VGND VGND VPWR VPWR _05920_ sky130_fd_sc_hd__nand3_1
X_11599_ _02786_ _02787_ VGND VGND VPWR VPWR _02884_ sky130_fd_sc_hd__and2b_1
XFILLER_0_113_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16126_ _07726_ _07730_ VGND VGND VPWR VPWR _07818_ sky130_fd_sc_hd__nor2_1
X_13338_ _04778_ _04779_ VGND VGND VPWR VPWR _04780_ sky130_fd_sc_hd__xnor2_1
X_16057_ _07669_ _07741_ _07742_ VGND VGND VPWR VPWR _07743_ sky130_fd_sc_hd__mux2_1
X_13269_ net615 net167 VGND VGND VPWR VPWR _04705_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15008_ _06495_ _06600_ VGND VGND VPWR VPWR _06601_ sky130_fd_sc_hd__xor2_1
XFILLER_0_138_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09500_ _00767_ _00774_ VGND VGND VPWR VPWR _00775_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09431_ net682 net689 net484 net474 VGND VGND VPWR VPWR _00707_ sky130_fd_sc_hd__and4_1
XFILLER_0_78_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09362_ _00612_ _00638_ VGND VGND VPWR VPWR _00639_ sky130_fd_sc_hd__xnor2_1
X_08313_ _03987_ _03998_ VGND VGND VPWR VPWR _04009_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09293_ _00487_ _00502_ VGND VGND VPWR VPWR _00570_ sky130_fd_sc_hd__and2b_1
XFILLER_0_75_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_11 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_22 net936 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08244_ net544 net387 _03225_ _03236_ VGND VGND VPWR VPWR _03257_ sky130_fd_sc_hd__o2bb2a_1
XANTENNA_33 net692 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_44 net51 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_55 net421 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_144_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08175_ net603 net489 net478 net698 VGND VGND VPWR VPWR _02506_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_132_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_868 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10970_ net785 net452 VGND VGND VPWR VPWR _02198_ sky130_fd_sc_hd__nand2_1
X_09629_ _00842_ _00841_ VGND VGND VPWR VPWR _00902_ sky130_fd_sc_hd__and2b_1
XFILLER_0_78_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12640_ _03957_ _04014_ _03816_ VGND VGND VPWR VPWR _04017_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_38_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12571_ _03939_ _03940_ VGND VGND VPWR VPWR _03941_ sky130_fd_sc_hd__nor2_1
XFILLER_0_148_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14310_ net314 _04540_ _05782_ _05783_ VGND VGND VPWR VPWR _05836_ sky130_fd_sc_hd__o31a_1
X_11522_ _02799_ VGND VGND VPWR VPWR _00064_ sky130_fd_sc_hd__clkbuf_1
X_15290_ _06902_ _06907_ VGND VGND VPWR VPWR _06908_ sky130_fd_sc_hd__xor2_2
XFILLER_0_136_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14241_ _05754_ _05760_ VGND VGND VPWR VPWR _05761_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_80_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11453_ net757 net444 VGND VGND VPWR VPWR _02725_ sky130_fd_sc_hd__nand2_1
X_10404_ _01628_ _01629_ VGND VGND VPWR VPWR _01630_ sky130_fd_sc_hd__or2b_1
X_14172_ _05683_ _05686_ VGND VGND VPWR VPWR _05687_ sky130_fd_sc_hd__xor2_1
X_11384_ _02646_ _02647_ _02631_ VGND VGND VPWR VPWR _02650_ sky130_fd_sc_hd__a21o_1
XFILLER_0_104_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13123_ net293 _04460_ _04463_ _04461_ VGND VGND VPWR VPWR _04546_ sky130_fd_sc_hd__a22o_1
XFILLER_0_21_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10335_ Q_cos\[12\] D_sin\[12\] VGND VGND VPWR VPWR _01569_ sky130_fd_sc_hd__and2b_1
XFILLER_0_103_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13054_ _04366_ _04368_ _04367_ VGND VGND VPWR VPWR _04471_ sky130_fd_sc_hd__a21bo_1
X_10266_ net133 net109 VGND VGND VPWR VPWR _01510_ sky130_fd_sc_hd__and2b_1
X_12005_ _03263_ _03266_ _03264_ VGND VGND VPWR VPWR _03325_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_84_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10197_ _01439_ _01446_ _01449_ VGND VGND VPWR VPWR _01451_ sky130_fd_sc_hd__o21a_1
XFILLER_0_108_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13956_ _05451_ _05452_ VGND VGND VPWR VPWR _05453_ sky130_fd_sc_hd__xnor2_1
X_12907_ _04307_ _04308_ _04309_ VGND VGND VPWR VPWR _04311_ sky130_fd_sc_hd__a21o_1
X_13887_ _05290_ _05289_ VGND VGND VPWR VPWR _05378_ sky130_fd_sc_hd__and2b_1
X_15626_ _07189_ _07274_ VGND VGND VPWR VPWR _07275_ sky130_fd_sc_hd__xnor2_2
X_12838_ _04128_ _04134_ _04135_ VGND VGND VPWR VPWR _04235_ sky130_fd_sc_hd__or3_1
XFILLER_0_8_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15557_ _07197_ _07198_ VGND VGND VPWR VPWR _07199_ sky130_fd_sc_hd__nor2_1
X_12769_ _04157_ _04158_ VGND VGND VPWR VPWR _04159_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14508_ _05997_ _06002_ VGND VGND VPWR VPWR _06053_ sky130_fd_sc_hd__or2b_1
X_15488_ _07122_ _07123_ VGND VGND VPWR VPWR _07124_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_127_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput20 Q[0] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_114_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput31 Q[2] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_2
X_14439_ net220 net678 VGND VGND VPWR VPWR _05977_ sky130_fd_sc_hd__nand2_1
XFILLER_0_114_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput42 cos[12] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__buf_2
XFILLER_0_142_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput53 cos[5] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_1
Xinput64 sin[14] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_24_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput75 sin[7] VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__clkbuf_2
X_16109_ net270 net638 _07797_ VGND VGND VPWR VPWR _07799_ sky130_fd_sc_hd__and3_1
XFILLER_0_141_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09980_ _01071_ _01246_ VGND VGND VPWR VPWR _01248_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08931_ _00197_ _00211_ VGND VGND VPWR VPWR _00212_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08862_ net534 net357 _00141_ _00142_ VGND VGND VPWR VPWR _00144_ sky130_fd_sc_hd__nand4_1
X_08793_ _08101_ _08102_ net882 VGND VGND VPWR VPWR _08104_ sky130_fd_sc_hd__nand3_4
XFILLER_0_79_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09414_ _00541_ _00689_ VGND VGND VPWR VPWR _00690_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_149_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09345_ _00618_ _00619_ _00621_ VGND VGND VPWR VPWR _00622_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_63_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09276_ _00551_ _00553_ VGND VGND VPWR VPWR _00554_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_63_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08227_ _02996_ _03029_ _03062_ VGND VGND VPWR VPWR _03073_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_132_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08158_ net567 net577 net377 net368 VGND VGND VPWR VPWR _02321_ sky130_fd_sc_hd__nand4_1
XFILLER_0_31_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10120_ Q_sin\[1\] D_cos\[1\] VGND VGND VPWR VPWR _01384_ sky130_fd_sc_hd__or2b_1
X_10051_ _01316_ _01317_ VGND VGND VPWR VPWR _01318_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13810_ _05292_ _05293_ VGND VGND VPWR VPWR _05294_ sky130_fd_sc_hd__nor2_1
X_14790_ _06356_ _06361_ _06338_ _06339_ VGND VGND VPWR VPWR _06363_ sky130_fd_sc_hd__o211ai_2
X_13741_ _05216_ _05218_ VGND VGND VPWR VPWR _05219_ sky130_fd_sc_hd__or2_2
X_10953_ _01942_ _01961_ VGND VGND VPWR VPWR _02182_ sky130_fd_sc_hd__and2_1
X_13672_ _05087_ _05093_ VGND VGND VPWR VPWR _05143_ sky130_fd_sc_hd__nand2_1
X_10884_ _02065_ _02058_ _02064_ VGND VGND VPWR VPWR _02110_ sky130_fd_sc_hd__nand3_1
XFILLER_0_85_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15411_ _06946_ _06948_ VGND VGND VPWR VPWR _07040_ sky130_fd_sc_hd__nand2_1
X_12623_ net301 net805 _03995_ _03996_ VGND VGND VPWR VPWR _03999_ sky130_fd_sc_hd__o2bb2a_1
X_16391_ clknet_4_12_0_clk _00104_ net345 VGND VGND VPWR VPWR Q_sin\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_81_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15342_ _06952_ _06964_ VGND VGND VPWR VPWR _06965_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_53_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12554_ _03917_ _03919_ _03918_ VGND VGND VPWR VPWR _03923_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_65_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11505_ _02780_ _02781_ VGND VGND VPWR VPWR _02782_ sky130_fd_sc_hd__xnor2_1
X_15273_ _06888_ _06889_ VGND VGND VPWR VPWR _06891_ sky130_fd_sc_hd__or2_1
XFILLER_0_53_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12485_ _03829_ _03846_ VGND VGND VPWR VPWR _03847_ sky130_fd_sc_hd__xnor2_1
X_14224_ _05738_ _05739_ _05741_ VGND VGND VPWR VPWR _05744_ sky130_fd_sc_hd__and3_1
X_11436_ _02492_ _02704_ _02706_ VGND VGND VPWR VPWR _02707_ sky130_fd_sc_hd__o21a_1
XFILLER_0_124_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14155_ _05667_ _05668_ VGND VGND VPWR VPWR _05669_ sky130_fd_sc_hd__or2_1
X_11367_ _02526_ _02535_ _02534_ VGND VGND VPWR VPWR _02631_ sky130_fd_sc_hd__a21o_1
XFILLER_0_21_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13106_ _04525_ _04526_ _04354_ VGND VGND VPWR VPWR _04528_ sky130_fd_sc_hd__a21o_1
X_10318_ _01554_ VGND VGND VPWR VPWR _00047_ sky130_fd_sc_hd__clkbuf_1
X_14086_ net279 net148 net138 net288 VGND VGND VPWR VPWR _05594_ sky130_fd_sc_hd__a22oi_2
X_11298_ _02553_ _02554_ _02555_ VGND VGND VPWR VPWR _02556_ sky130_fd_sc_hd__nand3_2
X_13037_ _04450_ _04451_ VGND VGND VPWR VPWR _04452_ sky130_fd_sc_hd__xnor2_1
X_10249_ net88 _01495_ net130 VGND VGND VPWR VPWR _01496_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14988_ _06487_ _06579_ VGND VGND VPWR VPWR _06580_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13939_ _05165_ _05433_ VGND VGND VPWR VPWR _05434_ sky130_fd_sc_hd__xor2_1
XFILLER_0_135_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15609_ _07241_ _07255_ VGND VGND VPWR VPWR _07256_ sky130_fd_sc_hd__or2_1
XFILLER_0_17_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09130_ net593 net937 VGND VGND VPWR VPWR _00409_ sky130_fd_sc_hd__or2_1
XFILLER_0_8_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09061_ net666 net374 net365 net675 VGND VGND VPWR VPWR _00341_ sky130_fd_sc_hd__a22o_1
XFILLER_0_44_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09963_ _01231_ VGND VGND VPWR VPWR _00015_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08914_ _08048_ _08142_ VGND VGND VPWR VPWR _00195_ sky130_fd_sc_hd__nor2_1
X_09894_ _01162_ _01142_ _01143_ VGND VGND VPWR VPWR _01164_ sky130_fd_sc_hd__and3_1
X_08845_ _00123_ _00124_ _00125_ VGND VGND VPWR VPWR _00127_ sky130_fd_sc_hd__nand3_1
X_08776_ _08078_ _08086_ VGND VGND VPWR VPWR _08087_ sky130_fd_sc_hd__xor2_2
XFILLER_0_79_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_8_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_8_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_137_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09328_ _00601_ _00602_ _00603_ VGND VGND VPWR VPWR _00605_ sky130_fd_sc_hd__a21o_1
XFILLER_0_63_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09259_ net631 net621 net402 net392 VGND VGND VPWR VPWR _00537_ sky130_fd_sc_hd__nand4_1
XFILLER_0_51_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclone67 net644 VGND VGND VPWR VPWR net873 sky130_fd_sc_hd__buf_4
XFILLER_0_106_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_880 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12270_ _03567_ _03599_ _03610_ VGND VGND VPWR VPWR _03612_ sky130_fd_sc_hd__o21bai_1
X_11221_ _02435_ _02470_ _02471_ VGND VGND VPWR VPWR _02472_ sky130_fd_sc_hd__or3_2
XFILLER_0_105_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11152_ net756 net471 net462 net765 VGND VGND VPWR VPWR _02396_ sky130_fd_sc_hd__a22o_1
XFILLER_0_101_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10103_ _01206_ _01294_ _01198_ VGND VGND VPWR VPWR _01369_ sky130_fd_sc_hd__o21a_1
XFILLER_0_101_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15960_ _07584_ _07590_ VGND VGND VPWR VPWR _07637_ sky130_fd_sc_hd__and2b_1
X_11083_ _02318_ _02319_ _02320_ VGND VGND VPWR VPWR _02322_ sky130_fd_sc_hd__nand3_2
X_10034_ _01291_ _01248_ _01300_ VGND VGND VPWR VPWR _01301_ sky130_fd_sc_hd__nor3_1
X_14911_ _06043_ _06494_ VGND VGND VPWR VPWR _06495_ sky130_fd_sc_hd__nand2_1
X_15891_ net296 net648 _07475_ _07474_ VGND VGND VPWR VPWR _07562_ sky130_fd_sc_hd__a31o_1
X_14842_ net219 net605 net700 net203 VGND VGND VPWR VPWR _06420_ sky130_fd_sc_hd__a22o_1
X_14773_ net221 net588 VGND VGND VPWR VPWR _06345_ sky130_fd_sc_hd__and2_1
X_11985_ _03302_ _03303_ VGND VGND VPWR VPWR _03304_ sky130_fd_sc_hd__nand2_1
XFILLER_0_98_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10936_ _02110_ _02109_ _02111_ VGND VGND VPWR VPWR _02163_ sky130_fd_sc_hd__and3_1
X_13724_ _05062_ _05067_ VGND VGND VPWR VPWR _05201_ sky130_fd_sc_hd__and2b_1
XFILLER_0_86_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10867_ _02091_ _02092_ VGND VGND VPWR VPWR _02093_ sky130_fd_sc_hd__nor2_1
X_13655_ _05078_ _05125_ VGND VGND VPWR VPWR _05126_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_73_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12606_ net189 net179 net754 net762 VGND VGND VPWR VPWR _03980_ sky130_fd_sc_hd__nand4_1
X_13586_ D_sin\[7\] _05050_ _04752_ VGND VGND VPWR VPWR _05051_ sky130_fd_sc_hd__mux2_1
X_16374_ clknet_4_3_0_clk _00087_ net333 VGND VGND VPWR VPWR D_sin\[10\] sky130_fd_sc_hd__dfrtp_1
X_10798_ _02017_ _02022_ _02023_ VGND VGND VPWR VPWR _02024_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_143_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15325_ net166 net676 _06945_ _06946_ VGND VGND VPWR VPWR _06947_ sky130_fd_sc_hd__a22o_1
X_12537_ _03843_ _03861_ _03903_ VGND VGND VPWR VPWR _03904_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15256_ _06869_ _06870_ _06851_ VGND VGND VPWR VPWR _06872_ sky130_fd_sc_hd__a21o_1
X_12468_ net198 net804 VGND VGND VPWR VPWR _03828_ sky130_fd_sc_hd__nand2_1
XFILLER_0_112_727 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_850 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11419_ _02685_ _02686_ _02653_ VGND VGND VPWR VPWR _02688_ sky130_fd_sc_hd__a21o_1
X_14207_ _05636_ _05639_ _05723_ VGND VGND VPWR VPWR _05725_ sky130_fd_sc_hd__o21ai_1
X_15187_ _06708_ _06723_ _06724_ _06728_ VGND VGND VPWR VPWR _06796_ sky130_fd_sc_hd__a31o_1
X_12399_ _03750_ _03751_ VGND VGND VPWR VPWR _03752_ sky130_fd_sc_hd__xnor2_1
X_14138_ _05632_ _05649_ VGND VGND VPWR VPWR _05650_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14069_ _05573_ _05574_ VGND VGND VPWR VPWR _05575_ sky130_fd_sc_hd__nor2_1
XFILLER_0_146_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08630_ _06890_ _07456_ VGND VGND VPWR VPWR _07466_ sky130_fd_sc_hd__nor2_1
XFILLER_0_146_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08561_ _06476_ _06497_ VGND VGND VPWR VPWR _06715_ sky130_fd_sc_hd__or2b_1
XFILLER_0_89_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08492_ _05937_ _05948_ VGND VGND VPWR VPWR _05959_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09113_ _00296_ _00314_ _00391_ VGND VGND VPWR VPWR _00392_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_95_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09044_ net694 net348 net506 net532 VGND VGND VPWR VPWR _00324_ sky130_fd_sc_hd__a22o_1
XFILLER_0_5_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09946_ _01213_ _01214_ VGND VGND VPWR VPWR _01215_ sky130_fd_sc_hd__and2b_1
X_09877_ _01145_ _01146_ VGND VGND VPWR VPWR _01147_ sky130_fd_sc_hd__nor2_1
X_08828_ _03051_ _08043_ _08045_ VGND VGND VPWR VPWR _08138_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08759_ _08061_ _08068_ _08069_ VGND VGND VPWR VPWR _08070_ sky130_fd_sc_hd__nand3_1
X_11770_ _02984_ _03069_ VGND VGND VPWR VPWR _03070_ sky130_fd_sc_hd__and2_1
X_10721_ net899 _01945_ _01939_ _01930_ VGND VGND VPWR VPWR _01947_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_83_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13440_ net714 net295 net284 net723 VGND VGND VPWR VPWR _04891_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_137_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10652_ net760 net389 VGND VGND VPWR VPWR _01878_ sky130_fd_sc_hd__nand2_1
XFILLER_0_82_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13371_ _04808_ _04815_ VGND VGND VPWR VPWR _04816_ sky130_fd_sc_hd__xnor2_1
X_10583_ _01800_ _01807_ _01808_ VGND VGND VPWR VPWR _01809_ sky130_fd_sc_hd__nand3_2
X_15110_ net557 _06710_ _06711_ VGND VGND VPWR VPWR _06712_ sky130_fd_sc_hd__a21bo_1
X_12322_ _03643_ _03667_ VGND VGND VPWR VPWR _03668_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16090_ net247 net664 _07776_ VGND VGND VPWR VPWR _07778_ sky130_fd_sc_hd__and3_1
XFILLER_0_134_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15041_ _06627_ _06636_ VGND VGND VPWR VPWR _06637_ sky130_fd_sc_hd__xor2_2
X_12253_ _03584_ _03585_ VGND VGND VPWR VPWR _03594_ sky130_fd_sc_hd__and2b_1
XFILLER_0_31_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11204_ _02450_ _02451_ _02453_ VGND VGND VPWR VPWR _02454_ sky130_fd_sc_hd__o21a_1
X_12184_ _03455_ _03458_ _03516_ _03517_ VGND VGND VPWR VPWR _03520_ sky130_fd_sc_hd__o211a_1
X_11135_ _02377_ _02378_ VGND VGND VPWR VPWR _02379_ sky130_fd_sc_hd__nand2_1
X_15943_ Q_sin\[12\] _07618_ _00186_ VGND VGND VPWR VPWR _07620_ sky130_fd_sc_hd__mux2_1
X_11066_ _02229_ _02231_ _02302_ VGND VGND VPWR VPWR _02303_ sky130_fd_sc_hd__and3_1
X_10017_ _01219_ _01223_ VGND VGND VPWR VPWR _01285_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15874_ net911 _00187_ VGND VGND VPWR VPWR _07545_ sky130_fd_sc_hd__nor2_1
X_14825_ _06363_ _06362_ _06337_ VGND VGND VPWR VPWR _06402_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_116_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14756_ _06308_ _06324_ _06325_ VGND VGND VPWR VPWR _06326_ sky130_fd_sc_hd__and3_1
XFILLER_0_86_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11968_ _03217_ _03218_ _03284_ VGND VGND VPWR VPWR _03285_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_74_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13707_ _05180_ _05162_ _05163_ VGND VGND VPWR VPWR _05182_ sky130_fd_sc_hd__nor3_1
X_10919_ _02136_ _02141_ _02144_ VGND VGND VPWR VPWR _02145_ sky130_fd_sc_hd__and3_1
XFILLER_0_39_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14687_ net324 net239 net560 net569 VGND VGND VPWR VPWR _06250_ sky130_fd_sc_hd__and4_1
X_11899_ _03208_ _03209_ VGND VGND VPWR VPWR _03210_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_128_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13638_ _05105_ _05106_ VGND VGND VPWR VPWR _05107_ sky130_fd_sc_hd__nor2_1
XFILLER_0_42_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16357_ clknet_4_6_0_clk _00070_ net338 VGND VGND VPWR VPWR D_cos\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_125_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13569_ _04935_ _04933_ VGND VGND VPWR VPWR _05032_ sky130_fd_sc_hd__and2b_1
XFILLER_0_143_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15308_ net156 net305 net682 net934 VGND VGND VPWR VPWR _06928_ sky130_fd_sc_hd__nand4_1
XFILLER_0_81_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16288_ clknet_4_10_0_clk _00001_ net341 VGND VGND VPWR VPWR Q_cos\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_42_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15239_ net211 net201 net651 net643 VGND VGND VPWR VPWR _06853_ sky130_fd_sc_hd__and4_1
XFILLER_0_1_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09800_ _01069_ _01070_ VGND VGND VPWR VPWR _01071_ sky130_fd_sc_hd__nand2_4
Xfanout207 net208 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__buf_2
Xfanout218 net219 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__clkbuf_2
Xfanout229 net231 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__clkbuf_4
X_09731_ _00996_ _00997_ _01002_ VGND VGND VPWR VPWR _01003_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_66_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09662_ _00933_ _00934_ VGND VGND VPWR VPWR _00935_ sky130_fd_sc_hd__xnor2_1
X_08613_ _07249_ _07260_ _07271_ VGND VGND VPWR VPWR _07281_ sky130_fd_sc_hd__o21bai_1
X_09593_ _00760_ VGND VGND VPWR VPWR _00867_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08544_ _06508_ _06519_ VGND VGND VPWR VPWR _06530_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_82_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08475_ _04894_ _05763_ VGND VGND VPWR VPWR _05774_ sky130_fd_sc_hd__or2_1
XFILLER_0_92_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_850 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09027_ _00206_ VGND VGND VPWR VPWR _00307_ sky130_fd_sc_hd__inv_2
XFILLER_0_5_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout730 net731 VGND VGND VPWR VPWR net730 sky130_fd_sc_hd__clkbuf_2
Xfanout741 net745 VGND VGND VPWR VPWR net741 sky130_fd_sc_hd__clkbuf_4
X_09929_ net493 _00987_ VGND VGND VPWR VPWR _01198_ sky130_fd_sc_hd__nand2_2
Xfanout752 net755 VGND VGND VPWR VPWR net752 sky130_fd_sc_hd__dlymetal6s2s_1
XPHY_EDGE_ROW_130_Right_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout763 net764 VGND VGND VPWR VPWR net763 sky130_fd_sc_hd__buf_4
Xfanout774 net776 VGND VGND VPWR VPWR net774 sky130_fd_sc_hd__clkbuf_4
Xfanout785 net11 VGND VGND VPWR VPWR net785 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_99_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout796 net799 VGND VGND VPWR VPWR net796 sky130_fd_sc_hd__buf_4
X_12940_ _04248_ _04345_ VGND VGND VPWR VPWR _04346_ sky130_fd_sc_hd__or2_1
XFILLER_0_99_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12871_ _04267_ _04270_ VGND VGND VPWR VPWR _04271_ sky130_fd_sc_hd__xnor2_1
X_14610_ net169 net607 VGND VGND VPWR VPWR _06165_ sky130_fd_sc_hd__nand2_1
X_11822_ _03005_ _03008_ VGND VGND VPWR VPWR _03126_ sky130_fd_sc_hd__nand2_1
X_15590_ _07222_ _07234_ VGND VGND VPWR VPWR _07235_ sky130_fd_sc_hd__xor2_2
XFILLER_0_68_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14541_ net211 net201 net675 net684 VGND VGND VPWR VPWR _06089_ sky130_fd_sc_hd__and4_1
X_11753_ _03050_ VGND VGND VPWR VPWR _03052_ sky130_fd_sc_hd__inv_2
X_10704_ _01904_ _01928_ _01929_ _01843_ VGND VGND VPWR VPWR _01930_ sky130_fd_sc_hd__a211oi_4
X_14472_ net300 net585 VGND VGND VPWR VPWR _06013_ sky130_fd_sc_hd__nand2_1
X_11684_ _02900_ _02976_ VGND VGND VPWR VPWR _02977_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_64_750 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16211_ _07907_ _07908_ VGND VGND VPWR VPWR _07909_ sky130_fd_sc_hd__or2b_1
XFILLER_0_36_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10635_ _01858_ _01859_ _01860_ VGND VGND VPWR VPWR _01861_ sky130_fd_sc_hd__o21bai_1
X_13423_ _04870_ _04871_ VGND VGND VPWR VPWR _04873_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_107_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16142_ net287 net278 net619 VGND VGND VPWR VPWR _07834_ sky130_fd_sc_hd__and3_1
X_13354_ _04794_ _04795_ _04797_ VGND VGND VPWR VPWR _04798_ sky130_fd_sc_hd__a21o_1
X_10566_ _01787_ _01790_ _01791_ VGND VGND VPWR VPWR _01792_ sky130_fd_sc_hd__and3_1
X_12305_ _03530_ _03649_ _03650_ _03588_ VGND VGND VPWR VPWR _03651_ sky130_fd_sc_hd__a22o_1
XFILLER_0_106_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16073_ _07758_ _07759_ VGND VGND VPWR VPWR _07761_ sky130_fd_sc_hd__xnor2_2
X_13285_ _04721_ _04718_ _04719_ VGND VGND VPWR VPWR _04723_ sky130_fd_sc_hd__or3_1
X_10497_ _01719_ _01721_ _01722_ VGND VGND VPWR VPWR _01723_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_32_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15024_ _06609_ _06616_ _06618_ VGND VGND VPWR VPWR _06619_ sky130_fd_sc_hd__nand3_2
X_12236_ _03574_ _03575_ VGND VGND VPWR VPWR _03576_ sky130_fd_sc_hd__xnor2_1
X_12167_ _03498_ _03500_ VGND VGND VPWR VPWR _03501_ sky130_fd_sc_hd__nor2_1
X_11118_ _02251_ _02260_ _02259_ VGND VGND VPWR VPWR _02360_ sky130_fd_sc_hd__a21bo_1
X_12098_ _03424_ _03425_ VGND VGND VPWR VPWR _03426_ sky130_fd_sc_hd__nor2_1
XFILLER_0_36_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15926_ _07464_ _07485_ _07484_ VGND VGND VPWR VPWR _07601_ sky130_fd_sc_hd__a21bo_1
X_11049_ _02190_ _02284_ VGND VGND VPWR VPWR _02285_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_127_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput7 D[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
X_15857_ _07506_ _07525_ VGND VGND VPWR VPWR _07526_ sky130_fd_sc_hd__xnor2_1
X_14808_ net197 net700 VGND VGND VPWR VPWR _06383_ sky130_fd_sc_hd__nand2_1
X_15788_ _07329_ _07351_ _07349_ VGND VGND VPWR VPWR _07451_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_148_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14739_ _06192_ _06306_ VGND VGND VPWR VPWR _06307_ sky130_fd_sc_hd__or2_1
XFILLER_0_46_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08260_ _03279_ _03409_ _03399_ VGND VGND VPWR VPWR _03431_ sky130_fd_sc_hd__a21o_1
XFILLER_0_129_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08191_ _02615_ _02659_ _02670_ _02550_ VGND VGND VPWR VPWR _02681_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_61_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_764 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09714_ net620 net347 net500 net626 VGND VGND VPWR VPWR _00986_ sky130_fd_sc_hd__a22o_1
X_09645_ _00910_ _00917_ VGND VGND VPWR VPWR _00918_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09576_ _00770_ _00772_ _00849_ VGND VGND VPWR VPWR _00850_ sky130_fd_sc_hd__o21ai_1
X_08527_ _06201_ _06322_ _06333_ VGND VGND VPWR VPWR _06344_ sky130_fd_sc_hd__and3_1
XFILLER_0_148_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08458_ _05416_ _05449_ _05427_ VGND VGND VPWR VPWR _05590_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_147_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08389_ _04502_ _04829_ VGND VGND VPWR VPWR _04840_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_52_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10420_ _01623_ _01630_ _01645_ VGND VGND VPWR VPWR _01646_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_33_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10351_ Q_cos\[14\] D_sin\[14\] VGND VGND VPWR VPWR _01583_ sky130_fd_sc_hd__and2b_1
X_13070_ net719 net170 _04485_ _04486_ VGND VGND VPWR VPWR _04488_ sky130_fd_sc_hd__nand4_1
X_10282_ net929 _01523_ net134 VGND VGND VPWR VPWR _01524_ sky130_fd_sc_hd__mux2_1
X_12021_ _03323_ _03324_ _03340_ VGND VGND VPWR VPWR _03342_ sky130_fd_sc_hd__or3b_1
Xfanout560 net561 VGND VGND VPWR VPWR net560 sky130_fd_sc_hd__buf_4
Xfanout571 net572 VGND VGND VPWR VPWR net571 sky130_fd_sc_hd__clkbuf_4
Xfanout582 net33 VGND VGND VPWR VPWR net582 sky130_fd_sc_hd__buf_4
Xfanout593 net31 VGND VGND VPWR VPWR net593 sky130_fd_sc_hd__buf_2
X_13972_ _05468_ _05469_ VGND VGND VPWR VPWR _05470_ sky130_fd_sc_hd__xnor2_2
X_15711_ _07182_ _07090_ _07275_ VGND VGND VPWR VPWR _07367_ sky130_fd_sc_hd__nand3_1
X_12923_ _04237_ _04241_ VGND VGND VPWR VPWR _04329_ sky130_fd_sc_hd__nand2_1
X_15642_ _07284_ _07289_ VGND VGND VPWR VPWR _07291_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12854_ _04222_ _04227_ _04250_ VGND VGND VPWR VPWR _04253_ sky130_fd_sc_hd__and3_1
XFILLER_0_84_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11805_ net610 net468 VGND VGND VPWR VPWR _03108_ sky130_fd_sc_hd__nand2_1
X_15573_ net193 net623 VGND VGND VPWR VPWR _07217_ sky130_fd_sc_hd__nand2_1
X_12785_ _04173_ _04175_ _04176_ VGND VGND VPWR VPWR _04177_ sky130_fd_sc_hd__nand3_1
XFILLER_0_56_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14524_ _06062_ _06070_ VGND VGND VPWR VPWR _06071_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11736_ _03031_ _03032_ VGND VGND VPWR VPWR _03033_ sky130_fd_sc_hd__nand2_1
XFILLER_0_139_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14455_ _05990_ _05993_ _05991_ VGND VGND VPWR VPWR _05995_ sky130_fd_sc_hd__a21o_1
X_11667_ _02955_ _02956_ _02957_ VGND VGND VPWR VPWR _02958_ sky130_fd_sc_hd__a21o_1
XFILLER_0_118_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13406_ _04846_ _04854_ VGND VGND VPWR VPWR _04855_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_107_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10618_ _01725_ _01726_ _01727_ VGND VGND VPWR VPWR _01844_ sky130_fd_sc_hd__a21o_1
X_14386_ _05917_ _05918_ VGND VGND VPWR VPWR _05919_ sky130_fd_sc_hd__nor2_1
X_11598_ _02827_ _02882_ VGND VGND VPWR VPWR _02883_ sky130_fd_sc_hd__xor2_2
XFILLER_0_24_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16125_ _07815_ _07816_ VGND VGND VPWR VPWR _07817_ sky130_fd_sc_hd__nand2_1
XFILLER_0_141_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10549_ net741 net747 net353 net507 VGND VGND VPWR VPWR _01775_ sky130_fd_sc_hd__and4_1
X_13337_ _02154_ net68 VGND VGND VPWR VPWR _04779_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16056_ net936 net619 VGND VGND VPWR VPWR _07742_ sky130_fd_sc_hd__and2_1
XFILLER_0_110_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13268_ _04702_ _04703_ VGND VGND VPWR VPWR _04704_ sky130_fd_sc_hd__nand2_2
X_15007_ _06598_ _06599_ VGND VGND VPWR VPWR _06600_ sky130_fd_sc_hd__or2_1
X_12219_ _03354_ _03506_ _03556_ VGND VGND VPWR VPWR _03557_ sky130_fd_sc_hd__a21bo_1
X_13199_ _04626_ _04627_ _04516_ _04564_ VGND VGND VPWR VPWR _04629_ sky130_fd_sc_hd__a211o_1
XFILLER_0_20_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15909_ _07579_ _07580_ _07577_ _07578_ VGND VGND VPWR VPWR _07582_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_79_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09430_ net682 net484 net474 net689 VGND VGND VPWR VPWR _00706_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_149_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09361_ _00636_ _00637_ VGND VGND VPWR VPWR _00638_ sky130_fd_sc_hd__nor2_1
X_08312_ _02866_ _02888_ _02877_ VGND VGND VPWR VPWR _03998_ sky130_fd_sc_hd__o21ba_1
X_09292_ _00558_ _00482_ VGND VGND VPWR VPWR _00569_ sky130_fd_sc_hd__or2b_1
XFILLER_0_129_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_12 net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08243_ _03225_ _03236_ net544 net387 VGND VGND VPWR VPWR _03246_ sky130_fd_sc_hd__and4bb_1
XANTENNA_23 net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_144_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_34 net692 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_45 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_117_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_56 net459 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08174_ net603 net699 net489 net478 VGND VGND VPWR VPWR _02496_ sky130_fd_sc_hd__and4_1
XFILLER_0_6_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09628_ _00864_ _00865_ _00885_ _00886_ VGND VGND VPWR VPWR _00901_ sky130_fd_sc_hd__nor4_1
XFILLER_0_85_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09559_ net663 net671 net483 net473 VGND VGND VPWR VPWR _00833_ sky130_fd_sc_hd__and4_1
XFILLER_0_38_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12570_ net189 net762 net773 net179 VGND VGND VPWR VPWR _03940_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_26_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11521_ D_cos\[6\] _02798_ _01379_ VGND VGND VPWR VPWR _02799_ sky130_fd_sc_hd__mux2_1
XFILLER_0_80_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11452_ _02721_ _02722_ VGND VGND VPWR VPWR _02723_ sky130_fd_sc_hd__nor2_1
X_14240_ _05758_ _05759_ VGND VGND VPWR VPWR _05760_ sky130_fd_sc_hd__nor2_2
XFILLER_0_150_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10403_ _01617_ _01622_ VGND VGND VPWR VPWR _01629_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_12_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14171_ _05556_ _05684_ _05685_ VGND VGND VPWR VPWR _05686_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_1_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11383_ _02631_ _02646_ _02647_ VGND VGND VPWR VPWR _02649_ sky130_fd_sc_hd__nand3_1
X_10334_ net129 _01561_ _01568_ VGND VGND VPWR VPWR _00049_ sky130_fd_sc_hd__o21ai_1
X_13122_ _04459_ _04474_ _04475_ _04478_ VGND VGND VPWR VPWR _04544_ sky130_fd_sc_hd__a31o_1
X_13053_ _04465_ _04466_ _04467_ VGND VGND VPWR VPWR _04470_ sky130_fd_sc_hd__nand3_1
X_10265_ _01506_ _01502_ _01507_ VGND VGND VPWR VPWR _01509_ sky130_fd_sc_hd__o21ai_1
X_12004_ _03260_ _03278_ VGND VGND VPWR VPWR _03324_ sky130_fd_sc_hd__and2b_1
X_10196_ _01439_ _01446_ _01449_ VGND VGND VPWR VPWR _01450_ sky130_fd_sc_hd__nor3_1
XFILLER_0_108_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout390 net391 VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_21_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13955_ net704 net248 VGND VGND VPWR VPWR _05452_ sky130_fd_sc_hd__nand2_1
X_12906_ _04307_ _04308_ _04309_ VGND VGND VPWR VPWR _04310_ sky130_fd_sc_hd__nand3_4
X_13886_ _05282_ _05288_ VGND VGND VPWR VPWR _05377_ sky130_fd_sc_hd__and2b_1
XFILLER_0_57_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15625_ _07272_ _07273_ VGND VGND VPWR VPWR _07274_ sky130_fd_sc_hd__nor2_1
X_12837_ _04134_ _04135_ _04128_ VGND VGND VPWR VPWR _04234_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_56_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15556_ net262 net253 net539 net547 VGND VGND VPWR VPWR _07198_ sky130_fd_sc_hd__and4_1
XFILLER_0_56_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12768_ _04013_ _04015_ _04012_ VGND VGND VPWR VPWR _04158_ sky130_fd_sc_hd__o21ba_1
X_14507_ _06019_ _06026_ VGND VGND VPWR VPWR _06052_ sky130_fd_sc_hd__and2_1
XFILLER_0_83_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11719_ _03012_ _03013_ VGND VGND VPWR VPWR _03014_ sky130_fd_sc_hd__nor2_1
X_15487_ net272 net538 VGND VGND VPWR VPWR _07123_ sky130_fd_sc_hd__nand2_1
X_12699_ net224 net617 VGND VGND VPWR VPWR _04082_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_30_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_116_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput10 D[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_2
X_14438_ net322 net237 net659 net669 VGND VGND VPWR VPWR _05976_ sky130_fd_sc_hd__and4_1
XFILLER_0_126_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput21 Q[10] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_4
Xinput32 Q[3] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_2
Xinput43 cos[13] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput54 cos[6] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_1
XFILLER_0_40_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14369_ _05895_ _05898_ _05899_ _05886_ VGND VGND VPWR VPWR _05900_ sky130_fd_sc_hd__a211oi_2
Xinput65 sin[15] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_1
Xinput76 sin[8] VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_141_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16108_ net270 net637 _07797_ VGND VGND VPWR VPWR _07798_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_122_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08930_ _00209_ _00210_ VGND VGND VPWR VPWR _00211_ sky130_fd_sc_hd__xor2_1
X_16039_ _07719_ _07722_ VGND VGND VPWR VPWR _07723_ sky130_fd_sc_hd__xor2_1
XFILLER_0_58_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08861_ net534 net357 _00141_ _00142_ VGND VGND VPWR VPWR _00143_ sky130_fd_sc_hd__a22o_1
X_08792_ _04240_ net816 _04317_ VGND VGND VPWR VPWR _08103_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_74_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09413_ net383 _00614_ _00615_ _00688_ VGND VGND VPWR VPWR _00689_ sky130_fd_sc_hd__a31o_2
XFILLER_0_90_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09344_ _00620_ _00539_ _00540_ _00535_ VGND VGND VPWR VPWR _00621_ sky130_fd_sc_hd__a31o_1
XFILLER_0_75_642 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09275_ _00432_ _00458_ _00552_ VGND VGND VPWR VPWR _00553_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_74_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08226_ _03040_ _03051_ VGND VGND VPWR VPWR _03062_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_90_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08157_ net567 net577 net377 net368 VGND VGND VPWR VPWR _02310_ sky130_fd_sc_hd__and4_1
XFILLER_0_43_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10050_ net655 net442 _01261_ _01260_ VGND VGND VPWR VPWR _01317_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_98_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13740_ _05058_ _05130_ _05217_ VGND VGND VPWR VPWR _05218_ sky130_fd_sc_hd__a21oi_1
X_10952_ _02009_ _02050_ _02088_ _02090_ _02179_ VGND VGND VPWR VPWR _02180_ sky130_fd_sc_hd__o2111a_1
X_13671_ _05109_ _05117_ VGND VGND VPWR VPWR _05142_ sky130_fd_sc_hd__and2_1
X_10883_ _02099_ _02107_ _02108_ VGND VGND VPWR VPWR _02109_ sky130_fd_sc_hd__a21o_1
X_15410_ _07017_ _07038_ VGND VGND VPWR VPWR _07039_ sky130_fd_sc_hd__xor2_2
XFILLER_0_78_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12622_ _03995_ _03996_ net301 net805 VGND VGND VPWR VPWR _03997_ sky130_fd_sc_hd__and4bb_1
X_16390_ clknet_4_12_0_clk _00103_ net345 VGND VGND VPWR VPWR Q_sin\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_65_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15341_ _06962_ _06963_ VGND VGND VPWR VPWR _06964_ sky130_fd_sc_hd__xor2_1
XFILLER_0_93_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12553_ _03791_ _03792_ _03790_ VGND VGND VPWR VPWR _03922_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_26_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11504_ _02668_ _02676_ _02675_ VGND VGND VPWR VPWR _02781_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_136_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15272_ _06785_ _06787_ _06783_ VGND VGND VPWR VPWR _06889_ sky130_fd_sc_hd__a21o_1
XFILLER_0_81_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12484_ _03838_ _03837_ VGND VGND VPWR VPWR _03846_ sky130_fd_sc_hd__and2b_1
XFILLER_0_123_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14223_ _05738_ _05739_ _05741_ VGND VGND VPWR VPWR _05743_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_34_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11435_ _02497_ _02598_ _02705_ VGND VGND VPWR VPWR _02706_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_123_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11366_ _02515_ _02518_ VGND VGND VPWR VPWR _02630_ sky130_fd_sc_hd__nand2_1
XFILLER_0_104_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14154_ _05509_ _05606_ _05507_ VGND VGND VPWR VPWR _05668_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10317_ net924 _01553_ net129 VGND VGND VPWR VPWR _01554_ sky130_fd_sc_hd__mux2_1
X_13105_ _04354_ _04525_ _04526_ VGND VGND VPWR VPWR _04527_ sky130_fd_sc_hd__nand3_1
XFILLER_0_95_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11297_ _02455_ _02461_ _02460_ VGND VGND VPWR VPWR _02555_ sky130_fd_sc_hd__a21bo_1
X_14085_ _05522_ _05530_ _05592_ VGND VGND VPWR VPWR _05593_ sky130_fd_sc_hd__a21oi_1
X_10248_ _01493_ _01494_ VGND VGND VPWR VPWR _01495_ sky130_fd_sc_hd__xnor2_1
X_13036_ _04248_ _04345_ _04347_ VGND VGND VPWR VPWR _04451_ sky130_fd_sc_hd__o21ba_1
X_10179_ _01433_ _01434_ VGND VGND VPWR VPWR _01435_ sky130_fd_sc_hd__nand2_1
X_14987_ net120 _06578_ VGND VGND VPWR VPWR _06579_ sky130_fd_sc_hd__or2_1
XFILLER_0_135_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13938_ _05349_ _05432_ VGND VGND VPWR VPWR _05433_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_135_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13869_ _05356_ _05344_ _05345_ VGND VGND VPWR VPWR _05358_ sky130_fd_sc_hd__nor3_1
XFILLER_0_147_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15608_ _07246_ _07254_ VGND VGND VPWR VPWR _07255_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15539_ _07091_ _07092_ _07178_ VGND VGND VPWR VPWR _07180_ sky130_fd_sc_hd__and3_1
XFILLER_0_44_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_703 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09060_ _00249_ _00251_ _00250_ net403 VGND VGND VPWR VPWR _00340_ sky130_fd_sc_hd__a22o_1
XFILLER_0_4_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09962_ Q_cos\[15\] _01230_ _00661_ VGND VGND VPWR VPWR _01231_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08913_ net697 _00193_ VGND VGND VPWR VPWR _00194_ sky130_fd_sc_hd__nor2_1
XFILLER_0_110_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09893_ _01142_ _01143_ _01162_ VGND VGND VPWR VPWR _01163_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08844_ _00123_ _00124_ _00125_ VGND VGND VPWR VPWR _00126_ sky130_fd_sc_hd__a21o_1
X_08775_ _08084_ _08085_ VGND VGND VPWR VPWR _08086_ sky130_fd_sc_hd__and2b_1
XFILLER_0_149_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09327_ _00601_ _00602_ _00603_ VGND VGND VPWR VPWR _00604_ sky130_fd_sc_hd__nand3_1
XFILLER_0_63_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09258_ net621 net402 net392 net631 VGND VGND VPWR VPWR _00536_ sky130_fd_sc_hd__a22o_1
XFILLER_0_118_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08209_ net567 net577 net351 net504 VGND VGND VPWR VPWR _02877_ sky130_fd_sc_hd__and4_1
XFILLER_0_50_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09189_ _00387_ _00466_ VGND VGND VPWR VPWR _00468_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11220_ _02468_ _02469_ _02361_ _02436_ VGND VGND VPWR VPWR _02471_ sky130_fd_sc_hd__o211a_1
X_11151_ net756 net462 VGND VGND VPWR VPWR _02395_ sky130_fd_sc_hd__nand2_1
X_10102_ net620 net457 VGND VGND VPWR VPWR _01368_ sky130_fd_sc_hd__nand2_1
X_11082_ _02218_ _02220_ _02219_ VGND VGND VPWR VPWR _02320_ sky130_fd_sc_hd__a21bo_1
X_10033_ _01071_ _01299_ VGND VGND VPWR VPWR _01300_ sky130_fd_sc_hd__xor2_1
X_14910_ _06492_ _06493_ VGND VGND VPWR VPWR _06494_ sky130_fd_sc_hd__and2_1
X_15890_ _07559_ _07560_ VGND VGND VPWR VPWR _07561_ sky130_fd_sc_hd__nor2_1
X_14841_ _06412_ _06414_ _06418_ VGND VGND VPWR VPWR _06419_ sky130_fd_sc_hd__nand3_1
X_14772_ _06250_ _06249_ _06248_ VGND VGND VPWR VPWR _06343_ sky130_fd_sc_hd__o21ai_1
X_11984_ _03299_ _03300_ VGND VGND VPWR VPWR _03303_ sky130_fd_sc_hd__or2_1
X_13723_ _05197_ _05198_ VGND VGND VPWR VPWR _05200_ sky130_fd_sc_hd__xor2_1
X_10935_ _02151_ _02134_ _02152_ _02161_ VGND VGND VPWR VPWR _02162_ sky130_fd_sc_hd__and4_1
XFILLER_0_105_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13654_ _05121_ _05124_ VGND VGND VPWR VPWR _05125_ sky130_fd_sc_hd__xor2_1
XFILLER_0_14_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10866_ net752 net528 net399 net786 VGND VGND VPWR VPWR _02092_ sky130_fd_sc_hd__a22oi_1
X_12605_ net199 net754 _03926_ _03925_ VGND VGND VPWR VPWR _03979_ sky130_fd_sc_hd__a31o_1
X_16373_ clknet_4_3_0_clk _00086_ net333 VGND VGND VPWR VPWR D_sin\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_27_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13585_ _05045_ _05049_ VGND VGND VPWR VPWR _05050_ sky130_fd_sc_hd__xnor2_2
X_10797_ _02011_ _02016_ _02012_ VGND VGND VPWR VPWR _02023_ sky130_fd_sc_hd__nand3_1
XFILLER_0_26_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15324_ net183 net173 net660 net668 VGND VGND VPWR VPWR _06946_ sky130_fd_sc_hd__nand4_1
XFILLER_0_136_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12536_ _03881_ _03862_ _03901_ _03902_ VGND VGND VPWR VPWR _03903_ sky130_fd_sc_hd__or4_1
XFILLER_0_14_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15255_ _06851_ _06869_ _06870_ VGND VGND VPWR VPWR _06871_ sky130_fd_sc_hd__nand3_2
X_12467_ _03821_ _03820_ VGND VGND VPWR VPWR _03827_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_144_Right_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14206_ _05636_ _05639_ _05723_ VGND VGND VPWR VPWR _05724_ sky130_fd_sc_hd__or3_1
X_11418_ _02653_ _02685_ _02686_ VGND VGND VPWR VPWR _02687_ sky130_fd_sc_hd__nand3_1
XFILLER_0_124_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15186_ net251 net601 _06699_ _06794_ VGND VGND VPWR VPWR _06795_ sky130_fd_sc_hd__a31o_1
X_12398_ net198 net772 VGND VGND VPWR VPWR _03751_ sky130_fd_sc_hd__nand2_1
XFILLER_0_104_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14137_ _05647_ _05648_ VGND VGND VPWR VPWR _05649_ sky130_fd_sc_hd__xnor2_1
X_11349_ net747 net470 _02504_ _02503_ net480 VGND VGND VPWR VPWR _02611_ sky130_fd_sc_hd__a32o_1
XFILLER_0_120_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14068_ _05518_ _05521_ _05572_ VGND VGND VPWR VPWR _05574_ sky130_fd_sc_hd__o21a_1
X_13019_ _04327_ _04329_ _04430_ _04431_ VGND VGND VPWR VPWR _04433_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_146_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08560_ _06617_ _06693_ VGND VGND VPWR VPWR _06704_ sky130_fd_sc_hd__or2_1
XFILLER_0_89_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08491_ _05079_ _05373_ _05362_ VGND VGND VPWR VPWR _05948_ sky130_fd_sc_hd__a21o_1
XFILLER_0_76_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09112_ _00313_ _00297_ VGND VGND VPWR VPWR _00391_ sky130_fd_sc_hd__or2b_1
XFILLER_0_32_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09043_ _00321_ _00322_ VGND VGND VPWR VPWR _00323_ sky130_fd_sc_hd__xor2_1
XFILLER_0_5_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_111_Right_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09945_ _01069_ _01197_ _01212_ VGND VGND VPWR VPWR _01214_ sky130_fd_sc_hd__a21o_1
XFILLER_0_110_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09876_ net635 net626 net483 net473 VGND VGND VPWR VPWR _01146_ sky130_fd_sc_hd__and4_1
X_08827_ _08135_ _08136_ VGND VGND VPWR VPWR _08137_ sky130_fd_sc_hd__nand2_1
X_08758_ _08065_ _08066_ _08067_ VGND VGND VPWR VPWR _08069_ sky130_fd_sc_hd__a21o_1
XFILLER_0_95_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08689_ _07991_ _07992_ VGND VGND VPWR VPWR _08001_ sky130_fd_sc_hd__xnor2_1
X_10720_ _01930_ _01939_ _01945_ net899 VGND VGND VPWR VPWR _01946_ sky130_fd_sc_hd__o211a_1
XFILLER_0_137_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10651_ _01871_ _01872_ _01876_ VGND VGND VPWR VPWR _01877_ sky130_fd_sc_hd__a21o_1
XFILLER_0_91_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10582_ _01804_ _01805_ _01806_ VGND VGND VPWR VPWR _01808_ sky130_fd_sc_hd__a21o_1
X_13370_ _04809_ _04814_ VGND VGND VPWR VPWR _04815_ sky130_fd_sc_hd__xor2_2
XFILLER_0_63_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12321_ _03656_ _03666_ VGND VGND VPWR VPWR _03667_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_90_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15040_ _06634_ _06635_ VGND VGND VPWR VPWR _06636_ sky130_fd_sc_hd__and2b_1
X_12252_ _03587_ _03586_ VGND VGND VPWR VPWR _03592_ sky130_fd_sc_hd__and2b_1
XFILLER_0_50_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11203_ net796 net522 net889 net141 VGND VGND VPWR VPWR _02453_ sky130_fd_sc_hd__a22o_1
X_12183_ _03516_ _03517_ _03455_ _03458_ VGND VGND VPWR VPWR _03519_ sky130_fd_sc_hd__a211oi_1
X_11134_ _02374_ _02375_ _02206_ VGND VGND VPWR VPWR _02378_ sky130_fd_sc_hd__a21o_1
X_15942_ _07547_ _07617_ VGND VGND VPWR VPWR _07618_ sky130_fd_sc_hd__xnor2_1
X_11065_ _02300_ _02301_ VGND VGND VPWR VPWR _02302_ sky130_fd_sc_hd__xnor2_1
X_10016_ _01282_ _01283_ VGND VGND VPWR VPWR _01284_ sky130_fd_sc_hd__xnor2_1
X_15873_ _07539_ _07542_ VGND VGND VPWR VPWR _07544_ sky130_fd_sc_hd__xnor2_1
X_14824_ _06398_ _06397_ _06400_ VGND VGND VPWR VPWR _06401_ sky130_fd_sc_hd__nand3_1
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14755_ _06199_ _06323_ _06316_ _06314_ VGND VGND VPWR VPWR _06325_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_58_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11967_ _03213_ _03216_ VGND VGND VPWR VPWR _03284_ sky130_fd_sc_hd__or2b_1
XFILLER_0_59_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13706_ _05162_ _05163_ _05180_ VGND VGND VPWR VPWR _05181_ sky130_fd_sc_hd__o21a_1
X_10918_ net770 net527 _02143_ VGND VGND VPWR VPWR _02144_ sky130_fd_sc_hd__nand3_1
X_14686_ net324 net560 net569 net239 VGND VGND VPWR VPWR _06249_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_58_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11898_ net711 net443 VGND VGND VPWR VPWR _03209_ sky130_fd_sc_hd__nand2_1
X_13637_ net613 net704 net289 net280 VGND VGND VPWR VPWR _05106_ sky130_fd_sc_hd__and4_1
X_10849_ _02053_ _02067_ _02066_ VGND VGND VPWR VPWR _02075_ sky130_fd_sc_hd__a21o_1
XFILLER_0_144_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16356_ clknet_4_6_0_clk _00069_ net338 VGND VGND VPWR VPWR D_cos\[11\] sky130_fd_sc_hd__dfrtp_1
X_13568_ _05004_ _05030_ VGND VGND VPWR VPWR _05031_ sky130_fd_sc_hd__xnor2_2
X_15307_ net156 net682 net934 net305 VGND VGND VPWR VPWR _06927_ sky130_fd_sc_hd__a22o_1
X_12519_ _03882_ _03883_ VGND VGND VPWR VPWR _03884_ sky130_fd_sc_hd__xnor2_1
X_16287_ clknet_4_10_0_clk _00000_ net341 VGND VGND VPWR VPWR Q_cos\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_2_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13499_ _04944_ _04942_ VGND VGND VPWR VPWR _04955_ sky130_fd_sc_hd__or2b_1
XFILLER_0_125_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15238_ net201 net651 net643 net211 VGND VGND VPWR VPWR _06852_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_74_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15169_ _06774_ _06775_ _06599_ _06684_ VGND VGND VPWR VPWR _06777_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_2_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout208 net833 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__buf_4
Xfanout219 net71 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_120_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_7_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_7_0_clk sky130_fd_sc_hd__clkbuf_8
X_09730_ _00998_ _01001_ VGND VGND VPWR VPWR _01002_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09661_ _00858_ _00859_ _00862_ VGND VGND VPWR VPWR _00934_ sky130_fd_sc_hd__a21bo_1
X_08612_ net569 net580 net524 net435 VGND VGND VPWR VPWR _07271_ sky130_fd_sc_hd__and4_1
X_09592_ _00797_ _00799_ _00803_ VGND VGND VPWR VPWR _00866_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_49_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08543_ _06377_ _06399_ _06388_ VGND VGND VPWR VPWR _06519_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08474_ _04861_ _04883_ VGND VGND VPWR VPWR _05763_ sky130_fd_sc_hd__nor2_1
XFILLER_0_119_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_842 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09026_ _00304_ _00305_ VGND VGND VPWR VPWR _00306_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_131_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout720 net721 VGND VGND VPWR VPWR net720 sky130_fd_sc_hd__clkbuf_4
Xfanout731 net732 VGND VGND VPWR VPWR net731 sky130_fd_sc_hd__clkbuf_4
X_09928_ _01071_ _01157_ VGND VGND VPWR VPWR _01197_ sky130_fd_sc_hd__or2_1
Xfanout742 net745 VGND VGND VPWR VPWR net742 sky130_fd_sc_hd__clkbuf_2
Xfanout753 net754 VGND VGND VPWR VPWR net753 sky130_fd_sc_hd__clkbuf_4
Xfanout764 net14 VGND VGND VPWR VPWR net764 sky130_fd_sc_hd__buf_2
Xfanout775 net776 VGND VGND VPWR VPWR net775 sky130_fd_sc_hd__clkbuf_4
Xfanout786 net791 VGND VGND VPWR VPWR net786 sky130_fd_sc_hd__buf_2
X_09859_ _01077_ _01080_ _01127_ VGND VGND VPWR VPWR _01129_ sky130_fd_sc_hd__o21a_1
Xfanout797 net799 VGND VGND VPWR VPWR net797 sky130_fd_sc_hd__buf_2
X_12870_ _04268_ _04269_ VGND VGND VPWR VPWR _04270_ sky130_fd_sc_hd__nor2_1
X_11821_ _03101_ _03124_ VGND VGND VPWR VPWR _03125_ sky130_fd_sc_hd__xnor2_2
X_14540_ net195 net694 VGND VGND VPWR VPWR _06088_ sky130_fd_sc_hd__nand2_1
X_11752_ _02906_ _02910_ _02907_ VGND VGND VPWR VPWR _03050_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_56_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10703_ _01840_ _01841_ _01842_ VGND VGND VPWR VPWR _01929_ sky130_fd_sc_hd__a21oi_2
X_14471_ _05872_ _05874_ _05873_ VGND VGND VPWR VPWR _06012_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_83_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11683_ _02972_ _02974_ VGND VGND VPWR VPWR _02976_ sky130_fd_sc_hd__xnor2_2
X_16210_ _07895_ _07863_ _07906_ VGND VGND VPWR VPWR _07908_ sky130_fd_sc_hd__a21o_1
X_13422_ net757 net250 VGND VGND VPWR VPWR _04871_ sky130_fd_sc_hd__nand2_1
X_10634_ net734 net743 net418 net410 VGND VGND VPWR VPWR _01860_ sky130_fd_sc_hd__and4_1
XFILLER_0_64_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16141_ _07800_ _07801_ _07793_ VGND VGND VPWR VPWR _07833_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_36_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13353_ net713 net301 VGND VGND VPWR VPWR _04797_ sky130_fd_sc_hd__and2_1
X_10565_ net733 net361 _01788_ _01789_ VGND VGND VPWR VPWR _01791_ sky130_fd_sc_hd__nand4_1
X_12304_ _03537_ _03535_ VGND VGND VPWR VPWR _03650_ sky130_fd_sc_hd__or2_1
XFILLER_0_134_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16072_ _07644_ _07647_ VGND VGND VPWR VPWR _07759_ sky130_fd_sc_hd__nor2_1
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13284_ _04718_ _04719_ _04721_ VGND VGND VPWR VPWR _04722_ sky130_fd_sc_hd__o21ai_1
X_10496_ _01713_ _01718_ _01714_ VGND VGND VPWR VPWR _01722_ sky130_fd_sc_hd__nand3_1
XFILLER_0_121_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15023_ _06613_ _06614_ _06615_ VGND VGND VPWR VPWR _06618_ sky130_fd_sc_hd__a21o_1
X_12235_ net422 _00192_ VGND VGND VPWR VPWR _03575_ sky130_fd_sc_hd__nor2_1
X_12166_ net136 _03499_ VGND VGND VPWR VPWR _03500_ sky130_fd_sc_hd__and2_1
X_11117_ _02356_ _02357_ _02349_ VGND VGND VPWR VPWR _02359_ sky130_fd_sc_hd__a21o_1
X_12097_ _03332_ _03331_ VGND VGND VPWR VPWR _03425_ sky130_fd_sc_hd__and2b_1
XFILLER_0_36_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15925_ _07598_ _07599_ VGND VGND VPWR VPWR _07600_ sky130_fd_sc_hd__xnor2_1
X_11048_ _02282_ _02283_ VGND VGND VPWR VPWR _02284_ sky130_fd_sc_hd__and2_4
XFILLER_0_127_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput8 D[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
X_15856_ _07523_ _07524_ VGND VGND VPWR VPWR _07525_ sky130_fd_sc_hd__nand2_1
X_14807_ _06380_ _06381_ VGND VGND VPWR VPWR _06382_ sky130_fd_sc_hd__and2b_1
X_15787_ _07448_ _07449_ VGND VGND VPWR VPWR _07450_ sky130_fd_sc_hd__xnor2_1
X_12999_ _04297_ _04305_ _04304_ VGND VGND VPWR VPWR _04411_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_143_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14738_ net814 net607 net702 net309 VGND VGND VPWR VPWR _06306_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_143_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14669_ _06216_ _06219_ _06228_ _06229_ VGND VGND VPWR VPWR _06230_ sky130_fd_sc_hd__o211a_1
XFILLER_0_27_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08190_ _02299_ _02376_ _02539_ VGND VGND VPWR VPWR _02670_ sky130_fd_sc_hd__and3_1
XFILLER_0_144_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16339_ clknet_4_2_0_clk _00052_ net333 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_125_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_58_Left_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09713_ _00983_ _00984_ VGND VGND VPWR VPWR _00985_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09644_ _00915_ _00916_ VGND VGND VPWR VPWR _00917_ sky130_fd_sc_hd__xnor2_1
X_09575_ net630 _00769_ VGND VGND VPWR VPWR _00849_ sky130_fd_sc_hd__nand2_1
X_08526_ _06300_ _06311_ _06256_ VGND VGND VPWR VPWR _06333_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_67_Left_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08457_ _05405_ _05558_ _05568_ VGND VGND VPWR VPWR _05579_ sky130_fd_sc_hd__nand3_2
XFILLER_0_92_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08388_ _04785_ _04807_ _04818_ VGND VGND VPWR VPWR _04829_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_33_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10350_ _01569_ _01575_ _01578_ VGND VGND VPWR VPWR _01582_ sky130_fd_sc_hd__o21a_1
XFILLER_0_60_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09009_ _00286_ _00289_ VGND VGND VPWR VPWR _00290_ sky130_fd_sc_hd__xnor2_1
X_10281_ _01521_ _01522_ VGND VGND VPWR VPWR _01523_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_76_Left_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12020_ _03323_ _03324_ _03340_ VGND VGND VPWR VPWR _03341_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_130_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout550 net551 VGND VGND VPWR VPWR net550 sky130_fd_sc_hd__buf_4
Xfanout561 net562 VGND VGND VPWR VPWR net561 sky130_fd_sc_hd__buf_2
Xfanout572 net573 VGND VGND VPWR VPWR net572 sky130_fd_sc_hd__buf_6
Xfanout583 net586 VGND VGND VPWR VPWR net583 sky130_fd_sc_hd__clkbuf_4
X_13971_ _05361_ _05387_ VGND VGND VPWR VPWR _05469_ sky130_fd_sc_hd__nand2_1
Xfanout594 net31 VGND VGND VPWR VPWR net594 sky130_fd_sc_hd__clkbuf_2
X_15710_ _07182_ _07275_ VGND VGND VPWR VPWR _07366_ sky130_fd_sc_hd__nand2_1
X_12922_ _04234_ _04326_ VGND VGND VPWR VPWR _04327_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_87_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15641_ _07284_ _07289_ VGND VGND VPWR VPWR _07290_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_85_Left_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12853_ _04222_ _04227_ _04250_ VGND VGND VPWR VPWR _04252_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_69_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11804_ _03104_ _03106_ VGND VGND VPWR VPWR _03107_ sky130_fd_sc_hd__nor2_1
X_15572_ _07147_ _07145_ VGND VGND VPWR VPWR _07215_ sky130_fd_sc_hd__and2_1
XFILLER_0_84_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12784_ _04170_ _04172_ _04171_ VGND VGND VPWR VPWR _04176_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_139_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14523_ _06067_ _06068_ VGND VGND VPWR VPWR _06070_ sky130_fd_sc_hd__xnor2_1
X_11735_ _03028_ _03030_ _03010_ VGND VGND VPWR VPWR _03032_ sky130_fd_sc_hd__a21o_1
X_14454_ _05990_ _05991_ _05993_ VGND VGND VPWR VPWR _05994_ sky130_fd_sc_hd__nand3_2
XFILLER_0_138_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11666_ net513 net496 VGND VGND VPWR VPWR _02957_ sky130_fd_sc_hd__and2_1
XFILLER_0_71_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13405_ _04340_ _04847_ _04848_ _04849_ _04853_ VGND VGND VPWR VPWR _04854_ sky130_fd_sc_hd__a311oi_4
X_10617_ _01840_ _01841_ _01842_ VGND VGND VPWR VPWR _01843_ sky130_fd_sc_hd__and3_4
XFILLER_0_4_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14385_ net196 net550 _05914_ _05916_ VGND VGND VPWR VPWR _05918_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_141_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11597_ _02879_ _02881_ VGND VGND VPWR VPWR _02882_ sky130_fd_sc_hd__xnor2_2
X_16124_ _07750_ _07813_ _07811_ _07812_ VGND VGND VPWR VPWR _07816_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_24_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13336_ _04775_ _04777_ VGND VGND VPWR VPWR _04778_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_94_Left_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10548_ net741 net353 net507 net747 VGND VGND VPWR VPWR _01774_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_122_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16055_ _07667_ _07669_ _07668_ VGND VGND VPWR VPWR _07741_ sky130_fd_sc_hd__a21oi_1
X_13267_ net428 net514 net185 net175 VGND VGND VPWR VPWR _04703_ sky130_fd_sc_hd__nand4_2
X_10479_ _01699_ _01703_ _01704_ VGND VGND VPWR VPWR _01705_ sky130_fd_sc_hd__nand3_1
X_15006_ _06522_ _06524_ _06597_ VGND VGND VPWR VPWR _06599_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_110_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12218_ _03508_ _03497_ VGND VGND VPWR VPWR _03556_ sky130_fd_sc_hd__or2b_1
XFILLER_0_121_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13198_ _04516_ _04564_ _04626_ _04627_ VGND VGND VPWR VPWR _04628_ sky130_fd_sc_hd__o211ai_4
X_12149_ net422 net443 _03479_ VGND VGND VPWR VPWR _03481_ sky130_fd_sc_hd__and3_1
XFILLER_0_47_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15908_ _07577_ _07578_ _07579_ _07580_ VGND VGND VPWR VPWR _07581_ sky130_fd_sc_hd__o211a_1
X_15839_ _07505_ _07396_ VGND VGND VPWR VPWR _07506_ sky130_fd_sc_hd__or2_1
X_09360_ _00634_ _00635_ _00544_ _00613_ VGND VGND VPWR VPWR _00637_ sky130_fd_sc_hd__o211a_1
XFILLER_0_59_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08311_ _03943_ _03976_ VGND VGND VPWR VPWR _03987_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09291_ _00557_ _00555_ VGND VGND VPWR VPWR _00568_ sky130_fd_sc_hd__or2b_1
XFILLER_0_7_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_13 net933 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08242_ net695 net409 net398 net537 VGND VGND VPWR VPWR _03236_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_145_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_24 net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_35 net755 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_27_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_46 net76 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_57 net482 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08173_ _02430_ _02474_ VGND VGND VPWR VPWR _02485_ sky130_fd_sc_hd__xor2_1
XFILLER_0_144_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09627_ _00895_ _00894_ VGND VGND VPWR VPWR _00900_ sky130_fd_sc_hd__and2b_1
X_09558_ net663 net483 net473 net671 VGND VGND VPWR VPWR _00832_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_66_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08509_ net560 net524 net435 net569 VGND VGND VPWR VPWR _06146_ sky130_fd_sc_hd__a22oi_2
X_09489_ _00686_ _00689_ VGND VGND VPWR VPWR _00764_ sky130_fd_sc_hd__or2_1
X_11520_ _02714_ _02797_ VGND VGND VPWR VPWR _02798_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_81_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11451_ net738 net748 net463 net452 VGND VGND VPWR VPWR _02722_ sky130_fd_sc_hd__and4_1
XFILLER_0_123_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10402_ _01624_ _01627_ VGND VGND VPWR VPWR _01628_ sky130_fd_sc_hd__nor2_1
X_14170_ _05561_ _05550_ _05622_ VGND VGND VPWR VPWR _05685_ sky130_fd_sc_hd__o21ai_1
X_11382_ _02644_ _02645_ _02636_ VGND VGND VPWR VPWR _02647_ sky130_fd_sc_hd__a21o_1
XFILLER_0_21_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_150_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13121_ _04417_ _04419_ _04518_ _04519_ VGND VGND VPWR VPWR _04543_ sky130_fd_sc_hd__o211a_1
X_10333_ _01566_ _01567_ net129 VGND VGND VPWR VPWR _01568_ sky130_fd_sc_hd__or3b_1
X_13052_ _04465_ _04466_ _04467_ VGND VGND VPWR VPWR _04468_ sky130_fd_sc_hd__a21o_1
X_10264_ _01506_ _01502_ _01507_ VGND VGND VPWR VPWR _01508_ sky130_fd_sc_hd__or3_1
X_12003_ _03277_ _03262_ VGND VGND VPWR VPWR _03323_ sky130_fd_sc_hd__and2b_1
X_10195_ _01447_ _01448_ VGND VGND VPWR VPWR _01449_ sky130_fd_sc_hd__nor2_1
Xfanout380 net381 VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__clkbuf_2
Xfanout391 net53 VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__clkbuf_4
X_13954_ _05448_ _05450_ VGND VGND VPWR VPWR _05451_ sky130_fd_sc_hd__nor2_1
X_12905_ _04178_ _04183_ _04177_ VGND VGND VPWR VPWR _04309_ sky130_fd_sc_hd__a21bo_1
X_13885_ _05374_ _05375_ VGND VGND VPWR VPWR _05376_ sky130_fd_sc_hd__xor2_2
XFILLER_0_124_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15624_ _07268_ _07270_ VGND VGND VPWR VPWR _07273_ sky130_fd_sc_hd__and2_1
X_12836_ _04231_ _04232_ VGND VGND VPWR VPWR _04233_ sky130_fd_sc_hd__or2b_1
XFILLER_0_124_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15555_ net262 net538 net547 net253 VGND VGND VPWR VPWR _07197_ sky130_fd_sc_hd__a22oi_2
X_12767_ _04154_ _04153_ VGND VGND VPWR VPWR _04157_ sky130_fd_sc_hd__nand2b_1
X_14506_ _06012_ _06018_ VGND VGND VPWR VPWR _06051_ sky130_fd_sc_hd__and2b_1
XFILLER_0_83_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11718_ net513 net610 net486 net476 VGND VGND VPWR VPWR _03013_ sky130_fd_sc_hd__and4_1
X_15486_ _07120_ _07121_ VGND VGND VPWR VPWR _07122_ sky130_fd_sc_hd__nor2_1
XFILLER_0_140_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12698_ net328 net243 net429 net517 VGND VGND VPWR VPWR _04081_ sky130_fd_sc_hd__and4_1
X_14437_ _05956_ _05957_ _05967_ VGND VGND VPWR VPWR _05975_ sky130_fd_sc_hd__nand3_2
XFILLER_0_71_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput11 D[1] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_2
X_11649_ _02935_ _02936_ _02932_ VGND VGND VPWR VPWR _02938_ sky130_fd_sc_hd__a21o_1
XFILLER_0_24_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput22 Q[11] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__buf_1
XFILLER_0_140_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput33 Q[4] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__buf_1
XFILLER_0_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput44 cos[14] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_4
Xinput55 cos[7] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__buf_1
X_14368_ _05863_ _05870_ _05885_ VGND VGND VPWR VPWR _05899_ sky130_fd_sc_hd__and3_1
Xinput66 sin[16] VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_1
Xinput77 sin[9] VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__clkbuf_2
X_16107_ _07795_ _07796_ VGND VGND VPWR VPWR _07797_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13319_ _04671_ _04655_ VGND VGND VPWR VPWR _04759_ sky130_fd_sc_hd__or2b_1
XFILLER_0_150_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14299_ net228 _04540_ VGND VGND VPWR VPWR _05824_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16038_ _07720_ _07721_ VGND VGND VPWR VPWR _07722_ sky130_fd_sc_hd__nor2_1
XFILLER_0_122_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08860_ net684 net694 net374 net365 VGND VGND VPWR VPWR _00142_ sky130_fd_sc_hd__nand4_1
X_08791_ _08099_ _08100_ _08092_ VGND VGND VPWR VPWR _08102_ sky130_fd_sc_hd__a21o_1
XFILLER_0_74_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09412_ net621 net383 _00614_ _00615_ VGND VGND VPWR VPWR _00688_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_149_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09343_ _00443_ VGND VGND VPWR VPWR _00620_ sky130_fd_sc_hd__inv_2
XFILLER_0_48_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09274_ _00456_ _00457_ VGND VGND VPWR VPWR _00552_ sky130_fd_sc_hd__and2b_1
XFILLER_0_47_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08225_ net698 net458 VGND VGND VPWR VPWR _03051_ sky130_fd_sc_hd__nand2_1
XFILLER_0_90_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08156_ _02234_ _02288_ VGND VGND VPWR VPWR _02299_ sky130_fd_sc_hd__or2b_1
XFILLER_0_31_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08989_ _00237_ _00268_ _00269_ VGND VGND VPWR VPWR _00270_ sky130_fd_sc_hd__or3_4
XFILLER_0_98_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10951_ _02171_ _02176_ _02177_ _02178_ VGND VGND VPWR VPWR _02179_ sky130_fd_sc_hd__a31o_1
XFILLER_0_98_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13670_ _05115_ _05116_ VGND VGND VPWR VPWR _05141_ sky130_fd_sc_hd__and2_1
X_10882_ _02101_ _02106_ _02103_ VGND VGND VPWR VPWR _02108_ sky130_fd_sc_hd__and3_1
XFILLER_0_97_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12621_ net163 net782 net790 net310 VGND VGND VPWR VPWR _03996_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_149_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_125_Right_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15340_ _06856_ _06864_ _06863_ VGND VGND VPWR VPWR _06963_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_109_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12552_ _03917_ _03918_ _03919_ VGND VGND VPWR VPWR _03920_ sky130_fd_sc_hd__or3_1
XFILLER_0_19_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11503_ _02773_ _02778_ VGND VGND VPWR VPWR _02780_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_109_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15271_ _06790_ _06887_ VGND VGND VPWR VPWR _06888_ sky130_fd_sc_hd__xnor2_2
X_12483_ net218 net208 net788 net804 VGND VGND VPWR VPWR _03845_ sky130_fd_sc_hd__and4_1
X_14222_ _05740_ _05651_ VGND VGND VPWR VPWR _05741_ sky130_fd_sc_hd__or2_1
XFILLER_0_123_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11434_ _02387_ _02486_ _02487_ _02497_ _02598_ VGND VGND VPWR VPWR _02705_ sky130_fd_sc_hd__a32o_1
XFILLER_0_61_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14153_ _05509_ _05665_ VGND VGND VPWR VPWR _05667_ sky130_fd_sc_hd__xnor2_1
X_11365_ _02524_ _02560_ _02562_ VGND VGND VPWR VPWR _02629_ sky130_fd_sc_hd__nor3_1
X_13104_ _04522_ _04523_ _04421_ _04423_ VGND VGND VPWR VPWR _04526_ sky130_fd_sc_hd__o211ai_1
X_10316_ _01551_ _01552_ VGND VGND VPWR VPWR _01553_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_95_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14084_ _05523_ _05529_ VGND VGND VPWR VPWR _05592_ sky130_fd_sc_hd__and2b_1
XFILLER_0_21_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11296_ _02551_ _02552_ _02545_ VGND VGND VPWR VPWR _02554_ sky130_fd_sc_hd__a21o_1
X_13035_ _04448_ _04449_ VGND VGND VPWR VPWR _04450_ sky130_fd_sc_hd__nand2_1
X_10247_ D_cos\[18\] Q_sin\[18\] VGND VGND VPWR VPWR _01494_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_119_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10178_ Q_sin\[9\] D_cos\[9\] VGND VGND VPWR VPWR _01434_ sky130_fd_sc_hd__or2b_1
X_14986_ _06122_ _06233_ _06575_ _06576_ VGND VGND VPWR VPWR _06578_ sky130_fd_sc_hd__o22a_1
XFILLER_0_89_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13937_ _05261_ _05347_ _05346_ VGND VGND VPWR VPWR _05432_ sky130_fd_sc_hd__o21a_1
X_13868_ _05344_ _05345_ _05356_ VGND VGND VPWR VPWR _05357_ sky130_fd_sc_hd__o21a_1
XFILLER_0_29_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15607_ _07252_ _07253_ VGND VGND VPWR VPWR _07254_ sky130_fd_sc_hd__xor2_1
X_12819_ net274 net800 VGND VGND VPWR VPWR _04214_ sky130_fd_sc_hd__nand2_1
XFILLER_0_146_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13799_ _05146_ _05149_ _05147_ VGND VGND VPWR VPWR _05282_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_44_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15538_ _07091_ _07092_ _07178_ VGND VGND VPWR VPWR _07179_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_71_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15469_ _07100_ _07101_ net251 net565 VGND VGND VPWR VPWR _07103_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_115_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09961_ _01227_ _01229_ VGND VGND VPWR VPWR _01230_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08912_ _00192_ VGND VGND VPWR VPWR _00193_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_0_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09892_ _01160_ _01161_ VGND VGND VPWR VPWR _01162_ sky130_fd_sc_hd__nor2_1
XFILLER_0_85_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08843_ net558 net497 VGND VGND VPWR VPWR _00125_ sky130_fd_sc_hd__and2_1
XFILLER_0_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08774_ _08082_ _08083_ _08079_ VGND VGND VPWR VPWR _08085_ sky130_fd_sc_hd__a21o_1
XFILLER_0_88_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09326_ _00512_ _00514_ _00513_ VGND VGND VPWR VPWR _00603_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_8_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09257_ net622 net520 net432 net413 VGND VGND VPWR VPWR _00535_ sky130_fd_sc_hd__and4_2
XFILLER_0_8_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08208_ net587 net497 VGND VGND VPWR VPWR _02866_ sky130_fd_sc_hd__nand2_1
XFILLER_0_105_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09188_ _00387_ _00466_ VGND VGND VPWR VPWR _00467_ sky130_fd_sc_hd__and2_1
XFILLER_0_133_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11150_ net765 net471 VGND VGND VPWR VPWR _02394_ sky130_fd_sc_hd__nand2_1
X_10101_ net655 _00193_ _01321_ _01320_ VGND VGND VPWR VPWR _01367_ sky130_fd_sc_hd__o31a_1
X_11081_ _02315_ _02316_ _02317_ VGND VGND VPWR VPWR _02319_ sky130_fd_sc_hd__nand3_1
X_10032_ _01297_ _01298_ VGND VGND VPWR VPWR _01299_ sky130_fd_sc_hd__or2_1
X_14840_ _06415_ _06417_ VGND VGND VPWR VPWR _06418_ sky130_fd_sc_hd__nand2_1
X_14771_ _06250_ _06248_ _06249_ VGND VGND VPWR VPWR _06342_ sky130_fd_sc_hd__or3_1
X_11983_ _03299_ _03300_ VGND VGND VPWR VPWR _03302_ sky130_fd_sc_hd__nand2_1
X_13722_ _05063_ _05066_ _05064_ VGND VGND VPWR VPWR _05198_ sky130_fd_sc_hd__o21ba_1
X_10934_ _02153_ _02160_ _02145_ VGND VGND VPWR VPWR _02161_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_58_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13653_ _05004_ _05030_ _05122_ VGND VGND VPWR VPWR _05124_ sky130_fd_sc_hd__a21o_1
X_10865_ net752 net786 net528 net399 VGND VGND VPWR VPWR _02091_ sky130_fd_sc_hd__and4_1
XFILLER_0_128_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12604_ _03973_ _03975_ _03974_ VGND VGND VPWR VPWR _03978_ sky130_fd_sc_hd__a21o_1
X_16372_ clknet_4_9_0_clk _00085_ net341 VGND VGND VPWR VPWR D_sin\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_26_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13584_ _05046_ _05048_ VGND VGND VPWR VPWR _05049_ sky130_fd_sc_hd__nor2_1
X_10796_ _02018_ _02021_ VGND VGND VPWR VPWR _02022_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15323_ net182 net660 net668 net172 VGND VGND VPWR VPWR _06945_ sky130_fd_sc_hd__a22o_1
XFILLER_0_93_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12535_ _03860_ _03859_ _03845_ VGND VGND VPWR VPWR _03902_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_109_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15254_ _06865_ _06866_ _06867_ VGND VGND VPWR VPWR _06870_ sky130_fd_sc_hd__a21o_1
X_12466_ _03725_ _03724_ _03716_ VGND VGND VPWR VPWR _03826_ sky130_fd_sc_hd__a21o_1
XFILLER_0_62_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14205_ _05721_ _05722_ VGND VGND VPWR VPWR _05723_ sky130_fd_sc_hd__and2_1
X_11417_ _02683_ _02684_ _02556_ _02654_ VGND VGND VPWR VPWR _02686_ sky130_fd_sc_hd__o211ai_2
X_15185_ _06697_ _06698_ VGND VGND VPWR VPWR _06794_ sky130_fd_sc_hd__nor2_1
X_12397_ _03748_ _03749_ VGND VGND VPWR VPWR _03750_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14136_ net511 _04538_ VGND VGND VPWR VPWR _05648_ sky130_fd_sc_hd__or2_1
X_11348_ _02502_ _02518_ _02519_ _02522_ VGND VGND VPWR VPWR _02610_ sky130_fd_sc_hd__a31o_1
XFILLER_0_39_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14067_ _05518_ _05521_ _05572_ VGND VGND VPWR VPWR _05573_ sky130_fd_sc_hd__nor3_1
X_11279_ _02532_ _02533_ _02529_ VGND VGND VPWR VPWR _02535_ sky130_fd_sc_hd__a21o_1
X_13018_ _04327_ _04329_ _04430_ _04431_ VGND VGND VPWR VPWR _04432_ sky130_fd_sc_hd__or4_4
XFILLER_0_55_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14969_ _06538_ _06557_ _06558_ VGND VGND VPWR VPWR _06559_ sky130_fd_sc_hd__and3_1
X_08490_ _05915_ _05926_ VGND VGND VPWR VPWR _05937_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_146_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09111_ _00388_ _00378_ _00389_ VGND VGND VPWR VPWR _00390_ sky130_fd_sc_hd__o21a_1
XFILLER_0_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09042_ net573 net469 VGND VGND VPWR VPWR _00322_ sky130_fd_sc_hd__nand2_1
XFILLER_0_143_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09944_ _01069_ _01197_ _01212_ VGND VGND VPWR VPWR _01213_ sky130_fd_sc_hd__and3_1
X_09875_ net626 net483 net473 net635 VGND VGND VPWR VPWR _01145_ sky130_fd_sc_hd__a22oi_1
X_08826_ _08129_ _08134_ VGND VGND VPWR VPWR _08136_ sky130_fd_sc_hd__nand2_1
X_08757_ _08065_ _08066_ _08067_ VGND VGND VPWR VPWR _08068_ sky130_fd_sc_hd__nand3_1
X_08688_ _07997_ _07998_ _07999_ VGND VGND VPWR VPWR _08000_ sky130_fd_sc_hd__or3_1
XFILLER_0_67_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10650_ _01873_ _01874_ _01875_ VGND VGND VPWR VPWR _01876_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_48_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09309_ _00494_ _00496_ _00585_ VGND VGND VPWR VPWR _00586_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_91_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10581_ _01804_ _01805_ _01806_ VGND VGND VPWR VPWR _01807_ sky130_fd_sc_hd__nand3_1
XFILLER_0_134_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12320_ _03657_ _03665_ VGND VGND VPWR VPWR _03666_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_133_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12251_ _03591_ VGND VGND VPWR VPWR _00074_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_106_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11202_ net796 net889 VGND VGND VPWR VPWR _02451_ sky130_fd_sc_hd__nand2_4
X_12182_ _03515_ _03493_ _03494_ VGND VGND VPWR VPWR _03517_ sky130_fd_sc_hd__nand3_2
XFILLER_0_102_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11133_ _02206_ _02374_ _02375_ VGND VGND VPWR VPWR _02377_ sky130_fd_sc_hd__nand3_1
XFILLER_0_102_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15941_ _07548_ _07616_ VGND VGND VPWR VPWR _07617_ sky130_fd_sc_hd__xnor2_1
X_11064_ _02196_ _02197_ _02199_ VGND VGND VPWR VPWR _02301_ sky130_fd_sc_hd__a21boi_1
X_10015_ _01178_ _01193_ _01195_ VGND VGND VPWR VPWR _01283_ sky130_fd_sc_hd__o21a_1
X_15872_ _07370_ _07540_ _07541_ VGND VGND VPWR VPWR _07542_ sky130_fd_sc_hd__o21a_1
XFILLER_0_99_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14823_ _06361_ _06396_ _06395_ _06389_ VGND VGND VPWR VPWR _06400_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_59_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14754_ _06314_ _06316_ _06323_ _06199_ VGND VGND VPWR VPWR _06324_ sky130_fd_sc_hd__a211o_1
X_11966_ _03281_ _03282_ VGND VGND VPWR VPWR _03283_ sky130_fd_sc_hd__xor2_2
XFILLER_0_98_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10917_ _02141_ _02142_ VGND VGND VPWR VPWR _02143_ sky130_fd_sc_hd__and2_1
X_13705_ _05176_ _05179_ VGND VGND VPWR VPWR _05180_ sky130_fd_sc_hd__xnor2_1
X_14685_ net221 net579 VGND VGND VPWR VPWR _06248_ sky130_fd_sc_hd__nand2_1
X_11897_ _03206_ _03207_ VGND VGND VPWR VPWR _03208_ sky130_fd_sc_hd__nor2_1
X_13636_ net613 net289 net280 net704 VGND VGND VPWR VPWR _05105_ sky130_fd_sc_hd__a22oi_1
X_10848_ _02072_ _02073_ VGND VGND VPWR VPWR _02074_ sky130_fd_sc_hd__nor2_1
XFILLER_0_132_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16355_ clknet_4_6_0_clk _00068_ net339 VGND VGND VPWR VPWR D_cos\[10\] sky130_fd_sc_hd__dfrtp_1
X_13567_ _05027_ _05029_ VGND VGND VPWR VPWR _05030_ sky130_fd_sc_hd__xor2_2
X_10779_ _01999_ _02003_ _01979_ _01978_ VGND VGND VPWR VPWR _02005_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_81_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15306_ _06924_ _06925_ VGND VGND VPWR VPWR _06926_ sky130_fd_sc_hd__xor2_1
X_12518_ _03851_ _03850_ VGND VGND VPWR VPWR _03883_ sky130_fd_sc_hd__and2b_1
X_16286_ _07990_ VGND VGND VPWR VPWR _00114_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13498_ _04946_ _04948_ VGND VGND VPWR VPWR _04954_ sky130_fd_sc_hd__nor2_2
XFILLER_0_81_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15237_ _06841_ _06850_ VGND VGND VPWR VPWR _06851_ sky130_fd_sc_hd__xnor2_2
X_12449_ _03804_ _03805_ _03806_ VGND VGND VPWR VPWR _03807_ sky130_fd_sc_hd__nand3_2
XFILLER_0_22_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15168_ _06599_ _06684_ _06774_ _06775_ VGND VGND VPWR VPWR _06776_ sky130_fd_sc_hd__o211a_1
XFILLER_0_1_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14119_ _05577_ _05581_ VGND VGND VPWR VPWR _05629_ sky130_fd_sc_hd__nor2_1
Xfanout209 net72 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__buf_6
X_15099_ net251 net601 VGND VGND VPWR VPWR _06700_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_105_Left_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09660_ _00931_ _00932_ VGND VGND VPWR VPWR _00933_ sky130_fd_sc_hd__nor2_1
X_08611_ net569 net524 net435 net580 VGND VGND VPWR VPWR _07260_ sky130_fd_sc_hd__a22oi_2
X_09591_ _00863_ net124 _00861_ _00862_ VGND VGND VPWR VPWR _00865_ sky130_fd_sc_hd__o211a_2
X_08542_ _06476_ _06497_ VGND VGND VPWR VPWR _06508_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_77_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08473_ _05666_ _05623_ VGND VGND VPWR VPWR _05752_ sky130_fd_sc_hd__or2b_1
XFILLER_0_77_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_114_Left_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_134_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09025_ _00200_ _00201_ _00203_ _00199_ VGND VGND VPWR VPWR _00305_ sky130_fd_sc_hd__o22a_1
XFILLER_0_143_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout710 net2 VGND VGND VPWR VPWR net710 sky130_fd_sc_hd__buf_2
Xfanout721 net723 VGND VGND VPWR VPWR net721 sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_123_Left_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout732 net17 VGND VGND VPWR VPWR net732 sky130_fd_sc_hd__buf_4
X_09927_ _01177_ _01194_ VGND VGND VPWR VPWR _01196_ sky130_fd_sc_hd__or2_1
Xfanout743 net744 VGND VGND VPWR VPWR net743 sky130_fd_sc_hd__buf_4
Xfanout754 net755 VGND VGND VPWR VPWR net754 sky130_fd_sc_hd__clkbuf_4
Xfanout765 net768 VGND VGND VPWR VPWR net765 sky130_fd_sc_hd__clkbuf_4
Xfanout776 net12 VGND VGND VPWR VPWR net776 sky130_fd_sc_hd__buf_2
X_09858_ _01077_ _01080_ _01127_ VGND VGND VPWR VPWR _01128_ sky130_fd_sc_hd__nor3_1
Xfanout787 net791 VGND VGND VPWR VPWR net787 sky130_fd_sc_hd__buf_2
Xfanout798 net799 VGND VGND VPWR VPWR net798 sky130_fd_sc_hd__clkbuf_4
X_08809_ _08038_ _08039_ _08118_ _08119_ VGND VGND VPWR VPWR _08120_ sky130_fd_sc_hd__a211o_1
X_09789_ _01056_ _01059_ VGND VGND VPWR VPWR _01060_ sky130_fd_sc_hd__xnor2_2
X_11820_ _03122_ _03123_ VGND VGND VPWR VPWR _03124_ sky130_fd_sc_hd__or2_1
XFILLER_0_96_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11751_ _03043_ _03048_ VGND VGND VPWR VPWR _03049_ sky130_fd_sc_hd__xor2_2
XFILLER_0_83_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10702_ _01904_ _01911_ _01905_ VGND VGND VPWR VPWR _01928_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_132_Left_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14470_ _05958_ _05966_ VGND VGND VPWR VPWR _06011_ sky130_fd_sc_hd__or2b_1
X_11682_ _02827_ _02882_ _02973_ VGND VGND VPWR VPWR _02974_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_49_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13421_ _04868_ _04869_ VGND VGND VPWR VPWR _04870_ sky130_fd_sc_hd__nor2_1
X_10633_ net734 net418 net410 net743 VGND VGND VPWR VPWR _01859_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_138_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16140_ _07652_ _07805_ VGND VGND VPWR VPWR _07832_ sky130_fd_sc_hd__and2_1
X_13352_ net612 net705 net161 net312 VGND VGND VPWR VPWR _04795_ sky130_fd_sc_hd__nand4_2
XFILLER_0_23_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10564_ net733 net361 _01788_ _01789_ VGND VGND VPWR VPWR _01790_ sky130_fd_sc_hd__a22o_1
XFILLER_0_63_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12303_ _03527_ _03589_ VGND VGND VPWR VPWR _03649_ sky130_fd_sc_hd__nor2_1
XFILLER_0_122_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16071_ _07756_ _07757_ VGND VGND VPWR VPWR _07758_ sky130_fd_sc_hd__nor2_1
XFILLER_0_133_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13283_ _04608_ _04609_ _04610_ VGND VGND VPWR VPWR _04721_ sky130_fd_sc_hd__o21bai_1
X_10495_ _01662_ _01720_ VGND VGND VPWR VPWR _01721_ sky130_fd_sc_hd__nor2_1
X_15022_ _06613_ _06614_ _06615_ VGND VGND VPWR VPWR _06616_ sky130_fd_sc_hd__nand3_2
X_12234_ _03570_ _03573_ VGND VGND VPWR VPWR _03574_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_141_Left_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12165_ net792 net485 net475 VGND VGND VPWR VPWR _03499_ sky130_fd_sc_hd__and3_1
XFILLER_0_20_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11116_ _02349_ _02356_ _02357_ VGND VGND VPWR VPWR _02358_ sky130_fd_sc_hd__nand3_2
X_12096_ _03325_ _03330_ VGND VGND VPWR VPWR _03424_ sky130_fd_sc_hd__and2b_1
XFILLER_0_127_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15924_ _04881_ net531 VGND VGND VPWR VPWR _07599_ sky130_fd_sc_hd__or2_1
X_11047_ _02280_ _02281_ _02191_ _02193_ VGND VGND VPWR VPWR _02283_ sky130_fd_sc_hd__o211ai_1
Xinput9 D[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_2
X_15855_ _07520_ _07522_ VGND VGND VPWR VPWR _07524_ sky130_fd_sc_hd__or2_1
X_14806_ net212 net597 net605 net202 VGND VGND VPWR VPWR _06381_ sky130_fd_sc_hd__a22o_1
X_15786_ _07321_ _07322_ _07326_ _07327_ _07352_ VGND VGND VPWR VPWR _07449_ sky130_fd_sc_hd__o32ai_4
XFILLER_0_98_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12998_ _04407_ _04408_ _04399_ VGND VGND VPWR VPWR _04410_ sky130_fd_sc_hd__a21o_1
XFILLER_0_86_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14737_ _06287_ _06286_ VGND VGND VPWR VPWR _06305_ sky130_fd_sc_hd__or2b_1
X_11949_ net229 net314 net485 net475 VGND VGND VPWR VPWR _03264_ sky130_fd_sc_hd__and4_1
XFILLER_0_86_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14668_ _06226_ _06227_ _06220_ _06221_ VGND VGND VPWR VPWR _06229_ sky130_fd_sc_hd__a211o_1
XFILLER_0_86_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13619_ net214 net204 net798 VGND VGND VPWR VPWR _05086_ sky130_fd_sc_hd__and3_1
XFILLER_0_7_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14599_ _06145_ _06151_ _06152_ VGND VGND VPWR VPWR _06153_ sky130_fd_sc_hd__nand3_2
XFILLER_0_55_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16338_ clknet_4_1_0_clk _00051_ net332 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_14_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16269_ _07902_ _07905_ _07903_ VGND VGND VPWR VPWR _07972_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_2_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09712_ net662 net465 VGND VGND VPWR VPWR _00984_ sky130_fd_sc_hd__nand2_1
X_09643_ _00837_ _00840_ _00838_ VGND VGND VPWR VPWR _00916_ sky130_fd_sc_hd__o21ba_1
X_09574_ _00845_ _00846_ _00828_ _00829_ VGND VGND VPWR VPWR _00848_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_139_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08525_ _06256_ _06300_ _06311_ VGND VGND VPWR VPWR _06322_ sky130_fd_sc_hd__nand3_1
XFILLER_0_77_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08456_ _05210_ _05199_ _05123_ VGND VGND VPWR VPWR _05568_ sky130_fd_sc_hd__a21o_1
XFILLER_0_148_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08387_ _04774_ _04763_ _04513_ _03822_ VGND VGND VPWR VPWR _04818_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_147_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09008_ _08037_ _00287_ _00288_ VGND VGND VPWR VPWR _00289_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_20_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10280_ _01511_ _01516_ _01512_ VGND VGND VPWR VPWR _01522_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_13_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout540 net545 VGND VGND VPWR VPWR net540 sky130_fd_sc_hd__clkbuf_4
Xfanout551 net36 VGND VGND VPWR VPWR net551 sky130_fd_sc_hd__buf_6
Xfanout562 net563 VGND VGND VPWR VPWR net562 sky130_fd_sc_hd__buf_4
Xfanout573 net34 VGND VGND VPWR VPWR net573 sky130_fd_sc_hd__clkbuf_4
X_13970_ _05466_ _05467_ VGND VGND VPWR VPWR _05468_ sky130_fd_sc_hd__nor2_1
Xfanout584 net586 VGND VGND VPWR VPWR net584 sky130_fd_sc_hd__clkbuf_4
Xfanout595 net600 VGND VGND VPWR VPWR net595 sky130_fd_sc_hd__clkbuf_4
X_12921_ _04324_ _04325_ VGND VGND VPWR VPWR _04326_ sky130_fd_sc_hd__nand2_1
X_15640_ _07287_ _07288_ VGND VGND VPWR VPWR _07289_ sky130_fd_sc_hd__xor2_1
XFILLER_0_69_822 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12852_ _04247_ _04249_ VGND VGND VPWR VPWR _04250_ sky130_fd_sc_hd__or2_1
X_11803_ net425 net511 net486 net476 VGND VGND VPWR VPWR _03106_ sky130_fd_sc_hd__and4_1
X_15571_ _07193_ _07213_ VGND VGND VPWR VPWR _07214_ sky130_fd_sc_hd__xnor2_1
X_12783_ _04082_ _04083_ _04081_ VGND VGND VPWR VPWR _04175_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_68_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14522_ _06013_ _06016_ _06015_ VGND VGND VPWR VPWR _06068_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_83_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11734_ _03010_ _03028_ _03030_ VGND VGND VPWR VPWR _03031_ sky130_fd_sc_hd__nand3_1
XFILLER_0_138_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14453_ _05983_ _05984_ _05989_ VGND VGND VPWR VPWR _05993_ sky130_fd_sc_hd__a21o_1
X_11665_ net318 net425 net350 net503 VGND VGND VPWR VPWR _02956_ sky130_fd_sc_hd__nand4_2
Xclkbuf_4_6_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_6_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_37_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10616_ _01628_ _01629_ VGND VGND VPWR VPWR _01842_ sky130_fd_sc_hd__xnor2_1
X_13404_ _04641_ _04850_ _04852_ VGND VGND VPWR VPWR _04853_ sky130_fd_sc_hd__o21ba_1
X_14384_ _05914_ _05916_ net196 net550 VGND VGND VPWR VPWR _05917_ sky130_fd_sc_hd__and4bb_1
X_11596_ _02760_ _02785_ _02880_ VGND VGND VPWR VPWR _02881_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_3_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16123_ _07811_ _07812_ _07750_ _07813_ VGND VGND VPWR VPWR _07815_ sky130_fd_sc_hd__a211o_1
X_13335_ _04662_ _04663_ _04776_ VGND VGND VPWR VPWR _04777_ sky130_fd_sc_hd__o21a_1
X_10547_ net756 net499 VGND VGND VPWR VPWR _01773_ sky130_fd_sc_hd__nand2_1
X_16054_ _07737_ _07739_ VGND VGND VPWR VPWR _07740_ sky130_fd_sc_hd__xnor2_1
X_13266_ net428 net185 net175 net514 VGND VGND VPWR VPWR _04702_ sky130_fd_sc_hd__a22o_1
XFILLER_0_11_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10478_ net516 net440 _01696_ _01698_ VGND VGND VPWR VPWR _01704_ sky130_fd_sc_hd__a22o_1
XFILLER_0_121_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15005_ _06522_ _06524_ _06597_ VGND VGND VPWR VPWR _06598_ sky130_fd_sc_hd__and3_1
X_12217_ _03486_ _03488_ _03554_ VGND VGND VPWR VPWR _03555_ sky130_fd_sc_hd__o21ai_1
X_13197_ _04624_ _04625_ _04588_ VGND VGND VPWR VPWR _04627_ sky130_fd_sc_hd__o21ai_2
X_12148_ net422 net443 _03479_ VGND VGND VPWR VPWR _03480_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_138_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12079_ _03405_ VGND VGND VPWR VPWR _00071_ sky130_fd_sc_hd__clkbuf_1
X_15907_ _07501_ VGND VGND VPWR VPWR _07580_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_139_Right_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15838_ _07290_ _07378_ _07393_ VGND VGND VPWR VPWR _07505_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_78_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15769_ _07424_ _07429_ VGND VGND VPWR VPWR _07430_ sky130_fd_sc_hd__xnor2_2
X_08310_ _03954_ _03965_ VGND VGND VPWR VPWR _03976_ sky130_fd_sc_hd__nor2_1
XFILLER_0_129_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09290_ _00567_ VGND VGND VPWR VPWR _00006_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_145_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08241_ net695 net537 net409 net398 VGND VGND VPWR VPWR _03225_ sky130_fd_sc_hd__and4_1
XFILLER_0_6_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_14 net219 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_7_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_25 net321 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_36 net755 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_144_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_47 net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_58 net492 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_08172_ net949 _02463_ VGND VGND VPWR VPWR _02474_ sky130_fd_sc_hd__or2_4
XFILLER_0_132_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput110 net110 VGND VGND VPWR VPWR beta[3] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_106_Right_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09626_ _00899_ VGND VGND VPWR VPWR _00010_ sky130_fd_sc_hd__clkbuf_1
X_09557_ _00767_ _00774_ VGND VGND VPWR VPWR _00831_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08508_ net580 net416 VGND VGND VPWR VPWR _06135_ sky130_fd_sc_hd__nand2_1
X_09488_ _00760_ _00761_ _00743_ _00744_ VGND VGND VPWR VPWR _00763_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_148_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08439_ _05362_ _05373_ VGND VGND VPWR VPWR _05384_ sky130_fd_sc_hd__and2b_1
XFILLER_0_136_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11450_ net738 net462 net452 net748 VGND VGND VPWR VPWR _02721_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_135_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10401_ net773 net362 _01625_ _01626_ VGND VGND VPWR VPWR _01627_ sky130_fd_sc_hd__and4_1
X_11381_ _02636_ _02644_ _02645_ VGND VGND VPWR VPWR _02646_ sky130_fd_sc_hd__nand3_2
X_13120_ _04351_ _04455_ VGND VGND VPWR VPWR _04542_ sky130_fd_sc_hd__nor2_1
X_10332_ _01555_ _01562_ _01565_ VGND VGND VPWR VPWR _01567_ sky130_fd_sc_hd__o21a_1
XFILLER_0_104_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13051_ net739 net302 VGND VGND VPWR VPWR _04467_ sky130_fd_sc_hd__and2_1
X_10263_ D_sin\[2\] Q_cos\[2\] VGND VGND VPWR VPWR _01507_ sky130_fd_sc_hd__xnor2_1
X_12002_ _03296_ _03298_ _03303_ VGND VGND VPWR VPWR _03321_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_100_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10194_ D_cos\[11\] Q_sin\[11\] VGND VGND VPWR VPWR _01448_ sky130_fd_sc_hd__and2b_1
Xfanout370 net371 VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__clkbuf_4
Xfanout381 net382 VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__buf_4
Xfanout392 net393 VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__clkbuf_4
X_13953_ net512 net611 net264 net255 VGND VGND VPWR VPWR _05450_ sky130_fd_sc_hd__and4_1
X_12904_ _04304_ _04305_ _04297_ VGND VGND VPWR VPWR _04308_ sky130_fd_sc_hd__a21o_1
X_13884_ _05283_ _05287_ _05284_ VGND VGND VPWR VPWR _05375_ sky130_fd_sc_hd__o21ba_1
X_15623_ _07268_ _07270_ VGND VGND VPWR VPWR _07272_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12835_ net823 _04228_ _04168_ _04113_ VGND VGND VPWR VPWR _04232_ sky130_fd_sc_hd__o211ai_1
X_15554_ _07120_ _07123_ _07121_ VGND VGND VPWR VPWR _07196_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_29_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12766_ _04149_ _04155_ VGND VGND VPWR VPWR _04156_ sky130_fd_sc_hd__xnor2_1
X_14505_ _05956_ _05975_ _06006_ _06007_ VGND VGND VPWR VPWR _06050_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_127_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11717_ net513 net486 net476 net610 VGND VGND VPWR VPWR _03012_ sky130_fd_sc_hd__a22oi_1
X_15485_ net287 net278 net692 net531 VGND VGND VPWR VPWR _07121_ sky130_fd_sc_hd__and4_1
XFILLER_0_72_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12697_ _04059_ _04060_ _04071_ VGND VGND VPWR VPWR _04080_ sky130_fd_sc_hd__nand3_1
XFILLER_0_127_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14436_ _05900_ _05971_ _05972_ _05973_ VGND VGND VPWR VPWR _05974_ sky130_fd_sc_hd__nand4b_2
X_11648_ _02932_ _02935_ _02936_ VGND VGND VPWR VPWR _02937_ sky130_fd_sc_hd__nand3_1
XFILLER_0_140_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput12 D[2] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_2
Xinput23 Q[12] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_1
Xinput34 Q[5] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_114_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput45 cos[15] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__buf_1
XFILLER_0_142_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14367_ _05896_ _05897_ VGND VGND VPWR VPWR _05898_ sky130_fd_sc_hd__or2b_1
X_11579_ _02764_ _02766_ VGND VGND VPWR VPWR _02862_ sky130_fd_sc_hd__nand2_2
XFILLER_0_24_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput56 cos[8] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__buf_4
XFILLER_0_3_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput67 sin[17] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__clkbuf_2
Xinput78 start VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__clkbuf_1
X_16106_ net286 net277 net628 net619 VGND VGND VPWR VPWR _07796_ sky130_fd_sc_hd__and4_1
XFILLER_0_52_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13318_ _04756_ _04743_ _04757_ VGND VGND VPWR VPWR _04758_ sky130_fd_sc_hd__o21a_1
X_14298_ _05779_ _05780_ _05778_ VGND VGND VPWR VPWR _05823_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_122_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16037_ _07635_ _07634_ VGND VGND VPWR VPWR _07721_ sky130_fd_sc_hd__and2b_1
XFILLER_0_149_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13249_ net705 net161 net312 net713 VGND VGND VPWR VPWR _04683_ sky130_fd_sc_hd__a22o_1
XFILLER_0_20_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08790_ _08092_ _08099_ _08100_ VGND VGND VPWR VPWR _08101_ sky130_fd_sc_hd__nand3_2
XFILLER_0_79_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09411_ _00686_ _00619_ VGND VGND VPWR VPWR _00687_ sky130_fd_sc_hd__nand2_1
XFILLER_0_149_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09342_ _00541_ _00616_ _00617_ VGND VGND VPWR VPWR _00619_ sky130_fd_sc_hd__nand3_1
XFILLER_0_90_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09273_ _00523_ _00550_ VGND VGND VPWR VPWR _00551_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_145_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08224_ _02931_ _02942_ _02953_ VGND VGND VPWR VPWR _03040_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_15_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_132_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08155_ _02245_ _02278_ VGND VGND VPWR VPWR _02288_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_99_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08988_ _00266_ _00267_ _00165_ _00238_ VGND VGND VPWR VPWR _00269_ sky130_fd_sc_hd__o211a_1
X_10950_ _02174_ _02175_ _02081_ _02173_ VGND VGND VPWR VPWR _02178_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_97_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09609_ _00881_ _00882_ VGND VGND VPWR VPWR _00883_ sky130_fd_sc_hd__xnor2_1
X_10881_ _02101_ _02103_ _02106_ VGND VGND VPWR VPWR _02107_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12620_ net162 net310 net782 net790 VGND VGND VPWR VPWR _03995_ sky130_fd_sc_hd__and4_1
XFILLER_0_66_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12551_ net329 net709 net718 net244 VGND VGND VPWR VPWR _03919_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_148_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11502_ _02776_ _02777_ VGND VGND VPWR VPWR _02778_ sky130_fd_sc_hd__xnor2_1
X_15270_ _06884_ _06886_ VGND VGND VPWR VPWR _06887_ sky130_fd_sc_hd__xnor2_2
X_12482_ _03824_ _03842_ VGND VGND VPWR VPWR _03843_ sky130_fd_sc_hd__xor2_1
X_11433_ _02488_ _02489_ _02599_ VGND VGND VPWR VPWR _02704_ sky130_fd_sc_hd__or3_1
X_14221_ _05649_ _05632_ VGND VGND VPWR VPWR _05740_ sky130_fd_sc_hd__and2b_1
X_14152_ _05654_ _05664_ VGND VGND VPWR VPWR _05665_ sky130_fd_sc_hd__xnor2_1
X_11364_ _02609_ _02627_ VGND VGND VPWR VPWR _02628_ sky130_fd_sc_hd__xor2_2
XFILLER_0_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10315_ _01543_ _01546_ _01544_ VGND VGND VPWR VPWR _01552_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_21_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13103_ _04421_ _04423_ _04522_ _04523_ VGND VGND VPWR VPWR _04525_ sky130_fd_sc_hd__a211o_1
XFILLER_0_131_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14083_ _05509_ _05533_ _05507_ VGND VGND VPWR VPWR _05591_ sky130_fd_sc_hd__a21o_1
X_11295_ _02545_ _02551_ _02552_ VGND VGND VPWR VPWR _02553_ sky130_fd_sc_hd__nand3_1
X_13034_ _04441_ _04446_ VGND VGND VPWR VPWR _04449_ sky130_fd_sc_hd__nand2_1
X_10246_ _01485_ _01490_ _01486_ VGND VGND VPWR VPWR _01493_ sky130_fd_sc_hd__a21boi_1
X_10177_ D_cos\[9\] Q_sin\[9\] VGND VGND VPWR VPWR _01433_ sky130_fd_sc_hd__or2b_1
X_14985_ _06122_ _06233_ _06575_ _06576_ VGND VGND VPWR VPWR _06577_ sky130_fd_sc_hd__nor4_2
XFILLER_0_89_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13936_ _05165_ _05353_ _05270_ VGND VGND VPWR VPWR _05431_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_44_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13867_ _05354_ _05355_ VGND VGND VPWR VPWR _05356_ sky130_fd_sc_hd__xor2_1
XFILLER_0_29_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15606_ _07126_ _07128_ VGND VGND VPWR VPWR _07253_ sky130_fd_sc_hd__nand2_1
X_12818_ _04206_ _04212_ VGND VGND VPWR VPWR _04213_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13798_ _05280_ _05162_ VGND VGND VPWR VPWR _05281_ sky130_fd_sc_hd__or2_1
XFILLER_0_56_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15537_ _07094_ _07177_ VGND VGND VPWR VPWR _07178_ sky130_fd_sc_hd__xnor2_1
X_12749_ _04135_ _04136_ VGND VGND VPWR VPWR _04137_ sky130_fd_sc_hd__or2b_1
XFILLER_0_56_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15468_ net251 net565 _07100_ _07101_ VGND VGND VPWR VPWR _07102_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_44_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14419_ _05945_ _05946_ _05952_ VGND VGND VPWR VPWR _05955_ sky130_fd_sc_hd__a21o_1
X_15399_ net297 net934 VGND VGND VPWR VPWR _07027_ sky130_fd_sc_hd__and2_1
XFILLER_0_40_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09960_ _01109_ _01113_ _01174_ _01228_ VGND VGND VPWR VPWR _01229_ sky130_fd_sc_hd__o31a_1
X_08911_ _00191_ VGND VGND VPWR VPWR _00192_ sky130_fd_sc_hd__buf_6
XFILLER_0_110_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09891_ _01158_ _01159_ VGND VGND VPWR VPWR _01161_ sky130_fd_sc_hd__and2_1
X_08842_ net900 net551 net351 net506 VGND VGND VPWR VPWR _00124_ sky130_fd_sc_hd__nand4_2
X_08773_ _08079_ _08082_ _08083_ VGND VGND VPWR VPWR _08084_ sky130_fd_sc_hd__and3_1
XFILLER_0_109_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09325_ net682 net494 _00599_ _00600_ VGND VGND VPWR VPWR _00602_ sky130_fd_sc_hd__nand4_2
XFILLER_0_36_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09256_ _00532_ _00533_ VGND VGND VPWR VPWR _00534_ sky130_fd_sc_hd__nor2_1
XFILLER_0_106_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08207_ _02386_ _02408_ _02397_ VGND VGND VPWR VPWR _02855_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_62_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_133_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09187_ _00390_ _00465_ VGND VGND VPWR VPWR _00466_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_90_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10100_ _01362_ _01365_ VGND VGND VPWR VPWR _01366_ sky130_fd_sc_hd__xnor2_1
X_11080_ _02315_ _02316_ _02317_ VGND VGND VPWR VPWR _02318_ sky130_fd_sc_hd__a21o_1
X_10031_ _01292_ _01296_ VGND VGND VPWR VPWR _01298_ sky130_fd_sc_hd__nor2_1
X_14770_ _06253_ _06252_ _06241_ VGND VGND VPWR VPWR _06341_ sky130_fd_sc_hd__a21o_1
X_11982_ net711 _00191_ VGND VGND VPWR VPWR _03300_ sky130_fd_sc_hd__or2_1
X_13721_ _05191_ _05196_ VGND VGND VPWR VPWR _05197_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_86_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10933_ _02147_ _02158_ _02124_ VGND VGND VPWR VPWR _02160_ sky130_fd_sc_hd__or3b_1
XFILLER_0_129_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10864_ _02083_ _02089_ VGND VGND VPWR VPWR _02090_ sky130_fd_sc_hd__nor2_1
X_13652_ _05027_ _05029_ VGND VGND VPWR VPWR _05122_ sky130_fd_sc_hd__nor2_1
XFILLER_0_38_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12603_ _03973_ _03974_ _03975_ VGND VGND VPWR VPWR _03977_ sky130_fd_sc_hd__nand3_2
X_16371_ clknet_4_9_0_clk _00084_ net341 VGND VGND VPWR VPWR D_sin\[7\] sky130_fd_sc_hd__dfrtp_1
X_10795_ _02019_ _02020_ VGND VGND VPWR VPWR _02021_ sky130_fd_sc_hd__and2b_1
X_13583_ _04859_ _04857_ _04950_ VGND VGND VPWR VPWR _05048_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_137_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15322_ _06852_ _06855_ _06853_ VGND VGND VPWR VPWR _06943_ sky130_fd_sc_hd__o21bai_1
X_12534_ _03892_ _03897_ _03900_ VGND VGND VPWR VPWR _03901_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15253_ _06865_ _06866_ _06867_ VGND VGND VPWR VPWR _06869_ sky130_fd_sc_hd__nand3_2
X_12465_ _03725_ _03716_ _03724_ VGND VGND VPWR VPWR _03825_ sky130_fd_sc_hd__nand3_1
X_14204_ _05657_ _05660_ _05719_ VGND VGND VPWR VPWR _05722_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_112_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11416_ _02556_ _02654_ _02683_ _02684_ VGND VGND VPWR VPWR _02685_ sky130_fd_sc_hd__a211o_1
XFILLER_0_34_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_842 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15184_ _06702_ _06703_ _06792_ VGND VGND VPWR VPWR _06793_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_111_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12396_ net217 net207 net753 net763 VGND VGND VPWR VPWR _03749_ sky130_fd_sc_hd__and4_1
XFILLER_0_1_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11347_ _02584_ _02585_ _02608_ VGND VGND VPWR VPWR _02609_ sky130_fd_sc_hd__o21ai_2
X_14135_ _05643_ _05646_ VGND VGND VPWR VPWR _05647_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11278_ _02529_ _02532_ _02533_ VGND VGND VPWR VPWR _02534_ sky130_fd_sc_hd__and3_1
X_14066_ _05570_ _05571_ VGND VGND VPWR VPWR _05572_ sky130_fd_sc_hd__xnor2_1
X_10229_ net131 net85 VGND VGND VPWR VPWR _01479_ sky130_fd_sc_hd__and2b_1
X_13017_ _04428_ _04429_ _04341_ _04342_ VGND VGND VPWR VPWR _04431_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_146_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14968_ _06554_ _06555_ _06556_ VGND VGND VPWR VPWR _06558_ sky130_fd_sc_hd__a21o_1
XFILLER_0_89_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13919_ net230 net315 net288 net279 VGND VGND VPWR VPWR _05412_ sky130_fd_sc_hd__and4_1
X_14899_ Q_sin\[0\] _06482_ _05626_ VGND VGND VPWR VPWR _06483_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09110_ _00376_ _00377_ VGND VGND VPWR VPWR _00389_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09041_ net478 _00319_ _00320_ VGND VGND VPWR VPWR _00321_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_115_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmax_cap120 net930 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_102_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09943_ _01210_ _01211_ VGND VGND VPWR VPWR _01212_ sky130_fd_sc_hd__nand2_1
XFILLER_0_111_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09874_ _01081_ _01089_ VGND VGND VPWR VPWR _01144_ sky130_fd_sc_hd__nor2_1
X_08825_ _08129_ _08134_ VGND VGND VPWR VPWR _08135_ sky130_fd_sc_hd__or2_1
X_08756_ _03943_ _03954_ _03965_ VGND VGND VPWR VPWR _08067_ sky130_fd_sc_hd__o21bai_1
X_08687_ _07835_ _07846_ _07716_ _07814_ _07792_ VGND VGND VPWR VPWR _07999_ sky130_fd_sc_hd__o221a_1
XFILLER_0_95_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09308_ _00488_ _00493_ VGND VGND VPWR VPWR _00585_ sky130_fd_sc_hd__nand2_1
X_10580_ _01730_ _01731_ _01729_ VGND VGND VPWR VPWR _01806_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_118_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09239_ _00421_ _00423_ _00422_ VGND VGND VPWR VPWR _00517_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_134_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12250_ D_cos\[16\] _03590_ _03242_ VGND VGND VPWR VPWR _03591_ sky130_fd_sc_hd__mux2_1
X_11201_ net141 net522 VGND VGND VPWR VPWR _02450_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_875 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12181_ _03493_ _03494_ _03515_ VGND VGND VPWR VPWR _03516_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11132_ _02372_ _02373_ _02273_ _02275_ VGND VGND VPWR VPWR _02375_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_101_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15940_ _07614_ _07615_ VGND VGND VPWR VPWR _07616_ sky130_fd_sc_hd__xnor2_1
X_11063_ _02297_ _02298_ VGND VGND VPWR VPWR _02300_ sky130_fd_sc_hd__nand2_1
X_10014_ _01280_ _01281_ VGND VGND VPWR VPWR _01282_ sky130_fd_sc_hd__nor2_1
X_15871_ _07375_ _07363_ _07455_ VGND VGND VPWR VPWR _07541_ sky130_fd_sc_hd__a21o_1
X_14822_ _06390_ _06391_ VGND VGND VPWR VPWR _06398_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14753_ _06187_ _06188_ _06198_ VGND VGND VPWR VPWR _06323_ sky130_fd_sc_hd__o21ba_1
X_11965_ _03191_ _03193_ _03196_ VGND VGND VPWR VPWR _03282_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13704_ _05084_ _05095_ _05178_ VGND VGND VPWR VPWR _05179_ sky130_fd_sc_hd__a21o_1
X_10916_ _02139_ _02140_ VGND VGND VPWR VPWR _02142_ sky130_fd_sc_hd__or2_1
X_14684_ _06243_ _06244_ _06242_ VGND VGND VPWR VPWR _06247_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11896_ net610 net703 net461 net451 VGND VGND VPWR VPWR _03207_ sky130_fd_sc_hd__and4_1
XFILLER_0_128_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13635_ _05016_ _05023_ _05022_ VGND VGND VPWR VPWR _05104_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_41_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10847_ _02071_ _02070_ VGND VGND VPWR VPWR _02073_ sky130_fd_sc_hd__and2b_1
XFILLER_0_27_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16354_ clknet_4_6_0_clk _00067_ net339 VGND VGND VPWR VPWR D_cos\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_125_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13566_ _04920_ _04932_ _05028_ VGND VGND VPWR VPWR _05029_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_26_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10778_ _01978_ _01979_ _02003_ _01999_ VGND VGND VPWR VPWR _02004_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_143_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15305_ net273 net555 VGND VGND VPWR VPWR _06925_ sky130_fd_sc_hd__nand2_1
X_12517_ net223 net788 VGND VGND VPWR VPWR _03882_ sky130_fd_sc_hd__nand2_1
XFILLER_0_136_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16285_ Q_sin\[18\] _07989_ _00186_ VGND VGND VPWR VPWR _07990_ sky130_fd_sc_hd__mux2_2
X_13497_ _04953_ VGND VGND VPWR VPWR _00083_ sky130_fd_sc_hd__clkbuf_1
X_15236_ _06848_ _06849_ VGND VGND VPWR VPWR _06850_ sky130_fd_sc_hd__or2b_1
XFILLER_0_124_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12448_ _03796_ _03803_ _03802_ VGND VGND VPWR VPWR _03806_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15167_ _06772_ _06773_ _06685_ _06667_ VGND VGND VPWR VPWR _06775_ sky130_fd_sc_hd__a211o_1
XFILLER_0_140_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12379_ net189 net179 net789 VGND VGND VPWR VPWR _03730_ sky130_fd_sc_hd__and3_1
XFILLER_0_50_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14118_ _05621_ _05620_ VGND VGND VPWR VPWR _05628_ sky130_fd_sc_hd__and2b_1
X_15098_ _06697_ _06698_ VGND VGND VPWR VPWR _06699_ sky130_fd_sc_hd__xor2_2
X_14049_ _05312_ _05396_ _05408_ VGND VGND VPWR VPWR _05554_ sky130_fd_sc_hd__a21o_1
X_08610_ net589 net416 VGND VGND VPWR VPWR _07249_ sky130_fd_sc_hd__nand2_1
X_09590_ _00861_ _00862_ _00863_ net124 VGND VGND VPWR VPWR _00864_ sky130_fd_sc_hd__a211oi_2
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08541_ _05633_ _06486_ VGND VGND VPWR VPWR _06497_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_82_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08472_ _05590_ _05612_ VGND VGND VPWR VPWR _05742_ sky130_fd_sc_hd__or2b_1
XFILLER_0_49_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_794 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09024_ _00298_ _00303_ VGND VGND VPWR VPWR _00304_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_842 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout700 net702 VGND VGND VPWR VPWR net700 sky130_fd_sc_hd__clkbuf_4
Xfanout711 net712 VGND VGND VPWR VPWR net711 sky130_fd_sc_hd__buf_2
X_09926_ _01177_ _01194_ VGND VGND VPWR VPWR _01195_ sky130_fd_sc_hd__nand2_1
Xfanout722 net723 VGND VGND VPWR VPWR net722 sky130_fd_sc_hd__clkbuf_4
Xfanout733 net737 VGND VGND VPWR VPWR net733 sky130_fd_sc_hd__buf_2
Xfanout744 net745 VGND VGND VPWR VPWR net744 sky130_fd_sc_hd__clkbuf_4
Xfanout755 net15 VGND VGND VPWR VPWR net755 sky130_fd_sc_hd__buf_2
Xfanout766 net768 VGND VGND VPWR VPWR net766 sky130_fd_sc_hd__clkbuf_4
X_09857_ _01125_ _01126_ VGND VGND VPWR VPWR _01127_ sky130_fd_sc_hd__xnor2_1
Xfanout777 net779 VGND VGND VPWR VPWR net777 sky130_fd_sc_hd__clkbuf_4
Xfanout788 net790 VGND VGND VPWR VPWR net788 sky130_fd_sc_hd__buf_2
Xfanout799 net10 VGND VGND VPWR VPWR net799 sky130_fd_sc_hd__buf_2
X_08808_ _08116_ _08117_ _03073_ VGND VGND VPWR VPWR _08119_ sky130_fd_sc_hd__a21oi_1
X_09788_ _01057_ _01058_ VGND VGND VPWR VPWR _01059_ sky130_fd_sc_hd__nor2_1
X_08739_ _08048_ _08049_ VGND VGND VPWR VPWR _08050_ sky130_fd_sc_hd__nand2_1
XFILLER_0_95_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11750_ _03046_ _03047_ VGND VGND VPWR VPWR _03048_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_68_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10701_ _01914_ _01925_ _01926_ VGND VGND VPWR VPWR _01927_ sky130_fd_sc_hd__nand3_1
XFILLER_0_55_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11681_ _02879_ _02881_ VGND VGND VPWR VPWR _02973_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13420_ net738 net748 net267 net257 VGND VGND VPWR VPWR _04869_ sky130_fd_sc_hd__and4_1
XFILLER_0_48_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10632_ net726 net438 VGND VGND VPWR VPWR _01858_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10563_ net716 net724 net381 net371 VGND VGND VPWR VPWR _01789_ sky130_fd_sc_hd__nand4_2
XFILLER_0_118_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13351_ net612 net161 net312 net705 VGND VGND VPWR VPWR _04794_ sky130_fd_sc_hd__a22o_1
X_12302_ _03645_ _03646_ VGND VGND VPWR VPWR _03647_ sky130_fd_sc_hd__nor2_1
X_16070_ _07754_ _07755_ _07752_ _07753_ VGND VGND VPWR VPWR _07757_ sky130_fd_sc_hd__o211a_1
X_10494_ net733 net390 _01660_ _01661_ VGND VGND VPWR VPWR _01720_ sky130_fd_sc_hd__o2bb2a_1
X_13282_ _04715_ _04716_ _04717_ VGND VGND VPWR VPWR _04719_ sky130_fd_sc_hd__a21oi_1
X_15021_ _06511_ _06513_ _06512_ VGND VGND VPWR VPWR _06615_ sky130_fd_sc_hd__a21bo_1
X_12233_ _03476_ _03480_ _03481_ _03571_ VGND VGND VPWR VPWR _03573_ sky130_fd_sc_hd__o31a_1
XFILLER_0_122_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12164_ net792 net485 net475 net136 VGND VGND VPWR VPWR _03498_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_102_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11115_ _02352_ _02353_ _02355_ VGND VGND VPWR VPWR _02357_ sky130_fd_sc_hd__a21o_1
X_12095_ _03421_ _03422_ VGND VGND VPWR VPWR _03423_ sky130_fd_sc_hd__xor2_1
X_15923_ _07593_ _07596_ VGND VGND VPWR VPWR _07598_ sky130_fd_sc_hd__xnor2_1
X_11046_ _02191_ _02193_ _02280_ _02281_ VGND VGND VPWR VPWR _02282_ sky130_fd_sc_hd__a211o_1
X_15854_ _07520_ _07522_ VGND VGND VPWR VPWR _07523_ sky130_fd_sc_hd__nand2_1
X_14805_ net212 net202 net597 net605 VGND VGND VPWR VPWR _06380_ sky130_fd_sc_hd__and4_1
X_15785_ _07446_ _07447_ VGND VGND VPWR VPWR _07448_ sky130_fd_sc_hd__nor2_1
X_12997_ _04399_ _04407_ _04408_ VGND VGND VPWR VPWR _04409_ sky130_fd_sc_hd__nand3_2
X_14736_ _06283_ _06285_ VGND VGND VPWR VPWR _06304_ sky130_fd_sc_hd__or2b_1
X_11948_ net229 net485 net475 net314 VGND VGND VPWR VPWR _03263_ sky130_fd_sc_hd__a22oi_2
X_14667_ _06220_ _06221_ _06226_ _06227_ VGND VGND VPWR VPWR _06228_ sky130_fd_sc_hd__o211ai_4
X_11879_ _03186_ _03187_ VGND VGND VPWR VPWR _03188_ sky130_fd_sc_hd__xor2_4
XFILLER_0_129_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13618_ _05019_ _05021_ VGND VGND VPWR VPWR _05085_ sky130_fd_sc_hd__nand2_1
X_14598_ _06139_ _06144_ _06143_ VGND VGND VPWR VPWR _06152_ sky130_fd_sc_hd__a21o_1
X_16337_ clknet_4_3_0_clk _00050_ net332 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13549_ _05008_ _05009_ VGND VGND VPWR VPWR _05010_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16268_ _07969_ _07970_ VGND VGND VPWR VPWR _07971_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_124_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15219_ _06717_ _06714_ _06716_ VGND VGND VPWR VPWR _06831_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_22_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16199_ net247 net648 VGND VGND VPWR VPWR _07896_ sky130_fd_sc_hd__nand2_1
XFILLER_0_112_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09711_ _00981_ _00982_ VGND VGND VPWR VPWR _00983_ sky130_fd_sc_hd__nor2_1
X_09642_ _00913_ _00914_ VGND VGND VPWR VPWR _00915_ sky130_fd_sc_hd__xnor2_1
X_09573_ _00828_ _00829_ _00845_ _00846_ VGND VGND VPWR VPWR _00847_ sky130_fd_sc_hd__o211a_1
X_08524_ _06267_ _06289_ _06278_ VGND VGND VPWR VPWR _06311_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08455_ _05460_ _05536_ _05547_ VGND VGND VPWR VPWR _05558_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_9_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08386_ _02692_ _04796_ VGND VGND VPWR VPWR _04807_ sky130_fd_sc_hd__and2_1
XFILLER_0_45_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_130_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09007_ _08120_ _08122_ _00183_ VGND VGND VPWR VPWR _00288_ sky130_fd_sc_hd__a21o_1
Xfanout530 net533 VGND VGND VPWR VPWR net530 sky130_fd_sc_hd__buf_4
Xfanout541 net542 VGND VGND VPWR VPWR net541 sky130_fd_sc_hd__buf_6
Xfanout552 net554 VGND VGND VPWR VPWR net552 sky130_fd_sc_hd__buf_2
X_09909_ _01075_ _01153_ _01155_ VGND VGND VPWR VPWR _01178_ sky130_fd_sc_hd__a21oi_1
Xfanout563 net35 VGND VGND VPWR VPWR net563 sky130_fd_sc_hd__buf_4
Xfanout574 net582 VGND VGND VPWR VPWR net574 sky130_fd_sc_hd__clkbuf_4
Xfanout585 net586 VGND VGND VPWR VPWR net585 sky130_fd_sc_hd__clkbuf_2
Xfanout596 net600 VGND VGND VPWR VPWR net596 sky130_fd_sc_hd__clkbuf_2
X_12920_ _04321_ _04322_ _04323_ VGND VGND VPWR VPWR _04325_ sky130_fd_sc_hd__o21ai_1
X_12851_ _04246_ _04248_ VGND VGND VPWR VPWR _04249_ sky130_fd_sc_hd__and2b_1
X_11802_ net425 net486 net476 net511 VGND VGND VPWR VPWR _03104_ sky130_fd_sc_hd__a22oi_2
X_15570_ _07211_ _07212_ VGND VGND VPWR VPWR _07213_ sky130_fd_sc_hd__and2_1
X_12782_ _04170_ _04171_ _04172_ VGND VGND VPWR VPWR _04173_ sky130_fd_sc_hd__or3_1
Xrebuffer90 net895 VGND VGND VPWR VPWR net896 sky130_fd_sc_hd__clkbuf_1
X_14521_ _06063_ _06066_ VGND VGND VPWR VPWR _06067_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_138_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11733_ _03026_ _03027_ _03011_ VGND VGND VPWR VPWR _03030_ sky130_fd_sc_hd__a21o_1
XFILLER_0_68_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14452_ _05946_ _05952_ _05945_ VGND VGND VPWR VPWR _05991_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_22_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11664_ net318 net350 net503 net425 VGND VGND VPWR VPWR _02955_ sky130_fd_sc_hd__a22o_1
X_13403_ _04649_ _04747_ VGND VGND VPWR VPWR _04852_ sky130_fd_sc_hd__nor2_1
XFILLER_0_24_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10615_ _01826_ _01838_ _01837_ VGND VGND VPWR VPWR _01841_ sky130_fd_sc_hd__a21o_1
X_14383_ net213 net537 net544 net203 VGND VGND VPWR VPWR _05916_ sky130_fd_sc_hd__a22oi_1
X_11595_ _02783_ _02784_ VGND VGND VPWR VPWR _02880_ sky130_fd_sc_hd__nor2_1
X_16122_ _07751_ _07730_ _07731_ VGND VGND VPWR VPWR _07813_ sky130_fd_sc_hd__nor3_1
XFILLER_0_24_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13334_ _04656_ _04661_ VGND VGND VPWR VPWR _04776_ sky130_fd_sc_hd__nand2_1
XFILLER_0_52_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10546_ _01770_ _01771_ VGND VGND VPWR VPWR _01772_ sky130_fd_sc_hd__nor2_1
XFILLER_0_106_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16053_ net270 net647 VGND VGND VPWR VPWR _07739_ sky130_fd_sc_hd__nand2_1
XFILLER_0_121_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13265_ _04602_ _04604_ _04603_ net215 VGND VGND VPWR VPWR _04701_ sky130_fd_sc_hd__a22o_1
X_10477_ _01700_ _01701_ _01702_ VGND VGND VPWR VPWR _01703_ sky130_fd_sc_hd__o21bai_1
X_15004_ _06594_ _06596_ VGND VGND VPWR VPWR _06597_ sky130_fd_sc_hd__xor2_1
X_12216_ net511 _00193_ _03489_ VGND VGND VPWR VPWR _03554_ sky130_fd_sc_hd__or3_1
X_13196_ _04588_ _04624_ _04625_ VGND VGND VPWR VPWR _04626_ sky130_fd_sc_hd__or3_2
X_12147_ _03477_ _03478_ VGND VGND VPWR VPWR _03479_ sky130_fd_sc_hd__nor2_1
XFILLER_0_138_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12078_ D_cos\[13\] _03404_ _03242_ VGND VGND VPWR VPWR _03405_ sky130_fd_sc_hd__mux2_1
X_15906_ _07496_ _07497_ VGND VGND VPWR VPWR _07579_ sky130_fd_sc_hd__or2b_1
X_11029_ _01800_ _01808_ _01807_ VGND VGND VPWR VPWR _02263_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_2_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15837_ _07432_ _07436_ _07440_ VGND VGND VPWR VPWR _07504_ sky130_fd_sc_hd__o21ai_2
X_15768_ _07427_ _07428_ VGND VGND VPWR VPWR _07429_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_86_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14719_ _06165_ _06284_ VGND VGND VPWR VPWR _06285_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_129_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15699_ _07261_ _07263_ VGND VGND VPWR VPWR _07354_ sky130_fd_sc_hd__nor2_1
X_08240_ _03138_ _03192_ _03181_ VGND VGND VPWR VPWR _03214_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_731 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_129_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_15 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_26 net391 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_55_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_37 net799 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_117_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08171_ _02441_ _02452_ net603 net497 VGND VGND VPWR VPWR _02463_ sky130_fd_sc_hd__and4bb_1
XANTENNA_48 net158 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_103_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_59 net737 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput100 net100 VGND VGND VPWR VPWR beta[11] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_113_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput111 net111 VGND VGND VPWR VPWR beta[4] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_23_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09625_ Q_cos\[10\] _00898_ _00661_ VGND VGND VPWR VPWR _00899_ sky130_fd_sc_hd__mux2_1
XFILLER_0_97_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09556_ _00768_ _00773_ VGND VGND VPWR VPWR _00830_ sky130_fd_sc_hd__or2_1
XFILLER_0_77_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08507_ _06091_ _06102_ _06080_ VGND VGND VPWR VPWR _06124_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_93_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09487_ _00743_ _00744_ _00760_ _00761_ VGND VGND VPWR VPWR _00762_ sky130_fd_sc_hd__o211a_1
X_08438_ net841 _05351_ _05340_ _05308_ VGND VGND VPWR VPWR _05373_ sky130_fd_sc_hd__a211o_1
XFILLER_0_81_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08369_ _02223_ _04611_ VGND VGND VPWR VPWR _04622_ sky130_fd_sc_hd__nor2_1
XFILLER_0_150_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10400_ net754 net380 net370 net762 VGND VGND VPWR VPWR _01626_ sky130_fd_sc_hd__a22o_1
XFILLER_0_116_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11380_ _02641_ _02642_ _02643_ VGND VGND VPWR VPWR _02645_ sky130_fd_sc_hd__a21o_1
XFILLER_0_116_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10331_ _01555_ _01562_ _01565_ VGND VGND VPWR VPWR _01566_ sky130_fd_sc_hd__nor3_1
XFILLER_0_21_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10262_ Q_cos\[1\] D_sin\[1\] VGND VGND VPWR VPWR _01506_ sky130_fd_sc_hd__and2b_1
X_13050_ net722 net731 net161 net312 VGND VGND VPWR VPWR _04466_ sky130_fd_sc_hd__nand4_1
XFILLER_0_131_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12001_ _03315_ _03313_ VGND VGND VPWR VPWR _03320_ sky130_fd_sc_hd__and2b_1
X_10193_ Q_sin\[11\] D_cos\[11\] VGND VGND VPWR VPWR _01447_ sky130_fd_sc_hd__and2b_1
Xfanout360 net363 VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__clkbuf_4
Xfanout371 net372 VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__buf_4
Xfanout382 net54 VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__buf_6
XFILLER_0_17_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout393 net395 VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__clkbuf_4
X_13952_ net512 net264 net255 net611 VGND VGND VPWR VPWR _05448_ sky130_fd_sc_hd__a22oi_1
X_12903_ _04297_ _04304_ net879 VGND VGND VPWR VPWR _04307_ sky130_fd_sc_hd__nand3_2
X_13883_ _05367_ _05372_ VGND VGND VPWR VPWR _05374_ sky130_fd_sc_hd__xnor2_2
X_15622_ _07094_ _07177_ _07269_ VGND VGND VPWR VPWR _07270_ sky130_fd_sc_hd__a21oi_1
X_12834_ _04113_ _04168_ _04228_ net823 VGND VGND VPWR VPWR _04231_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_69_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15553_ _07119_ _07133_ _07134_ _07137_ VGND VGND VPWR VPWR _07195_ sky130_fd_sc_hd__a31o_1
XFILLER_0_84_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12765_ _04012_ _04153_ _04154_ VGND VGND VPWR VPWR _04155_ sky130_fd_sc_hd__a21o_1
XFILLER_0_56_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14504_ _06046_ _06048_ VGND VGND VPWR VPWR _06049_ sky130_fd_sc_hd__nor2_1
X_11716_ _02930_ _02938_ _02937_ VGND VGND VPWR VPWR _03011_ sky130_fd_sc_hd__a21bo_1
X_15484_ net287 net692 net530 net278 VGND VGND VPWR VPWR _07120_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_83_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12696_ _04074_ _04078_ VGND VGND VPWR VPWR _04079_ sky130_fd_sc_hd__or2b_1
XFILLER_0_126_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14435_ _05886_ _05899_ _05898_ _05895_ VGND VGND VPWR VPWR _05973_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_83_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11647_ net232 net358 _02933_ _02934_ VGND VGND VPWR VPWR _02936_ sky130_fd_sc_hd__nand4_2
XFILLER_0_83_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput13 D[3] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_2
XFILLER_0_126_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput24 Q[13] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_1
Xinput35 Q[6] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14366_ _05894_ _05890_ VGND VGND VPWR VPWR _05897_ sky130_fd_sc_hd__xnor2_1
X_11578_ _02859_ _02860_ VGND VGND VPWR VPWR _02861_ sky130_fd_sc_hd__xnor2_2
Xinput46 cos[16] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__buf_1
Xinput57 cos[9] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__buf_4
Xinput68 sin[18] VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__clkbuf_4
X_16105_ net277 net628 net619 net286 VGND VGND VPWR VPWR _07795_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_141_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13317_ _04740_ _04741_ VGND VGND VPWR VPWR _04757_ sky130_fd_sc_hd__nand2_1
XFILLER_0_134_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10529_ _01747_ _01754_ VGND VGND VPWR VPWR _01755_ sky130_fd_sc_hd__xnor2_2
X_14297_ _05764_ _05789_ _05765_ VGND VGND VPWR VPWR _05822_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_122_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16036_ _07627_ _07633_ VGND VGND VPWR VPWR _07720_ sky130_fd_sc_hd__and2b_1
XFILLER_0_122_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13248_ _04680_ _04681_ VGND VGND VPWR VPWR _04682_ sky130_fd_sc_hd__xor2_1
XFILLER_0_58_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13179_ _04499_ _04500_ _04501_ VGND VGND VPWR VPWR _04607_ sky130_fd_sc_hd__nor3_1
XFILLER_0_149_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09410_ _00535_ VGND VGND VPWR VPWR _00686_ sky130_fd_sc_hd__inv_2
X_09341_ _00616_ _00617_ _00541_ VGND VGND VPWR VPWR _00618_ sky130_fd_sc_hd__a21o_1
X_09272_ _00547_ _00549_ VGND VGND VPWR VPWR _00550_ sky130_fd_sc_hd__xor2_2
XFILLER_0_16_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08223_ _02996_ _03007_ _03018_ VGND VGND VPWR VPWR _03029_ sky130_fd_sc_hd__nand3_2
XFILLER_0_62_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08154_ _02256_ _02267_ VGND VGND VPWR VPWR _02278_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08987_ _00165_ _00238_ _00266_ _00267_ VGND VGND VPWR VPWR _00268_ sky130_fd_sc_hd__a211oi_4
Xclkbuf_4_5_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_5_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_98_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09608_ net546 net937 VGND VGND VPWR VPWR _00882_ sky130_fd_sc_hd__or2_1
X_10880_ net770 net438 _02104_ _02105_ VGND VGND VPWR VPWR _02106_ sky130_fd_sc_hd__a31o_1
XFILLER_0_39_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09539_ _00740_ _00813_ VGND VGND VPWR VPWR _00814_ sky130_fd_sc_hd__xor2_1
XFILLER_0_39_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12550_ net224 net727 VGND VGND VPWR VPWR _03918_ sky130_fd_sc_hd__nand2_1
X_11501_ net890 _02671_ _02672_ _02451_ VGND VGND VPWR VPWR _02777_ sky130_fd_sc_hd__a22o_1
XFILLER_0_109_758 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12481_ _03840_ _03841_ VGND VGND VPWR VPWR _03842_ sky130_fd_sc_hd__nor2_1
XFILLER_0_136_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14220_ _05670_ _05673_ _05736_ _05737_ VGND VGND VPWR VPWR _05739_ sky130_fd_sc_hd__a211o_1
XFILLER_0_123_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11432_ _02700_ _02701_ VGND VGND VPWR VPWR _02702_ sky130_fd_sc_hd__nand2_1
XFILLER_0_80_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14151_ _05564_ _05663_ VGND VGND VPWR VPWR _05664_ sky130_fd_sc_hd__xnor2_1
X_11363_ _02610_ _02625_ VGND VGND VPWR VPWR _02627_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13102_ _04520_ _04521_ _04456_ VGND VGND VPWR VPWR _04523_ sky130_fd_sc_hd__a21oi_1
X_10314_ _01549_ _01550_ VGND VGND VPWR VPWR _01551_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14082_ _05563_ _05587_ VGND VGND VPWR VPWR _05589_ sky130_fd_sc_hd__nor2_1
X_11294_ _02548_ _02549_ _02457_ _02458_ VGND VGND VPWR VPWR _02552_ sky130_fd_sc_hd__a211o_1
X_13033_ _04441_ _04446_ VGND VGND VPWR VPWR _04448_ sky130_fd_sc_hd__or2_1
X_10245_ _01492_ VGND VGND VPWR VPWR _00036_ sky130_fd_sc_hd__clkbuf_1
X_10176_ _01432_ VGND VGND VPWR VPWR _00027_ sky130_fd_sc_hd__clkbuf_1
X_14984_ _06572_ _06573_ net827 _06488_ VGND VGND VPWR VPWR _06576_ sky130_fd_sc_hd__a211oi_2
Xfanout190 net844 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__clkbuf_2
X_13935_ _05409_ _05338_ _05428_ VGND VGND VPWR VPWR _05430_ sky130_fd_sc_hd__nor3_1
XFILLER_0_135_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13866_ _05165_ _05268_ _05270_ VGND VGND VPWR VPWR _05355_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_76_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15605_ _07250_ _07251_ VGND VGND VPWR VPWR _07252_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_147_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12817_ _04208_ _04211_ VGND VGND VPWR VPWR _04212_ sky130_fd_sc_hd__xnor2_1
X_13797_ _05143_ _05145_ _05159_ VGND VGND VPWR VPWR _05280_ sky130_fd_sc_hd__a21oi_1
X_15536_ _07175_ _07176_ VGND VGND VPWR VPWR _07177_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12748_ _04134_ _04133_ _04117_ _04116_ VGND VGND VPWR VPWR _04136_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_56_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15467_ net265 net932 net547 net555 VGND VGND VPWR VPWR _07101_ sky130_fd_sc_hd__and4_1
X_12679_ _04056_ _04058_ _04057_ VGND VGND VPWR VPWR _04060_ sky130_fd_sc_hd__a21o_1
XFILLER_0_114_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14418_ _05913_ _05919_ _05912_ VGND VGND VPWR VPWR _05954_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_114_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15398_ net156 net305 net673 net683 VGND VGND VPWR VPWR _07026_ sky130_fd_sc_hd__nand4_1
XFILLER_0_53_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14349_ net160 net309 net590 net599 VGND VGND VPWR VPWR _05878_ sky130_fd_sc_hd__and4_1
XFILLER_0_8_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_110_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08910_ _00190_ VGND VGND VPWR VPWR _00191_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_0_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16019_ _07621_ _07691_ VGND VGND VPWR VPWR _07701_ sky130_fd_sc_hd__nand2_1
X_09890_ _01158_ _01159_ VGND VGND VPWR VPWR _01160_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08841_ net900 net351 net506 net551 VGND VGND VPWR VPWR _00123_ sky130_fd_sc_hd__a22o_1
X_08772_ net541 net360 _08080_ _08081_ VGND VGND VPWR VPWR _08083_ sky130_fd_sc_hd__nand4_1
XFILLER_0_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09324_ net682 net494 _00599_ _00600_ VGND VGND VPWR VPWR _00601_ sky130_fd_sc_hd__a22o_1
XFILLER_0_118_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_146_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09255_ _00530_ _00531_ _00524_ VGND VGND VPWR VPWR _00533_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_16_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08206_ _02822_ _02833_ VGND VGND VPWR VPWR _02844_ sky130_fd_sc_hd__or2b_1
XFILLER_0_8_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09186_ _00392_ _00464_ VGND VGND VPWR VPWR _00465_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10030_ _01292_ _01296_ VGND VGND VPWR VPWR _01297_ sky130_fd_sc_hd__and2_1
X_11981_ _03296_ _03298_ VGND VGND VPWR VPWR _03299_ sky130_fd_sc_hd__xnor2_1
X_13720_ _05194_ _05195_ VGND VGND VPWR VPWR _05196_ sky130_fd_sc_hd__xnor2_1
X_10932_ _02154_ net415 _02155_ _02156_ _02157_ VGND VGND VPWR VPWR _02158_ sky130_fd_sc_hd__a2111o_2
XFILLER_0_98_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13651_ _05102_ _05120_ VGND VGND VPWR VPWR _05121_ sky130_fd_sc_hd__xnor2_2
X_10863_ _02082_ _02052_ VGND VGND VPWR VPWR _02089_ sky130_fd_sc_hd__and2b_1
X_12602_ _03966_ _03967_ _03972_ VGND VGND VPWR VPWR _03975_ sky130_fd_sc_hd__a21o_1
X_16370_ clknet_4_9_0_clk _00083_ net341 VGND VGND VPWR VPWR D_sin\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_39_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13582_ net119 _04951_ _04846_ VGND VGND VPWR VPWR _05046_ sky130_fd_sc_hd__and3b_1
X_10794_ net734 net528 net399 net769 VGND VGND VPWR VPWR _02020_ sky130_fd_sc_hd__a22o_1
X_15321_ _06844_ _06847_ VGND VGND VPWR VPWR _06942_ sky130_fd_sc_hd__nand2_1
X_12533_ _03892_ _03897_ _03898_ VGND VGND VPWR VPWR _03900_ sky130_fd_sc_hd__o21a_1
XFILLER_0_66_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15252_ _06736_ net822 _06744_ VGND VGND VPWR VPWR _06867_ sky130_fd_sc_hd__a21bo_1
X_12464_ _03819_ _03823_ VGND VGND VPWR VPWR _03824_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14203_ _05657_ _05660_ _05719_ VGND VGND VPWR VPWR _05721_ sky130_fd_sc_hd__or3_1
X_11415_ _02680_ _02682_ _02664_ VGND VGND VPWR VPWR _02684_ sky130_fd_sc_hd__a21oi_1
X_15183_ _06686_ _06701_ VGND VGND VPWR VPWR _06792_ sky130_fd_sc_hd__nand2_1
X_12395_ net217 net753 net763 net207 VGND VGND VPWR VPWR _03748_ sky130_fd_sc_hd__a22oi_2
X_14134_ _05574_ _05645_ VGND VGND VPWR VPWR _05646_ sky130_fd_sc_hd__nor2_1
XFILLER_0_50_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11346_ _02579_ _02582_ VGND VGND VPWR VPWR _02608_ sky130_fd_sc_hd__or2b_1
XFILLER_0_104_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14065_ net512 net248 VGND VGND VPWR VPWR _05571_ sky130_fd_sc_hd__nand2_1
X_11277_ net614 net359 _02530_ _02531_ VGND VGND VPWR VPWR _02533_ sky130_fd_sc_hd__nand4_2
X_13016_ _04341_ _04342_ _04428_ _04429_ VGND VGND VPWR VPWR _04430_ sky130_fd_sc_hd__o211a_1
X_10228_ _01467_ _01470_ _01476_ VGND VGND VPWR VPWR _01478_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_146_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10159_ _01409_ _01412_ _01410_ VGND VGND VPWR VPWR _01418_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_55_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14967_ _06554_ _06555_ _06556_ VGND VGND VPWR VPWR _06557_ sky130_fd_sc_hd__nand3_4
XFILLER_0_89_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13918_ net231 net288 net279 net315 VGND VGND VPWR VPWR _05411_ sky130_fd_sc_hd__a22oi_2
X_14898_ _06236_ _06479_ _06480_ _06481_ VGND VGND VPWR VPWR _06482_ sky130_fd_sc_hd__o31a_1
X_13849_ _05246_ _05249_ _05247_ VGND VGND VPWR VPWR _05336_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_76_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15519_ _07155_ _07157_ _07153_ VGND VGND VPWR VPWR _07158_ sky130_fd_sc_hd__or3b_1
XFILLER_0_143_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09040_ net548 net488 net478 net557 VGND VGND VPWR VPWR _00320_ sky130_fd_sc_hd__a22o_1
XFILLER_0_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmax_cap121 _02589_ VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__buf_6
XFILLER_0_13_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09942_ _01071_ _01209_ VGND VGND VPWR VPWR _01211_ sky130_fd_sc_hd__or2_1
X_09873_ _01120_ _01141_ VGND VGND VPWR VPWR _01143_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08824_ _08132_ _08133_ VGND VGND VPWR VPWR _08134_ sky130_fd_sc_hd__xnor2_1
X_08755_ _08062_ _08063_ _08064_ VGND VGND VPWR VPWR _08066_ sky130_fd_sc_hd__nand3_1
X_08686_ _07716_ _07814_ VGND VGND VPWR VPWR _07998_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_137_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09307_ _00582_ _00583_ VGND VGND VPWR VPWR _00584_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_146_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09238_ _00512_ _00513_ _00514_ VGND VGND VPWR VPWR _00516_ sky130_fd_sc_hd__nand3_1
XFILLER_0_8_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09169_ net650 net383 VGND VGND VPWR VPWR _00448_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11200_ net318 net394 VGND VGND VPWR VPWR _02449_ sky130_fd_sc_hd__nand2_1
X_12180_ _03513_ _03514_ VGND VGND VPWR VPWR _03515_ sky130_fd_sc_hd__and2b_1
X_11131_ _02273_ _02275_ _02372_ _02373_ VGND VGND VPWR VPWR _02374_ sky130_fd_sc_hd__a211o_1
XFILLER_0_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11062_ _02291_ _02296_ VGND VGND VPWR VPWR _02298_ sky130_fd_sc_hd__nand2_1
X_10013_ _01214_ _01217_ _01278_ _01279_ VGND VGND VPWR VPWR _01281_ sky130_fd_sc_hd__a211oi_1
X_15870_ _07365_ _07457_ VGND VGND VPWR VPWR _07540_ sky130_fd_sc_hd__nand2_1
X_14821_ _06389_ _06395_ _06396_ _06361_ VGND VGND VPWR VPWR _06397_ sky130_fd_sc_hd__a211o_1
XFILLER_0_25_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_99_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14752_ _06319_ _06318_ _06320_ VGND VGND VPWR VPWR _06321_ sky130_fd_sc_hd__nand3_2
X_11964_ _03258_ _03280_ VGND VGND VPWR VPWR _03281_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_59_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13703_ _05083_ _05082_ VGND VGND VPWR VPWR _05178_ sky130_fd_sc_hd__and2b_1
X_10915_ _02139_ _02140_ VGND VGND VPWR VPWR _02141_ sky130_fd_sc_hd__nand2_1
X_14683_ _06242_ _06243_ _06244_ VGND VGND VPWR VPWR _06246_ sky130_fd_sc_hd__nand3_1
X_11895_ net610 net461 net451 net703 VGND VGND VPWR VPWR _03206_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_39_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13634_ _04995_ _04997_ VGND VGND VPWR VPWR _05103_ sky130_fd_sc_hd__nand2_1
X_10846_ _02070_ _02071_ VGND VGND VPWR VPWR _02072_ sky130_fd_sc_hd__and2b_1
X_16353_ clknet_4_12_0_clk _00066_ net345 VGND VGND VPWR VPWR D_cos\[8\] sky130_fd_sc_hd__dfrtp_1
X_13565_ _04931_ _04929_ VGND VGND VPWR VPWR _05028_ sky130_fd_sc_hd__and2b_1
XFILLER_0_81_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10777_ _01999_ _02001_ _02002_ VGND VGND VPWR VPWR _02003_ sky130_fd_sc_hd__nand3_2
X_15304_ net540 _06820_ _06923_ VGND VGND VPWR VPWR _06924_ sky130_fd_sc_hd__a21bo_1
X_12516_ _03845_ _03860_ _03859_ VGND VGND VPWR VPWR _03881_ sky130_fd_sc_hd__and3_1
XFILLER_0_54_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16284_ _07950_ _07988_ VGND VGND VPWR VPWR _07989_ sky130_fd_sc_hd__xnor2_1
X_13496_ D_sin\[6\] _04952_ _04752_ VGND VGND VPWR VPWR _04953_ sky130_fd_sc_hd__mux2_1
XFILLER_0_82_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15235_ _06845_ _06847_ _06842_ VGND VGND VPWR VPWR _06849_ sky130_fd_sc_hd__a21o_1
XFILLER_0_125_878 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12447_ _03752_ _03761_ _03760_ VGND VGND VPWR VPWR _03805_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_140_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15166_ _06685_ _06667_ _06772_ net898 VGND VGND VPWR VPWR _06774_ sky130_fd_sc_hd__o211ai_2
X_12378_ net198 net789 _03714_ _03711_ VGND VGND VPWR VPWR _03729_ sky130_fd_sc_hd__a31o_1
X_14117_ _05627_ VGND VGND VPWR VPWR _00091_ sky130_fd_sc_hd__clkbuf_1
X_11329_ _02565_ _02566_ _02588_ VGND VGND VPWR VPWR _02590_ sky130_fd_sc_hd__o21ba_1
X_15097_ _06491_ _06593_ _06592_ VGND VGND VPWR VPWR _06698_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_66_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14048_ _05477_ _05398_ _05406_ VGND VGND VPWR VPWR _05553_ sky130_fd_sc_hd__nor3b_1
X_15999_ _07677_ _07679_ VGND VGND VPWR VPWR _07680_ sky130_fd_sc_hd__xnor2_1
X_08540_ _05655_ _05644_ VGND VGND VPWR VPWR _06486_ sky130_fd_sc_hd__nor2_1
X_08471_ _05579_ _05698_ _05709_ _05720_ VGND VGND VPWR VPWR _05731_ sky130_fd_sc_hd__a211o_1
XFILLER_0_147_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09023_ _00301_ _00302_ VGND VGND VPWR VPWR _00303_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_28_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout701 net702 VGND VGND VPWR VPWR net701 sky130_fd_sc_hd__buf_2
X_09925_ _01178_ _01193_ VGND VGND VPWR VPWR _01194_ sky130_fd_sc_hd__xor2_1
XFILLER_0_111_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout712 net714 VGND VGND VPWR VPWR net712 sky130_fd_sc_hd__clkbuf_4
Xfanout723 net728 VGND VGND VPWR VPWR net723 sky130_fd_sc_hd__clkbuf_2
Xfanout734 net737 VGND VGND VPWR VPWR net734 sky130_fd_sc_hd__clkbuf_2
Xfanout745 net746 VGND VGND VPWR VPWR net745 sky130_fd_sc_hd__buf_2
Xfanout756 net759 VGND VGND VPWR VPWR net756 sky130_fd_sc_hd__buf_4
X_09856_ net671 net441 VGND VGND VPWR VPWR _01126_ sky130_fd_sc_hd__nand2_1
Xfanout767 net768 VGND VGND VPWR VPWR net767 sky130_fd_sc_hd__clkbuf_2
Xfanout778 net779 VGND VGND VPWR VPWR net778 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_0_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout789 net790 VGND VGND VPWR VPWR net789 sky130_fd_sc_hd__dlymetal6s2s_1
X_08807_ _03073_ _08116_ _08117_ VGND VGND VPWR VPWR _08118_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_37_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09787_ _01018_ _01017_ VGND VGND VPWR VPWR _01058_ sky130_fd_sc_hd__and2b_1
X_08738_ _08041_ _08047_ VGND VGND VPWR VPWR _08049_ sky130_fd_sc_hd__or2_1
XFILLER_0_68_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08669_ net606 net701 net408 net397 VGND VGND VPWR VPWR _07889_ sky130_fd_sc_hd__and4_1
XFILLER_0_95_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10700_ _01913_ _01912_ _01900_ _01886_ VGND VGND VPWR VPWR _01926_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_138_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11680_ _02923_ _02971_ VGND VGND VPWR VPWR _02972_ sky130_fd_sc_hd__xor2_2
XFILLER_0_36_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10631_ _01831_ _01829_ _01830_ VGND VGND VPWR VPWR _01857_ sky130_fd_sc_hd__or3_1
XFILLER_0_107_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13350_ _04791_ _04792_ VGND VGND VPWR VPWR _04793_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_46_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10562_ net716 net381 net371 net724 VGND VGND VPWR VPWR _01788_ sky130_fd_sc_hd__a22o_1
XFILLER_0_134_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12301_ _03643_ _03644_ _03592_ VGND VGND VPWR VPWR _03646_ sky130_fd_sc_hd__a21oi_1
X_13281_ _04715_ _04716_ _04717_ VGND VGND VPWR VPWR _04718_ sky130_fd_sc_hd__and3_2
XFILLER_0_16_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10493_ _01713_ _01714_ _01718_ VGND VGND VPWR VPWR _01719_ sky130_fd_sc_hd__a21o_1
X_15020_ _06610_ _06611_ _06612_ VGND VGND VPWR VPWR _06614_ sky130_fd_sc_hd__nand3_1
X_12232_ _03484_ _03483_ VGND VGND VPWR VPWR _03571_ sky130_fd_sc_hd__or2b_1
XFILLER_0_121_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12163_ _03441_ _03445_ _03495_ VGND VGND VPWR VPWR _03497_ sky130_fd_sc_hd__a21bo_1
X_11114_ _02352_ _02353_ _02355_ VGND VGND VPWR VPWR _02356_ sky130_fd_sc_hd__nand3_1
X_12094_ _03326_ _03329_ _03327_ VGND VGND VPWR VPWR _03422_ sky130_fd_sc_hd__o21ba_1
X_15922_ _07594_ _07595_ VGND VGND VPWR VPWR _07596_ sky130_fd_sc_hd__nor2_1
X_11045_ _02277_ _02279_ _01693_ VGND VGND VPWR VPWR _02281_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_127_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15853_ _04538_ net539 VGND VGND VPWR VPWR _07522_ sky130_fd_sc_hd__or2_1
XFILLER_0_99_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14804_ _06373_ _06374_ _06378_ VGND VGND VPWR VPWR _06379_ sky130_fd_sc_hd__nand3_1
X_15784_ _07418_ _07419_ _07443_ _07444_ VGND VGND VPWR VPWR _07447_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_99_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12996_ _04403_ _04405_ _04406_ VGND VGND VPWR VPWR _04408_ sky130_fd_sc_hd__a21o_1
XFILLER_0_87_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14735_ _06296_ _06301_ _06302_ VGND VGND VPWR VPWR _06303_ sky130_fd_sc_hd__nor3_1
XFILLER_0_59_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11947_ _03185_ _03189_ _03261_ VGND VGND VPWR VPWR _03262_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_143_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14666_ _06225_ _06224_ _06215_ _06204_ VGND VGND VPWR VPWR _06227_ sky130_fd_sc_hd__o211ai_2
X_11878_ net794 net358 VGND VGND VPWR VPWR _03187_ sky130_fd_sc_hd__nand2_2
X_13617_ _05082_ _05083_ VGND VGND VPWR VPWR _05084_ sky130_fd_sc_hd__xnor2_1
X_10829_ net742 net528 net399 net777 VGND VGND VPWR VPWR _02055_ sky130_fd_sc_hd__a22o_1
X_14597_ _06149_ _06150_ VGND VGND VPWR VPWR _06151_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_82_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16336_ clknet_4_2_0_clk _00049_ net333 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dfrtp_1
X_13548_ _05007_ _05006_ _05005_ VGND VGND VPWR VPWR _05009_ sky130_fd_sc_hd__and3b_1
XFILLER_0_54_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16267_ _04540_ net657 _07907_ _07908_ VGND VGND VPWR VPWR _07970_ sky130_fd_sc_hd__o31a_1
XFILLER_0_113_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13479_ _04826_ _04827_ VGND VGND VPWR VPWR _04934_ sky130_fd_sc_hd__or2b_1
XFILLER_0_70_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15218_ _06826_ _06827_ _06828_ VGND VGND VPWR VPWR _06830_ sky130_fd_sc_hd__nand3_1
XFILLER_0_112_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16198_ _07853_ _07860_ VGND VGND VPWR VPWR _07895_ sky130_fd_sc_hd__or2b_1
X_15149_ net193 net183 net669 net676 VGND VGND VPWR VPWR _06755_ sky130_fd_sc_hd__nand4_1
XFILLER_0_11_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_870 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09710_ net645 net654 net483 net473 VGND VGND VPWR VPWR _00982_ sky130_fd_sc_hd__and4_1
XFILLER_0_93_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09641_ net645 net493 VGND VGND VPWR VPWR _00914_ sky130_fd_sc_hd__nand2_1
XFILLER_0_93_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09572_ _00830_ _00831_ _00844_ VGND VGND VPWR VPWR _00846_ sky130_fd_sc_hd__nand3_1
XFILLER_0_26_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08523_ _06267_ _06278_ _06289_ VGND VGND VPWR VPWR _06300_ sky130_fd_sc_hd__nand3_1
XFILLER_0_148_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08454_ _05471_ _05525_ _05481_ VGND VGND VPWR VPWR _05547_ sky130_fd_sc_hd__nand3_1
XFILLER_0_92_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08385_ _02496_ net857 _02681_ VGND VGND VPWR VPWR _04796_ sky130_fd_sc_hd__or3_1
XFILLER_0_46_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09006_ _08124_ _00184_ VGND VGND VPWR VPWR _00287_ sky130_fd_sc_hd__nand2_2
XFILLER_0_41_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout520 net523 VGND VGND VPWR VPWR net520 sky130_fd_sc_hd__buf_4
Xfanout531 net533 VGND VGND VPWR VPWR net531 sky130_fd_sc_hd__buf_2
Xfanout542 net545 VGND VGND VPWR VPWR net542 sky130_fd_sc_hd__buf_6
X_09908_ _01138_ _01139_ _01137_ VGND VGND VPWR VPWR _01177_ sky130_fd_sc_hd__a21o_1
Xfanout553 net554 VGND VGND VPWR VPWR net553 sky130_fd_sc_hd__clkbuf_4
Xfanout564 net573 VGND VGND VPWR VPWR net564 sky130_fd_sc_hd__clkbuf_4
Xfanout575 net582 VGND VGND VPWR VPWR net575 sky130_fd_sc_hd__clkbuf_4
Xfanout586 net32 VGND VGND VPWR VPWR net586 sky130_fd_sc_hd__buf_2
X_09839_ _00819_ _00897_ _00969_ _01040_ VGND VGND VPWR VPWR _01110_ sky130_fd_sc_hd__or4_1
Xfanout597 net600 VGND VGND VPWR VPWR net597 sky130_fd_sc_hd__clkbuf_4
X_12850_ net800 net267 VGND VGND VPWR VPWR _04248_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11801_ _02993_ _03001_ _03000_ VGND VGND VPWR VPWR _03103_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_96_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12781_ net327 net320 net430 net242 VGND VGND VPWR VPWR _04172_ sky130_fd_sc_hd__a22oi_2
Xrebuffer80 _06646_ VGND VGND VPWR VPWR net886 sky130_fd_sc_hd__buf_1
X_14520_ _06064_ _06065_ VGND VGND VPWR VPWR _06066_ sky130_fd_sc_hd__nor2_1
Xrebuffer91 net931 VGND VGND VPWR VPWR net897 sky130_fd_sc_hd__clkbuf_1
X_11732_ _03011_ _03026_ _03027_ VGND VGND VPWR VPWR _03028_ sky130_fd_sc_hd__nand3_1
XFILLER_0_139_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14451_ _05983_ _05984_ _05989_ VGND VGND VPWR VPWR _05990_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_54_Left_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11663_ _02951_ _02952_ VGND VGND VPWR VPWR _02954_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_126_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13402_ _04649_ _04747_ VGND VGND VPWR VPWR _04850_ sky130_fd_sc_hd__and2_1
X_10614_ _01826_ _01837_ _01838_ VGND VGND VPWR VPWR _01840_ sky130_fd_sc_hd__nand3_1
X_14382_ net213 net203 net537 net544 VGND VGND VPWR VPWR _05914_ sky130_fd_sc_hd__and4_1
XFILLER_0_107_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11594_ _02849_ _02878_ VGND VGND VPWR VPWR _02879_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_24_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16121_ _07810_ _07790_ _07791_ VGND VGND VPWR VPWR _07812_ sky130_fd_sc_hd__or3_2
XFILLER_0_106_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13333_ _04771_ _04773_ VGND VGND VPWR VPWR _04775_ sky130_fd_sc_hd__xnor2_1
X_10545_ net785 net470 _01769_ VGND VGND VPWR VPWR _01771_ sky130_fd_sc_hd__and3_1
XFILLER_0_122_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16052_ _07735_ _07736_ VGND VGND VPWR VPWR _07737_ sky130_fd_sc_hd__nor2_1
X_13264_ _04594_ _04596_ VGND VGND VPWR VPWR _04700_ sky130_fd_sc_hd__nand2_1
X_10476_ net709 net717 net420 net412 VGND VGND VPWR VPWR _01702_ sky130_fd_sc_hd__and4_1
XFILLER_0_32_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15003_ _06491_ _06492_ VGND VGND VPWR VPWR _06596_ sky130_fd_sc_hd__nand2_1
X_12215_ _03551_ _03552_ VGND VGND VPWR VPWR _03553_ sky130_fd_sc_hd__nor2_1
X_13195_ _04621_ _04623_ _04511_ _04590_ VGND VGND VPWR VPWR _04625_ sky130_fd_sc_hd__o211a_1
XFILLER_0_20_676 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_63_Left_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12146_ net227 net313 net460 net450 VGND VGND VPWR VPWR _03478_ sky130_fd_sc_hd__and4_1
XFILLER_0_47_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12077_ _03397_ _03403_ VGND VGND VPWR VPWR _03404_ sky130_fd_sc_hd__xor2_1
X_15905_ _07576_ _07569_ _07570_ VGND VGND VPWR VPWR _07578_ sky130_fd_sc_hd__nor3_1
X_11028_ _02259_ _02260_ _02251_ VGND VGND VPWR VPWR _02262_ sky130_fd_sc_hd__a21o_1
X_15836_ _07413_ _07416_ _07500_ net122 VGND VGND VPWR VPWR _07503_ sky130_fd_sc_hd__a211o_1
XFILLER_0_99_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15767_ net248 net539 VGND VGND VPWR VPWR _07428_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12979_ net725 net170 _04386_ _04387_ VGND VGND VPWR VPWR _04389_ sky130_fd_sc_hd__nand4_1
XFILLER_0_59_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14718_ _06167_ _06166_ VGND VGND VPWR VPWR _06284_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_72_Left_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15698_ _07327_ _07352_ VGND VGND VPWR VPWR _07353_ sky130_fd_sc_hd__xor2_1
XFILLER_0_59_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_129_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14649_ _06178_ _06181_ VGND VGND VPWR VPWR _06208_ sky130_fd_sc_hd__and2_1
XFILLER_0_145_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_120_Right_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XANTENNA_16 net226 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_28_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_27 net477 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_129_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_38 clknet_4_2_0_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08170_ net587 net352 net504 net595 VGND VGND VPWR VPWR _02452_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_28_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_49 net932 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_103_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16319_ clknet_4_7_0_clk _00032_ net338 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_103_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput101 net101 VGND VGND VPWR VPWR beta[12] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput112 net112 VGND VGND VPWR VPWR beta[5] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_81_Left_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09624_ _00826_ _00897_ VGND VGND VPWR VPWR _00898_ sky130_fd_sc_hd__xnor2_1
X_09555_ _00751_ _00758_ VGND VGND VPWR VPWR _00829_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_90_Left_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08506_ _06080_ _06091_ _06102_ VGND VGND VPWR VPWR _06113_ sky130_fd_sc_hd__or3_1
X_09486_ _00745_ _00746_ _00759_ VGND VGND VPWR VPWR _00761_ sky130_fd_sc_hd__nand3_1
XFILLER_0_78_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08437_ _05308_ _05340_ _05351_ net841 VGND VGND VPWR VPWR _05362_ sky130_fd_sc_hd__o211a_1
XFILLER_0_19_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08368_ net561 net387 _02201_ _02212_ VGND VGND VPWR VPWR _04611_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_19_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08299_ _03669_ _03723_ VGND VGND VPWR VPWR _03855_ sky130_fd_sc_hd__or2b_1
X_10330_ _01563_ _01564_ VGND VGND VPWR VPWR _01565_ sky130_fd_sc_hd__nor2_1
XFILLER_0_103_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10261_ _01505_ VGND VGND VPWR VPWR _00039_ sky130_fd_sc_hd__clkbuf_1
X_12000_ _03319_ VGND VGND VPWR VPWR _00070_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_103_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10192_ _01441_ _01442_ VGND VGND VPWR VPWR _01446_ sky130_fd_sc_hd__and2b_1
Xfanout350 net57 VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__buf_2
Xfanout361 net363 VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_108_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout372 net55 VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__buf_6
Xfanout383 net384 VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__clkbuf_4
X_13951_ _05325_ _05328_ _05326_ VGND VGND VPWR VPWR _05447_ sky130_fd_sc_hd__o21ba_1
Xfanout394 net395 VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_129_Left_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12902_ _04301_ _04302_ _04303_ VGND VGND VPWR VPWR _04305_ sky130_fd_sc_hd__a21o_1
X_13882_ _05370_ _05371_ VGND VGND VPWR VPWR _05372_ sky130_fd_sc_hd__xnor2_2
X_15621_ _07176_ _07175_ VGND VGND VPWR VPWR _07269_ sky130_fd_sc_hd__and2b_1
X_12833_ _04227_ _04202_ _04203_ _04226_ VGND VGND VPWR VPWR _04230_ sky130_fd_sc_hd__and4_2
XFILLER_0_124_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15552_ _04539_ net575 _07112_ _07192_ VGND VGND VPWR VPWR _07193_ sky130_fd_sc_hd__o31ai_2
X_12764_ _04151_ _04010_ _04150_ _04147_ VGND VGND VPWR VPWR _04154_ sky130_fd_sc_hd__o211a_1
XFILLER_0_68_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14503_ _06028_ _06033_ _06045_ VGND VGND VPWR VPWR _06048_ sky130_fd_sc_hd__and3_1
X_11715_ _02954_ _02962_ _02961_ VGND VGND VPWR VPWR _03010_ sky130_fd_sc_hd__a21o_1
X_15483_ _07040_ _07048_ _07047_ VGND VGND VPWR VPWR _07119_ sky130_fd_sc_hd__a21o_1
XFILLER_0_83_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12695_ _04074_ _04076_ _04077_ VGND VGND VPWR VPWR _04078_ sky130_fd_sc_hd__or3_1
X_14434_ _05969_ _05968_ _05938_ _05934_ VGND VGND VPWR VPWR _05972_ sky130_fd_sc_hd__o211ai_2
X_11646_ net232 net358 _02933_ _02934_ VGND VGND VPWR VPWR _02935_ sky130_fd_sc_hd__a22o_1
XFILLER_0_37_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput14 D[4] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_1
X_14365_ net291 net698 VGND VGND VPWR VPWR _05896_ sky130_fd_sc_hd__nand2_1
Xinput25 Q[14] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__buf_4
Xinput36 Q[7] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__buf_2
X_11577_ _02773_ _02778_ _02850_ VGND VGND VPWR VPWR _02860_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_141_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput47 cos[17] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__buf_1
X_16104_ _07740_ _07743_ _07793_ VGND VGND VPWR VPWR _07794_ sky130_fd_sc_hd__a21oi_1
Xinput58 rstb VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__buf_2
X_13316_ _04651_ VGND VGND VPWR VPWR _04756_ sky130_fd_sc_hd__inv_2
Xinput69 sin[1] VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__buf_4
X_10528_ _01748_ _01753_ VGND VGND VPWR VPWR _01754_ sky130_fd_sc_hd__xnor2_1
X_14296_ _05818_ _05820_ VGND VGND VPWR VPWR _05821_ sky130_fd_sc_hd__xor2_1
XFILLER_0_150_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16035_ _07717_ _07718_ VGND VGND VPWR VPWR _07719_ sky130_fd_sc_hd__xor2_1
X_13247_ net749 net274 VGND VGND VPWR VPWR _04681_ sky130_fd_sc_hd__nand2_1
X_10459_ _01679_ _01684_ VGND VGND VPWR VPWR _01685_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13178_ _04602_ _04605_ VGND VGND VPWR VPWR _04606_ sky130_fd_sc_hd__xnor2_1
X_12129_ _03378_ _03381_ _03457_ _03458_ VGND VGND VPWR VPWR _03460_ sky130_fd_sc_hd__a211o_1
XFILLER_0_74_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15819_ _07465_ _07467_ _07483_ VGND VGND VPWR VPWR _07484_ sky130_fd_sc_hd__a21o_1
X_09340_ net630 net383 _00614_ _00615_ VGND VGND VPWR VPWR _00617_ sky130_fd_sc_hd__nand4_1
XFILLER_0_90_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_838 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09271_ _00442_ _00455_ _00548_ VGND VGND VPWR VPWR _00549_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_114_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08222_ _02811_ _02844_ _02985_ VGND VGND VPWR VPWR _03018_ sky130_fd_sc_hd__nand3_1
XFILLER_0_145_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08153_ net562 net378 net369 net567 VGND VGND VPWR VPWR _02267_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_16_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08986_ _00264_ _00265_ _00248_ VGND VGND VPWR VPWR _00267_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_3_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09607_ _00877_ _00880_ VGND VGND VPWR VPWR _00881_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09538_ _00811_ _00812_ VGND VGND VPWR VPWR _00813_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09469_ _00710_ _00717_ VGND VGND VPWR VPWR _00744_ sky130_fd_sc_hd__and2_1
X_11500_ _02774_ _02775_ VGND VGND VPWR VPWR _02776_ sky130_fd_sc_hd__nor2_1
X_12480_ _03825_ _03826_ _03839_ VGND VGND VPWR VPWR _03841_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_46_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11431_ _02698_ _02699_ _02596_ VGND VGND VPWR VPWR _02701_ sky130_fd_sc_hd__a21o_1
XFILLER_0_136_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14150_ _05661_ _05662_ VGND VGND VPWR VPWR _05663_ sky130_fd_sc_hd__xor2_1
X_11362_ _02623_ _02624_ VGND VGND VPWR VPWR _02625_ sky130_fd_sc_hd__xnor2_2
X_13101_ _04456_ _04520_ _04521_ VGND VGND VPWR VPWR _04522_ sky130_fd_sc_hd__and3_2
X_10313_ Q_cos\[9\] D_sin\[9\] VGND VGND VPWR VPWR _01550_ sky130_fd_sc_hd__or2b_1
XFILLER_0_132_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14081_ _05563_ _05587_ VGND VGND VPWR VPWR _05588_ sky130_fd_sc_hd__and2_1
X_11293_ _02457_ _02458_ _02548_ _02549_ VGND VGND VPWR VPWR _02551_ sky130_fd_sc_hd__o211ai_2
X_13032_ _04444_ _04445_ VGND VGND VPWR VPWR _04446_ sky130_fd_sc_hd__xnor2_1
X_10244_ net87 _01491_ net130 VGND VGND VPWR VPWR _01492_ sky130_fd_sc_hd__mux2_1
X_10175_ net96 _01431_ net133 VGND VGND VPWR VPWR _01432_ sky130_fd_sc_hd__mux2_1
XFILLER_0_100_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14983_ net826 _06488_ _06572_ _06573_ VGND VGND VPWR VPWR _06575_ sky130_fd_sc_hd__o211a_4
Xfanout180 net181 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__clkbuf_4
Xfanout191 net843 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__clkbuf_4
X_13934_ _05409_ _05338_ _05428_ VGND VGND VPWR VPWR _05429_ sky130_fd_sc_hd__o21a_1
X_13865_ _05165_ _05353_ VGND VGND VPWR VPWR _05354_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15604_ net297 net674 VGND VGND VPWR VPWR _07251_ sky130_fd_sc_hd__nand2_1
X_12816_ _04209_ _04210_ VGND VGND VPWR VPWR _04211_ sky130_fd_sc_hd__nor2_1
X_13796_ _05200_ _05202_ _05206_ VGND VGND VPWR VPWR _05279_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_146_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15535_ _07068_ _07070_ _07072_ VGND VGND VPWR VPWR _07176_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_96_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12747_ _04116_ _04117_ _04133_ _04134_ VGND VGND VPWR VPWR _04135_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_127_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15466_ net265 net547 net555 net932 VGND VGND VPWR VPWR _07100_ sky130_fd_sc_hd__a22oi_1
X_12678_ _04056_ _04057_ _04058_ VGND VGND VPWR VPWR _04059_ sky130_fd_sc_hd__nand3_2
XFILLER_0_37_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_830 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14417_ _05945_ _05946_ _05952_ VGND VGND VPWR VPWR _05953_ sky130_fd_sc_hd__nand3_2
X_11629_ _02810_ _02816_ VGND VGND VPWR VPWR _02916_ sky130_fd_sc_hd__nand2_1
XFILLER_0_115_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15397_ net156 net673 net683 net305 VGND VGND VPWR VPWR _07025_ sky130_fd_sc_hd__a22o_1
XFILLER_0_8_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14348_ net160 net590 net599 net309 VGND VGND VPWR VPWR _05877_ sky130_fd_sc_hd__a22o_1
X_14279_ _05751_ _05802_ VGND VGND VPWR VPWR _05803_ sky130_fd_sc_hd__and2_1
XFILLER_0_122_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16018_ _07700_ VGND VGND VPWR VPWR _00109_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08840_ _00120_ _00121_ VGND VGND VPWR VPWR _00122_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08771_ net541 net360 _08080_ _08081_ VGND VGND VPWR VPWR _08082_ sky130_fd_sc_hd__a22o_1
XFILLER_0_85_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_782 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09323_ net663 net673 net348 net501 VGND VGND VPWR VPWR _00600_ sky130_fd_sc_hd__nand4_2
XFILLER_0_146_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09254_ _00524_ _00530_ _00531_ VGND VGND VPWR VPWR _00532_ sky130_fd_sc_hd__and3_1
XFILLER_0_8_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08205_ _02746_ _02800_ VGND VGND VPWR VPWR _02833_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_7_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09185_ _00462_ _00463_ VGND VGND VPWR VPWR _00464_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08969_ net839 net640 net413 VGND VGND VPWR VPWR _00250_ sky130_fd_sc_hd__and3_1
X_11980_ _03211_ _03212_ _03297_ VGND VGND VPWR VPWR _03298_ sky130_fd_sc_hd__a21oi_2
X_10931_ net522 VGND VGND VPWR VPWR _02157_ sky130_fd_sc_hd__inv_2
XFILLER_0_79_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10862_ _02049_ _02084_ _02083_ VGND VGND VPWR VPWR _02088_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13650_ _05103_ _05119_ VGND VGND VPWR VPWR _05120_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12601_ _03929_ _03930_ _03924_ VGND VGND VPWR VPWR _03974_ sky130_fd_sc_hd__a21bo_1
X_13581_ _04954_ _05044_ VGND VGND VPWR VPWR _05045_ sky130_fd_sc_hd__xor2_4
XFILLER_0_109_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10793_ net734 net769 net528 net399 VGND VGND VPWR VPWR _02019_ sky130_fd_sc_hd__and4_1
X_15320_ _06920_ _06940_ VGND VGND VPWR VPWR _06941_ sky130_fd_sc_hd__xor2_2
XFILLER_0_93_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12532_ _03856_ _03857_ VGND VGND VPWR VPWR _03898_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_109_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15251_ _06863_ _06864_ _06856_ VGND VGND VPWR VPWR _06866_ sky130_fd_sc_hd__a21o_1
X_12463_ net198 net804 _03820_ _03821_ VGND VGND VPWR VPWR _03823_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_124_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11414_ _02664_ _02680_ _02682_ VGND VGND VPWR VPWR _02683_ sky130_fd_sc_hd__and3_1
X_14202_ _05717_ _05718_ VGND VGND VPWR VPWR _05719_ sky130_fd_sc_hd__xnor2_1
X_15182_ _06681_ _06779_ _06778_ VGND VGND VPWR VPWR _06790_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_34_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12394_ _03707_ _03708_ _03702_ VGND VGND VPWR VPWR _03747_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_22_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14133_ _05576_ _05575_ VGND VGND VPWR VPWR _05645_ sky130_fd_sc_hd__and2b_1
XFILLER_0_1_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11345_ _02568_ _02587_ _02606_ VGND VGND VPWR VPWR _02607_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_39_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14064_ _05567_ _05569_ VGND VGND VPWR VPWR _05570_ sky130_fd_sc_hd__nor2_1
X_11276_ net614 net359 _02530_ _02531_ VGND VGND VPWR VPWR _02532_ sky130_fd_sc_hd__a22o_1
X_13015_ _04425_ _04427_ _04252_ VGND VGND VPWR VPWR _04429_ sky130_fd_sc_hd__a21o_1
X_10227_ _01467_ _01470_ _01476_ VGND VGND VPWR VPWR _01477_ sky130_fd_sc_hd__or3_1
X_10158_ _01415_ _01416_ VGND VGND VPWR VPWR _01417_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10089_ net647 _00193_ VGND VGND VPWR VPWR _01355_ sky130_fd_sc_hd__nor2_1
X_14966_ _06093_ _06101_ _06100_ VGND VGND VPWR VPWR _06556_ sky130_fd_sc_hd__a21bo_1
X_13917_ _05168_ _05348_ VGND VGND VPWR VPWR _05410_ sky130_fd_sc_hd__nor2_1
X_14897_ _06479_ _06480_ _06236_ VGND VGND VPWR VPWR _06481_ sky130_fd_sc_hd__o21ai_1
X_13848_ _05333_ _05334_ VGND VGND VPWR VPWR _05335_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13779_ net933 net174 net795 VGND VGND VPWR VPWR _05260_ sky130_fd_sc_hd__and3_1
XFILLER_0_85_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15518_ net182 net172 net651 net873 VGND VGND VPWR VPWR _07157_ sky130_fd_sc_hd__and4_1
XFILLER_0_45_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15449_ _07078_ _07080_ VGND VGND VPWR VPWR _07082_ sky130_fd_sc_hd__nand2_1
Xclkbuf_4_4_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_4_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_143_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap122 _07501_ VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__buf_1
XFILLER_0_142_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09941_ _01071_ _01209_ VGND VGND VPWR VPWR _01210_ sky130_fd_sc_hd__nand2_1
X_09872_ _01120_ _01141_ VGND VGND VPWR VPWR _01142_ sky130_fd_sc_hd__nand2_1
X_08823_ net698 net442 VGND VGND VPWR VPWR _08133_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08754_ _08062_ _08063_ _08064_ VGND VGND VPWR VPWR _08065_ sky130_fd_sc_hd__a21o_1
X_08685_ _07879_ _07996_ VGND VGND VPWR VPWR _07997_ sky130_fd_sc_hd__or2_1
XFILLER_0_136_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09306_ _00489_ _00492_ _00490_ VGND VGND VPWR VPWR _00583_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_118_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09237_ _00512_ _00513_ _00514_ VGND VGND VPWR VPWR _00515_ sky130_fd_sc_hd__a21o_1
XFILLER_0_145_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09168_ net641 net631 net402 net392 VGND VGND VPWR VPWR _00447_ sky130_fd_sc_hd__nand4_2
XFILLER_0_31_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09099_ _00294_ _00378_ VGND VGND VPWR VPWR _00379_ sky130_fd_sc_hd__xnor2_2
X_11130_ _02370_ _02371_ _02306_ VGND VGND VPWR VPWR _02373_ sky130_fd_sc_hd__a21oi_1
X_11061_ _02291_ _02296_ VGND VGND VPWR VPWR _02297_ sky130_fd_sc_hd__or2_1
X_10012_ _01278_ _01279_ _01214_ _01217_ VGND VGND VPWR VPWR _01280_ sky130_fd_sc_hd__o211a_1
XFILLER_0_99_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14820_ _06357_ _06360_ _06359_ VGND VGND VPWR VPWR _06396_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_116_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14751_ _06316_ _06317_ _06296_ _06303_ VGND VGND VPWR VPWR _06320_ sky130_fd_sc_hd__a211o_1
X_11963_ _03260_ _03278_ VGND VGND VPWR VPWR _03280_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_98_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13702_ _05165_ _05175_ VGND VGND VPWR VPWR _05176_ sky130_fd_sc_hd__xor2_1
X_10914_ net791 net803 net438 net419 VGND VGND VPWR VPWR _02140_ sky130_fd_sc_hd__and4_1
X_14682_ net324 net553 net560 net239 VGND VGND VPWR VPWR _06244_ sky130_fd_sc_hd__a22o_1
X_11894_ _03104_ _03108_ _03106_ VGND VGND VPWR VPWR _03205_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_129_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10845_ net786 net389 _02055_ _02054_ VGND VGND VPWR VPWR _02071_ sky130_fd_sc_hd__a31o_1
X_13633_ _05099_ _05100_ VGND VGND VPWR VPWR _05102_ sky130_fd_sc_hd__nand2_1
XFILLER_0_132_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16352_ clknet_4_12_0_clk _00065_ net345 VGND VGND VPWR VPWR D_cos\[7\] sky130_fd_sc_hd__dfrtp_1
X_10776_ _01998_ _01997_ _01996_ _01993_ VGND VGND VPWR VPWR _02002_ sky130_fd_sc_hd__o211ai_2
X_13564_ _05015_ _05026_ VGND VGND VPWR VPWR _05027_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_54_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15303_ net291 net540 net546 net282 VGND VGND VPWR VPWR _06923_ sky130_fd_sc_hd__a22o_1
X_12515_ _03818_ _03874_ VGND VGND VPWR VPWR _03880_ sky130_fd_sc_hd__xor2_1
X_16283_ _07956_ _07986_ VGND VGND VPWR VPWR _07988_ sky130_fd_sc_hd__xnor2_1
X_13495_ _04858_ _04951_ VGND VGND VPWR VPWR _04952_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_109_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15234_ _06842_ _06845_ _06847_ VGND VGND VPWR VPWR _06848_ sky130_fd_sc_hd__and3_1
XFILLER_0_81_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12446_ _03796_ _03802_ _03803_ VGND VGND VPWR VPWR _03804_ sky130_fd_sc_hd__nand3_1
XFILLER_0_140_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15165_ _06769_ _06771_ _06705_ VGND VGND VPWR VPWR _06773_ sky130_fd_sc_hd__a21o_1
X_12377_ _03709_ _03710_ _03726_ VGND VGND VPWR VPWR _03728_ sky130_fd_sc_hd__nand3_1
XFILLER_0_22_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14116_ D_sin\[14\] _05625_ _05626_ VGND VGND VPWR VPWR _05627_ sky130_fd_sc_hd__mux2_1
X_11328_ _02565_ _02566_ _02588_ VGND VGND VPWR VPWR _02589_ sky130_fd_sc_hd__nor3b_2
X_15096_ _06694_ _06696_ VGND VGND VPWR VPWR _06697_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_10_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11259_ _02509_ _02510_ _02511_ VGND VGND VPWR VPWR _02513_ sky130_fd_sc_hd__nand3_1
X_14047_ _05550_ _05551_ VGND VGND VPWR VPWR _05552_ sky130_fd_sc_hd__or2_2
X_15998_ _07571_ _07678_ _07578_ VGND VGND VPWR VPWR _07679_ sky130_fd_sc_hd__a21o_1
X_14949_ _06535_ _06536_ VGND VGND VPWR VPWR _06537_ sky130_fd_sc_hd__and2b_1
XFILLER_0_77_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08470_ _05242_ _05253_ _05264_ VGND VGND VPWR VPWR _05720_ sky130_fd_sc_hd__and3_1
XFILLER_0_15_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_127_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09022_ net593 net442 VGND VGND VPWR VPWR _00302_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09924_ _01191_ _01192_ VGND VGND VPWR VPWR _01193_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout702 net20 VGND VGND VPWR VPWR net702 sky130_fd_sc_hd__clkbuf_4
Xfanout713 net714 VGND VGND VPWR VPWR net713 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout724 net728 VGND VGND VPWR VPWR net724 sky130_fd_sc_hd__buf_2
Xfanout735 net736 VGND VGND VPWR VPWR net735 sky130_fd_sc_hd__clkbuf_4
Xfanout746 net16 VGND VGND VPWR VPWR net746 sky130_fd_sc_hd__buf_2
X_09855_ _01123_ _01124_ VGND VGND VPWR VPWR _01125_ sky130_fd_sc_hd__nor2_1
Xfanout757 net759 VGND VGND VPWR VPWR net757 sky130_fd_sc_hd__clkbuf_4
Xfanout768 net13 VGND VGND VPWR VPWR net768 sky130_fd_sc_hd__buf_2
Xfanout779 net12 VGND VGND VPWR VPWR net779 sky130_fd_sc_hd__buf_2
XFILLER_0_147_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08806_ _08114_ _08115_ _08040_ _04480_ VGND VGND VPWR VPWR _08117_ sky130_fd_sc_hd__a211o_1
X_09786_ _01011_ _01016_ VGND VGND VPWR VPWR _01057_ sky130_fd_sc_hd__and2b_1
X_08737_ _08041_ _08047_ VGND VGND VPWR VPWR _08048_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_134_Right_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08668_ _07738_ _07868_ VGND VGND VPWR VPWR _07879_ sky130_fd_sc_hd__xor2_1
XFILLER_0_96_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08599_ _07107_ _07118_ VGND VGND VPWR VPWR _07129_ sky130_fd_sc_hd__nor2_1
XFILLER_0_49_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10630_ _01659_ _01855_ VGND VGND VPWR VPWR _01856_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_119_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10561_ net715 net390 _01739_ _01738_ VGND VGND VPWR VPWR _01787_ sky130_fd_sc_hd__a31o_1
XFILLER_0_11_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12300_ _03592_ _03643_ _03644_ VGND VGND VPWR VPWR _03645_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_101_Left_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13280_ net225 net144 VGND VGND VPWR VPWR _04717_ sky130_fd_sc_hd__nand2_1
X_10492_ _01715_ _01716_ _01717_ VGND VGND VPWR VPWR _01718_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_51_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12231_ _03568_ _03569_ VGND VGND VPWR VPWR _03570_ sky130_fd_sc_hd__xor2_1
XFILLER_0_133_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12162_ net495 _03270_ VGND VGND VPWR VPWR _03495_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11113_ _02252_ _02254_ _02253_ VGND VGND VPWR VPWR _02355_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_102_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12093_ _03418_ _03419_ VGND VGND VPWR VPWR _03421_ sky130_fd_sc_hd__nor2_1
X_15921_ _07515_ _07514_ VGND VGND VPWR VPWR _07595_ sky130_fd_sc_hd__and2b_1
X_11044_ _01693_ _02277_ _02279_ VGND VGND VPWR VPWR _02280_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_110_Left_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15852_ _07516_ _07519_ VGND VGND VPWR VPWR _07520_ sky130_fd_sc_hd__xnor2_1
X_14803_ net221 net597 _06375_ _06376_ VGND VGND VPWR VPWR _06378_ sky130_fd_sc_hd__a31o_1
X_15783_ _07418_ _07419_ _07443_ _07444_ VGND VGND VPWR VPWR _07446_ sky130_fd_sc_hd__a2bb2oi_1
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12995_ _04403_ _04405_ _04406_ VGND VGND VPWR VPWR _04407_ sky130_fd_sc_hd__nand3_2
XFILLER_0_98_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14734_ _06294_ _06295_ _06269_ _06282_ VGND VGND VPWR VPWR _06302_ sky130_fd_sc_hd__a211oi_2
X_11946_ _03188_ _02994_ VGND VGND VPWR VPWR _03261_ sky130_fd_sc_hd__or2b_1
X_14665_ _06204_ _06215_ _06224_ _06225_ VGND VGND VPWR VPWR _06226_ sky130_fd_sc_hd__a211o_2
X_11877_ net794 _00851_ _03089_ VGND VGND VPWR VPWR _03186_ sky130_fd_sc_hd__and3_2
XFILLER_0_39_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13616_ _04921_ _05008_ _05009_ _05012_ VGND VGND VPWR VPWR _05083_ sky130_fd_sc_hd__o31a_1
X_10828_ net742 net777 net528 net399 VGND VGND VPWR VPWR _02054_ sky130_fd_sc_hd__and4_1
X_14596_ net196 net579 VGND VGND VPWR VPWR _06150_ sky130_fd_sc_hd__nand2_1
XFILLER_0_54_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16335_ clknet_4_2_0_clk _00048_ net333 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_82_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13547_ _05005_ _05006_ _05007_ VGND VGND VPWR VPWR _05008_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_27_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10759_ net752 net760 net419 net411 VGND VGND VPWR VPWR _01985_ sky130_fd_sc_hd__and4_1
XFILLER_0_70_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16266_ _07963_ _07968_ VGND VGND VPWR VPWR _07969_ sky130_fd_sc_hd__xnor2_1
X_13478_ _04920_ _04932_ VGND VGND VPWR VPWR _04933_ sky130_fd_sc_hd__xor2_2
XFILLER_0_23_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15217_ _06826_ _06827_ _06828_ VGND VGND VPWR VPWR _06829_ sky130_fd_sc_hd__a21o_1
XFILLER_0_113_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12429_ _03781_ _03784_ VGND VGND VPWR VPWR _03785_ sky130_fd_sc_hd__xnor2_1
X_16197_ _07833_ _07842_ _07893_ VGND VGND VPWR VPWR _07894_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_124_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15148_ net193 net668 net676 net183 VGND VGND VPWR VPWR _06754_ sky130_fd_sc_hd__a22o_1
XFILLER_0_22_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15079_ _06585_ _06678_ VGND VGND VPWR VPWR _06679_ sky130_fd_sc_hd__xnor2_1
X_09640_ _00911_ _00912_ VGND VGND VPWR VPWR _00913_ sky130_fd_sc_hd__nor2_1
X_09571_ _00830_ _00831_ _00844_ VGND VGND VPWR VPWR _00845_ sky130_fd_sc_hd__a21o_1
X_08522_ net561 net416 _05514_ _05503_ VGND VGND VPWR VPWR _06289_ sky130_fd_sc_hd__a22o_1
XFILLER_0_117_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08453_ _05471_ _05481_ _05525_ VGND VGND VPWR VPWR _05536_ sky130_fd_sc_hd__a21o_1
XFILLER_0_148_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08384_ _03822_ _04513_ _04763_ _04774_ VGND VGND VPWR VPWR _04785_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_9_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09005_ _00284_ _00285_ VGND VGND VPWR VPWR _00286_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout510 net40 VGND VGND VPWR VPWR net510 sky130_fd_sc_hd__buf_12
Xfanout521 net523 VGND VGND VPWR VPWR net521 sky130_fd_sc_hd__buf_6
Xfanout532 net533 VGND VGND VPWR VPWR net532 sky130_fd_sc_hd__clkbuf_4
X_09907_ _01176_ VGND VGND VPWR VPWR _00014_ sky130_fd_sc_hd__clkbuf_1
Xfanout543 net544 VGND VGND VPWR VPWR net543 sky130_fd_sc_hd__buf_4
Xfanout554 net36 VGND VGND VPWR VPWR net554 sky130_fd_sc_hd__clkbuf_2
Xfanout565 net566 VGND VGND VPWR VPWR net565 sky130_fd_sc_hd__buf_2
Xfanout576 net582 VGND VGND VPWR VPWR net576 sky130_fd_sc_hd__buf_2
X_09838_ _01037_ _01108_ VGND VGND VPWR VPWR _01109_ sky130_fd_sc_hd__xnor2_2
Xfanout587 net591 VGND VGND VPWR VPWR net587 sky130_fd_sc_hd__clkbuf_4
Xfanout598 net599 VGND VGND VPWR VPWR net598 sky130_fd_sc_hd__buf_2
X_09769_ _00974_ _01040_ VGND VGND VPWR VPWR _01041_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_814 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11800_ _03024_ _03026_ VGND VGND VPWR VPWR _03102_ sky130_fd_sc_hd__nand2_1
X_12780_ net225 net517 VGND VGND VPWR VPWR _04171_ sky130_fd_sc_hd__nand2_1
XFILLER_0_95_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer70 _07379_ VGND VGND VPWR VPWR net876 sky130_fd_sc_hd__clkbuf_1
Xrebuffer81 net886 VGND VGND VPWR VPWR net887 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_96_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer92 _06773_ VGND VGND VPWR VPWR net898 sky130_fd_sc_hd__clkbuf_1
X_11731_ _03024_ _03025_ _03016_ VGND VGND VPWR VPWR _03027_ sky130_fd_sc_hd__a21o_1
XFILLER_0_96_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14450_ _05985_ _05988_ VGND VGND VPWR VPWR _05989_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11662_ net711 net467 VGND VGND VPWR VPWR _02952_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13401_ _04641_ _04642_ _04645_ _04748_ VGND VGND VPWR VPWR _04849_ sky130_fd_sc_hd__nor4_4
XFILLER_0_126_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10613_ _01826_ _01837_ _01838_ VGND VGND VPWR VPWR _01839_ sky130_fd_sc_hd__and3_1
X_14381_ _05906_ _05911_ _05910_ VGND VGND VPWR VPWR _05913_ sky130_fd_sc_hd__a21o_1
X_11593_ _02873_ _02876_ VGND VGND VPWR VPWR _02878_ sky130_fd_sc_hd__xor2_2
XFILLER_0_91_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16120_ _07790_ _07791_ _07810_ VGND VGND VPWR VPWR _07811_ sky130_fd_sc_hd__o21ai_1
X_10544_ net785 net470 _01769_ VGND VGND VPWR VPWR _01770_ sky130_fd_sc_hd__a21oi_1
X_13332_ _04772_ VGND VGND VPWR VPWR _04773_ sky130_fd_sc_hd__inv_2
XFILLER_0_134_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16051_ net286 net277 net637 net628 VGND VGND VPWR VPWR _07736_ sky130_fd_sc_hd__and4_1
X_10475_ net709 net420 net412 net717 VGND VGND VPWR VPWR _01701_ sky130_fd_sc_hd__a22oi_2
X_13263_ _04601_ _04619_ _04620_ VGND VGND VPWR VPWR _04699_ sky130_fd_sc_hd__nand3_1
XFILLER_0_106_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15002_ _06592_ _06593_ VGND VGND VPWR VPWR _06594_ sky130_fd_sc_hd__nand2_1
X_12214_ _03348_ _03511_ _03549_ VGND VGND VPWR VPWR _03552_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_121_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13194_ _04511_ _04590_ _04621_ _04623_ VGND VGND VPWR VPWR _04624_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_121_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12145_ net227 net460 net450 net313 VGND VGND VPWR VPWR _03477_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_102_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12076_ _03239_ _03400_ _03401_ _03080_ _03402_ VGND VGND VPWR VPWR _03403_ sky130_fd_sc_hd__o221ai_4
X_15904_ _07569_ _07570_ _07576_ VGND VGND VPWR VPWR _07577_ sky130_fd_sc_hd__o21a_1
X_11027_ _02251_ _02259_ _02260_ VGND VGND VPWR VPWR _02261_ sky130_fd_sc_hd__nand3_2
X_15835_ _07500_ net122 _07413_ _07416_ VGND VGND VPWR VPWR _07502_ sky130_fd_sc_hd__o211ai_1
X_15766_ _07425_ _07426_ VGND VGND VPWR VPWR _07427_ sky130_fd_sc_hd__nor2_1
X_12978_ net725 net170 _04386_ _04387_ VGND VGND VPWR VPWR _04388_ sky130_fd_sc_hd__a22o_1
X_14717_ _06255_ _06259_ _06257_ VGND VGND VPWR VPWR _06283_ sky130_fd_sc_hd__o21ba_1
X_11929_ D_cos\[11\] _03241_ _03242_ VGND VGND VPWR VPWR _03243_ sky130_fd_sc_hd__mux2_1
X_15697_ _07329_ _07351_ VGND VGND VPWR VPWR _07352_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_145_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14648_ _06183_ VGND VGND VPWR VPWR _06207_ sky130_fd_sc_hd__inv_2
XANTENNA_17 net236 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_28 net518 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XANTENNA_39 net843 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_144_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14579_ net213 net203 net552 net561 VGND VGND VPWR VPWR _06131_ sky130_fd_sc_hd__and4_1
XFILLER_0_82_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16318_ clknet_4_6_0_clk _00031_ net338 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_103_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16249_ _07941_ _07947_ _07939_ VGND VGND VPWR VPWR _07950_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_2_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput102 net102 VGND VGND VPWR VPWR beta[13] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_11_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput113 net113 VGND VGND VPWR VPWR beta[6] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_113_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09623_ _00827_ _00896_ VGND VGND VPWR VPWR _00897_ sky130_fd_sc_hd__xnor2_2
X_09554_ _00757_ _00756_ VGND VGND VPWR VPWR _00828_ sky130_fd_sc_hd__and2b_1
XFILLER_0_77_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08505_ net553 net524 net435 net560 VGND VGND VPWR VPWR _06102_ sky130_fd_sc_hd__a22oi_2
X_09485_ _00745_ _00746_ _00759_ VGND VGND VPWR VPWR _00760_ sky130_fd_sc_hd__a21o_1
XFILLER_0_144_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08436_ _04731_ _04742_ _04753_ _02681_ VGND VGND VPWR VPWR _05351_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_18_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08367_ _04535_ _04545_ _04589_ VGND VGND VPWR VPWR _04600_ sky130_fd_sc_hd__a21o_1
X_08298_ _02920_ _02975_ VGND VGND VPWR VPWR _03844_ sky130_fd_sc_hd__and2_1
XFILLER_0_6_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10260_ net108 _01504_ net134 VGND VGND VPWR VPWR _01505_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10191_ net921 VGND VGND VPWR VPWR _01445_ sky130_fd_sc_hd__inv_2
Xfanout340 net341 VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__buf_4
Xfanout351 net355 VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__clkbuf_4
Xfanout362 net363 VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__buf_2
Xfanout373 net382 VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__clkbuf_4
X_13950_ _05322_ _05343_ _05342_ VGND VGND VPWR VPWR _05446_ sky130_fd_sc_hd__a21bo_1
Xfanout384 net386 VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__clkbuf_2
Xfanout395 net52 VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__clkbuf_4
X_12901_ _04301_ _04302_ _04303_ VGND VGND VPWR VPWR _04304_ sky130_fd_sc_hd__nand3_1
X_13881_ net712 net248 VGND VGND VPWR VPWR _05371_ sky130_fd_sc_hd__nand2_1
X_15620_ _07191_ _07267_ VGND VGND VPWR VPWR _07268_ sky130_fd_sc_hd__xnor2_1
X_12832_ _04202_ _04203_ _04226_ _04227_ VGND VGND VPWR VPWR _04228_ sky130_fd_sc_hd__a22oi_2
X_15551_ _07109_ _07111_ VGND VGND VPWR VPWR _07192_ sky130_fd_sc_hd__or2b_1
X_12763_ _04147_ _04150_ _04010_ _04151_ VGND VGND VPWR VPWR _04153_ sky130_fd_sc_hd__a211o_1
XFILLER_0_96_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14502_ _06028_ _06033_ _06045_ VGND VGND VPWR VPWR _06046_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_83_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11714_ _03005_ _03008_ VGND VGND VPWR VPWR _03009_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_127_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15482_ _07032_ _07034_ VGND VGND VPWR VPWR _07117_ sky130_fd_sc_hd__nand2_1
X_12694_ _04073_ _04072_ _04040_ _03977_ VGND VGND VPWR VPWR _04077_ sky130_fd_sc_hd__o211a_1
X_14433_ _05934_ _05938_ _05968_ _05969_ VGND VGND VPWR VPWR _05971_ sky130_fd_sc_hd__a211o_2
XFILLER_0_127_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_872 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11645_ net150 net142 net375 net366 VGND VGND VPWR VPWR _02934_ sky130_fd_sc_hd__nand4_2
XFILLER_0_71_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14364_ _05890_ _05894_ VGND VGND VPWR VPWR _05895_ sky130_fd_sc_hd__or2b_1
Xinput15 D[5] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_2
Xinput26 Q[15] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_6
X_11576_ _02851_ _02858_ VGND VGND VPWR VPWR _02859_ sky130_fd_sc_hd__xnor2_2
Xinput37 Q[8] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_1
XFILLER_0_24_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput48 cos[18] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_4
X_16103_ net936 _07668_ VGND VGND VPWR VPWR _07793_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput59 sin[0] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__buf_4
X_13315_ _04746_ _04744_ VGND VGND VPWR VPWR _04755_ sky130_fd_sc_hd__and2b_1
X_10527_ _01749_ _01752_ VGND VGND VPWR VPWR _01753_ sky130_fd_sc_hd__xnor2_1
X_14295_ _05770_ _05787_ _05819_ VGND VGND VPWR VPWR _05820_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_122_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16034_ _07628_ _07632_ _07630_ VGND VGND VPWR VPWR _07718_ sky130_fd_sc_hd__o21ba_1
X_10458_ _01680_ _01683_ VGND VGND VPWR VPWR _01684_ sky130_fd_sc_hd__xnor2_1
X_13246_ net284 _04678_ _04679_ VGND VGND VPWR VPWR _04680_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_149_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10389_ net616 net529 net935 net735 VGND VGND VPWR VPWR _01615_ sky130_fd_sc_hd__a22oi_1
X_13177_ net215 _04603_ _04604_ VGND VGND VPWR VPWR _04605_ sky130_fd_sc_hd__a21bo_1
X_12128_ _03457_ _03458_ _03378_ _03381_ VGND VGND VPWR VPWR _03459_ sky130_fd_sc_hd__o211a_1
X_12059_ _03380_ _03381_ _03383_ VGND VGND VPWR VPWR _03384_ sky130_fd_sc_hd__and3_1
XFILLER_0_74_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15818_ _07481_ _07482_ VGND VGND VPWR VPWR _07483_ sky130_fd_sc_hd__or2_1
XFILLER_0_59_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15749_ _07284_ _07407_ VGND VGND VPWR VPWR _07408_ sky130_fd_sc_hd__xor2_1
XFILLER_0_90_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09270_ _00453_ _00454_ VGND VGND VPWR VPWR _00548_ sky130_fd_sc_hd__and2_1
XFILLER_0_145_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08221_ _02430_ _02474_ _02485_ _02528_ VGND VGND VPWR VPWR _03007_ sky130_fd_sc_hd__a22o_1
XFILLER_0_117_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08152_ net562 net567 net378 net369 VGND VGND VPWR VPWR _02256_ sky130_fd_sc_hd__and4_1
XFILLER_0_82_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08985_ _00248_ _00264_ _00265_ VGND VGND VPWR VPWR _00266_ sky130_fd_sc_hd__and3_4
X_09606_ _00878_ _00879_ VGND VGND VPWR VPWR _00880_ sky130_fd_sc_hd__nor2_1
X_09537_ _00807_ _00808_ _00810_ VGND VGND VPWR VPWR _00812_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_149_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09468_ _00715_ _00716_ VGND VGND VPWR VPWR _00743_ sky130_fd_sc_hd__and2_1
XFILLER_0_54_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_148_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08419_ net536 net524 net437 net543 VGND VGND VPWR VPWR _05166_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_108_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09399_ _00673_ _00674_ VGND VGND VPWR VPWR _00675_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_81_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11430_ _02596_ _02698_ _02699_ VGND VGND VPWR VPWR _02700_ sky130_fd_sc_hd__nand3_1
XFILLER_0_34_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11361_ net774 net937 VGND VGND VPWR VPWR _02624_ sky130_fd_sc_hd__nor2_1
XFILLER_0_61_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10312_ D_sin\[9\] Q_cos\[9\] VGND VGND VPWR VPWR _01549_ sky130_fd_sc_hd__or2b_1
X_13100_ _04518_ _04519_ _04417_ _04419_ VGND VGND VPWR VPWR _04521_ sky130_fd_sc_hd__a211o_1
X_11292_ _02546_ _02547_ _02451_ VGND VGND VPWR VPWR _02549_ sky130_fd_sc_hd__o21ai_1
X_14080_ _05585_ _05586_ VGND VGND VPWR VPWR _05587_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10243_ _01487_ _01490_ VGND VGND VPWR VPWR _01491_ sky130_fd_sc_hd__xnor2_1
X_13031_ net800 net250 VGND VGND VPWR VPWR _04445_ sky130_fd_sc_hd__nand2_1
XFILLER_0_131_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10174_ _01429_ _01430_ VGND VGND VPWR VPWR _01431_ sky130_fd_sc_hd__xnor2_2
X_14982_ _06570_ _06571_ _06046_ VGND VGND VPWR VPWR _06573_ sky130_fd_sc_hd__a21o_1
Xfanout170 net171 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__clkbuf_4
Xfanout181 net75 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__clkbuf_4
Xfanout192 net74 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__buf_6
XFILLER_0_89_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13933_ _05425_ _05426_ VGND VGND VPWR VPWR _05428_ sky130_fd_sc_hd__and2_1
XFILLER_0_88_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13864_ _05350_ _05352_ VGND VGND VPWR VPWR _05353_ sky130_fd_sc_hd__nor2_1
X_15603_ _07247_ _07248_ VGND VGND VPWR VPWR _07250_ sky130_fd_sc_hd__nor2_1
X_12815_ net749 net162 net310 net757 VGND VGND VPWR VPWR _04210_ sky130_fd_sc_hd__a22oi_2
X_13795_ _05276_ _05182_ _05273_ _05274_ VGND VGND VPWR VPWR _05278_ sky130_fd_sc_hd__o211a_1
X_15534_ _07116_ _07174_ VGND VGND VPWR VPWR _07175_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_56_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12746_ _04118_ _04120_ _04132_ VGND VGND VPWR VPWR _04134_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_84_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15465_ _07019_ _07023_ _07021_ VGND VGND VPWR VPWR _07099_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_84_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12677_ _04048_ _04049_ _04055_ VGND VGND VPWR VPWR _04058_ sky130_fd_sc_hd__a21o_1
X_14416_ _05950_ _05951_ VGND VGND VPWR VPWR _05952_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11628_ _02912_ _02914_ VGND VGND VPWR VPWR _02915_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_4_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15396_ _07022_ _07023_ VGND VGND VPWR VPWR _07024_ sky130_fd_sc_hd__xor2_1
XFILLER_0_142_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14347_ _05872_ _05875_ VGND VGND VPWR VPWR _05876_ sky130_fd_sc_hd__xnor2_2
X_11559_ _02837_ _02838_ _02839_ VGND VGND VPWR VPWR _02840_ sky130_fd_sc_hd__a21o_1
XFILLER_0_52_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14278_ _05800_ _05801_ VGND VGND VPWR VPWR _05802_ sky130_fd_sc_hd__nor2_1
X_16017_ Q_sin\[13\] _07699_ _00186_ VGND VGND VPWR VPWR _07700_ sky130_fd_sc_hd__mux2_1
X_13229_ _04659_ _04660_ VGND VGND VPWR VPWR _04661_ sky130_fd_sc_hd__xor2_1
XFILLER_0_100_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08770_ net694 net534 net374 net365 VGND VGND VPWR VPWR _08081_ sky130_fd_sc_hd__nand4_2
XFILLER_0_109_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09322_ net663 net348 net501 net673 VGND VGND VPWR VPWR _00599_ sky130_fd_sc_hd__a22o_1
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_148_Left_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09253_ _00528_ _00529_ _00525_ VGND VGND VPWR VPWR _00531_ sky130_fd_sc_hd__a21o_1
XFILLER_0_7_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08204_ _02245_ _02267_ _02256_ VGND VGND VPWR VPWR _02822_ sky130_fd_sc_hd__o21ba_1
X_09184_ _00315_ _00373_ _00372_ VGND VGND VPWR VPWR _00463_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_16_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08968_ net658 net393 VGND VGND VPWR VPWR _00249_ sky130_fd_sc_hd__and2_1
X_08899_ _00179_ _00180_ VGND VGND VPWR VPWR _00181_ sky130_fd_sc_hd__and2_1
X_10930_ net800 VGND VGND VPWR VPWR _02156_ sky130_fd_sc_hd__inv_2
XFILLER_0_86_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10861_ _02009_ _02050_ _02085_ _02086_ VGND VGND VPWR VPWR _02087_ sky130_fd_sc_hd__a22o_1
XFILLER_0_39_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12600_ _03966_ _03967_ _03972_ VGND VGND VPWR VPWR _03973_ sky130_fd_sc_hd__nand3_1
X_13580_ _05042_ _05043_ VGND VGND VPWR VPWR _05044_ sky130_fd_sc_hd__and2_2
X_10792_ net777 net389 VGND VGND VPWR VPWR _02018_ sky130_fd_sc_hd__nand2_1
XFILLER_0_109_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12531_ _03893_ _03894_ _03895_ _03891_ _03896_ VGND VGND VPWR VPWR _03897_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_136_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15250_ _06856_ _06863_ _06864_ VGND VGND VPWR VPWR _06865_ sky130_fd_sc_hd__nand3_1
XFILLER_0_136_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12462_ net218 net208 net780 net788 VGND VGND VPWR VPWR _03821_ sky130_fd_sc_hd__and4_1
X_14201_ net313 net249 VGND VGND VPWR VPWR _05718_ sky130_fd_sc_hd__nand2_1
X_11413_ _02677_ _02678_ _02679_ VGND VGND VPWR VPWR _02682_ sky130_fd_sc_hd__a21o_1
XFILLER_0_22_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15181_ _06789_ VGND VGND VPWR VPWR _00099_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_50_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12393_ _03731_ _03744_ VGND VGND VPWR VPWR _03746_ sky130_fd_sc_hd__xor2_1
XFILLER_0_34_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14132_ _05641_ _05642_ VGND VGND VPWR VPWR _05643_ sky130_fd_sc_hd__xor2_2
X_11344_ _02586_ _02569_ VGND VGND VPWR VPWR _02606_ sky130_fd_sc_hd__or2b_1
X_14063_ net315 net424 net264 net254 VGND VGND VPWR VPWR _05569_ sky130_fd_sc_hd__and4_1
X_11275_ net428 net515 net376 net367 VGND VGND VPWR VPWR _02531_ sky130_fd_sc_hd__nand4_2
XFILLER_0_120_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_148_Right_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13014_ _04252_ _04425_ _04427_ VGND VGND VPWR VPWR _04428_ sky130_fd_sc_hd__nand3_2
X_10226_ _01474_ _01475_ VGND VGND VPWR VPWR _01476_ sky130_fd_sc_hd__nor2_1
X_10157_ Q_sin\[6\] D_cos\[6\] VGND VGND VPWR VPWR _01416_ sky130_fd_sc_hd__or2b_1
X_10088_ _01316_ _01317_ _01315_ VGND VGND VPWR VPWR _01354_ sky130_fd_sc_hd__o21ai_1
X_14965_ _06551_ net821 _06544_ VGND VGND VPWR VPWR _06555_ sky130_fd_sc_hd__a21o_1
X_13916_ _05336_ _05335_ VGND VGND VPWR VPWR _05409_ sky130_fd_sc_hd__and2b_1
X_14896_ _06475_ _06470_ _06474_ VGND VGND VPWR VPWR _06480_ sky130_fd_sc_hd__nor3_1
XFILLER_0_76_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13847_ net231 net298 VGND VGND VPWR VPWR _05334_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13778_ _05169_ _05172_ _05170_ VGND VGND VPWR VPWR _05259_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_18_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15517_ _07153_ _07154_ _07155_ VGND VGND VPWR VPWR _07156_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_45_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12729_ _04113_ _04114_ VGND VGND VPWR VPWR _04115_ sky130_fd_sc_hd__nand2_1
XFILLER_0_128_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_115_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15448_ _07078_ _07080_ VGND VGND VPWR VPWR _07081_ sky130_fd_sc_hd__or2_1
XFILLER_0_72_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15379_ _07003_ _07004_ VGND VGND VPWR VPWR _07005_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_142_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xmax_cap123 _05439_ VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__buf_1
XFILLER_0_96_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09940_ _01199_ _01208_ VGND VGND VPWR VPWR _01209_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_115_Right_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09871_ _01122_ _01140_ VGND VGND VPWR VPWR _01141_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_29_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08822_ _08043_ _08130_ _08131_ VGND VGND VPWR VPWR _08132_ sky130_fd_sc_hd__a21oi_1
X_08753_ net567 net499 VGND VGND VPWR VPWR _08064_ sky130_fd_sc_hd__and2_1
XFILLER_0_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08684_ _07889_ _07994_ _07995_ VGND VGND VPWR VPWR _07996_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_95_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09305_ _00576_ _00581_ VGND VGND VPWR VPWR _00582_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_91_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09236_ net934 net494 VGND VGND VPWR VPWR _00514_ sky130_fd_sc_hd__and2_1
XFILLER_0_118_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09167_ net631 net402 net392 net641 VGND VGND VPWR VPWR _00446_ sky130_fd_sc_hd__a22o_1
XFILLER_0_134_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09098_ _00376_ _00377_ VGND VGND VPWR VPWR _00378_ sky130_fd_sc_hd__xnor2_2
X_11060_ _02294_ _02295_ VGND VGND VPWR VPWR _02296_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_101_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10011_ _01252_ _01277_ VGND VGND VPWR VPWR _01279_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14750_ _06297_ _06299_ VGND VGND VPWR VPWR _06319_ sky130_fd_sc_hd__nor2_1
X_11962_ _03262_ _03277_ VGND VGND VPWR VPWR _03278_ sky130_fd_sc_hd__xnor2_2
X_13701_ _05167_ _05174_ VGND VGND VPWR VPWR _05175_ sky130_fd_sc_hd__xnor2_1
X_10913_ _02120_ _02138_ VGND VGND VPWR VPWR _02139_ sky130_fd_sc_hd__nor2_1
X_14681_ net324 net239 net553 net560 VGND VGND VPWR VPWR _06243_ sky130_fd_sc_hd__nand4_2
X_11893_ _03103_ _03118_ _03119_ _03122_ VGND VGND VPWR VPWR _03204_ sky130_fd_sc_hd__a31o_1
X_13632_ _05096_ _05098_ VGND VGND VPWR VPWR _05100_ sky130_fd_sc_hd__nand2_1
X_10844_ _02032_ _02069_ VGND VGND VPWR VPWR _02070_ sky130_fd_sc_hd__or2_1
XFILLER_0_132_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16351_ clknet_4_12_0_clk _00064_ net345 VGND VGND VPWR VPWR D_cos\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_66_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13563_ _05016_ _05024_ VGND VGND VPWR VPWR _05026_ sky130_fd_sc_hd__xnor2_2
X_10775_ _01977_ _02000_ VGND VGND VPWR VPWR _02001_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15302_ _06841_ _06849_ _06848_ VGND VGND VPWR VPWR _06921_ sky130_fd_sc_hd__a21o_1
XFILLER_0_66_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12514_ _03818_ _03878_ VGND VGND VPWR VPWR _03879_ sky130_fd_sc_hd__and2b_1
X_16282_ _07958_ _07985_ VGND VGND VPWR VPWR _07986_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_26_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13494_ _04859_ _04950_ VGND VGND VPWR VPWR _04951_ sky130_fd_sc_hd__xor2_2
XFILLER_0_136_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15233_ net166 net685 _06843_ _06844_ VGND VGND VPWR VPWR _06847_ sky130_fd_sc_hd__nand4_2
X_12445_ _03793_ _03795_ _03794_ VGND VGND VPWR VPWR _03803_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15164_ _06705_ _06769_ net815 VGND VGND VPWR VPWR _06772_ sky130_fd_sc_hd__nand3_2
X_12376_ _03709_ _03710_ _03726_ VGND VGND VPWR VPWR _03727_ sky130_fd_sc_hd__and3_1
X_14115_ _02170_ VGND VGND VPWR VPWR _05626_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_50_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11327_ _02568_ _02587_ VGND VGND VPWR VPWR _02588_ sky130_fd_sc_hd__xor2_1
X_15095_ _06695_ VGND VGND VPWR VPWR _06696_ sky130_fd_sc_hd__inv_2
XFILLER_0_120_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14046_ _05480_ _05549_ VGND VGND VPWR VPWR _05551_ sky130_fd_sc_hd__nor2_1
X_11258_ _02509_ _02510_ _02511_ VGND VGND VPWR VPWR _02512_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10209_ D_cos\[13\] Q_sin\[13\] VGND VGND VPWR VPWR _01461_ sky130_fd_sc_hd__and2b_1
X_11189_ _02336_ _02338_ VGND VGND VPWR VPWR _02437_ sky130_fd_sc_hd__nand2_1
X_15997_ _07574_ VGND VGND VPWR VPWR _07678_ sky130_fd_sc_hd__inv_2
X_14948_ _06533_ _06534_ _06529_ VGND VGND VPWR VPWR _06536_ sky130_fd_sc_hd__a21o_1
XFILLER_0_82_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14879_ _06404_ _06460_ _06433_ _06457_ VGND VGND VPWR VPWR _06461_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_89_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_786 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09021_ _00201_ _00299_ _00300_ VGND VGND VPWR VPWR _00301_ sky130_fd_sc_hd__a21o_1
XFILLER_0_72_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09923_ net671 _00192_ VGND VGND VPWR VPWR _01192_ sky130_fd_sc_hd__or2_1
Xfanout703 net706 VGND VGND VPWR VPWR net703 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_111_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout714 net19 VGND VGND VPWR VPWR net714 sky130_fd_sc_hd__clkbuf_2
Xfanout725 net728 VGND VGND VPWR VPWR net725 sky130_fd_sc_hd__buf_2
Xfanout736 net737 VGND VGND VPWR VPWR net736 sky130_fd_sc_hd__clkbuf_4
X_09854_ net654 net662 net455 net446 VGND VGND VPWR VPWR _01124_ sky130_fd_sc_hd__and4_1
Xfanout747 net750 VGND VGND VPWR VPWR net747 sky130_fd_sc_hd__clkbuf_4
Xfanout758 net759 VGND VGND VPWR VPWR net758 sky130_fd_sc_hd__clkbuf_2
Xfanout769 net771 VGND VGND VPWR VPWR net769 sky130_fd_sc_hd__clkbuf_4
X_08805_ _08040_ _04480_ _08114_ _08115_ VGND VGND VPWR VPWR _08116_ sky130_fd_sc_hd__o211ai_2
X_09785_ _01054_ _01055_ VGND VGND VPWR VPWR _01056_ sky130_fd_sc_hd__xor2_2
XFILLER_0_56_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08736_ _08045_ _08046_ VGND VGND VPWR VPWR _08047_ sky130_fd_sc_hd__nor2_1
XFILLER_0_95_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08667_ _07695_ _07749_ VGND VGND VPWR VPWR _07868_ sky130_fd_sc_hd__nor2_1
XFILLER_0_95_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08598_ net589 net596 net407 net396 VGND VGND VPWR VPWR _07118_ sky130_fd_sc_hd__and4_1
XFILLER_0_48_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10560_ net741 net361 _01752_ _01751_ VGND VGND VPWR VPWR _01786_ sky130_fd_sc_hd__a31o_1
XFILLER_0_24_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09219_ _00494_ _00496_ VGND VGND VPWR VPWR _00497_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_51_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10491_ net717 net726 net420 net410 VGND VGND VPWR VPWR _01717_ sky130_fd_sc_hd__and4_1
X_12230_ _03478_ _03481_ VGND VGND VPWR VPWR _03569_ sky130_fd_sc_hd__nor2_1
XFILLER_0_121_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12161_ _03472_ _03430_ _03492_ VGND VGND VPWR VPWR _03494_ sky130_fd_sc_hd__nand3_1
XFILLER_0_102_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11112_ net151 net889 _02350_ _02351_ VGND VGND VPWR VPWR _02353_ sky130_fd_sc_hd__a22o_1
X_12092_ _03357_ _03360_ _03417_ VGND VGND VPWR VPWR _03419_ sky130_fd_sc_hd__o21a_1
X_15920_ _07507_ _07513_ VGND VGND VPWR VPWR _07594_ sky130_fd_sc_hd__and2b_1
X_11043_ _02275_ _02276_ _02194_ _01822_ VGND VGND VPWR VPWR _02279_ sky130_fd_sc_hd__a211o_1
X_15851_ _07517_ _07518_ VGND VGND VPWR VPWR _07519_ sky130_fd_sc_hd__nor2_1
Xclkbuf_4_3_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_3_0_clk sky130_fd_sc_hd__clkbuf_8
X_14802_ net324 net239 net580 net588 VGND VGND VPWR VPWR _06376_ sky130_fd_sc_hd__and4_1
X_15782_ _07420_ _07442_ VGND VGND VPWR VPWR _07444_ sky130_fd_sc_hd__or2_1
X_12994_ _04298_ _04300_ _04299_ VGND VGND VPWR VPWR _04406_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_98_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14733_ _06297_ _06299_ VGND VGND VPWR VPWR _06301_ sky130_fd_sc_hd__xnor2_1
X_11945_ _03171_ _03178_ _03259_ VGND VGND VPWR VPWR _03260_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_99_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14664_ _05900_ _05971_ _05972_ _05973_ VGND VGND VPWR VPWR _06225_ sky130_fd_sc_hd__and4b_1
XFILLER_0_52_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11876_ _03089_ _03092_ VGND VGND VPWR VPWR _03185_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13615_ _04921_ _05081_ VGND VGND VPWR VPWR _05082_ sky130_fd_sc_hd__xor2_4
XFILLER_0_7_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10827_ _02023_ _02017_ _02022_ VGND VGND VPWR VPWR _02053_ sky130_fd_sc_hd__nand3_1
X_14595_ _06147_ _06148_ VGND VGND VPWR VPWR _06149_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16334_ clknet_4_2_0_clk _00047_ net333 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_125_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13546_ net194 net143 VGND VGND VPWR VPWR _05007_ sky130_fd_sc_hd__nand2_1
X_10758_ net752 net419 net411 net760 VGND VGND VPWR VPWR _01984_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_82_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16265_ _07966_ _07967_ VGND VGND VPWR VPWR _07968_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_82_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13477_ _04929_ _04931_ VGND VGND VPWR VPWR _04932_ sky130_fd_sc_hd__xnor2_2
X_10689_ _01888_ _01893_ VGND VGND VPWR VPWR _01915_ sky130_fd_sc_hd__nand2_1
X_15216_ net300 net540 VGND VGND VPWR VPWR _06828_ sky130_fd_sc_hd__and2_1
XFILLER_0_112_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12428_ _03782_ _03783_ VGND VGND VPWR VPWR _03784_ sky130_fd_sc_hd__nor2_1
XFILLER_0_140_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16196_ _07658_ _07841_ VGND VGND VPWR VPWR _07893_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15147_ net661 _06638_ _06642_ _06640_ VGND VGND VPWR VPWR _06753_ sky130_fd_sc_hd__a22o_1
X_12359_ _03699_ _03700_ _03695_ VGND VGND VPWR VPWR _03708_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15078_ _06676_ _06677_ VGND VGND VPWR VPWR _06678_ sky130_fd_sc_hd__nor2_1
XFILLER_0_120_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14029_ _05516_ _05531_ VGND VGND VPWR VPWR _05532_ sky130_fd_sc_hd__xnor2_1
X_09570_ _00836_ _00843_ VGND VGND VPWR VPWR _00844_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08521_ _06080_ _06102_ _06091_ VGND VGND VPWR VPWR _06278_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_78_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08452_ _05492_ _05503_ _05514_ VGND VGND VPWR VPWR _05525_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08383_ _04665_ _04698_ _04709_ _04720_ VGND VGND VPWR VPWR _04774_ sky130_fd_sc_hd__a211o_1
XFILLER_0_147_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_115_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09004_ _00282_ _00283_ _00189_ VGND VGND VPWR VPWR _00285_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_116_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xwire2 _06763_ VGND VGND VPWR VPWR net931 sky130_fd_sc_hd__buf_2
Xfanout500 net501 VGND VGND VPWR VPWR net500 sky130_fd_sc_hd__clkbuf_4
Xfanout511 net512 VGND VGND VPWR VPWR net511 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_111_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09906_ Q_cos\[14\] _01175_ _00661_ VGND VGND VPWR VPWR _01176_ sky130_fd_sc_hd__mux2_1
Xfanout522 net523 VGND VGND VPWR VPWR net522 sky130_fd_sc_hd__clkbuf_4
Xfanout533 net38 VGND VGND VPWR VPWR net533 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_6_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout544 net545 VGND VGND VPWR VPWR net544 sky130_fd_sc_hd__buf_4
XFILLER_0_67_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout555 net556 VGND VGND VPWR VPWR net555 sky130_fd_sc_hd__clkbuf_4
Xfanout566 net573 VGND VGND VPWR VPWR net566 sky130_fd_sc_hd__clkbuf_4
X_09837_ _01106_ _01107_ VGND VGND VPWR VPWR _01108_ sky130_fd_sc_hd__nor2_1
Xfanout577 net582 VGND VGND VPWR VPWR net577 sky130_fd_sc_hd__clkbuf_4
Xfanout588 net589 VGND VGND VPWR VPWR net588 sky130_fd_sc_hd__buf_2
Xfanout599 net600 VGND VGND VPWR VPWR net599 sky130_fd_sc_hd__clkbuf_4
X_09768_ _00975_ _01039_ VGND VGND VPWR VPWR _01040_ sky130_fd_sc_hd__xnor2_1
X_08719_ _08029_ _08030_ VGND VGND VPWR VPWR _08031_ sky130_fd_sc_hd__nor2_1
X_09699_ _00969_ _00971_ VGND VGND VPWR VPWR _00972_ sky130_fd_sc_hd__xor2_1
Xrebuffer60 _08109_ VGND VGND VPWR VPWR net866 sky130_fd_sc_hd__buf_6
Xrebuffer71 _00260_ VGND VGND VPWR VPWR net877 sky130_fd_sc_hd__buf_1
Xrebuffer82 _03355_ VGND VGND VPWR VPWR net888 sky130_fd_sc_hd__clkbuf_1
X_11730_ _03016_ _03024_ _03025_ VGND VGND VPWR VPWR _03026_ sky130_fd_sc_hd__nand3_1
XFILLER_0_68_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer93 _01848_ VGND VGND VPWR VPWR net899 sky130_fd_sc_hd__buf_1
XFILLER_0_138_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11661_ _02949_ _02950_ VGND VGND VPWR VPWR _02951_ sky130_fd_sc_hd__nor2_1
X_13400_ _04641_ _04642_ _04748_ VGND VGND VPWR VPWR _04848_ sky130_fd_sc_hd__nor3_4
X_10612_ _01722_ _01719_ _01721_ VGND VGND VPWR VPWR _01838_ sky130_fd_sc_hd__a21o_1
X_14380_ _05906_ _05910_ _05911_ VGND VGND VPWR VPWR _05912_ sky130_fd_sc_hd__nand3_1
XFILLER_0_37_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11592_ _02770_ _02874_ _02875_ VGND VGND VPWR VPWR _02876_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_36_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13331_ _04659_ _04660_ _04658_ VGND VGND VPWR VPWR _04772_ sky130_fd_sc_hd__o21ba_1
X_10543_ _01767_ _01768_ VGND VGND VPWR VPWR _01769_ sky130_fd_sc_hd__nor2_1
XFILLER_0_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16050_ net277 net637 net628 net286 VGND VGND VPWR VPWR _07735_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_106_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13262_ _04675_ _04696_ VGND VGND VPWR VPWR _04697_ sky130_fd_sc_hd__xor2_1
X_10474_ net616 net440 VGND VGND VPWR VPWR _01700_ sky130_fd_sc_hd__nand2_1
XFILLER_0_121_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15001_ _06587_ _06591_ VGND VGND VPWR VPWR _06593_ sky130_fd_sc_hd__nand2_1
X_12213_ _03348_ _03511_ _03549_ VGND VGND VPWR VPWR _03551_ sky130_fd_sc_hd__and3_1
XFILLER_0_122_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13193_ _04619_ _04620_ _04601_ VGND VGND VPWR VPWR _04623_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_32_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12144_ _03437_ _03440_ _03438_ VGND VGND VPWR VPWR _03476_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_138_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12075_ _03248_ _03245_ _03316_ VGND VGND VPWR VPWR _03402_ sky130_fd_sc_hd__o21ai_1
X_15903_ _07571_ _07574_ VGND VGND VPWR VPWR _07576_ sky130_fd_sc_hd__xor2_1
X_11026_ _02255_ _02257_ _02258_ VGND VGND VPWR VPWR _02260_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15834_ _07498_ _07486_ _07487_ VGND VGND VPWR VPWR _07501_ sky130_fd_sc_hd__nor3_1
X_15765_ net269 net260 net690 net531 VGND VGND VPWR VPWR _07426_ sky130_fd_sc_hd__and4_1
X_12977_ net708 net716 net191 net180 VGND VGND VPWR VPWR _04387_ sky130_fd_sc_hd__nand4_1
XFILLER_0_87_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14716_ _06269_ _06280_ _06281_ VGND VGND VPWR VPWR _06282_ sky130_fd_sc_hd__nor3_1
X_11928_ _02170_ VGND VGND VPWR VPWR _03242_ sky130_fd_sc_hd__clkbuf_8
X_15696_ _07349_ _07350_ VGND VGND VPWR VPWR _07351_ sky130_fd_sc_hd__nor2_1
X_14647_ _06192_ _06194_ VGND VGND VPWR VPWR _06206_ sky130_fd_sc_hd__and2_1
X_11859_ net316 net486 net476 net423 VGND VGND VPWR VPWR _03166_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_7_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_18 net276 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_14578_ _06123_ _06128_ _06129_ VGND VGND VPWR VPWR _06130_ sky130_fd_sc_hd__nand3_1
XFILLER_0_103_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_29 net518 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16317_ clknet_4_5_0_clk _00030_ net335 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dfrtp_1
X_13529_ _04986_ _04987_ VGND VGND VPWR VPWR _04988_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_42_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16248_ _00187_ _07948_ _07949_ VGND VGND VPWR VPWR _00113_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_113_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput103 net103 VGND VGND VPWR VPWR beta[14] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_23_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput114 net114 VGND VGND VPWR VPWR beta[7] sky130_fd_sc_hd__clkbuf_4
X_16179_ _07848_ _07873_ VGND VGND VPWR VPWR _07875_ sky130_fd_sc_hd__nor2_1
XFILLER_0_140_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09622_ _00894_ _00895_ VGND VGND VPWR VPWR _00896_ sky130_fd_sc_hd__xnor2_2
X_09553_ _00815_ _00814_ VGND VGND VPWR VPWR _00827_ sky130_fd_sc_hd__and2b_1
X_08504_ net553 net560 net524 net435 VGND VGND VPWR VPWR _06091_ sky130_fd_sc_hd__and4_1
XFILLER_0_144_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09484_ _00751_ _00758_ VGND VGND VPWR VPWR _00759_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_148_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08435_ _05308_ _05318_ _05329_ VGND VGND VPWR VPWR _05340_ sky130_fd_sc_hd__nor3_1
XFILLER_0_77_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08366_ _04556_ _04567_ _04578_ VGND VGND VPWR VPWR _04589_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_80_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08297_ _02855_ _02909_ VGND VGND VPWR VPWR _03833_ sky130_fd_sc_hd__and2b_1
XFILLER_0_116_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_131_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10190_ _01444_ VGND VGND VPWR VPWR _00029_ sky130_fd_sc_hd__clkbuf_1
Xfanout330 net331 VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__clkbuf_4
Xfanout341 net346 VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__buf_4
Xfanout352 net355 VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__clkbuf_4
Xfanout363 net56 VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_17_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout374 net382 VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__buf_2
Xfanout385 net386 VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__clkbuf_4
Xfanout396 net397 VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__buf_2
X_12900_ _04171_ _04172_ _04170_ VGND VGND VPWR VPWR _04303_ sky130_fd_sc_hd__o21bai_1
X_13880_ _05368_ _05369_ VGND VGND VPWR VPWR _05370_ sky130_fd_sc_hd__nor2_1
X_12831_ _04224_ _04225_ _04222_ _04223_ VGND VGND VPWR VPWR _04227_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_69_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15550_ _07097_ _07115_ _07190_ VGND VGND VPWR VPWR _07191_ sky130_fd_sc_hd__a21bo_1
X_12762_ _03949_ _03951_ _04005_ _04006_ VGND VGND VPWR VPWR _04151_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_84_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14501_ _06043_ _06044_ VGND VGND VPWR VPWR _06045_ sky130_fd_sc_hd__or2_1
X_11713_ _02929_ _02940_ _03006_ VGND VGND VPWR VPWR _03008_ sky130_fd_sc_hd__o21bai_1
X_15481_ _07097_ _07115_ VGND VGND VPWR VPWR _07116_ sky130_fd_sc_hd__xor2_1
XFILLER_0_56_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12693_ _04023_ _04037_ VGND VGND VPWR VPWR _04076_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_37_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14432_ _05956_ _05957_ _05967_ VGND VGND VPWR VPWR _05969_ sky130_fd_sc_hd__and3_1
X_11644_ net142 net375 net366 net150 VGND VGND VPWR VPWR _02933_ sky130_fd_sc_hd__a22o_1
XFILLER_0_71_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14363_ _05891_ _05892_ VGND VGND VPWR VPWR _05894_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_64_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11575_ _02852_ _02856_ _02857_ VGND VGND VPWR VPWR _02858_ sky130_fd_sc_hd__o21a_1
Xinput16 D[6] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_1
Xinput27 Q[16] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__buf_6
XFILLER_0_91_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16102_ _07769_ _07789_ VGND VGND VPWR VPWR _07791_ sky130_fd_sc_hd__nor2_1
Xinput38 Q[9] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_4
X_13314_ _04754_ VGND VGND VPWR VPWR _00081_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_107_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput49 cos[1] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__buf_8
X_10526_ _01750_ _01751_ VGND VGND VPWR VPWR _01752_ sky130_fd_sc_hd__nor2_1
X_14294_ _05788_ _05768_ VGND VGND VPWR VPWR _05819_ sky130_fd_sc_hd__or2b_1
X_16033_ _07714_ _07715_ VGND VGND VPWR VPWR _07717_ sky130_fd_sc_hd__nor2_1
X_13245_ net17 net295 net284 net746 VGND VGND VPWR VPWR _04679_ sky130_fd_sc_hd__a22o_1
X_10457_ _01681_ _01682_ VGND VGND VPWR VPWR _01683_ sky130_fd_sc_hd__nor2_1
XFILLER_0_122_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13176_ net235 net215 net153 net225 VGND VGND VPWR VPWR _04604_ sky130_fd_sc_hd__a22o_1
X_10388_ net616 net735 net529 net935 VGND VGND VPWR VPWR _01614_ sky130_fd_sc_hd__and4_1
X_12127_ _03456_ _03434_ _03435_ VGND VGND VPWR VPWR _03458_ sky130_fd_sc_hd__and3_1
X_12058_ _03283_ _03306_ _03382_ VGND VGND VPWR VPWR _03383_ sky130_fd_sc_hd__a21o_1
X_11009_ net724 net361 _02238_ _02239_ VGND VGND VPWR VPWR _02241_ sky130_fd_sc_hd__nand4_1
X_15817_ _07472_ _07480_ VGND VGND VPWR VPWR _07482_ sky130_fd_sc_hd__nor2_1
XFILLER_0_87_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15748_ _07405_ _07406_ VGND VGND VPWR VPWR _07407_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15679_ net262 net531 net539 net253 VGND VGND VPWR VPWR _07332_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_59_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08220_ _02811_ _02844_ _02985_ VGND VGND VPWR VPWR _02996_ sky130_fd_sc_hd__a21o_1
XFILLER_0_7_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08151_ net577 net360 VGND VGND VPWR VPWR _02245_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08984_ _00261_ _00262_ _00263_ VGND VGND VPWR VPWR _00265_ sky130_fd_sc_hd__a21o_1
XFILLER_0_48_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09605_ _00796_ _00795_ VGND VGND VPWR VPWR _00879_ sky130_fd_sc_hd__and2b_1
X_09536_ _00807_ _00808_ _00810_ VGND VGND VPWR VPWR _00811_ sky130_fd_sc_hd__nor3b_2
XFILLER_0_93_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09467_ _00703_ _00720_ VGND VGND VPWR VPWR _00742_ sky130_fd_sc_hd__and2_1
XFILLER_0_38_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08418_ net552 net416 VGND VGND VPWR VPWR _05155_ sky130_fd_sc_hd__nand2_1
X_09398_ net556 net441 VGND VGND VPWR VPWR _00674_ sky130_fd_sc_hd__nand2_1
XFILLER_0_65_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08349_ _04371_ _04382_ _04185_ VGND VGND VPWR VPWR _04404_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_46_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_129_Right_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11360_ _02620_ _02622_ VGND VGND VPWR VPWR _02623_ sky130_fd_sc_hd__xor2_2
XFILLER_0_15_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10311_ _01548_ VGND VGND VPWR VPWR _00046_ sky130_fd_sc_hd__clkbuf_1
X_11291_ _02451_ _02546_ _02547_ VGND VGND VPWR VPWR _02548_ sky130_fd_sc_hd__or3_1
XFILLER_0_30_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13030_ _04345_ _04442_ _04443_ VGND VGND VPWR VPWR _04444_ sky130_fd_sc_hd__a21oi_2
X_10242_ D_cos\[16\] _01488_ _01489_ VGND VGND VPWR VPWR _01490_ sky130_fd_sc_hd__o21a_1
XFILLER_0_30_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10173_ _01421_ _01424_ _01422_ VGND VGND VPWR VPWR _01430_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_100_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout160 net164 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__buf_6
X_14981_ _06046_ _06570_ _06571_ VGND VGND VPWR VPWR _06572_ sky130_fd_sc_hd__nand3_2
Xfanout171 net76 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__buf_2
Xfanout182 net183 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__clkbuf_4
Xfanout193 net195 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__clkbuf_4
X_13932_ _05410_ _05350_ _05424_ VGND VGND VPWR VPWR _05426_ sky130_fd_sc_hd__or3b_1
XFILLER_0_89_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13863_ _05346_ _05265_ _05349_ VGND VGND VPWR VPWR _05352_ sky130_fd_sc_hd__and3_1
X_15602_ net156 net305 net657 net665 VGND VGND VPWR VPWR _07248_ sky130_fd_sc_hd__and4_1
X_12814_ net749 net162 net310 net757 VGND VGND VPWR VPWR _04209_ sky130_fd_sc_hd__and4_1
X_13794_ _05273_ _05274_ _05276_ _05182_ VGND VGND VPWR VPWR _05277_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_96_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15533_ _07171_ _07172_ VGND VGND VPWR VPWR _07174_ sky130_fd_sc_hd__or2b_1
X_12745_ _04118_ _04120_ _04132_ VGND VGND VPWR VPWR _04133_ sky130_fd_sc_hd__and3_1
XFILLER_0_57_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15464_ _07017_ _07037_ _07036_ VGND VGND VPWR VPWR _07098_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12676_ _03967_ _03972_ _03966_ VGND VGND VPWR VPWR _04057_ sky130_fd_sc_hd__a21bo_1
X_14415_ net196 net900 _05947_ _05949_ VGND VGND VPWR VPWR _05951_ sky130_fd_sc_hd__o2bb2a_1
X_11627_ _02913_ VGND VGND VPWR VPWR _02914_ sky130_fd_sc_hd__inv_2
X_15395_ net273 net546 VGND VGND VPWR VPWR _07023_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_783 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14346_ _05873_ _05874_ VGND VGND VPWR VPWR _05875_ sky130_fd_sc_hd__nor2_1
X_11558_ net612 net495 VGND VGND VPWR VPWR _02839_ sky130_fd_sc_hd__and2_1
XFILLER_0_13_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10509_ _01732_ _01733_ _01734_ VGND VGND VPWR VPWR _01735_ sky130_fd_sc_hd__nand3_1
X_14277_ _05799_ _05753_ VGND VGND VPWR VPWR _05801_ sky130_fd_sc_hd__and2b_1
XFILLER_0_150_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11489_ net232 net318 net375 net366 VGND VGND VPWR VPWR _02764_ sky130_fd_sc_hd__nand4_2
XFILLER_0_110_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16016_ _07692_ _07698_ VGND VGND VPWR VPWR _07699_ sky130_fd_sc_hd__xor2_1
X_13228_ net775 net250 VGND VGND VPWR VPWR _04660_ sky130_fd_sc_hd__nand2_1
XFILLER_0_122_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13159_ _04582_ _04583_ _04566_ VGND VGND VPWR VPWR _04585_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_69_Left_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09321_ _00596_ _00597_ VGND VGND VPWR VPWR _00598_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_125_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09252_ _00525_ _00528_ _00529_ VGND VGND VPWR VPWR _00530_ sky130_fd_sc_hd__nand3_1
XFILLER_0_146_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08203_ _02746_ _02800_ VGND VGND VPWR VPWR _02811_ sky130_fd_sc_hd__or2b_1
XFILLER_0_118_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09183_ _00412_ _00461_ VGND VGND VPWR VPWR _00462_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08967_ _00239_ _00247_ VGND VGND VPWR VPWR _00248_ sky130_fd_sc_hd__xor2_1
X_08898_ _00177_ _00178_ _08051_ VGND VGND VPWR VPWR _00180_ sky130_fd_sc_hd__a21o_1
X_10860_ _02009_ _02047_ VGND VGND VPWR VPWR _02086_ sky130_fd_sc_hd__or2b_1
X_09519_ _00792_ _00793_ VGND VGND VPWR VPWR _00794_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_94_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10791_ _02011_ _02012_ _02016_ VGND VGND VPWR VPWR _02017_ sky130_fd_sc_hd__a21o_1
XFILLER_0_137_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12530_ _03889_ _03890_ VGND VGND VPWR VPWR _03896_ sky130_fd_sc_hd__nand2_1
XFILLER_0_54_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12461_ net218 net780 net788 net208 VGND VGND VPWR VPWR _03820_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14200_ _05715_ _05716_ VGND VGND VPWR VPWR _05717_ sky130_fd_sc_hd__nor2_1
X_11412_ _02677_ _02678_ _02679_ VGND VGND VPWR VPWR _02680_ sky130_fd_sc_hd__nand3_1
X_15180_ Q_sin\[3\] _06788_ _05626_ VGND VGND VPWR VPWR _06789_ sky130_fd_sc_hd__mux2_1
X_12392_ _03738_ _03743_ VGND VGND VPWR VPWR _03744_ sky130_fd_sc_hd__xor2_1
X_14131_ _05567_ _05571_ _05569_ VGND VGND VPWR VPWR _05642_ sky130_fd_sc_hd__o21ba_1
X_11343_ _02499_ _02591_ _02592_ VGND VGND VPWR VPWR _02605_ sky130_fd_sc_hd__and3_1
XFILLER_0_104_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14062_ net315 net264 net254 net424 VGND VGND VPWR VPWR _05567_ sky130_fd_sc_hd__a22oi_1
X_11274_ net426 net376 net367 net515 VGND VGND VPWR VPWR _02530_ sky130_fd_sc_hd__a22o_1
X_13013_ _04423_ _04424_ _04343_ net852 VGND VGND VPWR VPWR _04427_ sky130_fd_sc_hd__a211o_1
X_10225_ D_cos\[15\] Q_sin\[15\] VGND VGND VPWR VPWR _01475_ sky130_fd_sc_hd__and2b_1
XFILLER_0_30_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10156_ D_cos\[6\] Q_sin\[6\] VGND VGND VPWR VPWR _01415_ sky130_fd_sc_hd__or2b_1
XFILLER_0_146_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10087_ _01351_ _01352_ VGND VGND VPWR VPWR _01353_ sky130_fd_sc_hd__xor2_1
X_14964_ _06544_ _06551_ net821 VGND VGND VPWR VPWR _06554_ sky130_fd_sc_hd__nand3_2
XFILLER_0_89_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13915_ _05394_ _05392_ VGND VGND VPWR VPWR _05408_ sky130_fd_sc_hd__and2b_1
X_14895_ _06328_ _06468_ _06478_ VGND VGND VPWR VPWR _06479_ sky130_fd_sc_hd__o21a_1
XFILLER_0_71_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13846_ _05331_ _05332_ VGND VGND VPWR VPWR _05333_ sky130_fd_sc_hd__nor2_1
XFILLER_0_147_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13777_ _05255_ _05256_ _05236_ _05237_ VGND VGND VPWR VPWR _05258_ sky130_fd_sc_hd__a211oi_1
X_10989_ net733 net740 net353 net507 VGND VGND VPWR VPWR _02219_ sky130_fd_sc_hd__nand4_2
XFILLER_0_57_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15516_ net165 net660 VGND VGND VPWR VPWR _07155_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12728_ _04112_ _04111_ _04080_ _04059_ VGND VGND VPWR VPWR _04114_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_128_856 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15447_ _06898_ _06975_ _07079_ VGND VGND VPWR VPWR _07080_ sky130_fd_sc_hd__a21oi_1
X_12659_ _04026_ _04036_ VGND VGND VPWR VPWR _04038_ sky130_fd_sc_hd__and2b_1
XFILLER_0_25_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15378_ net251 net575 VGND VGND VPWR VPWR _07004_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14329_ _05853_ _05855_ VGND VGND VPWR VPWR _05856_ sky130_fd_sc_hd__nor2_1
Xmax_cap124 _00781_ VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__buf_1
XFILLER_0_123_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_110_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09870_ _01138_ _01139_ VGND VGND VPWR VPWR _01140_ sky130_fd_sc_hd__xnor2_1
X_08821_ net593 net602 net458 net449 VGND VGND VPWR VPWR _08131_ sky130_fd_sc_hd__and4_1
X_08752_ net551 net558 net351 net504 VGND VGND VPWR VPWR _08063_ sky130_fd_sc_hd__nand4_1
X_08683_ _07976_ _07993_ _07911_ VGND VGND VPWR VPWR _07995_ sky130_fd_sc_hd__a21o_1
XFILLER_0_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09304_ _00579_ _00580_ VGND VGND VPWR VPWR _00581_ sky130_fd_sc_hd__nor2_1
XFILLER_0_146_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09235_ net673 net682 net348 net501 VGND VGND VPWR VPWR _00513_ sky130_fd_sc_hd__nand4_2
XFILLER_0_8_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09166_ _00443_ _00444_ VGND VGND VPWR VPWR _00445_ sky130_fd_sc_hd__or2_1
XFILLER_0_114_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09097_ _00272_ _00274_ VGND VGND VPWR VPWR _00377_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10010_ _01252_ _01277_ VGND VGND VPWR VPWR _01278_ sky130_fd_sc_hd__nor2_1
X_09999_ _01181_ _01184_ VGND VGND VPWR VPWR _01267_ sky130_fd_sc_hd__nor2_1
XFILLER_0_98_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11961_ _03267_ _03276_ VGND VGND VPWR VPWR _03277_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_25_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10912_ net778 net438 _02118_ _02137_ VGND VGND VPWR VPWR _02138_ sky130_fd_sc_hd__o2bb2a_1
X_13700_ _05168_ _05173_ VGND VGND VPWR VPWR _05174_ sky130_fd_sc_hd__xor2_1
X_14680_ net221 net569 VGND VGND VPWR VPWR _06242_ sky130_fd_sc_hd__and2_1
X_11892_ _03146_ _03147_ _03201_ VGND VGND VPWR VPWR _03202_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_67_710 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13631_ _05096_ _05098_ VGND VGND VPWR VPWR _05099_ sky130_fd_sc_hd__or2_1
XFILLER_0_39_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10843_ net786 net379 net370 net802 VGND VGND VPWR VPWR _02069_ sky130_fd_sc_hd__a22oi_1
X_16350_ clknet_4_13_0_clk _00063_ net344 VGND VGND VPWR VPWR D_cos\[5\] sky130_fd_sc_hd__dfrtp_1
X_13562_ _05022_ _05023_ VGND VGND VPWR VPWR _05024_ sky130_fd_sc_hd__nand2_1
X_10774_ _01968_ _01974_ _01976_ VGND VGND VPWR VPWR _02000_ sky130_fd_sc_hd__and3_1
X_15301_ _06832_ _06834_ VGND VGND VPWR VPWR _06920_ sky130_fd_sc_hd__nand2_1
XFILLER_0_81_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12513_ _03862_ _03872_ _03876_ VGND VGND VPWR VPWR _03878_ sky130_fd_sc_hd__and3_1
X_16281_ _07962_ _07984_ VGND VGND VPWR VPWR _07985_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_136_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13493_ _04946_ _04948_ VGND VGND VPWR VPWR _04950_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_54_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15232_ net166 net685 _06843_ _06844_ VGND VGND VPWR VPWR _06845_ sky130_fd_sc_hd__a22o_1
X_12444_ _03799_ _03801_ VGND VGND VPWR VPWR _03802_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_35_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15163_ _06767_ _06768_ _06660_ _06706_ VGND VGND VPWR VPWR _06771_ sky130_fd_sc_hd__a211o_1
XFILLER_0_140_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12375_ _03716_ _03724_ _03725_ VGND VGND VPWR VPWR _03726_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_133_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14114_ _05560_ _05624_ VGND VGND VPWR VPWR _05625_ sky130_fd_sc_hd__xnor2_1
X_11326_ _02569_ _02586_ VGND VGND VPWR VPWR _02587_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15094_ net592 _06490_ _06589_ _06590_ VGND VGND VPWR VPWR _06695_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_10_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14045_ _05480_ _05549_ VGND VGND VPWR VPWR _05550_ sky130_fd_sc_hd__and2_1
X_11257_ net722 net498 VGND VGND VPWR VPWR _02511_ sky130_fd_sc_hd__and2_1
XFILLER_0_120_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10208_ Q_sin\[13\] D_cos\[13\] VGND VGND VPWR VPWR _01460_ sky130_fd_sc_hd__and2b_1
X_11188_ _02342_ _02361_ _02362_ VGND VGND VPWR VPWR _02436_ sky130_fd_sc_hd__nand3_2
X_10139_ _01397_ _01400_ VGND VGND VPWR VPWR _01401_ sky130_fd_sc_hd__nor2_1
X_15996_ _07653_ _07676_ VGND VGND VPWR VPWR _07677_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14947_ _06529_ _06533_ _06534_ VGND VGND VPWR VPWR _06535_ sky130_fd_sc_hd__and3_1
XFILLER_0_82_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14878_ _06403_ _06402_ _06401_ _06397_ VGND VGND VPWR VPWR _06460_ sky130_fd_sc_hd__o211a_1
X_13829_ _05219_ _05314_ VGND VGND VPWR VPWR _05315_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_147_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_122_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09020_ net574 net583 net459 net454 VGND VGND VPWR VPWR _00300_ sky130_fd_sc_hd__and4_1
XFILLER_0_31_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09922_ _01188_ _01190_ VGND VGND VPWR VPWR _01191_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout704 net706 VGND VGND VPWR VPWR net704 sky130_fd_sc_hd__buf_2
Xfanout715 net716 VGND VGND VPWR VPWR net715 sky130_fd_sc_hd__clkbuf_4
Xfanout726 net728 VGND VGND VPWR VPWR net726 sky130_fd_sc_hd__clkbuf_4
X_09853_ net654 net455 net446 net662 VGND VGND VPWR VPWR _01123_ sky130_fd_sc_hd__a22oi_1
Xfanout737 net17 VGND VGND VPWR VPWR net737 sky130_fd_sc_hd__buf_2
Xfanout748 net749 VGND VGND VPWR VPWR net748 sky130_fd_sc_hd__clkbuf_4
Xfanout759 net764 VGND VGND VPWR VPWR net759 sky130_fd_sc_hd__buf_2
X_08804_ _08112_ _08113_ _08053_ VGND VGND VPWR VPWR _08115_ sky130_fd_sc_hd__a21o_1
X_09784_ _01012_ _01015_ _01013_ VGND VGND VPWR VPWR _01055_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_56_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08735_ _08042_ _08044_ _03888_ _03921_ VGND VGND VPWR VPWR _08046_ sky130_fd_sc_hd__a211oi_1
X_08666_ _07792_ _07825_ _07835_ _07846_ VGND VGND VPWR VPWR _07857_ sky130_fd_sc_hd__a211o_1
XFILLER_0_96_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08597_ net589 net407 net396 net596 VGND VGND VPWR VPWR _07107_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_72_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09218_ _00495_ VGND VGND VPWR VPWR _00496_ sky130_fd_sc_hd__inv_2
XFILLER_0_17_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10490_ net717 net418 net410 net726 VGND VGND VPWR VPWR _01716_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_16_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09149_ _00424_ _00425_ _00426_ VGND VGND VPWR VPWR _00428_ sky130_fd_sc_hd__a21o_1
XFILLER_0_133_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_15_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12160_ _03472_ _03430_ _03492_ VGND VGND VPWR VPWR _03493_ sky130_fd_sc_hd__a21o_1
XFILLER_0_31_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11111_ net151 net889 _02350_ _02351_ VGND VGND VPWR VPWR _02352_ sky130_fd_sc_hd__nand4_4
X_12091_ _03357_ _03360_ _03417_ VGND VGND VPWR VPWR _03418_ sky130_fd_sc_hd__nor3_1
XFILLER_0_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11042_ _02194_ _01822_ _02275_ _02276_ VGND VGND VPWR VPWR _02277_ sky130_fd_sc_hd__o211ai_2
X_15850_ _07431_ _07430_ VGND VGND VPWR VPWR _07518_ sky130_fd_sc_hd__and2b_1
X_14801_ net324 net580 net588 net239 VGND VGND VPWR VPWR _06375_ sky130_fd_sc_hd__a22o_1
X_15781_ _07420_ _07442_ VGND VGND VPWR VPWR _07443_ sky130_fd_sc_hd__nand2_1
X_12993_ _04401_ _04402_ _04400_ VGND VGND VPWR VPWR _04405_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_87_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_24_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14732_ _06272_ _06277_ _06298_ VGND VGND VPWR VPWR _06299_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_87_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11944_ _03176_ _03177_ VGND VGND VPWR VPWR _03259_ sky130_fd_sc_hd__and2_1
XFILLER_0_143_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14663_ _05971_ _05972_ _06222_ _05900_ VGND VGND VPWR VPWR _06224_ sky130_fd_sc_hd__o2bb2a_1
X_11875_ _03180_ _03182_ _03115_ _03118_ VGND VGND VPWR VPWR _03184_ sky130_fd_sc_hd__o211a_1
X_16402_ clknet_4_15_0_clk next_state net342 VGND VGND VPWR VPWR state sky130_fd_sc_hd__dfrtp_4
X_10826_ _02045_ _02051_ VGND VGND VPWR VPWR _02052_ sky130_fd_sc_hd__or2_1
X_13614_ net194 _05005_ _05006_ _05080_ VGND VGND VPWR VPWR _05081_ sky130_fd_sc_hd__a31o_2
X_14594_ net212 net202 net561 net570 VGND VGND VPWR VPWR _06148_ sky130_fd_sc_hd__and4_1
XFILLER_0_27_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16333_ clknet_4_8_0_clk _00046_ net340 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10757_ net742 net439 VGND VGND VPWR VPWR _01983_ sky130_fd_sc_hd__nand2_1
X_13545_ net214 net204 net798 VGND VGND VPWR VPWR _05006_ sky130_fd_sc_hd__o21a_2
XFILLER_0_54_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16264_ net262 net625 VGND VGND VPWR VPWR _07967_ sky130_fd_sc_hd__nand2_1
X_13476_ _04822_ _04825_ _04930_ VGND VGND VPWR VPWR _04931_ sky130_fd_sc_hd__a21oi_2
X_10688_ _01886_ _01900_ _01912_ _01913_ VGND VGND VPWR VPWR _01914_ sky130_fd_sc_hd__a211o_1
XFILLER_0_113_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_33_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15215_ net159 net308 net934 net532 VGND VGND VPWR VPWR _06827_ sky130_fd_sc_hd__nand4_1
X_12427_ net190 net13 net782 net181 VGND VGND VPWR VPWR _03783_ sky130_fd_sc_hd__a22oi_2
X_16195_ _04540_ net665 _07869_ VGND VGND VPWR VPWR _07892_ sky130_fd_sc_hd__or3_1
XFILLER_0_2_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_140_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15146_ _06631_ _06633_ VGND VGND VPWR VPWR _06752_ sky130_fd_sc_hd__nand2_1
X_12358_ _03705_ _03706_ VGND VGND VPWR VPWR _03707_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11309_ _02402_ _02403_ _02567_ VGND VGND VPWR VPWR _02568_ sky130_fd_sc_hd__a21o_1
X_15077_ net809 _06675_ _06575_ VGND VGND VPWR VPWR _06677_ sky130_fd_sc_hd__a21oi_1
X_12289_ _03631_ _03632_ VGND VGND VPWR VPWR _03633_ sky130_fd_sc_hd__nor2_1
X_14028_ _05522_ _05530_ VGND VGND VPWR VPWR _05531_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_42_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15979_ _07657_ VGND VGND VPWR VPWR _07658_ sky130_fd_sc_hd__clkbuf_2
X_08520_ _05514_ _05492_ _05503_ VGND VGND VPWR VPWR _06267_ sky130_fd_sc_hd__nand3_1
X_08451_ net543 net553 net524 net435 VGND VGND VPWR VPWR _05514_ sky130_fd_sc_hd__nand4_2
XFILLER_0_77_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08382_ _02681_ _04731_ _04742_ _04753_ VGND VGND VPWR VPWR _04763_ sky130_fd_sc_hd__or4_4
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09003_ _00189_ _00282_ _00283_ VGND VGND VPWR VPWR _00284_ sky130_fd_sc_hd__nand3b_2
XFILLER_0_104_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout501 net510 VGND VGND VPWR VPWR net501 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_6_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09905_ _01117_ _01174_ VGND VGND VPWR VPWR _01175_ sky130_fd_sc_hd__xnor2_1
Xfanout512 net519 VGND VGND VPWR VPWR net512 sky130_fd_sc_hd__clkbuf_4
Xfanout523 net39 VGND VGND VPWR VPWR net523 sky130_fd_sc_hd__buf_6
Xfanout534 net535 VGND VGND VPWR VPWR net534 sky130_fd_sc_hd__buf_4
Xfanout545 net37 VGND VGND VPWR VPWR net545 sky130_fd_sc_hd__buf_6
Xfanout556 net563 VGND VGND VPWR VPWR net556 sky130_fd_sc_hd__clkbuf_4
X_09836_ _01101_ _01102_ _01104_ VGND VGND VPWR VPWR _01107_ sky130_fd_sc_hd__a21oi_1
Xfanout567 net572 VGND VGND VPWR VPWR net567 sky130_fd_sc_hd__clkbuf_4
Xfanout578 net582 VGND VGND VPWR VPWR net578 sky130_fd_sc_hd__clkbuf_2
Xfanout589 net590 VGND VGND VPWR VPWR net589 sky130_fd_sc_hd__clkbuf_4
X_09767_ _01037_ _01038_ VGND VGND VPWR VPWR _01039_ sky130_fd_sc_hd__nor2_1
X_08718_ _05959_ _08027_ VGND VGND VPWR VPWR _08030_ sky130_fd_sc_hd__nor2_1
X_09698_ _00819_ _00823_ _00897_ _00970_ VGND VGND VPWR VPWR _00971_ sky130_fd_sc_hd__o31a_1
XFILLER_0_96_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer50 _00856_ VGND VGND VPWR VPWR net856 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_83_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer61 _08100_ VGND VGND VPWR VPWR net867 sky130_fd_sc_hd__clkbuf_1
X_08649_ _07575_ _07651_ _07662_ VGND VGND VPWR VPWR _07673_ sky130_fd_sc_hd__a21o_1
Xrebuffer72 _04312_ VGND VGND VPWR VPWR net878 sky130_fd_sc_hd__buf_1
Xrebuffer83 net434 VGND VGND VPWR VPWR net889 sky130_fd_sc_hd__buf_6
Xrebuffer94 _03767_ VGND VGND VPWR VPWR net940 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_139_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11660_ net612 net703 net486 net475 VGND VGND VPWR VPWR _02950_ sky130_fd_sc_hd__and4_1
XFILLER_0_83_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10611_ _01833_ _01835_ _01836_ VGND VGND VPWR VPWR _01837_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_138_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11591_ _02780_ _02781_ VGND VGND VPWR VPWR _02875_ sky130_fd_sc_hd__and2b_1
XFILLER_0_107_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13330_ _04765_ _04770_ VGND VGND VPWR VPWR _04771_ sky130_fd_sc_hd__xor2_1
XFILLER_0_119_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10542_ net765 net774 net490 net481 VGND VGND VPWR VPWR _01768_ sky130_fd_sc_hd__and4_1
XFILLER_0_24_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13261_ _04694_ _04695_ VGND VGND VPWR VPWR _04696_ sky130_fd_sc_hd__nor2_1
X_10473_ _01696_ _01697_ _01698_ VGND VGND VPWR VPWR _01699_ sky130_fd_sc_hd__nand3_1
X_15000_ _06587_ _06591_ VGND VGND VPWR VPWR _06592_ sky130_fd_sc_hd__or2_1
X_12212_ _03547_ _03548_ VGND VGND VPWR VPWR _03549_ sky130_fd_sc_hd__or2_1
XFILLER_0_20_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13192_ _04601_ _04619_ _04620_ VGND VGND VPWR VPWR _04621_ sky130_fd_sc_hd__and3_1
XFILLER_0_121_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12143_ _03436_ _03447_ _03473_ VGND VGND VPWR VPWR _03475_ sky130_fd_sc_hd__a21o_1
XFILLER_0_102_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12074_ _03238_ _03400_ VGND VGND VPWR VPWR _03401_ sky130_fd_sc_hd__or2_1
X_15902_ _07282_ _07573_ VGND VGND VPWR VPWR _07574_ sky130_fd_sc_hd__xor2_2
X_11025_ _02255_ _02257_ _02258_ VGND VGND VPWR VPWR _02259_ sky130_fd_sc_hd__nand3_1
XFILLER_0_2_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15833_ _07486_ _07487_ _07498_ VGND VGND VPWR VPWR _07500_ sky130_fd_sc_hd__o21a_1
X_15764_ net262 net690 net531 net253 VGND VGND VPWR VPWR _07425_ sky130_fd_sc_hd__a22oi_2
X_12976_ net708 net191 net180 net716 VGND VGND VPWR VPWR _04386_ sky130_fd_sc_hd__a22o_1
XFILLER_0_86_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14715_ _06266_ _06268_ _06254_ VGND VGND VPWR VPWR _06281_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_59_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11927_ _03237_ _03240_ VGND VGND VPWR VPWR _03241_ sky130_fd_sc_hd__xnor2_1
X_15695_ _07256_ _07330_ _07348_ VGND VGND VPWR VPWR _07350_ sky130_fd_sc_hd__and3_1
XFILLER_0_129_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14646_ _06203_ _06202_ _06200_ _06176_ VGND VGND VPWR VPWR _06205_ sky130_fd_sc_hd__o211ai_2
X_11858_ _03165_ VGND VGND VPWR VPWR _00068_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_103_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_19 net276 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_10809_ _01993_ _01994_ _01995_ VGND VGND VPWR VPWR _02035_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_6_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14577_ _05925_ _05924_ _05923_ VGND VGND VPWR VPWR _06129_ sky130_fd_sc_hd__o21ai_1
X_11789_ net140 net358 VGND VGND VPWR VPWR _03090_ sky130_fd_sc_hd__and2_1
XFILLER_0_138_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16316_ clknet_4_5_0_clk _00029_ net335 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dfrtp_1
X_13528_ net721 net275 VGND VGND VPWR VPWR _04987_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16247_ net916 _00187_ VGND VGND VPWR VPWR _07949_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13459_ net234 net185 net175 net319 VGND VGND VPWR VPWR _04912_ sky130_fd_sc_hd__a22o_1
XFILLER_0_3_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput104 net104 VGND VGND VPWR VPWR beta[15] sky130_fd_sc_hd__clkbuf_4
Xoutput115 net115 VGND VGND VPWR VPWR beta[8] sky130_fd_sc_hd__clkbuf_4
X_16178_ _07848_ _07873_ VGND VGND VPWR VPWR _07874_ sky130_fd_sc_hd__and2_1
XFILLER_0_88_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15129_ net220 net210 net643 VGND VGND VPWR VPWR _06733_ sky130_fd_sc_hd__and3_1
XFILLER_0_10_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_50_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09621_ _00740_ _00813_ _00811_ VGND VGND VPWR VPWR _00895_ sky130_fd_sc_hd__a21oi_2
X_09552_ _00819_ _00823_ _00817_ VGND VGND VPWR VPWR _00826_ sky130_fd_sc_hd__o21bai_1
X_08503_ net572 net416 VGND VGND VPWR VPWR _06080_ sky130_fd_sc_hd__nand2_1
XFILLER_0_148_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09483_ _00756_ _00757_ VGND VGND VPWR VPWR _00758_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08434_ _05297_ _05286_ _05275_ _05242_ VGND VGND VPWR VPWR _05329_ sky130_fd_sc_hd__o211a_1
XFILLER_0_65_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08365_ net696 net536 net526 net437 VGND VGND VPWR VPWR _04578_ sky130_fd_sc_hd__and4_1
XFILLER_0_19_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08296_ _03029_ _03789_ _03800_ _03811_ VGND VGND VPWR VPWR _03822_ sky130_fd_sc_hd__and4_4
XFILLER_0_6_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_4_2_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_2_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_112_670 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout320 net321 VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__buf_4
Xfanout331 net59 VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__buf_6
Xfanout342 net343 VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__clkbuf_4
Xfanout353 net354 VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__clkbuf_4
Xfanout364 net372 VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__clkbuf_4
Xfanout375 net376 VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__clkbuf_4
Xfanout386 net391 VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__clkbuf_4
Xfanout397 net398 VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__dlymetal6s2s_1
X_09819_ _01081_ _01089_ VGND VGND VPWR VPWR _01090_ sky130_fd_sc_hd__xnor2_1
X_12830_ _04222_ _04223_ _04224_ _04225_ VGND VGND VPWR VPWR _04226_ sky130_fd_sc_hd__a211o_1
XFILLER_0_96_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12761_ _04144_ _04146_ _04145_ VGND VGND VPWR VPWR _04150_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_69_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14500_ net265 net697 _06042_ VGND VGND VPWR VPWR _06044_ sky130_fd_sc_hd__a21oi_1
X_11712_ _02925_ _02928_ VGND VGND VPWR VPWR _03006_ sky130_fd_sc_hd__and2b_1
X_15480_ _07098_ _07114_ VGND VGND VPWR VPWR _07115_ sky130_fd_sc_hd__xor2_1
XFILLER_0_68_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12692_ _03977_ _04040_ _04072_ _04073_ VGND VGND VPWR VPWR _04074_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_83_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14431_ _05956_ _05957_ _05967_ VGND VGND VPWR VPWR _05968_ sky130_fd_sc_hd__a21oi_1
X_11643_ net142 net385 _02854_ _02542_ VGND VGND VPWR VPWR _02932_ sky130_fd_sc_hd__a31o_1
XFILLER_0_127_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14362_ _05878_ _05877_ VGND VGND VPWR VPWR _05892_ sky130_fd_sc_hd__and2b_1
XFILLER_0_64_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11574_ net142 net385 _02853_ _02854_ VGND VGND VPWR VPWR _02857_ sky130_fd_sc_hd__a22o_1
XFILLER_0_52_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput17 D[7] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_2
X_16101_ _07769_ _07789_ VGND VGND VPWR VPWR _07790_ sky130_fd_sc_hd__and2_1
Xinput28 Q[17] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_141_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput39 cos[0] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__buf_4
XFILLER_0_24_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13313_ D_sin\[4\] _04751_ _04752_ VGND VGND VPWR VPWR _04754_ sky130_fd_sc_hd__mux2_1
X_10525_ net724 net733 net381 net371 VGND VGND VPWR VPWR _01751_ sky130_fd_sc_hd__and4_1
X_14293_ net271 net793 _05697_ _05695_ VGND VGND VPWR VPWR _05818_ sky130_fd_sc_hd__a31o_1
XFILLER_0_52_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16032_ _07660_ _07664_ _07713_ VGND VGND VPWR VPWR _07715_ sky130_fd_sc_hd__o21a_1
X_13244_ net17 net746 net295 VGND VGND VPWR VPWR _04678_ sky130_fd_sc_hd__and3_1
X_10456_ net774 net785 net490 net481 VGND VGND VPWR VPWR _01682_ sky130_fd_sc_hd__and4_1
XFILLER_0_150_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13175_ net235 net225 net153 VGND VGND VPWR VPWR _04603_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10387_ _01613_ VGND VGND VPWR VPWR _00057_ sky130_fd_sc_hd__clkbuf_1
X_12126_ _03434_ _03435_ _03456_ VGND VGND VPWR VPWR _03457_ sky130_fd_sc_hd__a21oi_1
X_12057_ _03281_ _03282_ VGND VGND VPWR VPWR _03382_ sky130_fd_sc_hd__and2_1
X_11008_ net724 net361 _02238_ _02239_ VGND VGND VPWR VPWR _02240_ sky130_fd_sc_hd__a22o_1
X_15816_ _07472_ _07480_ VGND VGND VPWR VPWR _07481_ sky130_fd_sc_hd__and2_1
XFILLER_0_59_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15747_ net165 net629 _07404_ VGND VGND VPWR VPWR _07406_ sky130_fd_sc_hd__nand3_1
X_12959_ net731 net739 net161 net310 VGND VGND VPWR VPWR _04367_ sky130_fd_sc_hd__nand4_1
XFILLER_0_87_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15678_ _07242_ _07245_ _07243_ VGND VGND VPWR VPWR _07331_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_114_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14629_ _06176_ _06184_ _06177_ VGND VGND VPWR VPWR _06186_ sky130_fd_sc_hd__and3_1
XFILLER_0_145_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08150_ _02201_ _02223_ VGND VGND VPWR VPWR _02234_ sky130_fd_sc_hd__nor2_2
XFILLER_0_126_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08983_ _00261_ _00262_ _00263_ VGND VGND VPWR VPWR _00264_ sky130_fd_sc_hd__nand3_2
XFILLER_0_139_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09604_ _00789_ _00794_ VGND VGND VPWR VPWR _00878_ sky130_fd_sc_hd__and2b_1
XFILLER_0_64_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09535_ _00685_ _00723_ _00809_ VGND VGND VPWR VPWR _00810_ sky130_fd_sc_hd__a21bo_1
X_09466_ _00702_ _00701_ VGND VGND VPWR VPWR _00741_ sky130_fd_sc_hd__and2b_1
XFILLER_0_149_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08417_ _04578_ _04567_ _04556_ VGND VGND VPWR VPWR _05144_ sky130_fd_sc_hd__o21ai_1
X_09397_ _00671_ _00672_ VGND VGND VPWR VPWR _00673_ sky130_fd_sc_hd__nor2_1
XFILLER_0_136_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08348_ _04185_ _04371_ _04382_ VGND VGND VPWR VPWR _04393_ sky130_fd_sc_hd__and3_4
XFILLER_0_46_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08279_ _03604_ _03615_ _03626_ VGND VGND VPWR VPWR _03637_ sky130_fd_sc_hd__nand3_4
XFILLER_0_15_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10310_ net115 _01547_ net133 VGND VGND VPWR VPWR _01548_ sky130_fd_sc_hd__mux2_1
X_11290_ net151 net141 net414 net405 VGND VGND VPWR VPWR _02547_ sky130_fd_sc_hd__and4_1
XFILLER_0_104_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10241_ D_cos\[16\] _01488_ _01474_ _01480_ VGND VGND VPWR VPWR _01489_ sky130_fd_sc_hd__a211o_1
XFILLER_0_104_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10172_ _01427_ _01428_ VGND VGND VPWR VPWR _01429_ sky130_fd_sc_hd__nand2_1
X_14980_ _06568_ _06569_ _06115_ _06117_ VGND VGND VPWR VPWR _06571_ sky130_fd_sc_hd__o211ai_2
Xfanout150 net154 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__clkbuf_4
Xfanout161 net163 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__clkbuf_4
Xfanout172 net173 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__clkbuf_4
Xfanout183 net186 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__buf_4
X_13931_ _05410_ _05350_ _05424_ VGND VGND VPWR VPWR _05425_ sky130_fd_sc_hd__o21bai_2
Xfanout194 net195 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__clkbuf_4
X_13862_ _05346_ _05265_ _05349_ VGND VGND VPWR VPWR _05350_ sky130_fd_sc_hd__a21oi_2
X_15601_ net156 net657 net665 net305 VGND VGND VPWR VPWR _07247_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_69_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12813_ net302 net767 VGND VGND VPWR VPWR _04208_ sky130_fd_sc_hd__nand2_1
X_13793_ _05176_ _05179_ VGND VGND VPWR VPWR _05276_ sky130_fd_sc_hd__and2_1
XFILLER_0_69_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15532_ _07168_ _07170_ VGND VGND VPWR VPWR _07172_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12744_ _04127_ _04131_ VGND VGND VPWR VPWR _04132_ sky130_fd_sc_hd__xnor2_1
X_15463_ _04539_ net584 _07012_ _07095_ VGND VGND VPWR VPWR _07097_ sky130_fd_sc_hd__o31ai_2
X_12675_ _04048_ _04049_ _04055_ VGND VGND VPWR VPWR _04056_ sky130_fd_sc_hd__nand3_1
X_14414_ _05947_ _05949_ net196 net900 VGND VGND VPWR VPWR _05950_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_37_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11626_ _02812_ _02815_ _02813_ VGND VGND VPWR VPWR _02913_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_108_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15394_ _07019_ _07021_ VGND VGND VPWR VPWR _07022_ sky130_fd_sc_hd__or2_1
XFILLER_0_64_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_7_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14345_ net160 net576 net584 net309 VGND VGND VPWR VPWR _05874_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11557_ net425 net513 net350 net502 VGND VGND VPWR VPWR _02838_ sky130_fd_sc_hd__nand4_1
XFILLER_0_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10508_ _01729_ _01731_ _01730_ VGND VGND VPWR VPWR _01734_ sky130_fd_sc_hd__o21ai_1
X_11488_ net232 net375 net366 net318 VGND VGND VPWR VPWR _02763_ sky130_fd_sc_hd__a22o_1
X_14276_ _05753_ _05799_ VGND VGND VPWR VPWR _05800_ sky130_fd_sc_hd__and2b_1
XFILLER_0_122_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16015_ _07370_ _07540_ _07693_ _07694_ _07697_ VGND VGND VPWR VPWR _07698_ sky130_fd_sc_hd__o311a_4
X_10439_ net733 net741 net381 net371 VGND VGND VPWR VPWR _01665_ sky130_fd_sc_hd__and4_1
X_13227_ _04549_ _04657_ _04658_ VGND VGND VPWR VPWR _04659_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_635 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13158_ _04566_ _04582_ _04583_ VGND VGND VPWR VPWR _04584_ sky130_fd_sc_hd__nand3_1
XFILLER_0_85_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12109_ net146 net137 net485 net475 VGND VGND VPWR VPWR _03438_ sky130_fd_sc_hd__and4_1
X_13089_ _04506_ _04507_ _04498_ VGND VGND VPWR VPWR _04509_ sky130_fd_sc_hd__a21o_1
XFILLER_0_109_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09320_ net538 net466 VGND VGND VPWR VPWR _00597_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09251_ net666 net356 _00526_ _00527_ VGND VGND VPWR VPWR _00529_ sky130_fd_sc_hd__nand4_2
XFILLER_0_29_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08202_ _02757_ _02790_ VGND VGND VPWR VPWR _02800_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_141_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09182_ _00459_ _00460_ VGND VGND VPWR VPWR _00461_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_44_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08966_ _00245_ _00246_ VGND VGND VPWR VPWR _00247_ sky130_fd_sc_hd__and2b_1
X_08897_ _08051_ _00177_ _00178_ VGND VGND VPWR VPWR _00179_ sky130_fd_sc_hd__nand3_2
XFILLER_0_98_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09518_ net546 net441 VGND VGND VPWR VPWR _00793_ sky130_fd_sc_hd__nand2_1
X_10790_ _02013_ _02014_ _02015_ VGND VGND VPWR VPWR _02016_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_93_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09449_ _00639_ _00641_ VGND VGND VPWR VPWR _00725_ sky130_fd_sc_hd__nor2_1
XFILLER_0_109_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12460_ net190 net804 VGND VGND VPWR VPWR _03819_ sky130_fd_sc_hd__nand2_1
XFILLER_0_124_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11411_ _02545_ _02552_ _02551_ VGND VGND VPWR VPWR _02679_ sky130_fd_sc_hd__a21bo_1
X_12391_ _03739_ _03742_ VGND VGND VPWR VPWR _03743_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11342_ _02591_ VGND VGND VPWR VPWR _02603_ sky130_fd_sc_hd__inv_2
X_14130_ _05634_ _05640_ VGND VGND VPWR VPWR _05641_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_104_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11273_ net318 net394 _02453_ _02527_ VGND VGND VPWR VPWR _02529_ sky130_fd_sc_hd__a31o_1
X_14061_ _05512_ _05532_ VGND VGND VPWR VPWR _05566_ sky130_fd_sc_hd__or2b_1
X_10224_ Q_sin\[15\] D_cos\[15\] VGND VGND VPWR VPWR _01474_ sky130_fd_sc_hd__and2b_1
X_13012_ _04343_ net852 _04423_ _04424_ VGND VGND VPWR VPWR _04425_ sky130_fd_sc_hd__o211ai_2
X_10155_ _01414_ VGND VGND VPWR VPWR _00024_ sky130_fd_sc_hd__clkbuf_1
X_10086_ net620 net466 _01237_ _01201_ VGND VGND VPWR VPWR _01352_ sky130_fd_sc_hd__a31o_1
X_14963_ _06548_ _06549_ _06550_ VGND VGND VPWR VPWR _06553_ sky130_fd_sc_hd__a21o_1
XFILLER_0_89_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13914_ _05398_ _05402_ _05406_ VGND VGND VPWR VPWR _05407_ sky130_fd_sc_hd__o21ai_2
X_14894_ _06470_ _06473_ _06474_ _06477_ VGND VGND VPWR VPWR _06478_ sky130_fd_sc_hd__and4bb_1
X_13845_ net157 net306 net149 net139 VGND VGND VPWR VPWR _05332_ sky130_fd_sc_hd__and4_1
XFILLER_0_29_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13776_ _05236_ _05237_ _05255_ _05256_ VGND VGND VPWR VPWR _05257_ sky130_fd_sc_hd__o211a_1
X_10988_ net733 net353 net507 net740 VGND VGND VPWR VPWR _02218_ sky130_fd_sc_hd__a22o_1
XFILLER_0_146_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15515_ net182 net172 net651 net873 VGND VGND VPWR VPWR _07154_ sky130_fd_sc_hd__nand4_1
X_12727_ _04059_ _04080_ _04111_ _04112_ VGND VGND VPWR VPWR _04113_ sky130_fd_sc_hd__a211o_1
XFILLER_0_139_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15446_ _06974_ _06973_ VGND VGND VPWR VPWR _07079_ sky130_fd_sc_hd__and2b_1
XFILLER_0_5_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12658_ _04026_ _04036_ VGND VGND VPWR VPWR _04037_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_26_855 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_111_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11609_ next_state _02893_ _02894_ VGND VGND VPWR VPWR _00065_ sky130_fd_sc_hd__a21oi_1
X_15377_ _07001_ _07002_ VGND VGND VPWR VPWR _07003_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12589_ net328 net617 net710 net243 VGND VGND VPWR VPWR _03961_ sky130_fd_sc_hd__a22o_1
XFILLER_0_105_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14328_ _05853_ _05854_ net196 net558 VGND VGND VPWR VPWR _05855_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_123_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap125 _06303_ VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__buf_1
XFILLER_0_40_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14259_ _05779_ _05780_ VGND VGND VPWR VPWR _05781_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08820_ net593 net458 VGND VGND VPWR VPWR _08130_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08751_ net551 net351 net504 net558 VGND VGND VPWR VPWR _08062_ sky130_fd_sc_hd__a22o_1
X_08682_ _07911_ _07976_ _07993_ VGND VGND VPWR VPWR _07994_ sky130_fd_sc_hd__nand3_1
XFILLER_0_136_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09303_ _00577_ _00578_ net564 net445 VGND VGND VPWR VPWR _00580_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_48_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09234_ net673 net348 net501 net682 VGND VGND VPWR VPWR _00512_ sky130_fd_sc_hd__a22o_1
XFILLER_0_145_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09165_ net520 net432 net413 VGND VGND VPWR VPWR _00444_ sky130_fd_sc_hd__o21a_1
XFILLER_0_16_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09096_ _00374_ _00375_ VGND VGND VPWR VPWR _00376_ sky130_fd_sc_hd__nor2_2
XFILLER_0_31_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09998_ _01264_ _01265_ VGND VGND VPWR VPWR _01266_ sky130_fd_sc_hd__nor2_1
X_08949_ _00226_ _00227_ _00228_ VGND VGND VPWR VPWR _00230_ sky130_fd_sc_hd__a21o_1
XFILLER_0_99_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11960_ _03274_ _03275_ VGND VGND VPWR VPWR _03276_ sky130_fd_sc_hd__xor2_2
X_10911_ _02119_ VGND VGND VPWR VPWR _02137_ sky130_fd_sc_hd__inv_2
X_11891_ _03143_ _03145_ VGND VGND VPWR VPWR _03201_ sky130_fd_sc_hd__or2b_1
X_13630_ _05015_ _05026_ _05097_ VGND VGND VPWR VPWR _05098_ sky130_fd_sc_hd__a21o_1
X_10842_ _02053_ _02066_ _02067_ VGND VGND VPWR VPWR _02068_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_88_Left_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13561_ _05020_ _05021_ _05017_ VGND VGND VPWR VPWR _05023_ sky130_fd_sc_hd__a21o_1
X_10773_ _01993_ _01996_ _01997_ _01998_ VGND VGND VPWR VPWR _01999_ sky130_fd_sc_hd__a211o_1
X_15300_ _06899_ _06918_ VGND VGND VPWR VPWR _06919_ sky130_fd_sc_hd__xor2_2
XFILLER_0_54_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12512_ _03874_ _03875_ VGND VGND VPWR VPWR _03876_ sky130_fd_sc_hd__and2_1
X_16280_ _07971_ _07983_ VGND VGND VPWR VPWR _07984_ sky130_fd_sc_hd__xnor2_1
X_13492_ _04838_ _04839_ _04947_ VGND VGND VPWR VPWR _04948_ sky130_fd_sc_hd__o21a_1
X_15231_ net186 net176 net668 net676 VGND VGND VPWR VPWR _06844_ sky130_fd_sc_hd__nand4_2
X_12443_ net198 net763 VGND VGND VPWR VPWR _03801_ sky130_fd_sc_hd__nand2_1
XFILLER_0_136_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15162_ net946 _06706_ _06767_ _06768_ VGND VGND VPWR VPWR _06769_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_34_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12374_ _03717_ _03718_ _03722_ VGND VGND VPWR VPWR _03725_ sky130_fd_sc_hd__nand3_1
X_14113_ _05561_ _05622_ VGND VGND VPWR VPWR _05624_ sky130_fd_sc_hd__xnor2_1
X_11325_ _02584_ _02585_ VGND VGND VPWR VPWR _02586_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_132_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15093_ _06687_ _06692_ VGND VGND VPWR VPWR _06694_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_97_Left_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11256_ net707 net713 net353 net509 VGND VGND VPWR VPWR _02510_ sky130_fd_sc_hd__nand4_1
X_14044_ _05545_ _05548_ VGND VGND VPWR VPWR _05549_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10207_ _01447_ _01451_ _01455_ VGND VGND VPWR VPWR _01459_ sky130_fd_sc_hd__o21a_1
X_11187_ _02433_ _02434_ VGND VGND VPWR VPWR _02435_ sky130_fd_sc_hd__or2_1
X_10138_ D_cos\[2\] _01398_ _01399_ VGND VGND VPWR VPWR _01400_ sky130_fd_sc_hd__o21a_1
X_15995_ _07655_ _07675_ VGND VGND VPWR VPWR _07676_ sky130_fd_sc_hd__xnor2_1
X_10069_ _01334_ _01335_ VGND VGND VPWR VPWR _01336_ sky130_fd_sc_hd__xnor2_1
X_14946_ net165 net541 _06531_ _06532_ VGND VGND VPWR VPWR _06534_ sky130_fd_sc_hd__nand4_2
XFILLER_0_106_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14877_ _06371_ _06404_ VGND VGND VPWR VPWR _06459_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13828_ _05312_ _05313_ VGND VGND VPWR VPWR _05314_ sky130_fd_sc_hd__or2_2
XFILLER_0_57_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13759_ _05168_ _05173_ VGND VGND VPWR VPWR _05238_ sky130_fd_sc_hd__or2_1
XFILLER_0_73_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15429_ net226 _06959_ VGND VGND VPWR VPWR _07060_ sky130_fd_sc_hd__and2_2
XFILLER_0_142_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_858 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09921_ _01129_ _01189_ VGND VGND VPWR VPWR _01190_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout705 net706 VGND VGND VPWR VPWR net705 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_0_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout716 net719 VGND VGND VPWR VPWR net716 sky130_fd_sc_hd__clkbuf_4
X_09852_ _01073_ _01091_ _01121_ VGND VGND VPWR VPWR _01122_ sky130_fd_sc_hd__a21o_1
Xfanout727 net728 VGND VGND VPWR VPWR net727 sky130_fd_sc_hd__buf_2
Xfanout738 net739 VGND VGND VPWR VPWR net738 sky130_fd_sc_hd__clkbuf_4
Xfanout749 net750 VGND VGND VPWR VPWR net749 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_147_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08803_ _08053_ net883 _08113_ VGND VGND VPWR VPWR _08114_ sky130_fd_sc_hd__nand3_4
X_09783_ _01048_ _01053_ VGND VGND VPWR VPWR _01054_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_147_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08734_ _03888_ _03921_ _08042_ _08044_ VGND VGND VPWR VPWR _08045_ sky130_fd_sc_hd__o211a_1
XFILLER_0_96_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08665_ _07390_ net876 _07151_ VGND VGND VPWR VPWR _07846_ sky130_fd_sc_hd__a21oi_1
X_08596_ _06355_ _07086_ VGND VGND VPWR VPWR _07096_ sky130_fd_sc_hd__or2_1
XFILLER_0_76_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09217_ _00397_ _00400_ _00398_ VGND VGND VPWR VPWR _00495_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_63_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09148_ _00424_ _00425_ _00426_ VGND VGND VPWR VPWR _00427_ sky130_fd_sc_hd__and3_1
XFILLER_0_31_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09079_ _00255_ _00353_ _00357_ _00358_ VGND VGND VPWR VPWR _00359_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_142_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11110_ net233 net320 net414 net406 VGND VGND VPWR VPWR _02351_ sky130_fd_sc_hd__nand4_4
X_12090_ _03415_ _03416_ VGND VGND VPWR VPWR _03417_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_102_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11041_ _02273_ _02274_ _02208_ VGND VGND VPWR VPWR _02276_ sky130_fd_sc_hd__a21o_1
X_14800_ net221 net588 _06347_ _06346_ VGND VGND VPWR VPWR _06374_ sky130_fd_sc_hd__a22o_1
X_15780_ _07422_ _07441_ VGND VGND VPWR VPWR _07442_ sky130_fd_sc_hd__xnor2_1
X_12992_ _04400_ _04401_ _04402_ VGND VGND VPWR VPWR _04403_ sky130_fd_sc_hd__or3_1
XFILLER_0_98_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14731_ net702 _06270_ _06279_ VGND VGND VPWR VPWR _06298_ sky130_fd_sc_hd__and3_1
X_11943_ _03255_ _03256_ VGND VGND VPWR VPWR _03258_ sky130_fd_sc_hd__or2b_1
XFILLER_0_99_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14662_ _05886_ _05899_ _05898_ _05895_ VGND VGND VPWR VPWR _06222_ sky130_fd_sc_hd__o211a_1
X_11874_ _03115_ _03118_ _03180_ _03182_ VGND VGND VPWR VPWR _03183_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_129_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16401_ clknet_4_5_0_clk _00114_ net339 VGND VGND VPWR VPWR Q_sin\[18\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_67_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13613_ net194 net798 _05005_ _05006_ VGND VGND VPWR VPWR _05080_ sky130_fd_sc_hd__a22oi_1
X_10825_ _02042_ _02044_ VGND VGND VPWR VPWR _02051_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14593_ net212 net560 net570 net202 VGND VGND VPWR VPWR _06147_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_55_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_883 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16332_ clknet_4_8_0_clk _00045_ net340 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_67_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13544_ net214 net204 net798 VGND VGND VPWR VPWR _05005_ sky130_fd_sc_hd__nand3_2
X_10756_ net734 net438 _01875_ _01874_ VGND VGND VPWR VPWR _01982_ sky130_fd_sc_hd__a22o_1
XFILLER_0_137_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16263_ net247 net648 _07898_ _07964_ VGND VGND VPWR VPWR _07966_ sky130_fd_sc_hd__a31o_1
X_13475_ net225 _04823_ VGND VGND VPWR VPWR _04930_ sky130_fd_sc_hd__and2_2
X_10687_ _01904_ _01911_ _01905_ VGND VGND VPWR VPWR _01913_ sky130_fd_sc_hd__and3_1
XFILLER_0_124_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15214_ net159 net934 net532 net308 VGND VGND VPWR VPWR _06826_ sky130_fd_sc_hd__a22o_1
X_12426_ net190 net181 net773 net782 VGND VGND VPWR VPWR _03782_ sky130_fd_sc_hd__and4_1
XFILLER_0_23_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16194_ _07864_ _07867_ VGND VGND VPWR VPWR _07891_ sky130_fd_sc_hd__or2_1
XFILLER_0_124_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15145_ _06746_ _06747_ _06749_ VGND VGND VPWR VPWR _06751_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_11_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12357_ net198 net780 VGND VGND VPWR VPWR _03706_ sky130_fd_sc_hd__nand2_1
XFILLER_0_121_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11308_ net785 net444 _02404_ VGND VGND VPWR VPWR _02567_ sky130_fd_sc_hd__and3_1
X_15076_ _06575_ _06674_ _06675_ VGND VGND VPWR VPWR _06676_ sky130_fd_sc_hd__and3_1
X_12288_ _03620_ _03548_ _03630_ VGND VGND VPWR VPWR _03632_ sky130_fd_sc_hd__o21a_1
X_14027_ _05523_ _05529_ VGND VGND VPWR VPWR _05530_ sky130_fd_sc_hd__xnor2_1
X_11239_ _02282_ _02289_ _02382_ VGND VGND VPWR VPWR _02492_ sky130_fd_sc_hd__a21o_1
X_15978_ _07550_ _07656_ VGND VGND VPWR VPWR _07657_ sky130_fd_sc_hd__or2_1
X_14929_ net874 _06512_ _06513_ VGND VGND VPWR VPWR _06515_ sky130_fd_sc_hd__nand3_1
XFILLER_0_117_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08450_ net543 net524 net435 net552 VGND VGND VPWR VPWR _05503_ sky130_fd_sc_hd__a22o_1
XFILLER_0_148_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08381_ _02550_ _02670_ _02659_ _02615_ VGND VGND VPWR VPWR _04753_ sky130_fd_sc_hd__o211a_1
XFILLER_0_9_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09002_ _00280_ _00281_ _00194_ VGND VGND VPWR VPWR _00283_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_115_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09904_ _01106_ _01173_ VGND VGND VPWR VPWR _01174_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_10_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout502 net510 VGND VGND VPWR VPWR net502 sky130_fd_sc_hd__clkbuf_4
Xfanout513 net519 VGND VGND VPWR VPWR net513 sky130_fd_sc_hd__clkbuf_4
Xfanout524 net525 VGND VGND VPWR VPWR net524 sky130_fd_sc_hd__clkbuf_4
Xfanout535 net38 VGND VGND VPWR VPWR net535 sky130_fd_sc_hd__buf_6
Xfanout546 net549 VGND VGND VPWR VPWR net546 sky130_fd_sc_hd__clkbuf_4
X_09835_ _01105_ VGND VGND VPWR VPWR _01106_ sky130_fd_sc_hd__clkbuf_2
Xfanout557 net563 VGND VGND VPWR VPWR net557 sky130_fd_sc_hd__clkbuf_4
Xfanout568 net572 VGND VGND VPWR VPWR net568 sky130_fd_sc_hd__clkbuf_2
Xfanout579 net580 VGND VGND VPWR VPWR net579 sky130_fd_sc_hd__buf_2
X_09766_ _00959_ _00976_ _01036_ VGND VGND VPWR VPWR _01038_ sky130_fd_sc_hd__nor3_1
X_08717_ _07488_ _08026_ _08028_ VGND VGND VPWR VPWR _08029_ sky130_fd_sc_hd__o21ba_2
X_09697_ _00827_ _00817_ _00896_ VGND VGND VPWR VPWR _00970_ sky130_fd_sc_hd__o21ai_1
Xrebuffer40 net545 VGND VGND VPWR VPWR net846 sky130_fd_sc_hd__clkbuf_2
Xrebuffer51 _02550_ VGND VGND VPWR VPWR net857 sky130_fd_sc_hd__clkbuf_1
Xrebuffer62 _04415_ VGND VGND VPWR VPWR net868 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_95_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08648_ _07586_ _07597_ _07640_ VGND VGND VPWR VPWR _07662_ sky130_fd_sc_hd__and3_1
Xrebuffer73 _04305_ VGND VGND VPWR VPWR net879 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_96_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer84 net889 VGND VGND VPWR VPWR net890 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer95 net652 VGND VGND VPWR VPWR net901 sky130_fd_sc_hd__buf_1
XFILLER_0_49_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08579_ _05731_ _05807_ _05817_ VGND VGND VPWR VPWR _06911_ sky130_fd_sc_hd__and3_1
XFILLER_0_138_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10610_ _01827_ _01832_ _01828_ VGND VGND VPWR VPWR _01836_ sky130_fd_sc_hd__nand3_1
XFILLER_0_64_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11590_ _02781_ _02780_ VGND VGND VPWR VPWR _02874_ sky130_fd_sc_hd__or2b_1
XFILLER_0_147_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10541_ net765 net490 net481 net774 VGND VGND VPWR VPWR _01767_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_106_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13260_ _04692_ _04693_ _04677_ VGND VGND VPWR VPWR _04695_ sky130_fd_sc_hd__o21a_1
X_10472_ net616 net420 net412 net709 VGND VGND VPWR VPWR _01698_ sky130_fd_sc_hd__a22o_1
XFILLER_0_121_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12211_ _03350_ _03546_ VGND VGND VPWR VPWR _03548_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_121_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13191_ _04616_ _04617_ _04618_ VGND VGND VPWR VPWR _04620_ sky130_fd_sc_hd__a21o_1
XFILLER_0_121_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12142_ _03353_ _03446_ VGND VGND VPWR VPWR _03473_ sky130_fd_sc_hd__nor2_1
X_12073_ _03398_ VGND VGND VPWR VPWR _03400_ sky130_fd_sc_hd__inv_2
X_15901_ _07492_ _07572_ VGND VGND VPWR VPWR _07573_ sky130_fd_sc_hd__xnor2_2
X_11024_ _01801_ _01803_ _01802_ VGND VGND VPWR VPWR _02258_ sky130_fd_sc_hd__o21bai_1
X_15832_ _07496_ _07497_ VGND VGND VPWR VPWR _07498_ sky130_fd_sc_hd__xor2_1
X_15763_ _07301_ _07305_ _07302_ VGND VGND VPWR VPWR _07424_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_63_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12975_ _04292_ _04294_ _04293_ VGND VGND VPWR VPWR _04385_ sky130_fd_sc_hd__o21bai_1
X_14714_ _06271_ _06279_ VGND VGND VPWR VPWR _06280_ sky130_fd_sc_hd__xor2_1
X_11926_ _03080_ _03238_ _03239_ VGND VGND VPWR VPWR _03240_ sky130_fd_sc_hd__o21ai_1
X_15694_ _07256_ _07330_ _07348_ VGND VGND VPWR VPWR _07349_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_68_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14645_ _06176_ _06200_ _06202_ _06203_ VGND VGND VPWR VPWR _06204_ sky130_fd_sc_hd__a211o_2
X_11857_ D_cos\[10\] _03164_ _01379_ VGND VGND VPWR VPWR _03165_ sky130_fd_sc_hd__mux2_1
X_10808_ _02026_ _02027_ _02033_ VGND VGND VPWR VPWR _02034_ sky130_fd_sc_hd__nand3_1
X_14576_ _06125_ _06126_ _06127_ VGND VGND VPWR VPWR _06128_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_67_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11788_ net796 net376 net366 VGND VGND VPWR VPWR _03089_ sky130_fd_sc_hd__nand3_2
XFILLER_0_27_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_144_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16315_ clknet_4_4_0_clk _00028_ net335 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dfrtp_1
X_13527_ _04984_ _04985_ VGND VGND VPWR VPWR _04986_ sky130_fd_sc_hd__nor2_1
X_10739_ _01962_ _01964_ VGND VGND VPWR VPWR _01965_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16246_ _07941_ _07947_ VGND VGND VPWR VPWR _07948_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_125_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13458_ net234 net194 _04819_ _04817_ net144 VGND VGND VPWR VPWR _04911_ sky130_fd_sc_hd__a32o_1
XFILLER_0_3_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12409_ _03760_ _03761_ _03752_ VGND VGND VPWR VPWR _03763_ sky130_fd_sc_hd__a21o_1
X_16177_ _07850_ _07872_ VGND VGND VPWR VPWR _07873_ sky130_fd_sc_hd__xnor2_1
Xoutput105 net105 VGND VGND VPWR VPWR beta[16] sky130_fd_sc_hd__clkbuf_4
X_13389_ _04732_ _04734_ VGND VGND VPWR VPWR _04836_ sky130_fd_sc_hd__nand2_1
Xoutput116 net116 VGND VGND VPWR VPWR beta[9] sky130_fd_sc_hd__clkbuf_4
X_15128_ net200 net660 VGND VGND VPWR VPWR _06732_ sky130_fd_sc_hd__and2_1
XFILLER_0_121_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_120_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15059_ _06653_ _06654_ _06655_ VGND VGND VPWR VPWR _06657_ sky130_fd_sc_hd__a21o_1
XFILLER_0_128_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09620_ _00891_ _00893_ VGND VGND VPWR VPWR _00894_ sky130_fd_sc_hd__xor2_2
X_09551_ _00825_ VGND VGND VPWR VPWR _00009_ sky130_fd_sc_hd__clkbuf_1
X_08502_ _06047_ _06058_ VGND VGND VPWR VPWR _06069_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_77_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09482_ _00711_ _00714_ _00712_ VGND VGND VPWR VPWR _00757_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_144_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08433_ _04894_ _05057_ VGND VGND VPWR VPWR _05318_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_148_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08364_ net696 net526 net437 net536 VGND VGND VPWR VPWR _04567_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_92_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08295_ _02996_ _03018_ _03007_ VGND VGND VPWR VPWR _03811_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout310 net311 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__clkbuf_4
Xfanout321 net6 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__buf_6
Xfanout332 net333 VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__clkbuf_4
Xfanout343 net344 VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__buf_2
Xfanout354 net355 VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__clkbuf_4
Xfanout365 net372 VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__buf_2
Xfanout376 net382 VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__buf_4
Xfanout387 net391 VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__clkbuf_4
X_09818_ _01087_ _01088_ VGND VGND VPWR VPWR _01089_ sky130_fd_sc_hd__or2_1
Xfanout398 net401 VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__buf_2
X_09749_ _00947_ _00946_ VGND VGND VPWR VPWR _01021_ sky130_fd_sc_hd__and2b_1
X_12760_ _04140_ _04148_ VGND VGND VPWR VPWR _04149_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_68_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11711_ _02992_ _03004_ VGND VGND VPWR VPWR _03005_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_139_535 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12691_ _04059_ _04060_ _04071_ VGND VGND VPWR VPWR _04073_ sky130_fd_sc_hd__and3_1
X_14430_ _05958_ _05966_ VGND VGND VPWR VPWR _05967_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_65_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11642_ net318 net358 _02867_ _02865_ net375 VGND VGND VPWR VPWR _02930_ sky130_fd_sc_hd__a32o_1
XFILLER_0_37_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14361_ net300 net607 VGND VGND VPWR VPWR _05891_ sky130_fd_sc_hd__nand2_1
XFILLER_0_119_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11573_ net385 _02853_ _02854_ VGND VGND VPWR VPWR _02856_ sky130_fd_sc_hd__nand3_2
Xinput18 D[8] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_1
X_16100_ _07772_ _07788_ VGND VGND VPWR VPWR _07789_ sky130_fd_sc_hd__xnor2_1
X_13312_ _02170_ VGND VGND VPWR VPWR _04752_ sky130_fd_sc_hd__buf_4
Xinput29 Q[18] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_1
X_10524_ net724 net381 net371 net733 VGND VGND VPWR VPWR _01750_ sky130_fd_sc_hd__a22oi_1
X_14292_ _05815_ _05798_ VGND VGND VPWR VPWR _05816_ sky130_fd_sc_hd__nor2_1
X_16031_ _07660_ _07664_ _07713_ VGND VGND VPWR VPWR _07714_ sky130_fd_sc_hd__nor3_1
XFILLER_0_122_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13243_ _04591_ _04598_ _04597_ VGND VGND VPWR VPWR _04677_ sky130_fd_sc_hd__a21oi_1
X_10455_ net774 net490 net481 net785 VGND VGND VPWR VPWR _01681_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_149_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13174_ net319 net205 VGND VGND VPWR VPWR _04602_ sky130_fd_sc_hd__and2_1
XFILLER_0_20_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10386_ net132 net919 VGND VGND VPWR VPWR _01613_ sky130_fd_sc_hd__or2_1
X_12125_ _03454_ _03455_ VGND VGND VPWR VPWR _03456_ sky130_fd_sc_hd__nor2_1
XFILLER_0_20_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12056_ _03379_ _03345_ _03346_ VGND VGND VPWR VPWR _03381_ sky130_fd_sc_hd__nand3_2
X_11007_ net708 net715 net381 net371 VGND VGND VPWR VPWR _02239_ sky130_fd_sc_hd__nand4_2
XFILLER_0_74_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15815_ _07478_ _07479_ VGND VGND VPWR VPWR _07480_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15746_ net165 net629 _07404_ VGND VGND VPWR VPWR _07405_ sky130_fd_sc_hd__a21o_1
X_12958_ net731 net161 net310 net739 VGND VGND VPWR VPWR _04366_ sky130_fd_sc_hd__a22o_1
XFILLER_0_48_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11909_ _03202_ _03220_ VGND VGND VPWR VPWR _03221_ sky130_fd_sc_hd__xor2_1
X_15677_ _07258_ _07240_ VGND VGND VPWR VPWR _07330_ sky130_fd_sc_hd__or2b_1
XFILLER_0_90_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12889_ _04281_ _04290_ VGND VGND VPWR VPWR _04291_ sky130_fd_sc_hd__xor2_2
XFILLER_0_87_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14628_ _06176_ _06177_ _06184_ VGND VGND VPWR VPWR _06185_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_135_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14559_ _06106_ _06107_ _06087_ VGND VGND VPWR VPWR _06109_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_83_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16229_ _07927_ _07914_ _07915_ VGND VGND VPWR VPWR _07929_ sky130_fd_sc_hd__and3_1
XFILLER_0_140_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08982_ _00153_ _00161_ _00160_ VGND VGND VPWR VPWR _00263_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_143_Right_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09603_ _00875_ _00876_ VGND VGND VPWR VPWR _00877_ sky130_fd_sc_hd__xor2_1
X_09534_ _00721_ _00722_ VGND VGND VPWR VPWR _00809_ sky130_fd_sc_hd__or2b_1
XFILLER_0_149_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09465_ _00668_ _00684_ _00739_ VGND VGND VPWR VPWR _00740_ sky130_fd_sc_hd__a21o_1
XFILLER_0_109_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08416_ _04578_ _04556_ _04567_ VGND VGND VPWR VPWR _05134_ sky130_fd_sc_hd__or3_1
XFILLER_0_47_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09396_ net538 net546 net456 net447 VGND VGND VPWR VPWR _00672_ sky130_fd_sc_hd__and4_1
XFILLER_0_108_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08347_ _04338_ _04349_ _04360_ VGND VGND VPWR VPWR _04382_ sky130_fd_sc_hd__a21o_1
XFILLER_0_62_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08278_ _03529_ _03539_ _03593_ VGND VGND VPWR VPWR _03626_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10240_ Q_sin\[16\] VGND VGND VPWR VPWR _01488_ sky130_fd_sc_hd__inv_2
XFILLER_0_131_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10171_ Q_sin\[8\] D_cos\[8\] VGND VGND VPWR VPWR _01428_ sky130_fd_sc_hd__or2b_1
XFILLER_0_112_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_110_Right_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout140 net9 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__buf_2
Xfanout151 net154 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__buf_2
Xfanout162 net163 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__clkbuf_4
X_13930_ _05415_ _05423_ VGND VGND VPWR VPWR _05424_ sky130_fd_sc_hd__xnor2_1
Xfanout173 net176 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__buf_4
Xfanout184 net186 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__buf_1
Xfanout195 net73 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__buf_4
X_13861_ _05168_ _05348_ VGND VGND VPWR VPWR _05349_ sky130_fd_sc_hd__xnor2_4
X_15600_ _07244_ _07245_ VGND VGND VPWR VPWR _07246_ sky130_fd_sc_hd__xnor2_1
X_12812_ _04121_ _04123_ _04122_ VGND VGND VPWR VPWR _04206_ sky130_fd_sc_hd__o21ba_1
X_13792_ _05272_ _05257_ _05258_ VGND VGND VPWR VPWR _05274_ sky130_fd_sc_hd__or3_2
X_15531_ _07168_ _07170_ VGND VGND VPWR VPWR _07171_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12743_ _04128_ _04129_ VGND VGND VPWR VPWR _04131_ sky130_fd_sc_hd__nor2_1
XFILLER_0_139_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15462_ _07008_ _07011_ VGND VGND VPWR VPWR _07095_ sky130_fd_sc_hd__or2b_1
XFILLER_0_84_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12674_ net948 _04054_ VGND VGND VPWR VPWR _04055_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14413_ net213 net695 net537 net203 VGND VGND VPWR VPWR _05949_ sky130_fd_sc_hd__a22oi_1
X_11625_ _02905_ _02911_ VGND VGND VPWR VPWR _02912_ sky130_fd_sc_hd__xor2_2
X_15393_ net287 net278 net533 net538 VGND VGND VPWR VPWR _07021_ sky130_fd_sc_hd__and4_1
XFILLER_0_65_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14344_ net160 net308 net576 net584 VGND VGND VPWR VPWR _05873_ sky130_fd_sc_hd__and4_1
XFILLER_0_123_700 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11556_ net425 net350 net502 net513 VGND VGND VPWR VPWR _02837_ sky130_fd_sc_hd__a22o_1
XFILLER_0_123_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10507_ _01697_ _01698_ _01696_ VGND VGND VPWR VPWR _01733_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_150_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14275_ _05797_ _05798_ VGND VGND VPWR VPWR _05799_ sky130_fd_sc_hd__nor2_1
X_11487_ net150 _02542_ _02666_ _02667_ VGND VGND VPWR VPWR _02762_ sky130_fd_sc_hd__o2bb2ai_2
XFILLER_0_150_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16014_ _07696_ _07546_ _07616_ VGND VGND VPWR VPWR _07697_ sky130_fd_sc_hd__a21bo_1
X_13226_ net757 net766 net268 net258 VGND VGND VPWR VPWR _04658_ sky130_fd_sc_hd__and4_1
X_10438_ net751 net361 VGND VGND VPWR VPWR _01664_ sky130_fd_sc_hd__nand2_1
XFILLER_0_123_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13157_ _04580_ _04581_ _04572_ VGND VGND VPWR VPWR _04583_ sky130_fd_sc_hd__a21o_1
XFILLER_0_21_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10369_ _01590_ _01596_ _01597_ VGND VGND VPWR VPWR _01599_ sky130_fd_sc_hd__or3_1
X_12108_ net137 net485 net475 net146 VGND VGND VPWR VPWR _03437_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_109_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13088_ _04498_ _04506_ _04507_ VGND VGND VPWR VPWR _04508_ sky130_fd_sc_hd__nand3_2
XFILLER_0_18_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12039_ net136 _03270_ VGND VGND VPWR VPWR _03362_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_108_Left_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_4_1_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_1_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_149_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15729_ net155 net304 net649 net639 VGND VGND VPWR VPWR _07386_ sky130_fd_sc_hd__and4_1
XFILLER_0_87_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09250_ net666 net356 _00526_ _00527_ VGND VGND VPWR VPWR _00528_ sky130_fd_sc_hd__a22o_1
XFILLER_0_47_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08201_ _02768_ _02779_ VGND VGND VPWR VPWR _02790_ sky130_fd_sc_hd__nor2_1
XFILLER_0_146_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09181_ _00337_ _00369_ _00368_ VGND VGND VPWR VPWR _00460_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_43_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_117_Left_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08965_ _00243_ _00244_ _00240_ VGND VGND VPWR VPWR _00246_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_126_Left_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08896_ _00175_ _00176_ net854 _08114_ VGND VGND VPWR VPWR _00178_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_79_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09517_ _00790_ _00791_ VGND VGND VPWR VPWR _00792_ sky130_fd_sc_hd__nor2_1
XFILLER_0_39_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09448_ _00685_ _00723_ VGND VGND VPWR VPWR _00724_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_137_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_135_Left_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09379_ _00469_ _00565_ VGND VGND VPWR VPWR _00656_ sky130_fd_sc_hd__nand2_1
XFILLER_0_46_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11410_ _02675_ _02676_ _02668_ VGND VGND VPWR VPWR _02678_ sky130_fd_sc_hd__a21o_1
X_12390_ _03740_ _03741_ VGND VGND VPWR VPWR _03742_ sky130_fd_sc_hd__nor2_1
XFILLER_0_117_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11341_ _02602_ VGND VGND VPWR VPWR _00062_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14060_ _05564_ _05531_ VGND VGND VPWR VPWR _05565_ sky130_fd_sc_hd__or2_1
X_11272_ net142 net797 net522 net889 VGND VGND VPWR VPWR _02527_ sky130_fd_sc_hd__and4_1
XFILLER_0_30_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13011_ _04421_ _04422_ _04356_ VGND VGND VPWR VPWR _04424_ sky130_fd_sc_hd__a21o_1
X_10223_ _01473_ VGND VGND VPWR VPWR _00033_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_120_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_144_Left_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10154_ net93 _01413_ net135 VGND VGND VPWR VPWR _01414_ sky130_fd_sc_hd__mux2_1
X_14962_ _06548_ _06549_ _06550_ VGND VGND VPWR VPWR _06551_ sky130_fd_sc_hd__nand3_1
X_10085_ net637 net442 VGND VGND VPWR VPWR _01351_ sky130_fd_sc_hd__nand2_1
X_13913_ _05312_ _05396_ VGND VGND VPWR VPWR _05406_ sky130_fd_sc_hd__nand2_1
X_14893_ _06230_ _06475_ VGND VGND VPWR VPWR _06477_ sky130_fd_sc_hd__xnor2_1
X_13844_ net306 net149 net139 net157 VGND VGND VPWR VPWR _05331_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_69_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13775_ _05238_ _05239_ _05254_ VGND VGND VPWR VPWR _05256_ sky130_fd_sc_hd__nand3_1
X_10987_ _02215_ _02216_ VGND VGND VPWR VPWR _02217_ sky130_fd_sc_hd__xnor2_1
X_15514_ net172 net651 net873 net182 VGND VGND VPWR VPWR _07153_ sky130_fd_sc_hd__a22o_1
X_12726_ _04099_ _04100_ _04110_ VGND VGND VPWR VPWR _04112_ sky130_fd_sc_hd__and3_1
XFILLER_0_127_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15445_ _06995_ _07077_ VGND VGND VPWR VPWR _07078_ sky130_fd_sc_hd__xor2_1
XFILLER_0_128_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12657_ _04027_ _04035_ VGND VGND VPWR VPWR _04036_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_143_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11608_ net909 _00187_ VGND VGND VPWR VPWR _02894_ sky130_fd_sc_hd__nor2_1
X_15376_ net265 net932 net556 net565 VGND VGND VPWR VPWR _07002_ sky130_fd_sc_hd__and4_1
XFILLER_0_52_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12588_ net224 net718 VGND VGND VPWR VPWR _03960_ sky130_fd_sc_hd__and2_1
XFILLER_0_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14327_ net213 net544 net552 net203 VGND VGND VPWR VPWR _05854_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_142_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11539_ _02721_ _02725_ _02722_ VGND VGND VPWR VPWR _02818_ sky130_fd_sc_hd__o21ba_2
Xmax_cap126 _03907_ VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__buf_1
X_14258_ _05715_ _05718_ _05716_ VGND VGND VPWR VPWR _05780_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_0_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13209_ _04637_ _04638_ _04541_ VGND VGND VPWR VPWR _04640_ sky130_fd_sc_hd__a21o_1
X_14189_ _05510_ _05704_ VGND VGND VPWR VPWR _05705_ sky130_fd_sc_hd__and2_1
X_08750_ _08059_ _08060_ VGND VGND VPWR VPWR _08061_ sky130_fd_sc_hd__xnor2_1
X_08681_ _07991_ _07992_ VGND VGND VPWR VPWR _07993_ sky130_fd_sc_hd__or2b_1
XFILLER_0_136_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09302_ net564 net445 _00577_ _00578_ VGND VGND VPWR VPWR _00579_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09233_ _00509_ _00510_ VGND VGND VPWR VPWR _00511_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_90_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_683 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09164_ net520 net432 net413 net621 VGND VGND VPWR VPWR _00443_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_28_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09095_ _00372_ _00373_ _00315_ VGND VGND VPWR VPWR _00375_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_71_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09997_ _01202_ _01257_ _01263_ VGND VGND VPWR VPWR _01265_ sky130_fd_sc_hd__o21a_1
X_08948_ _00226_ _00227_ _00228_ VGND VGND VPWR VPWR _00229_ sky130_fd_sc_hd__nand3_1
X_08879_ _00157_ _00158_ _00159_ VGND VGND VPWR VPWR _00161_ sky130_fd_sc_hd__a21o_1
X_10910_ _02129_ _02135_ VGND VGND VPWR VPWR _02136_ sky130_fd_sc_hd__or2_1
X_11890_ _03197_ _03198_ _03195_ _03196_ VGND VGND VPWR VPWR _03200_ sky130_fd_sc_hd__a211o_1
XFILLER_0_98_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10841_ _02023_ _02017_ _02022_ VGND VGND VPWR VPWR _02067_ sky130_fd_sc_hd__a21o_1
X_13560_ _05017_ _05020_ _05021_ VGND VGND VPWR VPWR _05022_ sky130_fd_sc_hd__nand3_1
XFILLER_0_66_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10772_ _01886_ _01887_ _01899_ VGND VGND VPWR VPWR _01998_ sky130_fd_sc_hd__and3_1
X_12511_ _03773_ _03873_ _03868_ _03870_ VGND VGND VPWR VPWR _03875_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_66_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13491_ _04841_ _04760_ VGND VGND VPWR VPWR _04947_ sky130_fd_sc_hd__or2b_1
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15230_ net186 net669 net676 net176 VGND VGND VPWR VPWR _06843_ sky130_fd_sc_hd__a22o_1
XFILLER_0_19_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12442_ _03797_ _03798_ VGND VGND VPWR VPWR _03799_ sky130_fd_sc_hd__nor2_1
XFILLER_0_136_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15161_ _06765_ net891 _06730_ VGND VGND VPWR VPWR _06768_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_62_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12373_ _03717_ _03718_ _03722_ VGND VGND VPWR VPWR _03724_ sky130_fd_sc_hd__a21o_1
X_14112_ _05620_ _05621_ VGND VGND VPWR VPWR _05622_ sky130_fd_sc_hd__xnor2_1
X_11324_ net785 net937 VGND VGND VPWR VPWR _02585_ sky130_fd_sc_hd__or2_1
X_15092_ _06688_ _06691_ VGND VGND VPWR VPWR _06692_ sky130_fd_sc_hd__xor2_2
XFILLER_0_120_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14043_ _05468_ _05469_ _05546_ VGND VGND VPWR VPWR _05548_ sky130_fd_sc_hd__a21oi_1
X_11255_ net707 net353 net509 net713 VGND VGND VPWR VPWR _02509_ sky130_fd_sc_hd__a22o_1
X_10206_ net131 _01456_ _01457_ _01458_ VGND VGND VPWR VPWR _00031_ sky130_fd_sc_hd__a31o_1
X_11186_ _02431_ _02432_ _02412_ VGND VGND VPWR VPWR _02434_ sky130_fd_sc_hd__a21oi_1
X_10137_ D_cos\[2\] _01398_ _01390_ _01386_ VGND VGND VPWR VPWR _01399_ sky130_fd_sc_hd__a211o_1
X_15994_ _07658_ _07674_ VGND VGND VPWR VPWR _07675_ sky130_fd_sc_hd__xnor2_1
X_10068_ _01280_ _01283_ _01281_ VGND VGND VPWR VPWR _01335_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14945_ net165 net541 _06531_ _06532_ VGND VGND VPWR VPWR _06533_ sky130_fd_sc_hd__a22o_1
XFILLER_0_82_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14876_ _06405_ _06455_ _06457_ VGND VGND VPWR VPWR _06458_ sky130_fd_sc_hd__or3b_1
XFILLER_0_15_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13827_ _05234_ _05235_ _05311_ VGND VGND VPWR VPWR _05313_ sky130_fd_sc_hd__nor3_1
XFILLER_0_9_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13758_ _05150_ _05158_ VGND VGND VPWR VPWR _05237_ sky130_fd_sc_hd__and2_1
XFILLER_0_128_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12709_ net199 net725 _04090_ _04091_ VGND VGND VPWR VPWR _04093_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_57_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13689_ _05141_ _05142_ _05160_ _05161_ VGND VGND VPWR VPWR _05162_ sky130_fd_sc_hd__o211a_1
XFILLER_0_73_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15428_ _07052_ _07058_ VGND VGND VPWR VPWR _07059_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15359_ _06783_ _06888_ _06784_ _06786_ VGND VGND VPWR VPWR _06984_ sky130_fd_sc_hd__or4b_4
XFILLER_0_143_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09920_ _01131_ _01130_ VGND VGND VPWR VPWR _01189_ sky130_fd_sc_hd__and2b_1
XFILLER_0_1_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout706 net2 VGND VGND VPWR VPWR net706 sky130_fd_sc_hd__clkbuf_2
X_09851_ _01074_ _01090_ VGND VGND VPWR VPWR _01121_ sky130_fd_sc_hd__nor2_1
Xfanout717 net719 VGND VGND VPWR VPWR net717 sky130_fd_sc_hd__clkbuf_4
Xfanout728 net18 VGND VGND VPWR VPWR net728 sky130_fd_sc_hd__buf_2
Xfanout739 net746 VGND VGND VPWR VPWR net739 sky130_fd_sc_hd__clkbuf_4
X_08802_ _08110_ _08111_ net868 _04437_ VGND VGND VPWR VPWR _08113_ sky130_fd_sc_hd__o211ai_2
X_09782_ _01051_ _01052_ VGND VGND VPWR VPWR _01053_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08733_ _03051_ _08043_ VGND VGND VPWR VPWR _08044_ sky130_fd_sc_hd__or2_1
XFILLER_0_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08664_ _07151_ _07390_ _07379_ VGND VGND VPWR VPWR _07835_ sky130_fd_sc_hd__and3_1
X_08595_ net604 net382 net369 net20 VGND VGND VPWR VPWR _07086_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_72_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09216_ _00488_ _00493_ VGND VGND VPWR VPWR _00494_ sky130_fd_sc_hd__xor2_2
XFILLER_0_146_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09147_ _00324_ _00326_ _00325_ VGND VGND VPWR VPWR _00426_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_17_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09078_ _00356_ _00354_ _00355_ VGND VGND VPWR VPWR _00358_ sky130_fd_sc_hd__or3_2
XFILLER_0_102_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11040_ _02208_ _02273_ _02274_ VGND VGND VPWR VPWR _02275_ sky130_fd_sc_hd__nand3_2
XFILLER_0_99_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12991_ net235 net246 net152 net331 VGND VGND VPWR VPWR _04402_ sky130_fd_sc_hd__a22oi_2
X_14730_ net814 net702 VGND VGND VPWR VPWR _06297_ sky130_fd_sc_hd__nand2_1
X_11942_ _03250_ _03254_ VGND VGND VPWR VPWR _03256_ sky130_fd_sc_hd__or2_1
XFILLER_0_99_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14661_ _06206_ _06211_ VGND VGND VPWR VPWR _06221_ sky130_fd_sc_hd__and2_1
X_11873_ _03093_ _03096_ _03179_ VGND VGND VPWR VPWR _03182_ sky130_fd_sc_hd__and3_1
X_16400_ clknet_4_5_0_clk _00113_ net339 VGND VGND VPWR VPWR Q_sin\[17\] sky130_fd_sc_hd__dfrtp_1
X_13612_ _05060_ _05077_ VGND VGND VPWR VPWR _05078_ sky130_fd_sc_hd__xnor2_1
X_10824_ _02047_ _02049_ VGND VGND VPWR VPWR _02050_ sky130_fd_sc_hd__nand2_1
X_14592_ _06139_ _06143_ _06144_ VGND VGND VPWR VPWR _06145_ sky130_fd_sc_hd__nand3_2
X_16331_ clknet_4_8_0_clk _00044_ net340 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__dfrtp_1
X_13543_ _05001_ _05002_ VGND VGND VPWR VPWR _05004_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10755_ _01875_ _01873_ _01874_ VGND VGND VPWR VPWR _01981_ sky130_fd_sc_hd__nand3_1
XFILLER_0_109_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16262_ _07854_ _07897_ VGND VGND VPWR VPWR _07964_ sky130_fd_sc_hd__nor2_1
X_13474_ _04921_ _04928_ VGND VGND VPWR VPWR _04929_ sky130_fd_sc_hd__xnor2_2
X_10686_ _01904_ _01905_ _01911_ VGND VGND VPWR VPWR _01912_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_82_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15213_ _06822_ _06823_ VGND VGND VPWR VPWR _06825_ sky130_fd_sc_hd__xor2_1
XFILLER_0_63_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12425_ net171 net790 VGND VGND VPWR VPWR _03781_ sky130_fd_sc_hd__nand2_1
X_16193_ _07883_ _07884_ VGND VGND VPWR VPWR _07890_ sky130_fd_sc_hd__and2b_1
XFILLER_0_124_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15144_ _06746_ _06747_ _06749_ VGND VGND VPWR VPWR _06750_ sky130_fd_sc_hd__and3_4
X_12356_ _03703_ _03704_ VGND VGND VPWR VPWR _03705_ sky130_fd_sc_hd__and2b_1
XFILLER_0_105_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11307_ _02563_ _02564_ _02470_ _02500_ VGND VGND VPWR VPWR _02566_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_10_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15075_ net820 _06673_ _06570_ _06572_ VGND VGND VPWR VPWR _06675_ sky130_fd_sc_hd__o211ai_2
X_12287_ _03620_ _03548_ _03630_ VGND VGND VPWR VPWR _03631_ sky130_fd_sc_hd__nor3_1
XFILLER_0_121_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14026_ _05527_ _05528_ VGND VGND VPWR VPWR _05529_ sky130_fd_sc_hd__nand2_1
X_11238_ _02285_ _02383_ VGND VGND VPWR VPWR _02491_ sky130_fd_sc_hd__or2b_4
X_11169_ net732 net740 net498 VGND VGND VPWR VPWR _02415_ sky130_fd_sc_hd__and3_1
X_15977_ _07492_ _07572_ VGND VGND VPWR VPWR _07656_ sky130_fd_sc_hd__nor2_1
XFILLER_0_26_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14928_ _06511_ _06512_ _06513_ VGND VGND VPWR VPWR _06514_ sky130_fd_sc_hd__a21o_1
XFILLER_0_78_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14859_ _06417_ _06435_ _06438_ VGND VGND VPWR VPWR _06439_ sky130_fd_sc_hd__nand3_1
XFILLER_0_89_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08380_ _04720_ _04709_ _04698_ _04665_ VGND VGND VPWR VPWR _04742_ sky130_fd_sc_hd__o211a_1
XFILLER_0_133_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09001_ _00194_ _00280_ _00281_ VGND VGND VPWR VPWR _00282_ sky130_fd_sc_hd__nand3_1
XFILLER_0_143_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09903_ _01171_ _01172_ VGND VGND VPWR VPWR _01173_ sky130_fd_sc_hd__and2_1
Xfanout503 net510 VGND VGND VPWR VPWR net503 sky130_fd_sc_hd__clkbuf_2
Xfanout514 net518 VGND VGND VPWR VPWR net514 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout525 net526 VGND VGND VPWR VPWR net525 sky130_fd_sc_hd__clkbuf_2
Xfanout536 net537 VGND VGND VPWR VPWR net536 sky130_fd_sc_hd__clkbuf_4
X_09834_ _01101_ _01102_ _01104_ VGND VGND VPWR VPWR _01105_ sky130_fd_sc_hd__and3_1
Xfanout547 net549 VGND VGND VPWR VPWR net547 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_67_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout558 net563 VGND VGND VPWR VPWR net558 sky130_fd_sc_hd__clkbuf_4
Xfanout569 net570 VGND VGND VPWR VPWR net569 sky130_fd_sc_hd__buf_4
X_09765_ _00959_ _00976_ _01036_ VGND VGND VPWR VPWR _01037_ sky130_fd_sc_hd__o21a_1
X_08716_ _05893_ _05959_ _08027_ VGND VGND VPWR VPWR _08028_ sky130_fd_sc_hd__and3_1
X_09696_ _00967_ _00968_ VGND VGND VPWR VPWR _00969_ sky130_fd_sc_hd__or2_1
Xrebuffer30 _06652_ VGND VGND VPWR VPWR net836 sky130_fd_sc_hd__clkbuf_1
Xrebuffer41 net846 VGND VGND VPWR VPWR net847 sky130_fd_sc_hd__clkbuf_1
Xrebuffer52 net857 VGND VGND VPWR VPWR net858 sky130_fd_sc_hd__clkbuf_1
X_08647_ _07586_ _07597_ _07640_ VGND VGND VPWR VPWR _07651_ sky130_fd_sc_hd__a21o_1
Xrebuffer63 _04178_ VGND VGND VPWR VPWR net869 sky130_fd_sc_hd__clkbuf_1
Xrebuffer74 _04818_ VGND VGND VPWR VPWR net880 sky130_fd_sc_hd__clkbuf_1
Xrebuffer85 _06766_ VGND VGND VPWR VPWR net891 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_95_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer96 _03105_ VGND VGND VPWR VPWR net902 sky130_fd_sc_hd__clkbuf_1
X_08578_ _05731_ _05817_ _05807_ VGND VGND VPWR VPWR _06900_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_77_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10540_ _01747_ _01754_ VGND VGND VPWR VPWR _01766_ sky130_fd_sc_hd__or2b_1
XFILLER_0_36_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10471_ net516 net440 VGND VGND VPWR VPWR _01697_ sky130_fd_sc_hd__and2_1
XFILLER_0_106_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12210_ _03350_ _03546_ VGND VGND VPWR VPWR _03547_ sky130_fd_sc_hd__and2_1
XFILLER_0_103_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13190_ _04616_ _04617_ _04618_ VGND VGND VPWR VPWR _04619_ sky130_fd_sc_hd__nand3_2
XFILLER_0_32_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_795 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12141_ _03423_ _03426_ VGND VGND VPWR VPWR _03472_ sky130_fd_sc_hd__or2_1
X_12072_ _03237_ _03317_ VGND VGND VPWR VPWR _03398_ sky130_fd_sc_hd__nor2_1
X_15900_ _07403_ _07490_ _07489_ VGND VGND VPWR VPWR _07572_ sky130_fd_sc_hd__o21a_1
X_11023_ _02253_ _02254_ _02252_ VGND VGND VPWR VPWR _02257_ sky130_fd_sc_hd__o21ai_1
X_15831_ _07282_ _07409_ _07279_ VGND VGND VPWR VPWR _07497_ sky130_fd_sc_hd__a21o_1
X_15762_ _07316_ _07421_ VGND VGND VPWR VPWR _07422_ sky130_fd_sc_hd__nand2_1
X_12974_ _04285_ _04287_ VGND VGND VPWR VPWR _04384_ sky130_fd_sc_hd__nand2_1
X_14713_ _06272_ _06277_ VGND VGND VPWR VPWR _06279_ sky130_fd_sc_hd__xor2_1
X_11925_ _03085_ _03070_ _03162_ VGND VGND VPWR VPWR _03239_ sky130_fd_sc_hd__o21ai_2
X_15693_ _07345_ _07346_ VGND VGND VPWR VPWR _07348_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_648 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14644_ _05934_ _05935_ _05936_ VGND VGND VPWR VPWR _06203_ sky130_fd_sc_hd__and3_1
X_11856_ _03084_ _03163_ VGND VGND VPWR VPWR _03164_ sky130_fd_sc_hd__xor2_1
XFILLER_0_74_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10807_ _02031_ _02032_ VGND VGND VPWR VPWR _02033_ sky130_fd_sc_hd__xor2_1
X_14575_ net326 net241 net537 net543 VGND VGND VPWR VPWR _06127_ sky130_fd_sc_hd__and4_1
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11787_ _02997_ _02999_ VGND VGND VPWR VPWR _03088_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16314_ clknet_4_8_0_clk _00027_ net340 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_137_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10738_ _01962_ _01963_ net770 net391 VGND VGND VPWR VPWR _01964_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_103_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13526_ net706 net712 net295 net284 VGND VGND VPWR VPWR _04985_ sky130_fd_sc_hd__and4_1
XFILLER_0_43_718 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16245_ _07823_ _07942_ _07943_ _07698_ _07946_ VGND VGND VPWR VPWR _07947_ sky130_fd_sc_hd__o221ai_4
X_13457_ net514 net167 _04811_ _04810_ net185 VGND VGND VPWR VPWR _04910_ sky130_fd_sc_hd__a32o_1
X_10669_ net786 net362 VGND VGND VPWR VPWR _01895_ sky130_fd_sc_hd__nand2_1
XFILLER_0_113_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_124_Right_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12408_ _03752_ _03760_ _03761_ VGND VGND VPWR VPWR _03762_ sky130_fd_sc_hd__nand3_1
X_16176_ _07852_ _07871_ VGND VGND VPWR VPWR _07872_ sky130_fd_sc_hd__xor2_1
X_13388_ _04833_ _04834_ VGND VGND VPWR VPWR _04835_ sky130_fd_sc_hd__or2_1
Xoutput106 net106 VGND VGND VPWR VPWR beta[17] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_23_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput117 net117 VGND VGND VPWR VPWR done sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15127_ _06637_ _06656_ _06657_ VGND VGND VPWR VPWR _06731_ sky130_fd_sc_hd__nand3_1
X_12339_ _03679_ _03686_ VGND VGND VPWR VPWR _03687_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15058_ _06653_ _06654_ _06655_ VGND VGND VPWR VPWR _06656_ sky130_fd_sc_hd__nand3_2
X_14009_ _05509_ VGND VGND VPWR VPWR _05510_ sky130_fd_sc_hd__inv_2
X_09550_ Q_cos\[9\] _00824_ _00661_ VGND VGND VPWR VPWR _00825_ sky130_fd_sc_hd__mux2_1
X_08501_ net595 net387 VGND VGND VPWR VPWR _06058_ sky130_fd_sc_hd__nand2_1
X_09481_ _00754_ _00755_ VGND VGND VPWR VPWR _00756_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08432_ _05242_ _05275_ _05286_ _05297_ VGND VGND VPWR VPWR _05308_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_148_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08363_ net543 net417 VGND VGND VPWR VPWR _04556_ sky130_fd_sc_hd__nand2_1
XFILLER_0_46_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08294_ net939 _03756_ _03453_ _03420_ VGND VGND VPWR VPWR _03800_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_74_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_131_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout300 net303 VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__buf_4
Xfanout311 net312 VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_10_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout322 net59 VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__clkbuf_4
Xfanout333 net334 VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__buf_4
Xfanout344 net345 VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__clkbuf_4
Xfanout355 net57 VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__buf_8
Xfanout366 net372 VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__buf_4
X_09817_ _01082_ _00990_ _01086_ VGND VGND VPWR VPWR _01088_ sky130_fd_sc_hd__nor3_1
Xfanout377 net382 VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__clkbuf_4
Xfanout388 net391 VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__clkbuf_2
Xfanout399 net935 VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__clkbuf_4
X_09748_ _00940_ _00945_ VGND VGND VPWR VPWR _01020_ sky130_fd_sc_hd__and2b_1
XFILLER_0_69_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09679_ _00948_ _00951_ VGND VGND VPWR VPWR _00952_ sky130_fd_sc_hd__xnor2_1
X_11710_ _03002_ _03003_ VGND VGND VPWR VPWR _03004_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12690_ _04059_ _04060_ _04071_ VGND VGND VPWR VPWR _04072_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_65_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11641_ _02925_ _02928_ VGND VGND VPWR VPWR _02929_ sky130_fd_sc_hd__xor2_2
XFILLER_0_92_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14360_ _05887_ _05889_ VGND VGND VPWR VPWR _05890_ sky130_fd_sc_hd__nor2_1
XFILLER_0_64_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11572_ net522 net394 net796 VGND VGND VPWR VPWR _02854_ sky130_fd_sc_hd__o21a_1
XFILLER_0_65_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_107_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13311_ _04748_ _04750_ VGND VGND VPWR VPWR _04751_ sky130_fd_sc_hd__xnor2_2
Xinput19 D[9] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_91_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10523_ net741 net361 VGND VGND VPWR VPWR _01749_ sky130_fd_sc_hd__nand2_1
X_14291_ _05792_ _05790_ VGND VGND VPWR VPWR _05815_ sky130_fd_sc_hd__and2b_1
XFILLER_0_150_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16030_ _07711_ _07712_ VGND VGND VPWR VPWR _07713_ sky130_fd_sc_hd__xnor2_1
X_13242_ _04580_ _04582_ VGND VGND VPWR VPWR _04675_ sky130_fd_sc_hd__nand2_1
X_10454_ net801 net470 VGND VGND VPWR VPWR _01680_ sky130_fd_sc_hd__nand2_1
XFILLER_0_150_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13173_ _04591_ _04599_ VGND VGND VPWR VPWR _04601_ sky130_fd_sc_hd__xor2_2
XFILLER_0_0_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10385_ _01612_ VGND VGND VPWR VPWR _00056_ sky130_fd_sc_hd__clkbuf_1
X_12124_ _03451_ _03452_ VGND VGND VPWR VPWR _03455_ sky130_fd_sc_hd__and2_1
X_12055_ _03345_ _03346_ _03379_ VGND VGND VPWR VPWR _03380_ sky130_fd_sc_hd__a21o_1
X_11006_ net707 net381 net371 net715 VGND VGND VPWR VPWR _02238_ sky130_fd_sc_hd__a22o_1
X_15814_ _07385_ _07388_ _07386_ VGND VGND VPWR VPWR _07479_ sky130_fd_sc_hd__o21ba_1
X_15745_ _07402_ _07403_ VGND VGND VPWR VPWR _07404_ sky130_fd_sc_hd__nor2_2
XFILLER_0_87_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12957_ _04363_ _04364_ VGND VGND VPWR VPWR _04365_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11908_ _03204_ _03219_ VGND VGND VPWR VPWR _03220_ sky130_fd_sc_hd__xnor2_2
X_15676_ _04539_ net566 _07208_ _07328_ VGND VGND VPWR VPWR _07329_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12888_ _04288_ _04289_ VGND VGND VPWR VPWR _04290_ sky130_fd_sc_hd__and2b_1
XFILLER_0_23_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14627_ _06182_ _06183_ VGND VGND VPWR VPWR _06184_ sky130_fd_sc_hd__xnor2_1
X_11839_ _03049_ _03052_ _03144_ VGND VGND VPWR VPWR _03145_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_7_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_876 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_128_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14558_ _06087_ _06106_ _06107_ VGND VGND VPWR VPWR _06108_ sky130_fd_sc_hd__and3_1
XFILLER_0_15_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13509_ net730 net738 net267 net257 VGND VGND VPWR VPWR _04966_ sky130_fd_sc_hd__and4_1
X_14489_ _06028_ _06029_ _06030_ _06031_ VGND VGND VPWR VPWR _06032_ sky130_fd_sc_hd__a211o_1
XFILLER_0_113_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16228_ _07914_ _07915_ _07927_ VGND VGND VPWR VPWR _07928_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_130_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16159_ _07796_ _07799_ VGND VGND VPWR VPWR _07853_ sky130_fd_sc_hd__nor2_1
XFILLER_0_140_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_39_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08981_ _00259_ _00260_ _00253_ VGND VGND VPWR VPWR _00262_ sky130_fd_sc_hd__a21o_1
XFILLER_0_139_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09602_ _00790_ _00793_ _00791_ VGND VGND VPWR VPWR _00876_ sky130_fd_sc_hd__o21ba_1
X_09533_ _00783_ _00784_ _00806_ VGND VGND VPWR VPWR _00808_ sky130_fd_sc_hd__o21a_1
XFILLER_0_3_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09464_ _00683_ _00669_ VGND VGND VPWR VPWR _00739_ sky130_fd_sc_hd__and2b_1
XFILLER_0_148_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08415_ _05101_ _05112_ VGND VGND VPWR VPWR _05123_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09395_ net538 net456 net447 net546 VGND VGND VPWR VPWR _00671_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_93_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08346_ _04338_ net840 net849 VGND VGND VPWR VPWR _04371_ sky130_fd_sc_hd__nand3_4
XFILLER_0_34_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08277_ _03214_ _03268_ _03203_ VGND VGND VPWR VPWR _03615_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_61_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10170_ D_cos\[8\] Q_sin\[8\] VGND VGND VPWR VPWR _01427_ sky130_fd_sc_hd__or2b_1
XFILLER_0_100_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout130 net131 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_100_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout141 net142 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__clkbuf_4
Xfanout152 net154 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__buf_4
Xfanout163 net164 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__buf_2
Xfanout174 net176 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__clkbuf_4
Xfanout185 net186 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__buf_2
Xfanout196 net73 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__buf_2
X_13860_ _05262_ _05347_ VGND VGND VPWR VPWR _05348_ sky130_fd_sc_hd__xor2_4
X_12811_ _04101_ _04109_ VGND VGND VPWR VPWR _04205_ sky130_fd_sc_hd__or2b_4
X_13791_ _05257_ _05258_ _05272_ VGND VGND VPWR VPWR _05273_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_57_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15530_ _07039_ _07067_ _07169_ VGND VGND VPWR VPWR _07170_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_96_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12742_ net294 net784 net801 net283 VGND VGND VPWR VPWR _04129_ sky130_fd_sc_hd__a22oi_1
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15461_ _06997_ _07015_ _07093_ VGND VGND VPWR VPWR _07094_ sky130_fd_sc_hd__a21bo_1
X_12673_ net199 net736 _04050_ _04051_ VGND VGND VPWR VPWR _04054_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_139_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14412_ net210 net200 net695 net535 VGND VGND VPWR VPWR _05947_ sky130_fd_sc_hd__and4_1
X_11624_ _02908_ _02910_ VGND VGND VPWR VPWR _02911_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_108_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15392_ net287 net533 net846 net278 VGND VGND VPWR VPWR _07019_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_65_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14343_ net300 net592 VGND VGND VPWR VPWR _05872_ sky130_fd_sc_hd__nand2_1
X_11555_ _02834_ _02835_ VGND VGND VPWR VPWR _02836_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_107_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_775 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10506_ _01729_ _01730_ _01731_ VGND VGND VPWR VPWR _01732_ sky130_fd_sc_hd__or3_1
XFILLER_0_69_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14274_ _05795_ _05793_ VGND VGND VPWR VPWR _05798_ sky130_fd_sc_hd__and2b_1
XFILLER_0_12_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11486_ net515 net359 _02658_ _02657_ net382 VGND VGND VPWR VPWR _02761_ sky130_fd_sc_hd__a32o_1
XFILLER_0_40_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16013_ _07548_ VGND VGND VPWR VPWR _07696_ sky130_fd_sc_hd__inv_2
X_13225_ net766 net258 VGND VGND VPWR VPWR _04657_ sky130_fd_sc_hd__nand2_1
X_10437_ _01660_ _01662_ VGND VGND VPWR VPWR _01663_ sky130_fd_sc_hd__nor2_1
XFILLER_0_122_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13156_ _04572_ _04580_ _04581_ VGND VGND VPWR VPWR _04582_ sky130_fd_sc_hd__nand3_1
X_10368_ _01590_ _01596_ _01597_ VGND VGND VPWR VPWR _01598_ sky130_fd_sc_hd__o21ai_1
X_12107_ _03361_ _03370_ _03368_ VGND VGND VPWR VPWR _03436_ sky130_fd_sc_hd__a21o_1
X_13087_ _04503_ _04504_ _04505_ VGND VGND VPWR VPWR _04507_ sky130_fd_sc_hd__a21o_1
X_10299_ Q_cos\[7\] D_sin\[7\] VGND VGND VPWR VPWR _01538_ sky130_fd_sc_hd__or2b_1
X_12038_ _03359_ _03360_ VGND VGND VPWR VPWR _03361_ sky130_fd_sc_hd__nor2_1
X_13989_ _05486_ _05487_ VGND VGND VPWR VPWR _05488_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15728_ net304 net649 net639 net155 VGND VGND VPWR VPWR _07385_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_88_798 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15659_ net297 net665 VGND VGND VPWR VPWR _07310_ sky130_fd_sc_hd__nand2_1
XFILLER_0_146_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08200_ net554 net378 net369 net558 VGND VGND VPWR VPWR _02779_ sky130_fd_sc_hd__a22oi_2
X_09180_ _00432_ _00458_ VGND VGND VPWR VPWR _00459_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08964_ _00240_ _00243_ _00244_ VGND VGND VPWR VPWR _00245_ sky130_fd_sc_hd__and3_1
X_08895_ net854 _08114_ _00175_ _00176_ VGND VGND VPWR VPWR _00177_ sky130_fd_sc_hd__a211o_1
X_09516_ net530 net538 net456 net447 VGND VGND VPWR VPWR _00791_ sky130_fd_sc_hd__and4_1
XFILLER_0_78_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09447_ _00721_ _00722_ VGND VGND VPWR VPWR _00723_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09378_ _00654_ VGND VGND VPWR VPWR _00655_ sky130_fd_sc_hd__buf_1
XFILLER_0_93_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08329_ _04086_ _04174_ VGND VGND VPWR VPWR _04185_ sky130_fd_sc_hd__xor2_1
XFILLER_0_117_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11340_ D_cos\[4\] _02601_ _01379_ VGND VGND VPWR VPWR _02602_ sky130_fd_sc_hd__mux2_1
XFILLER_0_61_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11271_ _02442_ _02444_ VGND VGND VPWR VPWR _02526_ sky130_fd_sc_hd__nand2_1
XFILLER_0_132_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13010_ _04356_ _04421_ _04422_ VGND VGND VPWR VPWR _04423_ sky130_fd_sc_hd__nand3_2
XFILLER_0_132_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10222_ net84 _01472_ net130 VGND VGND VPWR VPWR _01473_ sky130_fd_sc_hd__mux2_1
XFILLER_0_120_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10153_ _01411_ _01412_ VGND VGND VPWR VPWR _01413_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10084_ _01304_ _01326_ _01324_ VGND VGND VPWR VPWR _01350_ sky130_fd_sc_hd__a21oi_1
X_14961_ _06094_ _06096_ _06095_ VGND VGND VPWR VPWR _06550_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_55_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13912_ _05404_ VGND VGND VPWR VPWR _00088_ sky130_fd_sc_hd__clkbuf_1
X_14892_ _06233_ _06232_ VGND VGND VPWR VPWR _06475_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13843_ _05327_ _05328_ VGND VGND VPWR VPWR _05330_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10986_ net774 net471 VGND VGND VPWR VPWR _02216_ sky130_fd_sc_hd__nand2_1
X_13774_ _05238_ _05239_ _05254_ VGND VGND VPWR VPWR _05255_ sky130_fd_sc_hd__a21o_1
XFILLER_0_97_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15513_ _07054_ _07057_ _07055_ VGND VGND VPWR VPWR _07152_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_84_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12725_ _04099_ _04100_ _04110_ VGND VGND VPWR VPWR _04111_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_84_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15444_ _07074_ _07076_ VGND VGND VPWR VPWR _07077_ sky130_fd_sc_hd__xor2_1
XFILLER_0_26_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12656_ _04033_ _04034_ VGND VGND VPWR VPWR _04035_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_37_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11607_ _02890_ _02892_ VGND VGND VPWR VPWR _02893_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15375_ net265 net555 net565 net932 VGND VGND VPWR VPWR _07001_ sky130_fd_sc_hd__a22oi_2
X_12587_ net328 net243 net616 net709 VGND VGND VPWR VPWR _03959_ sky130_fd_sc_hd__nand4_1
XFILLER_0_20_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14326_ net213 net203 net544 net552 VGND VGND VPWR VPWR _05853_ sky130_fd_sc_hd__and4_1
XFILLER_0_53_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11538_ _02810_ _02816_ VGND VGND VPWR VPWR _02817_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_111_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmax_cap127 _02411_ VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__buf_1
XFILLER_0_150_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11469_ net713 net491 net480 net722 VGND VGND VPWR VPWR _02742_ sky130_fd_sc_hd__a22oi_1
X_14257_ _05777_ _05778_ VGND VGND VPWR VPWR _05779_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13208_ _04541_ _04637_ _04638_ VGND VGND VPWR VPWR _04639_ sky130_fd_sc_hd__nand3_1
XFILLER_0_21_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14188_ _05694_ _05703_ VGND VGND VPWR VPWR _05704_ sky130_fd_sc_hd__xnor2_1
X_13139_ _04561_ _04562_ VGND VGND VPWR VPWR _04563_ sky130_fd_sc_hd__xor2_1
X_08680_ _07933_ _07965_ VGND VGND VPWR VPWR _07992_ sky130_fd_sc_hd__xor2_1
XFILLER_0_88_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09301_ net546 net556 net458 net449 VGND VGND VPWR VPWR _00578_ sky130_fd_sc_hd__and4_1
XFILLER_0_119_804 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09232_ net546 net469 VGND VGND VPWR VPWR _00510_ sky130_fd_sc_hd__nand2_1
XFILLER_0_146_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09163_ _00433_ _00441_ VGND VGND VPWR VPWR _00442_ sky130_fd_sc_hd__xor2_2
XFILLER_0_134_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09094_ _00315_ _00372_ _00373_ VGND VGND VPWR VPWR _00374_ sky130_fd_sc_hd__and3_1
XFILLER_0_4_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09996_ _01202_ _01257_ _01263_ VGND VGND VPWR VPWR _01264_ sky130_fd_sc_hd__nor3_1
XFILLER_0_86_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08947_ _00123_ _00125_ _00124_ VGND VGND VPWR VPWR _00228_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_99_816 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08878_ _00157_ _00158_ _00159_ VGND VGND VPWR VPWR _00160_ sky130_fd_sc_hd__nand3_1
XFILLER_0_99_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_702 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10840_ _02058_ _02064_ _02065_ VGND VGND VPWR VPWR _02066_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_79_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10771_ _01886_ _01887_ _01899_ VGND VGND VPWR VPWR _01997_ sky130_fd_sc_hd__a21oi_1
X_12510_ _03868_ _03870_ _03773_ _03873_ VGND VGND VPWR VPWR _03874_ sky130_fd_sc_hd__a211o_1
X_13490_ _04860_ _04945_ VGND VGND VPWR VPWR _04946_ sky130_fd_sc_hd__xor2_2
XFILLER_0_136_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_109_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12441_ net217 net207 net745 net755 VGND VGND VPWR VPWR _03798_ sky130_fd_sc_hd__and4_1
XFILLER_0_35_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15160_ _06730_ _06765_ _06766_ VGND VGND VPWR VPWR _06767_ sky130_fd_sc_hd__or3_4
X_12372_ _03719_ _03720_ _03721_ VGND VGND VPWR VPWR _03722_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_23_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11323_ _02579_ _02582_ VGND VGND VPWR VPWR _02584_ sky130_fd_sc_hd__xor2_2
X_14111_ _05540_ _05544_ _05541_ VGND VGND VPWR VPWR _05621_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_133_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15091_ _06689_ _06690_ VGND VGND VPWR VPWR _06691_ sky130_fd_sc_hd__nand2_1
Xclkbuf_4_0_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_0_0_clk sky130_fd_sc_hd__clkbuf_8
XFILLER_0_120_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_668 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11254_ _02505_ _02507_ VGND VGND VPWR VPWR _02508_ sky130_fd_sc_hd__xor2_1
X_14042_ _05470_ _05473_ VGND VGND VPWR VPWR _05546_ sky130_fd_sc_hd__nor2_1
XFILLER_0_120_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10205_ net131 net82 VGND VGND VPWR VPWR _01458_ sky130_fd_sc_hd__and2b_1
XFILLER_0_120_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11185_ _02412_ _02431_ _02432_ VGND VGND VPWR VPWR _02433_ sky130_fd_sc_hd__and3_1
XFILLER_0_101_792 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10136_ Q_sin\[2\] VGND VGND VPWR VPWR _01398_ sky130_fd_sc_hd__inv_2
X_15993_ _07665_ _07672_ VGND VGND VPWR VPWR _07674_ sky130_fd_sc_hd__xnor2_1
X_10067_ _01331_ _01333_ VGND VGND VPWR VPWR _01334_ sky130_fd_sc_hd__xnor2_1
X_14944_ net183 net173 net693 net534 VGND VGND VPWR VPWR _06532_ sky130_fd_sc_hd__nand4_2
XFILLER_0_89_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14875_ _06401_ _06456_ VGND VGND VPWR VPWR _06457_ sky130_fd_sc_hd__and2_1
XFILLER_0_15_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13826_ _05234_ _05235_ _05311_ VGND VGND VPWR VPWR _05312_ sky130_fd_sc_hd__o21a_1
XFILLER_0_147_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13757_ _05157_ _05156_ VGND VGND VPWR VPWR _05236_ sky130_fd_sc_hd__and2b_1
X_10969_ net785 net462 net452 net801 VGND VGND VPWR VPWR _02197_ sky130_fd_sc_hd__a22o_1
X_12708_ _04090_ _04091_ net199 net725 VGND VGND VPWR VPWR _04092_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_17_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13688_ _05143_ _05145_ _05159_ VGND VGND VPWR VPWR _05161_ sky130_fd_sc_hd__nand3_1
XFILLER_0_122_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15427_ _07056_ _07057_ VGND VGND VPWR VPWR _07058_ sky130_fd_sc_hd__xor2_1
X_12639_ _04012_ _04013_ _04015_ VGND VGND VPWR VPWR _04016_ sky130_fd_sc_hd__or3_1
XFILLER_0_31_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15358_ _06783_ _06784_ _06982_ _06888_ VGND VGND VPWR VPWR _06983_ sky130_fd_sc_hd__or4_4
XFILLER_0_86_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14309_ _05816_ _05834_ VGND VGND VPWR VPWR _05835_ sky130_fd_sc_hd__xnor2_1
X_15289_ _06905_ _06906_ VGND VGND VPWR VPWR _06907_ sky130_fd_sc_hd__xor2_2
XFILLER_0_1_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09850_ _01060_ _01061_ _01119_ VGND VGND VPWR VPWR _01120_ sky130_fd_sc_hd__o21ai_2
Xfanout707 net708 VGND VGND VPWR VPWR net707 sky130_fd_sc_hd__clkbuf_4
Xfanout718 net719 VGND VGND VPWR VPWR net718 sky130_fd_sc_hd__clkbuf_2
Xfanout729 net731 VGND VGND VPWR VPWR net729 sky130_fd_sc_hd__clkbuf_4
X_08801_ net812 _04437_ _08110_ _08111_ VGND VGND VPWR VPWR _08112_ sky130_fd_sc_hd__a211o_1
X_09781_ net680 net441 VGND VGND VPWR VPWR _01052_ sky130_fd_sc_hd__nand2_1
X_08732_ net602 net449 VGND VGND VPWR VPWR _08043_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08663_ _07716_ _07814_ VGND VGND VPWR VPWR _07825_ sky130_fd_sc_hd__or2_1
XFILLER_0_96_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08594_ _06966_ _07064_ VGND VGND VPWR VPWR _07075_ sky130_fd_sc_hd__and2b_1
XFILLER_0_72_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_138_Right_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09215_ _00491_ _00492_ VGND VGND VPWR VPWR _00493_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_63_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09146_ _00421_ _00422_ _00423_ VGND VGND VPWR VPWR _00425_ sky130_fd_sc_hd__nand3_1
XFILLER_0_16_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09077_ _00354_ _00355_ _00356_ VGND VGND VPWR VPWR _00357_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_102_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09979_ _01071_ _01246_ VGND VGND VPWR VPWR _01247_ sky130_fd_sc_hd__and2_1
XFILLER_0_99_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12990_ net331 net235 net242 net152 VGND VGND VPWR VPWR _04401_ sky130_fd_sc_hd__and4_1
X_11941_ _03250_ _03254_ VGND VGND VPWR VPWR _03255_ sky130_fd_sc_hd__and2_1
X_14660_ _06209_ _06210_ VGND VGND VPWR VPWR _06220_ sky130_fd_sc_hd__and2b_1
X_11872_ _03093_ _03096_ _03179_ VGND VGND VPWR VPWR _03180_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_95_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13611_ _05061_ _05076_ VGND VGND VPWR VPWR _05077_ sky130_fd_sc_hd__xor2_1
X_10823_ _02040_ _02047_ _02048_ VGND VGND VPWR VPWR _02049_ sky130_fd_sc_hd__nand3_1
X_14591_ _06127_ _06126_ _06125_ VGND VGND VPWR VPWR _06144_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_105_Right_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16330_ clknet_4_8_0_clk _00043_ net340 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_27_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13542_ _04999_ _05000_ _04982_ VGND VGND VPWR VPWR _05002_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_82_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10754_ _01883_ _01877_ _01882_ VGND VGND VPWR VPWR _01980_ sky130_fd_sc_hd__nand3_1
XFILLER_0_39_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16261_ _07801_ _07919_ _07793_ VGND VGND VPWR VPWR _07963_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_70_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10685_ _01909_ _01910_ VGND VGND VPWR VPWR _01911_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_109_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13473_ _04925_ _04926_ VGND VGND VPWR VPWR _04928_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15212_ net273 net565 VGND VGND VPWR VPWR _06823_ sky130_fd_sc_hd__nand2_1
X_12424_ _03748_ _03751_ _03749_ VGND VGND VPWR VPWR _03780_ sky130_fd_sc_hd__o21ba_1
X_16192_ _07888_ VGND VGND VPWR VPWR _00112_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_22_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15143_ _06643_ net836 _06651_ VGND VGND VPWR VPWR _06749_ sky130_fd_sc_hd__a21bo_1
X_12355_ net216 net763 net772 net206 VGND VGND VPWR VPWR _03704_ sky130_fd_sc_hd__a22o_1
X_11306_ _02470_ _02500_ _02563_ _02564_ VGND VGND VPWR VPWR _02565_ sky130_fd_sc_hd__o211a_2
XFILLER_0_121_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15074_ _06570_ _06572_ _06671_ _06673_ VGND VGND VPWR VPWR _06674_ sky130_fd_sc_hd__a211o_1
X_12286_ _03350_ _03629_ VGND VGND VPWR VPWR _03630_ sky130_fd_sc_hd__xor2_1
XFILLER_0_120_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11237_ _02488_ _02489_ VGND VGND VPWR VPWR _02490_ sky130_fd_sc_hd__nor2_1
X_14025_ _05524_ _05526_ net298 net138 VGND VGND VPWR VPWR _05528_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_120_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11168_ net747 net480 VGND VGND VPWR VPWR _02414_ sky130_fd_sc_hd__and2_1
X_10119_ _01382_ _01383_ state net918 VGND VGND VPWR VPWR _00019_ sky130_fd_sc_hd__o2bb2a_1
X_15976_ _07556_ _07563_ _07654_ VGND VGND VPWR VPWR _07655_ sky130_fd_sc_hd__a21oi_1
X_11099_ _02334_ _02337_ _02338_ VGND VGND VPWR VPWR _02339_ sky130_fd_sc_hd__and3_1
XFILLER_0_117_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14927_ net300 net566 VGND VGND VPWR VPWR _06513_ sky130_fd_sc_hd__and2_1
XFILLER_0_89_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14858_ net222 net700 _06436_ _06437_ VGND VGND VPWR VPWR _06438_ sky130_fd_sc_hd__a31o_1
XFILLER_0_89_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_11_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_133_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13809_ _05198_ _05197_ VGND VGND VPWR VPWR _05293_ sky130_fd_sc_hd__and2b_1
XFILLER_0_147_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_852 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14789_ _06338_ _06339_ _06356_ _06361_ VGND VGND VPWR VPWR _06362_ sky130_fd_sc_hd__a211o_1
XFILLER_0_18_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_143_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09000_ _00278_ _00279_ _00177_ _00179_ VGND VGND VPWR VPWR _00281_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_131_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_20_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09902_ _01100_ _01118_ _01170_ VGND VGND VPWR VPWR _01172_ sky130_fd_sc_hd__or3_1
XFILLER_0_6_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout504 net505 VGND VGND VPWR VPWR net504 sky130_fd_sc_hd__buf_6
Xfanout515 net518 VGND VGND VPWR VPWR net515 sky130_fd_sc_hd__clkbuf_4
Xfanout526 net39 VGND VGND VPWR VPWR net526 sky130_fd_sc_hd__clkbuf_4
Xfanout537 net38 VGND VGND VPWR VPWR net537 sky130_fd_sc_hd__clkbuf_4
X_09833_ _01029_ _01030_ _01032_ _01103_ VGND VGND VPWR VPWR _01104_ sky130_fd_sc_hd__a31o_1
Xfanout548 net549 VGND VGND VPWR VPWR net548 sky130_fd_sc_hd__buf_4
Xfanout559 net563 VGND VGND VPWR VPWR net559 sky130_fd_sc_hd__buf_2
X_09764_ _01033_ _01035_ VGND VGND VPWR VPWR _01036_ sky130_fd_sc_hd__xnor2_1
X_08715_ _06014_ _06998_ VGND VGND VPWR VPWR _08027_ sky130_fd_sc_hd__nand2_1
X_09695_ _00900_ _00966_ VGND VGND VPWR VPWR _00968_ sky130_fd_sc_hd__nor2_1
Xrebuffer20 _06119_ VGND VGND VPWR VPWR net826 sky130_fd_sc_hd__buf_6
XFILLER_0_96_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer31 _06652_ VGND VGND VPWR VPWR net837 sky130_fd_sc_hd__clkbuf_1
Xrebuffer42 _03214_ VGND VGND VPWR VPWR net848 sky130_fd_sc_hd__clkbuf_1
Xrebuffer53 _08105_ VGND VGND VPWR VPWR net859 sky130_fd_sc_hd__clkbuf_1
X_08646_ _07608_ _07619_ _07629_ VGND VGND VPWR VPWR _07640_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_68_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer64 _06620_ VGND VGND VPWR VPWR net870 sky130_fd_sc_hd__clkbuf_1
Xrebuffer75 _04064_ VGND VGND VPWR VPWR net881 sky130_fd_sc_hd__buf_1
XFILLER_0_89_690 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer86 net891 VGND VGND VPWR VPWR net892 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_139_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer97 _04279_ VGND VGND VPWR VPWR net903 sky130_fd_sc_hd__buf_1
X_08577_ _06617_ _06857_ _06879_ _06650_ VGND VGND VPWR VPWR _06890_ sky130_fd_sc_hd__o211a_1
XFILLER_0_76_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer110 _02441_ VGND VGND VPWR VPWR net949 sky130_fd_sc_hd__dlymetal6s2s_1
X_10470_ net616 net709 net420 net412 VGND VGND VPWR VPWR _01696_ sky130_fd_sc_hd__nand4_1
XFILLER_0_32_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09129_ _00405_ _00407_ VGND VGND VPWR VPWR _00408_ sky130_fd_sc_hd__xnor2_1
X_12140_ _03466_ _03463_ VGND VGND VPWR VPWR _03471_ sky130_fd_sc_hd__or2b_1
XFILLER_0_102_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12071_ _03395_ _03396_ VGND VGND VPWR VPWR _03397_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11022_ _02252_ _02253_ _02254_ VGND VGND VPWR VPWR _02255_ sky130_fd_sc_hd__or3_1
X_15830_ _07282_ _07495_ VGND VGND VPWR VPWR _07496_ sky130_fd_sc_hd__xnor2_1
X_15761_ _07318_ VGND VGND VPWR VPWR _07421_ sky130_fd_sc_hd__inv_2
XFILLER_0_63_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12973_ _04291_ _04310_ _04311_ VGND VGND VPWR VPWR _04383_ sky130_fd_sc_hd__nand3_2
X_14712_ _06273_ _06276_ VGND VGND VPWR VPWR _06277_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11924_ _03072_ _03163_ VGND VGND VPWR VPWR _03238_ sky130_fd_sc_hd__or2_1
XFILLER_0_87_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15692_ _07343_ _07344_ VGND VGND VPWR VPWR _07346_ sky130_fd_sc_hd__or2_1
X_14643_ _05934_ _05935_ _05936_ VGND VGND VPWR VPWR _06202_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_86_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11855_ _03085_ _03162_ VGND VGND VPWR VPWR _03163_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_68_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10806_ net786 net802 net379 net370 VGND VGND VPWR VPWR _02032_ sky130_fd_sc_hd__and4_1
X_14574_ net326 net536 net543 net241 VGND VGND VPWR VPWR _06126_ sky130_fd_sc_hd__a22oi_2
X_11786_ _02990_ _02991_ VGND VGND VPWR VPWR _03087_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16313_ clknet_4_14_0_clk _00026_ net342 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_138_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13525_ net706 net295 net284 net714 VGND VGND VPWR VPWR _04984_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_125_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10737_ net726 net527 net401 net761 VGND VGND VPWR VPWR _01963_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_12_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16244_ _07945_ _07829_ _07885_ VGND VGND VPWR VPWR _07946_ sky130_fd_sc_hd__o21ai_2
X_13456_ _04888_ _04908_ VGND VGND VPWR VPWR _04909_ sky130_fd_sc_hd__xor2_2
X_10668_ _01888_ _01893_ VGND VGND VPWR VPWR _01894_ sky130_fd_sc_hd__xor2_1
XFILLER_0_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12407_ _03757_ _03759_ _03758_ VGND VGND VPWR VPWR _03761_ sky130_fd_sc_hd__a21o_1
XFILLER_0_140_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16175_ _07869_ _07870_ VGND VGND VPWR VPWR _07871_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10599_ _01759_ _01760_ _01761_ _01689_ VGND VGND VPWR VPWR _01825_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_106_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13387_ _04806_ _04832_ VGND VGND VPWR VPWR _04834_ sky130_fd_sc_hd__nor2_1
Xoutput107 net107 VGND VGND VPWR VPWR beta[18] sky130_fd_sc_hd__clkbuf_4
X_15126_ _06728_ _06729_ VGND VGND VPWR VPWR _06730_ sky130_fd_sc_hd__or2_1
X_12338_ _03682_ _03685_ VGND VGND VPWR VPWR _03686_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15057_ _06544_ _06553_ _06551_ VGND VGND VPWR VPWR _06655_ sky130_fd_sc_hd__a21bo_1
X_12269_ _03567_ _03599_ _03610_ VGND VGND VPWR VPWR _03611_ sky130_fd_sc_hd__or3b_1
X_14008_ _05507_ _05508_ VGND VGND VPWR VPWR _05509_ sky130_fd_sc_hd__nor2_2
XFILLER_0_128_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15959_ _07634_ _07635_ VGND VGND VPWR VPWR _07636_ sky130_fd_sc_hd__xor2_1
XFILLER_0_144_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08500_ _06025_ _06036_ VGND VGND VPWR VPWR _06047_ sky130_fd_sc_hd__nor2_1
X_09480_ net663 net493 VGND VGND VPWR VPWR _00755_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08431_ _04665_ _04676_ _04687_ VGND VGND VPWR VPWR _05297_ sky130_fd_sc_hd__and3_1
X_08362_ _03333_ _03322_ _03312_ VGND VGND VPWR VPWR _04545_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_58_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08293_ _03420_ _03453_ _03756_ _03767_ VGND VGND VPWR VPWR _03789_ sky130_fd_sc_hd__a211o_1
XFILLER_0_18_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_128_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout301 net303 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__clkbuf_4
Xfanout312 net60 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__clkbuf_4
Xfanout323 net59 VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__clkbuf_2
Xfanout334 net58 VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__buf_2
Xfanout345 net346 VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__buf_2
Xfanout356 net357 VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__clkbuf_4
X_09816_ _01082_ _00990_ _01086_ VGND VGND VPWR VPWR _01087_ sky130_fd_sc_hd__o21a_1
Xfanout367 net372 VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__buf_2
Xfanout378 net382 VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__buf_4
Xfanout389 net390 VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__clkbuf_4
X_09747_ _01017_ _01018_ VGND VGND VPWR VPWR _01019_ sky130_fd_sc_hd__xor2_2
X_09678_ _00949_ _00950_ VGND VGND VPWR VPWR _00951_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08629_ _06879_ _07445_ _06650_ VGND VGND VPWR VPWR _07456_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_83_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11640_ _02851_ _02927_ VGND VGND VPWR VPWR _02928_ sky130_fd_sc_hd__xor2_2
XFILLER_0_49_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11571_ net796 net522 net394 VGND VGND VPWR VPWR _02853_ sky130_fd_sc_hd__nand3_2
XFILLER_0_135_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13310_ _04749_ _04646_ _04641_ VGND VGND VPWR VPWR _04750_ sky130_fd_sc_hd__a21o_1
X_10522_ _01707_ _01709_ VGND VGND VPWR VPWR _01748_ sky130_fd_sc_hd__nor2_1
X_14290_ _05805_ _05811_ _05803_ VGND VGND VPWR VPWR _05814_ sky130_fd_sc_hd__a21o_1
XFILLER_0_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10453_ _01673_ _01678_ VGND VGND VPWR VPWR _01679_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_122_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13241_ _04588_ _04624_ _04625_ VGND VGND VPWR VPWR _04674_ sky130_fd_sc_hd__nor3_1
XFILLER_0_150_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10384_ net107 _01611_ net130 VGND VGND VPWR VPWR _01612_ sky130_fd_sc_hd__mux2_1
X_13172_ _04597_ _04598_ VGND VGND VPWR VPWR _04599_ sky130_fd_sc_hd__and2b_1
X_12123_ _03451_ _03452_ VGND VGND VPWR VPWR _03454_ sky130_fd_sc_hd__nor2_1
X_12054_ _03376_ _03378_ VGND VGND VPWR VPWR _03379_ sky130_fd_sc_hd__and2_1
X_11005_ _01796_ _01798_ _01797_ VGND VGND VPWR VPWR _02237_ sky130_fd_sc_hd__o21bai_1
X_15813_ _07475_ _07476_ VGND VGND VPWR VPWR _07478_ sky130_fd_sc_hd__xnor2_1
X_15744_ net182 net172 net623 VGND VGND VPWR VPWR _07403_ sky130_fd_sc_hd__o21ai_1
X_12956_ net775 net274 VGND VGND VPWR VPWR _04364_ sky130_fd_sc_hd__nand2_1
XFILLER_0_87_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11907_ _03217_ _03218_ VGND VGND VPWR VPWR _03219_ sky130_fd_sc_hd__xnor2_2
X_15675_ _07204_ _07207_ VGND VGND VPWR VPWR _07328_ sky130_fd_sc_hd__or2b_1
XFILLER_0_23_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12887_ _04286_ _04287_ _04282_ VGND VGND VPWR VPWR _04289_ sky130_fd_sc_hd__a21o_1
XFILLER_0_68_671 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14626_ _06159_ _06161_ _06160_ VGND VGND VPWR VPWR _06183_ sky130_fd_sc_hd__o21ba_1
X_11838_ _03043_ _03048_ VGND VGND VPWR VPWR _03144_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14557_ _06103_ _06104_ _06105_ VGND VGND VPWR VPWR _06107_ sky130_fd_sc_hd__a21o_1
X_11769_ _03066_ _03068_ VGND VGND VPWR VPWR _03069_ sky130_fd_sc_hd__xor2_1
XFILLER_0_28_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13508_ net730 net267 net257 net738 VGND VGND VPWR VPWR _04965_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_126_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14488_ _05880_ _05884_ VGND VGND VPWR VPWR _06031_ sky130_fd_sc_hd__and2_1
XFILLER_0_43_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16227_ _07916_ _07926_ VGND VGND VPWR VPWR _07927_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13439_ _04808_ _04815_ _04889_ VGND VGND VPWR VPWR _04890_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_24_763 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16158_ _07658_ _07802_ _07851_ VGND VGND VPWR VPWR _07852_ sky130_fd_sc_hd__a21o_1
X_15109_ net300 net548 net557 net291 VGND VGND VPWR VPWR _06711_ sky130_fd_sc_hd__a22o_1
XFILLER_0_11_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08980_ _00253_ _00259_ net877 VGND VGND VPWR VPWR _00261_ sky130_fd_sc_hd__nand3_1
X_16089_ net247 net664 _07776_ VGND VGND VPWR VPWR _07777_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_121_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09601_ _00869_ _00874_ VGND VGND VPWR VPWR _00875_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09532_ _00783_ _00784_ _00806_ VGND VGND VPWR VPWR _00807_ sky130_fd_sc_hd__nor3_1
XFILLER_0_64_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09463_ _00738_ VGND VGND VPWR VPWR _00008_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08414_ net572 net387 VGND VGND VPWR VPWR _05112_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09394_ _00594_ _00597_ _00595_ VGND VGND VPWR VPWR _00670_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_80_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_148_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08345_ _03539_ _03593_ _03529_ VGND VGND VPWR VPWR _04360_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08276_ _03529_ net842 _03593_ VGND VGND VPWR VPWR _03604_ sky130_fd_sc_hd__nand3_2
XFILLER_0_116_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout131 net132 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__clkbuf_2
Xfanout142 net144 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__clkbuf_4
Xfanout153 net154 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__buf_1
Xfanout164 net77 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__buf_6
Xfanout175 net176 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__buf_2
Xfanout186 net192 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__buf_6
Xfanout197 net73 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__buf_2
X_12810_ _04102_ _04107_ VGND VGND VPWR VPWR _04204_ sky130_fd_sc_hd__or2b_1
XFILLER_0_69_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13790_ _05269_ _05271_ VGND VGND VPWR VPWR _05272_ sky130_fd_sc_hd__xor2_1
X_12741_ net294 net283 net784 net806 VGND VGND VPWR VPWR _04128_ sky130_fd_sc_hd__and4_1
XFILLER_0_38_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15460_ _06999_ _07014_ VGND VGND VPWR VPWR _07093_ sky130_fd_sc_hd__or2b_1
XFILLER_0_38_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12672_ _04050_ _04051_ net199 net736 VGND VGND VPWR VPWR _04052_ sky130_fd_sc_hd__and4bb_1
X_14411_ _05942_ _05944_ _05943_ VGND VGND VPWR VPWR _05946_ sky130_fd_sc_hd__a21o_1
X_11623_ net738 net445 VGND VGND VPWR VPWR _02910_ sky130_fd_sc_hd__nand2_1
X_15391_ _06942_ _06950_ _06949_ VGND VGND VPWR VPWR _07018_ sky130_fd_sc_hd__a21o_1
XFILLER_0_37_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14342_ _05868_ _05869_ VGND VGND VPWR VPWR _05870_ sky130_fd_sc_hd__or2b_1
X_11554_ net720 net470 VGND VGND VPWR VPWR _02835_ sky130_fd_sc_hd__nand2_1
X_10505_ net516 net420 net412 net616 VGND VGND VPWR VPWR _01731_ sky130_fd_sc_hd__a22oi_2
X_14273_ _05793_ _05795_ VGND VGND VPWR VPWR _05797_ sky130_fd_sc_hd__and2b_1
XFILLER_0_40_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11485_ _02739_ _02759_ VGND VGND VPWR VPWR _02760_ sky130_fd_sc_hd__xnor2_2
X_16012_ _07539_ _07541_ _07617_ VGND VGND VPWR VPWR _07694_ sky130_fd_sc_hd__or3_1
XFILLER_0_122_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13224_ _04568_ _04570_ _04569_ net293 VGND VGND VPWR VPWR _04656_ sky130_fd_sc_hd__a22o_1
X_10436_ _01660_ _01661_ net733 net390 VGND VGND VPWR VPWR _01662_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_20_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13155_ _04576_ _04577_ _04579_ VGND VGND VPWR VPWR _04581_ sky130_fd_sc_hd__a21o_1
X_10367_ D_sin\[16\] Q_cos\[16\] VGND VGND VPWR VPWR _01597_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12106_ _03410_ _03433_ VGND VGND VPWR VPWR _03435_ sky130_fd_sc_hd__or2_1
X_10298_ D_sin\[7\] Q_cos\[7\] VGND VGND VPWR VPWR _01537_ sky130_fd_sc_hd__or2b_1
X_13086_ _04503_ _04504_ _04505_ VGND VGND VPWR VPWR _04506_ sky130_fd_sc_hd__nand3_1
XFILLER_0_18_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12037_ _03356_ _03357_ _03358_ VGND VGND VPWR VPWR _03360_ sky130_fd_sc_hd__nor3_1
XFILLER_0_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_125_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13988_ net424 net512 net263 net254 VGND VGND VPWR VPWR _05487_ sky130_fd_sc_hd__and4_1
X_15727_ _07382_ _07383_ VGND VGND VPWR VPWR _07384_ sky130_fd_sc_hd__xnor2_1
X_12939_ net783 net257 VGND VGND VPWR VPWR _04345_ sky130_fd_sc_hd__nand2_1
XFILLER_0_146_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15658_ _07307_ _07308_ VGND VGND VPWR VPWR _07309_ sky130_fd_sc_hd__nor2_1
XFILLER_0_68_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14609_ _06158_ _06163_ VGND VGND VPWR VPWR _06164_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_141_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15589_ _07232_ _07233_ VGND VGND VPWR VPWR _07234_ sky130_fd_sc_hd__and2_1
XFILLER_0_28_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_113_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08963_ net684 net365 _00241_ _00242_ VGND VGND VPWR VPWR _00244_ sky130_fd_sc_hd__nand4_1
X_08894_ _00173_ _00174_ _00115_ VGND VGND VPWR VPWR _00176_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_3_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09515_ net530 net456 net447 net538 VGND VGND VPWR VPWR _00790_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_38_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09446_ _00612_ _00638_ _00636_ VGND VGND VPWR VPWR _00722_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09377_ _00652_ _00653_ VGND VGND VPWR VPWR _00654_ sky130_fd_sc_hd__and2_1
XFILLER_0_148_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_836 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08328_ _04152_ _04163_ VGND VGND VPWR VPWR _04174_ sky130_fd_sc_hd__and2b_1
XFILLER_0_7_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08259_ _03279_ _03399_ _03409_ VGND VGND VPWR VPWR _03420_ sky130_fd_sc_hd__nand3_4
X_11270_ _02448_ _02466_ _02467_ VGND VGND VPWR VPWR _02525_ sky130_fd_sc_hd__nand3_2
X_10221_ _01470_ _01471_ VGND VGND VPWR VPWR _01472_ sky130_fd_sc_hd__nor2_1
X_10152_ _01403_ _01406_ _01404_ VGND VGND VPWR VPWR _01412_ sky130_fd_sc_hd__a21bo_1
X_10083_ _01347_ _01348_ VGND VGND VPWR VPWR _01349_ sky130_fd_sc_hd__nand2_1
X_14960_ _06546_ _06547_ _06545_ VGND VGND VPWR VPWR _06549_ sky130_fd_sc_hd__o21ai_1
X_13911_ D_sin\[11\] _05403_ _04752_ VGND VGND VPWR VPWR _05404_ sky130_fd_sc_hd__mux2_1
X_14891_ _06324_ _06472_ _06471_ _06219_ VGND VGND VPWR VPWR _06474_ sky130_fd_sc_hd__a211o_1
X_13842_ net512 net272 VGND VGND VPWR VPWR _05328_ sky130_fd_sc_hd__nand2_1
X_13773_ _05245_ _05252_ VGND VGND VPWR VPWR _05254_ sky130_fd_sc_hd__xnor2_1
X_10985_ _02213_ _02214_ VGND VGND VPWR VPWR _02215_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15512_ _07044_ _07046_ VGND VGND VPWR VPWR _07150_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12724_ _04101_ net904 VGND VGND VPWR VPWR _04110_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_139_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15443_ _06919_ _06971_ _06970_ VGND VGND VPWR VPWR _07076_ sky130_fd_sc_hd__a21oi_1
X_12655_ _03995_ _03997_ VGND VGND VPWR VPWR _04034_ sky130_fd_sc_hd__nor2_1
XFILLER_0_127_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11606_ _02710_ _02797_ _02891_ VGND VGND VPWR VPWR _02892_ sky130_fd_sc_hd__o21a_1
XFILLER_0_26_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15374_ net273 net555 _06923_ _06820_ net540 VGND VGND VPWR VPWR _07000_ sky130_fd_sc_hd__a32o_1
X_12586_ _03935_ _03946_ _03936_ VGND VGND VPWR VPWR _03958_ sky130_fd_sc_hd__nand3_1
XFILLER_0_52_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14325_ _05852_ VGND VGND VPWR VPWR _00095_ sky130_fd_sc_hd__clkbuf_1
X_11537_ _02814_ _02815_ VGND VGND VPWR VPWR _02816_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_20_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14256_ _05695_ _05700_ _05776_ VGND VGND VPWR VPWR _05778_ sky130_fd_sc_hd__o21ai_1
Xmax_cap128 _05340_ VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__buf_1
X_11468_ _02655_ _02663_ _02740_ VGND VGND VPWR VPWR _02741_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_150_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_110_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13207_ _04635_ _04636_ _04525_ _04527_ VGND VGND VPWR VPWR _04638_ sky130_fd_sc_hd__o211ai_2
X_10419_ _01640_ _01644_ VGND VGND VPWR VPWR _01645_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14187_ _05564_ _05702_ VGND VGND VPWR VPWR _05703_ sky130_fd_sc_hd__xnor2_1
X_11399_ _02665_ _02540_ _02542_ net150 VGND VGND VPWR VPWR _02666_ sky130_fd_sc_hd__a22o_1
XFILLER_0_0_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13138_ _04347_ _04448_ _04449_ VGND VGND VPWR VPWR _04562_ sky130_fd_sc_hd__and3_1
XFILLER_0_29_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13069_ net719 net170 _04485_ _04486_ VGND VGND VPWR VPWR _04487_ sky130_fd_sc_hd__a22o_1
XFILLER_0_136_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_119_Right_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09300_ net546 net458 net449 net556 VGND VGND VPWR VPWR _00577_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_48_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09231_ _00507_ _00508_ VGND VGND VPWR VPWR _00509_ sky130_fd_sc_hd__nor2_1
XFILLER_0_75_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09162_ _00439_ _00440_ VGND VGND VPWR VPWR _00441_ sky130_fd_sc_hd__nor2_1
XFILLER_0_16_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09093_ _00370_ _00371_ _00268_ _00316_ VGND VGND VPWR VPWR _00373_ sky130_fd_sc_hd__a211o_1
XFILLER_0_31_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09995_ _01261_ _01262_ VGND VGND VPWR VPWR _01263_ sky130_fd_sc_hd__xnor2_1
X_08946_ _00225_ _00223_ _00224_ VGND VGND VPWR VPWR _00227_ sky130_fd_sc_hd__nand3_1
X_08877_ _08093_ _08095_ _08094_ VGND VGND VPWR VPWR _00159_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_99_828 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10770_ _01993_ _01994_ _01995_ VGND VGND VPWR VPWR _01996_ sky130_fd_sc_hd__nand3_1
XFILLER_0_149_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09429_ _00630_ _00632_ VGND VGND VPWR VPWR _00705_ sky130_fd_sc_hd__and2_1
XFILLER_0_66_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_728 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_57_Left_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12440_ net217 net743 net753 net207 VGND VGND VPWR VPWR _03797_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_136_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12371_ net330 net245 net753 net763 VGND VGND VPWR VPWR _03721_ sky130_fd_sc_hd__and4_1
XFILLER_0_133_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14110_ _05618_ _05619_ VGND VGND VPWR VPWR _05620_ sky130_fd_sc_hd__xnor2_1
X_11322_ _02400_ _02580_ _02581_ VGND VGND VPWR VPWR _02582_ sky130_fd_sc_hd__a21o_1
X_15090_ net273 net266 net575 net584 VGND VGND VPWR VPWR _06690_ sky130_fd_sc_hd__nand4_1
XFILLER_0_50_658 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14041_ _05542_ _05544_ VGND VGND VPWR VPWR _05545_ sky130_fd_sc_hd__xnor2_1
X_11253_ net747 net470 VGND VGND VPWR VPWR _02507_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10204_ _01447_ _01451_ _01455_ VGND VGND VPWR VPWR _01457_ sky130_fd_sc_hd__or3_1
X_11184_ _02428_ _02429_ _02413_ VGND VGND VPWR VPWR _02432_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_66_Left_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10135_ _01395_ _01396_ VGND VGND VPWR VPWR _01397_ sky130_fd_sc_hd__nand2_1
X_15992_ _07666_ _07671_ VGND VGND VPWR VPWR _07672_ sky130_fd_sc_hd__xnor2_1
X_10066_ _01256_ _01275_ _01332_ VGND VGND VPWR VPWR _01333_ sky130_fd_sc_hd__a21oi_1
X_14943_ net183 net693 net534 net173 VGND VGND VPWR VPWR _06531_ sky130_fd_sc_hd__a22o_1
X_14874_ _06397_ _06400_ _06398_ VGND VGND VPWR VPWR _06456_ sky130_fd_sc_hd__a21o_1
X_13825_ _05307_ _05310_ VGND VGND VPWR VPWR _05311_ sky130_fd_sc_hd__xor2_1
XFILLER_0_58_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13756_ _05140_ _05215_ VGND VGND VPWR VPWR _05235_ sky130_fd_sc_hd__and2_1
X_10968_ _01768_ _01771_ VGND VGND VPWR VPWR _02196_ sky130_fd_sc_hd__or2_1
X_12707_ net216 net710 net716 net206 VGND VGND VPWR VPWR _04091_ sky130_fd_sc_hd__a22oi_1
XPHY_EDGE_ROW_75_Left_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13687_ _05143_ _05145_ _05159_ VGND VGND VPWR VPWR _05160_ sky130_fd_sc_hd__a21o_1
XFILLER_0_31_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10899_ _02121_ _02124_ VGND VGND VPWR VPWR _02125_ sky130_fd_sc_hd__and2b_1
X_15426_ net193 net873 VGND VGND VPWR VPWR _07057_ sky130_fd_sc_hd__and2_1
XFILLER_0_31_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12638_ _03816_ _03957_ _04014_ VGND VGND VPWR VPWR _04015_ sky130_fd_sc_hd__nand3_1
XFILLER_0_72_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_871 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_109_882 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15357_ net930 _06578_ _06676_ _06677_ VGND VGND VPWR VPWR _06982_ sky130_fd_sc_hd__or4_4
X_12569_ net189 net179 net762 net773 VGND VGND VPWR VPWR _03939_ sky130_fd_sc_hd__and4_1
XFILLER_0_53_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14308_ _05821_ _05833_ VGND VGND VPWR VPWR _05834_ sky130_fd_sc_hd__xnor2_1
X_15288_ net251 net584 VGND VGND VPWR VPWR _06906_ sky130_fd_sc_hd__nand2_1
XFILLER_0_124_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14239_ _05516_ _05757_ VGND VGND VPWR VPWR _05759_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_84_Left_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout708 net710 VGND VGND VPWR VPWR net708 sky130_fd_sc_hd__buf_4
Xfanout719 net19 VGND VGND VPWR VPWR net719 sky130_fd_sc_hd__clkbuf_2
X_08800_ _08108_ _08109_ _08076_ VGND VGND VPWR VPWR _08111_ sky130_fd_sc_hd__o21a_1
X_09780_ _01049_ _01050_ VGND VGND VPWR VPWR _01051_ sky130_fd_sc_hd__nor2_1
XFILLER_0_147_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_147_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08731_ net602 net458 net449 net698 VGND VGND VPWR VPWR _08042_ sky130_fd_sc_hd__a22o_1
X_08662_ _07781_ _07803_ VGND VGND VPWR VPWR _07814_ sky130_fd_sc_hd__or2_1
X_08593_ _06944_ _06955_ _06868_ _06890_ VGND VGND VPWR VPWR _07064_ sky130_fd_sc_hd__a211o_1
XPHY_EDGE_ROW_93_Left_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09214_ net574 net445 VGND VGND VPWR VPWR _00492_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09145_ _00421_ _00422_ _00423_ VGND VGND VPWR VPWR _00424_ sky130_fd_sc_hd__a21o_1
XFILLER_0_32_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09076_ net631 net413 VGND VGND VPWR VPWR _00356_ sky130_fd_sc_hd__nand2_1
XFILLER_0_115_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_142_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09978_ _01244_ _01245_ VGND VGND VPWR VPWR _01246_ sky130_fd_sc_hd__nand2_1
X_08929_ net602 net442 VGND VGND VPWR VPWR _00210_ sky130_fd_sc_hd__nand2_1
X_11940_ _02992_ _03253_ VGND VGND VPWR VPWR _03254_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11871_ _03171_ _03178_ VGND VGND VPWR VPWR _03179_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13610_ _05074_ _05075_ VGND VGND VPWR VPWR _05076_ sky130_fd_sc_hd__xnor2_1
X_10822_ _02003_ _02046_ _02045_ _02037_ VGND VGND VPWR VPWR _02048_ sky130_fd_sc_hd__a211o_1
XFILLER_0_95_831 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14590_ _06140_ _06141_ _06142_ VGND VGND VPWR VPWR _06143_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_79_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13541_ _04982_ _04999_ _05000_ VGND VGND VPWR VPWR _05001_ sky130_fd_sc_hd__and3_1
XFILLER_0_149_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10753_ _01914_ _01926_ _01925_ VGND VGND VPWR VPWR _01979_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_54_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_588 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16260_ _07959_ _07961_ VGND VGND VPWR VPWR _07962_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_137_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13472_ _04922_ _04923_ _04924_ VGND VGND VPWR VPWR _04926_ sky130_fd_sc_hd__and3_1
X_10684_ _01889_ _01891_ _01890_ VGND VGND VPWR VPWR _01910_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_35_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15211_ net555 _06820_ _06821_ VGND VGND VPWR VPWR _06822_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_124_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12423_ _03746_ _03764_ _03765_ VGND VGND VPWR VPWR _03779_ sky130_fd_sc_hd__nor3_1
X_16191_ Q_sin\[16\] _07887_ _00186_ VGND VGND VPWR VPWR _07888_ sky130_fd_sc_hd__mux2_4
XFILLER_0_23_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15142_ _06744_ _06745_ _06736_ VGND VGND VPWR VPWR _06747_ sky130_fd_sc_hd__a21o_1
X_12354_ net216 net206 net763 net772 VGND VGND VPWR VPWR _03703_ sky130_fd_sc_hd__and4_1
XFILLER_0_106_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11305_ _02560_ _02562_ _02524_ VGND VGND VPWR VPWR _02564_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_22_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15073_ _06669_ _06670_ _06499_ VGND VGND VPWR VPWR _06673_ sky130_fd_sc_hd__a21oi_2
X_12285_ _03627_ _03628_ VGND VGND VPWR VPWR _03629_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14024_ net298 net138 _05524_ _05526_ VGND VGND VPWR VPWR _05527_ sky130_fd_sc_hd__a211o_1
X_11236_ _02486_ _02487_ _02387_ VGND VGND VPWR VPWR _02489_ sky130_fd_sc_hd__a21oi_1
X_11167_ _02333_ _02340_ _02339_ VGND VGND VPWR VPWR _02413_ sky130_fd_sc_hd__a21o_1
X_10118_ _01381_ Q_sin\[0\] state VGND VGND VPWR VPWR _01383_ sky130_fd_sc_hd__o21a_1
X_15975_ _07561_ _07562_ VGND VGND VPWR VPWR _07654_ sky130_fd_sc_hd__and2_1
X_11098_ net715 net361 _02335_ _02336_ VGND VGND VPWR VPWR _02338_ sky130_fd_sc_hd__nand4_1
XFILLER_0_26_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10049_ _01314_ _01315_ VGND VGND VPWR VPWR _01316_ sky130_fd_sc_hd__nand2_1
X_14926_ net159 net308 net550 net557 VGND VGND VPWR VPWR _06512_ sky130_fd_sc_hd__nand4_1
XFILLER_0_117_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14857_ net325 net240 net599 net607 VGND VGND VPWR VPWR _06437_ sky130_fd_sc_hd__and4_1
X_13808_ _05191_ _05196_ VGND VGND VPWR VPWR _05292_ sky130_fd_sc_hd__and2b_1
X_14788_ _06357_ _06359_ _06360_ VGND VGND VPWR VPWR _06361_ sky130_fd_sc_hd__and3_2
XFILLER_0_9_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13739_ _05129_ _05126_ VGND VGND VPWR VPWR _05217_ sky130_fd_sc_hd__and2b_1
XFILLER_0_58_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15409_ _07036_ _07037_ VGND VGND VPWR VPWR _07038_ sky130_fd_sc_hd__and2b_1
XFILLER_0_6_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16389_ clknet_4_12_0_clk _00102_ net345 VGND VGND VPWR VPWR Q_sin\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_143_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09901_ _01100_ _01118_ _01170_ VGND VGND VPWR VPWR _01171_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_10_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout505 net506 VGND VGND VPWR VPWR net505 sky130_fd_sc_hd__buf_4
Xfanout516 net518 VGND VGND VPWR VPWR net516 sky130_fd_sc_hd__clkbuf_4
X_09832_ _01035_ _01033_ VGND VGND VPWR VPWR _01103_ sky130_fd_sc_hd__and2b_1
Xfanout527 net528 VGND VGND VPWR VPWR net527 sky130_fd_sc_hd__buf_2
Xfanout538 net545 VGND VGND VPWR VPWR net538 sky130_fd_sc_hd__clkbuf_4
Xfanout549 net36 VGND VGND VPWR VPWR net549 sky130_fd_sc_hd__buf_4
X_09763_ _00937_ _00955_ _01034_ VGND VGND VPWR VPWR _01035_ sky130_fd_sc_hd__a21oi_1
X_08714_ _07031_ _07499_ _08025_ _07053_ VGND VGND VPWR VPWR _08026_ sky130_fd_sc_hd__o211a_1
X_09694_ _00900_ _00966_ VGND VGND VPWR VPWR _00967_ sky130_fd_sc_hd__and2_1
Xrebuffer10 _04328_ VGND VGND VPWR VPWR net816 sky130_fd_sc_hd__clkbuf_1
Xrebuffer21 net826 VGND VGND VPWR VPWR net827 sky130_fd_sc_hd__clkbuf_1
Xrebuffer32 _06745_ VGND VGND VPWR VPWR net838 sky130_fd_sc_hd__clkbuf_1
X_08645_ net579 net589 net525 net435 VGND VGND VPWR VPWR _07629_ sky130_fd_sc_hd__and4_1
Xrebuffer43 _04360_ VGND VGND VPWR VPWR net849 sky130_fd_sc_hd__clkbuf_1
Xrebuffer54 net859 VGND VGND VPWR VPWR net860 sky130_fd_sc_hd__clkbuf_1
Xrebuffer65 _02589_ VGND VGND VPWR VPWR net871 sky130_fd_sc_hd__clkbuf_1
Xrebuffer76 _08103_ VGND VGND VPWR VPWR net882 sky130_fd_sc_hd__buf_1
XFILLER_0_107_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08576_ _06617_ _06693_ _06835_ _06846_ VGND VGND VPWR VPWR _06879_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_49_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer87 net897 VGND VGND VPWR VPWR net893 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer98 _04109_ VGND VGND VPWR VPWR net904 sky130_fd_sc_hd__buf_1
XFILLER_0_76_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer100 _04201_ VGND VGND VPWR VPWR net906 sky130_fd_sc_hd__buf_1
Xrebuffer111 _00269_ VGND VGND VPWR VPWR net950 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_91_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09128_ _00304_ _00305_ _00406_ VGND VGND VPWR VPWR _00407_ sky130_fd_sc_hd__o21a_1
XFILLER_0_32_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_121_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09059_ _00242_ _00244_ VGND VGND VPWR VPWR _00339_ sky130_fd_sc_hd__nand2_1
XFILLER_0_102_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12070_ _03320_ _03394_ VGND VGND VPWR VPWR _03396_ sky130_fd_sc_hd__nor2_1
X_11021_ net320 net415 net405 net429 VGND VGND VPWR VPWR _02254_ sky130_fd_sc_hd__a22oi_2
X_15760_ _07340_ _07342_ _07346_ VGND VGND VPWR VPWR _07420_ sky130_fd_sc_hd__o21ai_1
X_12972_ _04379_ _04380_ VGND VGND VPWR VPWR _04381_ sky130_fd_sc_hd__nand2_1
X_14711_ _06274_ _06275_ VGND VGND VPWR VPWR _06276_ sky130_fd_sc_hd__nor2_1
X_11923_ _03159_ _03235_ VGND VGND VPWR VPWR _03237_ sky130_fd_sc_hd__xnor2_1
X_15691_ _07343_ _07344_ VGND VGND VPWR VPWR _07345_ sky130_fd_sc_hd__nand2_1
X_14642_ _06176_ _06184_ _06177_ VGND VGND VPWR VPWR _06200_ sky130_fd_sc_hd__nand3_1
X_11854_ _03159_ _03161_ VGND VGND VPWR VPWR _03162_ sky130_fd_sc_hd__and2_1
XFILLER_0_68_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10805_ _02028_ _02030_ VGND VGND VPWR VPWR _02031_ sky130_fd_sc_hd__xor2_1
XFILLER_0_83_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14573_ net222 net553 VGND VGND VPWR VPWR _06125_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11785_ _02987_ _03065_ VGND VGND VPWR VPWR _03086_ sky130_fd_sc_hd__nor2_1
XFILLER_0_82_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16312_ clknet_4_8_0_clk _00025_ net340 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_82_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13524_ _04910_ _04918_ _04917_ VGND VGND VPWR VPWR _04983_ sky130_fd_sc_hd__a21o_1
XFILLER_0_27_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10736_ net726 net761 net527 net401 VGND VGND VPWR VPWR _01962_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_149_Left_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16243_ _07831_ VGND VGND VPWR VPWR _07945_ sky130_fd_sc_hd__inv_2
X_13455_ _04890_ _04907_ VGND VGND VPWR VPWR _04908_ sky130_fd_sc_hd__xnor2_2
X_10667_ _01889_ _01892_ VGND VGND VPWR VPWR _01893_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_125_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12406_ _03757_ _03758_ _03759_ VGND VGND VPWR VPWR _03760_ sky130_fd_sc_hd__nand3_1
X_16174_ _04539_ net664 VGND VGND VPWR VPWR _07870_ sky130_fd_sc_hd__nor2_1
XFILLER_0_23_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13386_ _04806_ _04832_ VGND VGND VPWR VPWR _04833_ sky130_fd_sc_hd__and2_1
X_10598_ _01822_ _01823_ VGND VGND VPWR VPWR _01824_ sky130_fd_sc_hd__or2_1
XFILLER_0_112_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15125_ _06725_ _06727_ _06707_ VGND VGND VPWR VPWR _06729_ sky130_fd_sc_hd__a21oi_1
Xoutput108 net108 VGND VGND VPWR VPWR beta[1] sky130_fd_sc_hd__clkbuf_4
X_12337_ _03683_ _03684_ VGND VGND VPWR VPWR _03685_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15056_ _06651_ _06652_ _06643_ VGND VGND VPWR VPWR _06654_ sky130_fd_sc_hd__a21o_1
XFILLER_0_120_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12268_ _03608_ _03609_ VGND VGND VPWR VPWR _03610_ sky130_fd_sc_hd__xnor2_1
X_14007_ _05164_ _05433_ VGND VGND VPWR VPWR _05508_ sky130_fd_sc_hd__and2_1
X_11219_ _02361_ _02436_ net905 _02469_ VGND VGND VPWR VPWR _02470_ sky130_fd_sc_hd__a211oi_4
X_12199_ _03471_ _03526_ VGND VGND VPWR VPWR _03535_ sky130_fd_sc_hd__and2b_1
Xoutput90 net90 VGND VGND VPWR VPWR alpha[2] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_128_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15958_ _07585_ _07589_ _07587_ VGND VGND VPWR VPWR _07635_ sky130_fd_sc_hd__o21ba_1
X_14909_ _06489_ _06491_ _06056_ _06061_ VGND VGND VPWR VPWR _06493_ sky130_fd_sc_hd__a211o_1
X_15889_ _07557_ _07558_ net936 net637 VGND VGND VPWR VPWR _07560_ sky130_fd_sc_hd__and4bb_1
X_08430_ _04665_ _04676_ _04687_ VGND VGND VPWR VPWR _05286_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_144_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_148_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08361_ _03333_ _03312_ _03322_ VGND VGND VPWR VPWR _04535_ sky130_fd_sc_hd__or3_1
XFILLER_0_18_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08292_ _03420_ _03453_ _03756_ net940 VGND VGND VPWR VPWR _03778_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_129_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_143_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout302 net303 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__clkbuf_2
Xfanout313 net314 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__clkbuf_4
Xfanout324 net326 VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__clkbuf_4
Xfanout335 net339 VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__clkbuf_4
Xfanout346 net58 VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__buf_4
Xfanout357 net56 VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__buf_4
X_09815_ _01083_ _01085_ VGND VGND VPWR VPWR _01086_ sky130_fd_sc_hd__xnor2_1
Xfanout368 net369 VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__clkbuf_4
Xfanout379 net381 VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_94_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09746_ _00941_ _00944_ _00942_ VGND VGND VPWR VPWR _01018_ sky130_fd_sc_hd__o21ba_1
X_09677_ _00876_ _00875_ VGND VGND VPWR VPWR _00950_ sky130_fd_sc_hd__and2b_1
X_08628_ _06704_ _06857_ VGND VGND VPWR VPWR _07445_ sky130_fd_sc_hd__or2_1
XFILLER_0_139_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_139_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08559_ _06617_ _06672_ _06682_ VGND VGND VPWR VPWR _06693_ sky130_fd_sc_hd__nor3_1
XFILLER_0_37_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11570_ net142 VGND VGND VPWR VPWR _02852_ sky130_fd_sc_hd__inv_2
XFILLER_0_25_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10521_ _01664_ _01666_ _01665_ VGND VGND VPWR VPWR _01747_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_33_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13240_ _04653_ _04672_ VGND VGND VPWR VPWR _04673_ sky130_fd_sc_hd__xor2_1
X_10452_ _01674_ _01677_ VGND VGND VPWR VPWR _01678_ sky130_fd_sc_hd__xnor2_1
X_13171_ _04595_ _04596_ _04592_ VGND VGND VPWR VPWR _04598_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10383_ _01609_ _01610_ VGND VGND VPWR VPWR _01611_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_103_652 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12122_ _03350_ _03373_ _03348_ VGND VGND VPWR VPWR _03452_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_130_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12053_ _03374_ _03375_ VGND VGND VPWR VPWR _03378_ sky130_fd_sc_hd__or2_1
X_11004_ _01789_ _01791_ VGND VGND VPWR VPWR _02236_ sky130_fd_sc_hd__nand2_1
X_15812_ net296 net647 VGND VGND VPWR VPWR _07476_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15743_ net182 net172 net623 VGND VGND VPWR VPWR _07402_ sky130_fd_sc_hd__and3_1
X_12955_ _04361_ _04362_ VGND VGND VPWR VPWR _04363_ sky130_fd_sc_hd__nor2_1
X_11906_ net720 _00191_ VGND VGND VPWR VPWR _03218_ sky130_fd_sc_hd__or2_1
X_15674_ _07323_ _07326_ VGND VGND VPWR VPWR _07327_ sky130_fd_sc_hd__xnor2_2
X_12886_ _04282_ _04286_ _04287_ VGND VGND VPWR VPWR _04288_ sky130_fd_sc_hd__and3_1
X_14625_ _06178_ _06181_ VGND VGND VPWR VPWR _06182_ sky130_fd_sc_hd__xor2_1
X_11837_ _03140_ _03142_ VGND VGND VPWR VPWR _03143_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_68_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14556_ _06103_ _06104_ _06105_ VGND VGND VPWR VPWR _06106_ sky130_fd_sc_hd__nand3_4
XFILLER_0_67_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11768_ _02900_ _02976_ _03067_ VGND VGND VPWR VPWR _03068_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_82_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10719_ _01845_ _01846_ _01847_ _01658_ VGND VGND VPWR VPWR _01945_ sky130_fd_sc_hd__o22ai_2
X_13507_ net731 net275 _04893_ _04892_ VGND VGND VPWR VPWR _04964_ sky130_fd_sc_hd__a31o_1
XFILLER_0_43_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14487_ _05876_ _05879_ VGND VGND VPWR VPWR _06030_ sky130_fd_sc_hd__and2_1
XFILLER_0_55_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11699_ _02990_ _02991_ VGND VGND VPWR VPWR _02992_ sky130_fd_sc_hd__nor2_2
XFILLER_0_70_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16226_ _07653_ _07925_ VGND VGND VPWR VPWR _07926_ sky130_fd_sc_hd__xnor2_1
X_13438_ _04809_ _04814_ VGND VGND VPWR VPWR _04889_ sky130_fd_sc_hd__and2_1
Xrebuffer1 _02539_ VGND VGND VPWR VPWR net807 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_125_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_140_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16157_ _07794_ _07804_ VGND VGND VPWR VPWR _07851_ sky130_fd_sc_hd__and2b_1
XFILLER_0_141_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13369_ _04812_ _04813_ VGND VGND VPWR VPWR _04814_ sky130_fd_sc_hd__xor2_2
XFILLER_0_2_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15108_ net300 net291 net548 VGND VGND VPWR VPWR _06710_ sky130_fd_sc_hd__and3_1
XFILLER_0_139_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16088_ _07774_ _07775_ VGND VGND VPWR VPWR _07776_ sky130_fd_sc_hd__nor2_1
X_15039_ _06632_ _06633_ _06629_ VGND VGND VPWR VPWR _06635_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09600_ _00872_ _00873_ VGND VGND VPWR VPWR _00874_ sky130_fd_sc_hd__xnor2_1
X_09531_ _00786_ _00805_ VGND VGND VPWR VPWR _00806_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09462_ Q_cos\[8\] _00737_ _00661_ VGND VGND VPWR VPWR _00738_ sky130_fd_sc_hd__mux2_1
XFILLER_0_149_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08413_ _04916_ _04905_ VGND VGND VPWR VPWR _05101_ sky130_fd_sc_hd__and2b_1
X_09393_ _00592_ _00609_ _00608_ VGND VGND VPWR VPWR _00669_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_148_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08344_ _04317_ _04328_ _04240_ VGND VGND VPWR VPWR _04349_ sky130_fd_sc_hd__a21o_1
XFILLER_0_74_686 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08275_ _03550_ _03583_ VGND VGND VPWR VPWR _03593_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_61_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout132 state VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__clkbuf_4
Xfanout143 net144 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__clkbuf_4
Xfanout154 net8 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__buf_4
Xfanout165 net168 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__buf_4
Xfanout176 net75 VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__clkbuf_4
Xfanout187 net192 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__clkbuf_4
Xfanout198 net199 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__clkbuf_4
X_09729_ _00766_ _01000_ VGND VGND VPWR VPWR _01001_ sky130_fd_sc_hd__xor2_1
X_12740_ _04125_ _04126_ VGND VGND VPWR VPWR _04127_ sky130_fd_sc_hd__xor2_1
XFILLER_0_97_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12671_ net216 net718 net727 net206 VGND VGND VPWR VPWR _04051_ sky130_fd_sc_hd__a22oi_1
X_14410_ _05942_ _05943_ _05944_ VGND VGND VPWR VPWR _05945_ sky130_fd_sc_hd__nand3_1
X_11622_ _02906_ _02907_ VGND VGND VPWR VPWR _02908_ sky130_fd_sc_hd__nor2_1
X_15390_ _06934_ _06936_ VGND VGND VPWR VPWR _07017_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14341_ _05856_ _05862_ VGND VGND VPWR VPWR _05869_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_107_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11553_ _02831_ _02832_ VGND VGND VPWR VPWR _02834_ sky130_fd_sc_hd__nor2_1
XFILLER_0_52_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10504_ net429 net440 VGND VGND VPWR VPWR _01730_ sky130_fd_sc_hd__nand2_1
XFILLER_0_107_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14272_ _05712_ _05734_ _05794_ VGND VGND VPWR VPWR _05795_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_52_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11484_ _02741_ _02758_ VGND VGND VPWR VPWR _02759_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_150_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16011_ _07539_ _07617_ VGND VGND VPWR VPWR _07693_ sky130_fd_sc_hd__or2_1
XFILLER_0_33_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13223_ _04566_ _04582_ _04583_ _04586_ VGND VGND VPWR VPWR _04655_ sky130_fd_sc_hd__a31o_1
X_10435_ net516 net529 net935 net726 VGND VGND VPWR VPWR _01661_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_150_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13154_ _04576_ _04577_ _04579_ VGND VGND VPWR VPWR _04580_ sky130_fd_sc_hd__nand3_1
XFILLER_0_21_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10366_ _01583_ _01586_ _01592_ VGND VGND VPWR VPWR _01596_ sky130_fd_sc_hd__o21a_1
XFILLER_0_131_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12105_ _03410_ _03433_ VGND VGND VPWR VPWR _03434_ sky130_fd_sc_hd__nand2_1
X_13085_ _04400_ _04402_ _04401_ VGND VGND VPWR VPWR _04505_ sky130_fd_sc_hd__o21bai_1
X_10297_ _01536_ VGND VGND VPWR VPWR _00044_ sky130_fd_sc_hd__clkbuf_1
X_12036_ _03356_ _03357_ _03358_ VGND VGND VPWR VPWR _03359_ sky130_fd_sc_hd__o21a_1
XFILLER_0_18_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13987_ net424 net263 net254 net512 VGND VGND VPWR VPWR _05486_ sky130_fd_sc_hd__a22oi_1
X_15726_ net272 net681 VGND VGND VPWR VPWR _07383_ sky130_fd_sc_hd__nand2_1
X_12938_ net783 net267 net257 net800 VGND VGND VPWR VPWR _04344_ sky130_fd_sc_hd__a22o_1
XFILLER_0_75_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15657_ net155 net304 net649 net657 VGND VGND VPWR VPWR _07308_ sky130_fd_sc_hd__and4_1
XFILLER_0_29_834 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12869_ net739 net749 net162 net310 VGND VGND VPWR VPWR _04269_ sky130_fd_sc_hd__and4_1
XFILLER_0_145_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14608_ _06159_ _06162_ VGND VGND VPWR VPWR _06163_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_56_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15588_ _07157_ _07223_ _07231_ VGND VGND VPWR VPWR _07233_ sky130_fd_sc_hd__or3_1
X_14539_ _06077_ _06086_ VGND VGND VPWR VPWR _06087_ sky130_fd_sc_hd__xor2_1
XFILLER_0_126_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16209_ _07895_ _07863_ _07906_ VGND VGND VPWR VPWR _07907_ sky130_fd_sc_hd__and3_1
XFILLER_0_113_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08962_ net684 net365 _00241_ _00242_ VGND VGND VPWR VPWR _00243_ sky130_fd_sc_hd__a22o_1
X_08893_ _00115_ _00173_ _00174_ VGND VGND VPWR VPWR _00175_ sky130_fd_sc_hd__and3_2
XFILLER_0_79_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09514_ _00706_ _00709_ _00707_ VGND VGND VPWR VPWR _00789_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_149_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09445_ _00703_ _00720_ VGND VGND VPWR VPWR _00721_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09376_ _00562_ _00651_ VGND VGND VPWR VPWR _00653_ sky130_fd_sc_hd__or2_1
XFILLER_0_19_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_664 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08327_ _04130_ _04141_ _04097_ VGND VGND VPWR VPWR _04163_ sky130_fd_sc_hd__a21o_1
XFILLER_0_74_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08258_ _03203_ _03214_ _03268_ VGND VGND VPWR VPWR _03409_ sky130_fd_sc_hd__a21o_1
XFILLER_0_15_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_104_Left_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08189_ _02626_ _02648_ VGND VGND VPWR VPWR _02659_ sky130_fd_sc_hd__or2b_1
XFILLER_0_15_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10220_ _01460_ _01466_ _01469_ VGND VGND VPWR VPWR _01471_ sky130_fd_sc_hd__nor3_1
X_10151_ _01409_ _01410_ VGND VGND VPWR VPWR _01411_ sky130_fd_sc_hd__nand2_1
X_10082_ _01333_ _01331_ VGND VGND VPWR VPWR _01348_ sky130_fd_sc_hd__or2b_1
X_13910_ _05399_ _05402_ VGND VGND VPWR VPWR _05403_ sky130_fd_sc_hd__xnor2_2
X_14890_ _06219_ _06471_ _06472_ _06324_ VGND VGND VPWR VPWR _06473_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_113_Left_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13841_ _05325_ _05326_ VGND VGND VPWR VPWR _05327_ sky130_fd_sc_hd__nor2_1
X_13772_ _05250_ _05251_ VGND VGND VPWR VPWR _05252_ sky130_fd_sc_hd__xnor2_1
X_10984_ net756 net768 net492 net481 VGND VGND VPWR VPWR _02214_ sky130_fd_sc_hd__and4_1
X_15511_ _07146_ _07148_ VGND VGND VPWR VPWR _07149_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_139_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12723_ _04102_ _04107_ VGND VGND VPWR VPWR _04109_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_128_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15442_ _07072_ _07073_ VGND VGND VPWR VPWR _07074_ sky130_fd_sc_hd__and2b_1
X_12654_ _04028_ _04032_ VGND VGND VPWR VPWR _04033_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11605_ _02698_ _02700_ _02796_ VGND VGND VPWR VPWR _02891_ sky130_fd_sc_hd__a21o_1
XFILLER_0_93_770 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15373_ _06920_ _06940_ _06938_ VGND VGND VPWR VPWR _06999_ sky130_fd_sc_hd__a21oi_1
X_12585_ _03955_ _03953_ _03956_ VGND VGND VPWR VPWR _03957_ sky130_fd_sc_hd__nand3_2
XFILLER_0_52_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_136_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_122_Left_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14324_ D_sin\[18\] _05851_ _05626_ VGND VGND VPWR VPWR _05852_ sky130_fd_sc_hd__mux2_1
X_11536_ net748 net445 VGND VGND VPWR VPWR _02815_ sky130_fd_sc_hd__nand2_2
XFILLER_0_53_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14255_ _05695_ _05700_ _05776_ VGND VGND VPWR VPWR _05777_ sky130_fd_sc_hd__or3_1
X_11467_ _02656_ _02662_ VGND VGND VPWR VPWR _02740_ sky130_fd_sc_hd__and2_1
Xmax_cap118 _05553_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__buf_1
X_13206_ _04525_ _04527_ _04635_ _04636_ VGND VGND VPWR VPWR _04637_ sky130_fd_sc_hd__a211o_1
X_10418_ _01643_ VGND VGND VPWR VPWR _01644_ sky130_fd_sc_hd__inv_2
X_14186_ _05662_ _05701_ VGND VGND VPWR VPWR _05702_ sky130_fd_sc_hd__xor2_1
X_11398_ net150 net394 VGND VGND VPWR VPWR _02665_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13137_ _04544_ _04560_ VGND VGND VPWR VPWR _04561_ sky130_fd_sc_hd__xnor2_1
X_10349_ net132 _01579_ _01580_ _01581_ VGND VGND VPWR VPWR _00051_ sky130_fd_sc_hd__a31o_1
X_13068_ net615 net708 net191 net180 VGND VGND VPWR VPWR _04486_ sky130_fd_sc_hd__nand4_1
X_12019_ _03338_ _03339_ VGND VGND VPWR VPWR _03340_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_131_Left_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_136_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_726 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15709_ _07363_ _07364_ VGND VGND VPWR VPWR _07365_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09230_ net532 net540 net484 net474 VGND VGND VPWR VPWR _00508_ sky130_fd_sc_hd__and4_1
XFILLER_0_61_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_118_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09161_ _00437_ _00438_ _00434_ VGND VGND VPWR VPWR _00440_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_84_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_140_Left_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09092_ _00268_ _00316_ _00370_ _00371_ VGND VGND VPWR VPWR _00372_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_32_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09994_ net654 net441 VGND VGND VPWR VPWR _01262_ sky130_fd_sc_hd__nand2_1
X_08945_ _00223_ _00224_ _00225_ VGND VGND VPWR VPWR _00226_ sky130_fd_sc_hd__a21o_1
X_08876_ _00155_ _00156_ _00154_ VGND VGND VPWR VPWR _00158_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_149_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09428_ _00604_ _00606_ VGND VGND VPWR VPWR _00704_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09359_ _00544_ _00613_ _00634_ _00635_ VGND VGND VPWR VPWR _00636_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_137_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_118_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12370_ net330 net753 net763 net245 VGND VGND VPWR VPWR _03720_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_117_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11321_ _02392_ _02399_ VGND VGND VPWR VPWR _02581_ sky130_fd_sc_hd__and2_1
XFILLER_0_132_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14040_ _05445_ _05464_ _05543_ VGND VGND VPWR VPWR _05544_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_31_851 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11252_ net480 _02503_ _02504_ VGND VGND VPWR VPWR _02505_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_105_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10203_ _01447_ _01451_ _01455_ VGND VGND VPWR VPWR _01456_ sky130_fd_sc_hd__o21ai_1
X_11183_ _02413_ _02428_ _02429_ VGND VGND VPWR VPWR _02431_ sky130_fd_sc_hd__nand3_1
X_10134_ Q_sin\[3\] D_cos\[3\] VGND VGND VPWR VPWR _01396_ sky130_fd_sc_hd__or2b_1
X_15991_ _07667_ _07670_ VGND VGND VPWR VPWR _07671_ sky130_fd_sc_hd__xnor2_1
X_10065_ _01276_ _01254_ VGND VGND VPWR VPWR _01332_ sky130_fd_sc_hd__and2b_1
X_14942_ _06088_ _06090_ _06089_ VGND VGND VPWR VPWR _06529_ sky130_fd_sc_hd__o21bai_1
X_14873_ _06433_ _06434_ _06451_ _06453_ VGND VGND VPWR VPWR _06455_ sky130_fd_sc_hd__or4_1
X_13824_ _05187_ _05208_ _05309_ VGND VGND VPWR VPWR _05310_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_15_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10967_ _01690_ _01691_ VGND VGND VPWR VPWR _02195_ sky130_fd_sc_hd__nor2_1
X_13755_ _05214_ _05211_ VGND VGND VPWR VPWR _05234_ sky130_fd_sc_hd__and2b_1
XFILLER_0_57_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12706_ net216 net206 net710 net716 VGND VGND VPWR VPWR _04090_ sky130_fd_sc_hd__and4_1
X_10898_ _02122_ _02123_ VGND VGND VPWR VPWR _02124_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_127_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13686_ _05150_ _05158_ VGND VGND VPWR VPWR _05159_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_73_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15425_ _07054_ _07055_ VGND VGND VPWR VPWR _07056_ sky130_fd_sc_hd__and2_1
X_12637_ _03953_ _03956_ _03955_ VGND VGND VPWR VPWR _04014_ sky130_fd_sc_hd__a21o_1
X_15356_ _06979_ _06980_ VGND VGND VPWR VPWR _06981_ sky130_fd_sc_hd__nand2_1
X_12568_ net171 net782 VGND VGND VPWR VPWR _03938_ sky130_fd_sc_hd__nand2_1
XFILLER_0_80_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11519_ _02698_ _02796_ VGND VGND VPWR VPWR _02797_ sky130_fd_sc_hd__xnor2_2
X_14307_ _05822_ _05832_ VGND VGND VPWR VPWR _05833_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_124_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15287_ net565 _06903_ _06904_ VGND VGND VPWR VPWR _06905_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_40_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12499_ _03843_ _03861_ VGND VGND VPWR VPWR _03862_ sky130_fd_sc_hd__nor2_1
XFILLER_0_123_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14238_ _05516_ _05757_ VGND VGND VPWR VPWR _05758_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_111_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_884 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14169_ _05552_ _05624_ VGND VGND VPWR VPWR _05684_ sky130_fd_sc_hd__or2_1
Xfanout709 net710 VGND VGND VPWR VPWR net709 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_147_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08730_ _03040_ _03051_ VGND VGND VPWR VPWR _08041_ sky130_fd_sc_hd__nor2_1
X_08661_ _07369_ _07770_ _07684_ _07760_ VGND VGND VPWR VPWR _07803_ sky130_fd_sc_hd__o211a_1
X_08592_ _06014_ _07042_ VGND VGND VPWR VPWR _07053_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09213_ _00489_ _00490_ VGND VGND VPWR VPWR _00491_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_146_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09144_ net532 net494 VGND VGND VPWR VPWR _00423_ sky130_fd_sc_hd__and2_1
XFILLER_0_134_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09075_ net520 net432 net621 VGND VGND VPWR VPWR _00355_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_142_650 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09977_ _01236_ _01243_ VGND VGND VPWR VPWR _01245_ sky130_fd_sc_hd__or2_1
X_08928_ _00207_ _00208_ VGND VGND VPWR VPWR _00209_ sky130_fd_sc_hd__xor2_1
XFILLER_0_99_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08859_ net684 net374 net365 net694 VGND VGND VPWR VPWR _00141_ sky130_fd_sc_hd__a22o_1
XFILLER_0_99_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11870_ _03176_ _03177_ VGND VGND VPWR VPWR _03178_ sky130_fd_sc_hd__xor2_2
XFILLER_0_86_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10821_ _02037_ _02045_ _02046_ _02003_ VGND VGND VPWR VPWR _02047_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10752_ _01914_ _01925_ _01926_ VGND VGND VPWR VPWR _01978_ sky130_fd_sc_hd__and3_1
X_13540_ _04997_ _04998_ _04983_ VGND VGND VPWR VPWR _05000_ sky130_fd_sc_hd__a21o_1
XFILLER_0_137_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13471_ _04922_ _04923_ _04924_ VGND VGND VPWR VPWR _04925_ sky130_fd_sc_hd__a21oi_1
X_10683_ _01906_ _01908_ VGND VGND VPWR VPWR _01909_ sky130_fd_sc_hd__xor2_2
XFILLER_0_125_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15210_ net291 net549 net555 net282 VGND VGND VPWR VPWR _06821_ sky130_fd_sc_hd__a22o_1
X_12422_ _03774_ _03776_ VGND VGND VPWR VPWR _03777_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_63_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16190_ _07830_ _07886_ VGND VGND VPWR VPWR _07887_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_35_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15141_ _06736_ _06744_ net838 VGND VGND VPWR VPWR _06746_ sky130_fd_sc_hd__nand3_1
X_12353_ _03695_ _03699_ _03700_ VGND VGND VPWR VPWR _03702_ sky130_fd_sc_hd__nand3_1
X_11304_ _02524_ _02560_ _02562_ VGND VGND VPWR VPWR _02563_ sky130_fd_sc_hd__or3_1
X_15072_ _06499_ _06669_ _06670_ VGND VGND VPWR VPWR _06671_ sky130_fd_sc_hd__and3_1
X_12284_ _03621_ _03625_ VGND VGND VPWR VPWR _03628_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14023_ net157 net306 net795 VGND VGND VPWR VPWR _05526_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_31_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11235_ _02387_ _02486_ _02487_ VGND VGND VPWR VPWR _02488_ sky130_fd_sc_hd__and3_1
XFILLER_0_121_878 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11166_ _02322_ _02324_ VGND VGND VPWR VPWR _02412_ sky130_fd_sc_hd__nand2_1
X_10117_ _01381_ Q_sin\[0\] VGND VGND VPWR VPWR _01382_ sky130_fd_sc_hd__nand2_1
X_15974_ _07652_ VGND VGND VPWR VPWR _07653_ sky130_fd_sc_hd__inv_2
XFILLER_0_93_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11097_ net715 net361 _02335_ _02336_ VGND VGND VPWR VPWR _02337_ sky130_fd_sc_hd__a22o_1
XFILLER_0_89_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10048_ _01307_ _01313_ VGND VGND VPWR VPWR _01315_ sky130_fd_sc_hd__nand2_1
X_14925_ net159 net550 net557 net308 VGND VGND VPWR VPWR _06511_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14856_ net325 net599 net607 net240 VGND VGND VPWR VPWR _06436_ sky130_fd_sc_hd__a22o_1
XFILLER_0_77_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13807_ _05289_ _05290_ VGND VGND VPWR VPWR _05291_ sky130_fd_sc_hd__xor2_1
X_14787_ _06340_ _06341_ _06354_ VGND VGND VPWR VPWR _06360_ sky130_fd_sc_hd__a21o_1
X_11999_ D_cos\[12\] _03318_ _03242_ VGND VGND VPWR VPWR _03319_ sky130_fd_sc_hd__mux2_1
XFILLER_0_58_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13738_ _05140_ _05215_ VGND VGND VPWR VPWR _05216_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_133_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13669_ _05060_ _05077_ _05139_ VGND VGND VPWR VPWR _05140_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_6_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15408_ _07034_ _07035_ _07018_ VGND VGND VPWR VPWR _07037_ sky130_fd_sc_hd__a21o_1
XFILLER_0_143_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16388_ clknet_4_13_0_clk _00101_ net344 VGND VGND VPWR VPWR Q_sin\[5\] sky130_fd_sc_hd__dfrtp_1
X_15339_ _06958_ _06961_ VGND VGND VPWR VPWR _06962_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_112_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09900_ _01168_ _01169_ VGND VGND VPWR VPWR _01170_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout506 net510 VGND VGND VPWR VPWR net506 sky130_fd_sc_hd__buf_6
XFILLER_0_67_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09831_ _01099_ _01100_ _01043_ _01027_ VGND VGND VPWR VPWR _01102_ sky130_fd_sc_hd__o211ai_1
Xfanout517 net518 VGND VGND VPWR VPWR net517 sky130_fd_sc_hd__clkbuf_2
Xfanout528 net529 VGND VGND VPWR VPWR net528 sky130_fd_sc_hd__buf_2
Xfanout539 net847 VGND VGND VPWR VPWR net539 sky130_fd_sc_hd__clkbuf_2
X_09762_ _00954_ _00939_ VGND VGND VPWR VPWR _01034_ sky130_fd_sc_hd__and2b_1
X_08713_ _07434_ _07466_ _08024_ _07075_ VGND VGND VPWR VPWR _08025_ sky130_fd_sc_hd__o211a_1
X_09693_ _00964_ _00965_ VGND VGND VPWR VPWR _00966_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_20_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer11 _06662_ VGND VGND VPWR VPWR net817 sky130_fd_sc_hd__clkbuf_1
X_08644_ net579 net525 net435 net589 VGND VGND VPWR VPWR _07619_ sky130_fd_sc_hd__a22oi_2
Xrebuffer22 _06041_ VGND VGND VPWR VPWR net828 sky130_fd_sc_hd__clkbuf_1
Xrebuffer33 net653 VGND VGND VPWR VPWR net839 sky130_fd_sc_hd__clkbuf_2
Xrebuffer44 _08108_ VGND VGND VPWR VPWR net850 sky130_fd_sc_hd__buf_1
XFILLER_0_49_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer55 _06778_ VGND VGND VPWR VPWR net861 sky130_fd_sc_hd__clkbuf_1
Xrebuffer66 _05229_ VGND VGND VPWR VPWR net938 sky130_fd_sc_hd__dlygate4sd1_1
X_08575_ _06704_ _06857_ VGND VGND VPWR VPWR _06868_ sky130_fd_sc_hd__and2_1
Xrebuffer77 _08112_ VGND VGND VPWR VPWR net883 sky130_fd_sc_hd__clkbuf_2
Xrebuffer88 _06623_ VGND VGND VPWR VPWR net894 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer99 _02468_ VGND VGND VPWR VPWR net905 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_119_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_107_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer101 net906 VGND VGND VPWR VPWR net907 sky130_fd_sc_hd__buf_1
XFILLER_0_106_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09127_ _00298_ _00303_ VGND VGND VPWR VPWR _00406_ sky130_fd_sc_hd__nand2_1
XFILLER_0_103_812 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09058_ _00261_ _00262_ _00263_ VGND VGND VPWR VPWR _00338_ sky130_fd_sc_hd__and3_1
XFILLER_0_60_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11020_ net320 net429 net415 net405 VGND VGND VPWR VPWR _02253_ sky130_fd_sc_hd__and4_1
X_12971_ _04377_ _04378_ _04357_ _04358_ VGND VGND VPWR VPWR _04380_ sky130_fd_sc_hd__a211o_1
X_14710_ net187 net598 net606 net177 VGND VGND VPWR VPWR _06275_ sky130_fd_sc_hd__a22oi_2
X_11922_ _03232_ _03234_ VGND VGND VPWR VPWR _03235_ sky130_fd_sc_hd__xor2_2
X_15690_ _04881_ net555 VGND VGND VPWR VPWR _07344_ sky130_fd_sc_hd__or2_1
XFILLER_0_68_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14641_ _06187_ _06188_ _06198_ VGND VGND VPWR VPWR _06199_ sky130_fd_sc_hd__nor3b_2
X_11853_ _03063_ _03086_ _03158_ VGND VGND VPWR VPWR _03161_ sky130_fd_sc_hd__or3_1
XFILLER_0_95_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10804_ _01969_ _02029_ VGND VGND VPWR VPWR _02030_ sky130_fd_sc_hd__xnor2_1
X_14572_ _05925_ _05923_ _05924_ VGND VGND VPWR VPWR _06123_ sky130_fd_sc_hd__or3_1
X_11784_ _03066_ _03068_ VGND VGND VPWR VPWR _03085_ sky130_fd_sc_hd__nor2_1
X_16311_ clknet_4_15_0_clk _00024_ net342 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_95_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13523_ _04896_ _04904_ _04903_ VGND VGND VPWR VPWR _04982_ sky130_fd_sc_hd__a21bo_1
X_10735_ _01940_ _01941_ _01923_ VGND VGND VPWR VPWR _01961_ sky130_fd_sc_hd__a21o_1
XFILLER_0_103_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16242_ _07692_ _07764_ _07942_ VGND VGND VPWR VPWR _07943_ sky130_fd_sc_hd__or3_1
XFILLER_0_125_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10666_ _01890_ _01891_ VGND VGND VPWR VPWR _01892_ sky130_fd_sc_hd__nor2_1
X_13454_ _04896_ _04906_ VGND VGND VPWR VPWR _04907_ sky130_fd_sc_hd__xor2_2
XFILLER_0_12_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12405_ net224 net743 _03753_ _03755_ VGND VGND VPWR VPWR _03759_ sky130_fd_sc_hd__a22o_1
X_16173_ _07864_ _07867_ VGND VGND VPWR VPWR _07869_ sky130_fd_sc_hd__xnor2_1
X_13385_ _04830_ _04831_ VGND VGND VPWR VPWR _04832_ sky130_fd_sc_hd__xor2_1
XFILLER_0_50_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10597_ _01820_ _01821_ _01695_ VGND VGND VPWR VPWR _01823_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_88_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15124_ _06707_ _06725_ _06727_ VGND VGND VPWR VPWR _06728_ sky130_fd_sc_hd__and3_1
Xoutput109 net109 VGND VGND VPWR VPWR beta[2] sky130_fd_sc_hd__buf_2
X_12336_ net227 _00193_ VGND VGND VPWR VPWR _03684_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15055_ _06643_ _06651_ net837 VGND VGND VPWR VPWR _06653_ sky130_fd_sc_hd__nand3_2
X_12267_ _03560_ _03564_ _03562_ VGND VGND VPWR VPWR _03609_ sky130_fd_sc_hd__o21ba_1
X_11218_ _02466_ _02467_ _02448_ VGND VGND VPWR VPWR _02469_ sky130_fd_sc_hd__a21oi_2
X_14006_ _05270_ _05433_ VGND VGND VPWR VPWR _05507_ sky130_fd_sc_hd__nor2_2
X_12198_ _03527_ VGND VGND VPWR VPWR _03534_ sky130_fd_sc_hd__inv_2
Xoutput80 net80 VGND VGND VPWR VPWR alpha[10] sky130_fd_sc_hd__clkbuf_4
Xoutput91 net91 VGND VGND VPWR VPWR alpha[3] sky130_fd_sc_hd__clkbuf_4
X_11149_ net774 net452 VGND VGND VPWR VPWR _02393_ sky130_fd_sc_hd__nand2_1
X_15957_ _07627_ _07633_ VGND VGND VPWR VPWR _07634_ sky130_fd_sc_hd__xnor2_1
X_14908_ _06056_ _06061_ _06489_ _06491_ VGND VGND VPWR VPWR _06492_ sky130_fd_sc_hd__o211ai_2
X_15888_ net936 net637 _07557_ _07558_ VGND VGND VPWR VPWR _07559_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_78_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14839_ net221 net605 _06415_ _06416_ VGND VGND VPWR VPWR _06417_ sky130_fd_sc_hd__nand4_2
XFILLER_0_148_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08360_ _03388_ net888 _03377_ VGND VGND VPWR VPWR _04524_ sky130_fd_sc_hd__nand3_1
XFILLER_0_86_651 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08291_ _03637_ _03648_ _03745_ VGND VGND VPWR VPWR _03767_ sky130_fd_sc_hd__and3_1
XFILLER_0_58_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_144_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_751 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout303 net61 VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__buf_4
Xfanout314 net315 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_111_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout325 net326 VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__clkbuf_2
Xfanout336 net337 VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__clkbuf_4
X_09814_ _00987_ _01084_ VGND VGND VPWR VPWR _01085_ sky130_fd_sc_hd__and2b_1
Xfanout347 net348 VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__clkbuf_4
Xfanout358 net56 VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__clkbuf_4
Xfanout369 net372 VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__buf_4
X_09745_ _01011_ _01016_ VGND VGND VPWR VPWR _01017_ sky130_fd_sc_hd__xnor2_2
X_09676_ _00869_ _00874_ VGND VGND VPWR VPWR _00949_ sky130_fd_sc_hd__and2b_1
X_08627_ _07401_ _07423_ VGND VGND VPWR VPWR _07434_ sky130_fd_sc_hd__nor2_1
X_08558_ _06595_ _06606_ _06344_ _06465_ VGND VGND VPWR VPWR _06682_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_77_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08489_ _05904_ _04785_ _04807_ VGND VGND VPWR VPWR _05926_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_91_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10520_ _01742_ _01744_ _01743_ VGND VGND VPWR VPWR _01746_ sky130_fd_sc_hd__a21o_1
XFILLER_0_9_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_135_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10451_ _01675_ _01676_ VGND VGND VPWR VPWR _01677_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13170_ _04592_ _04595_ _04596_ VGND VGND VPWR VPWR _04597_ sky130_fd_sc_hd__and3_1
X_10382_ D_sin\[18\] Q_cos\[18\] VGND VGND VPWR VPWR _01610_ sky130_fd_sc_hd__xnor2_1
X_12121_ _03449_ _03450_ VGND VGND VPWR VPWR _03451_ sky130_fd_sc_hd__and2_1
XFILLER_0_102_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12052_ _03374_ _03375_ VGND VGND VPWR VPWR _03376_ sky130_fd_sc_hd__nand2_1
X_11003_ _01795_ _01812_ _01813_ VGND VGND VPWR VPWR _02235_ sky130_fd_sc_hd__nand3_2
X_15811_ _07473_ _07474_ VGND VGND VPWR VPWR _07475_ sky130_fd_sc_hd__nor2_1
XFILLER_0_99_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15742_ _07285_ _07288_ _07286_ VGND VGND VPWR VPWR _07400_ sky130_fd_sc_hd__o21ba_1
X_12954_ net758 net767 net293 net283 VGND VGND VPWR VPWR _04362_ sky130_fd_sc_hd__and4_1
XFILLER_0_87_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11905_ _03213_ _03216_ VGND VGND VPWR VPWR _03217_ sky130_fd_sc_hd__xor2_2
X_15673_ _07239_ _07259_ _07324_ VGND VGND VPWR VPWR _07326_ sky130_fd_sc_hd__o21a_2
XFILLER_0_59_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12885_ net171 net736 _04283_ _04285_ VGND VGND VPWR VPWR _04287_ sky130_fd_sc_hd__nand4_1
X_14624_ _05867_ _06180_ VGND VGND VPWR VPWR _06181_ sky130_fd_sc_hd__and2b_1
X_11836_ _03141_ VGND VGND VPWR VPWR _03142_ sky130_fd_sc_hd__inv_2
XFILLER_0_56_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14555_ _05984_ _05989_ _05983_ VGND VGND VPWR VPWR _06105_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_126_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11767_ _02974_ _02972_ VGND VGND VPWR VPWR _03067_ sky130_fd_sc_hd__and2b_1
XFILLER_0_83_654 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13506_ _04888_ _04908_ _04962_ VGND VGND VPWR VPWR _04963_ sky130_fd_sc_hd__o21bai_2
X_10718_ _01920_ _01936_ VGND VGND VPWR VPWR _01944_ sky130_fd_sc_hd__nand2_1
X_14486_ _06010_ _06011_ _06027_ VGND VGND VPWR VPWR _06029_ sky130_fd_sc_hd__nand3_2
X_11698_ _02856_ _02926_ _02924_ VGND VGND VPWR VPWR _02991_ sky130_fd_sc_hd__a21oi_2
X_16225_ _07917_ _07924_ VGND VGND VPWR VPWR _07925_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_732 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13437_ _04793_ _04802_ _04801_ VGND VGND VPWR VPWR _04888_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_141_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer2 _08120_ VGND VGND VPWR VPWR net808 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_23_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10649_ net742 net751 net418 net410 VGND VGND VPWR VPWR _01875_ sky130_fd_sc_hd__nand4_1
XFILLER_0_130_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16156_ _07783_ _07785_ _07849_ VGND VGND VPWR VPWR _07850_ sky130_fd_sc_hd__o21ai_1
X_13368_ net514 net167 VGND VGND VPWR VPWR _04813_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15107_ net282 net565 VGND VGND VPWR VPWR _06709_ sky130_fd_sc_hd__and2_1
XFILLER_0_140_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12319_ _03659_ _03664_ VGND VGND VPWR VPWR _03665_ sky130_fd_sc_hd__xnor2_1
X_16087_ net261 net252 net647 net656 VGND VGND VPWR VPWR _07775_ sky130_fd_sc_hd__and4_1
X_13299_ _04673_ _04736_ _04737_ VGND VGND VPWR VPWR _04738_ sky130_fd_sc_hd__nand3_1
XFILLER_0_48_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15038_ _06629_ _06632_ _06633_ VGND VGND VPWR VPWR _06634_ sky130_fd_sc_hd__and3_1
XFILLER_0_139_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09530_ _00788_ _00804_ VGND VGND VPWR VPWR _00805_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09461_ _00664_ _00736_ VGND VGND VPWR VPWR _00737_ sky130_fd_sc_hd__xor2_1
XFILLER_0_64_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08412_ _04633_ _04600_ _04622_ VGND VGND VPWR VPWR _05090_ sky130_fd_sc_hd__nand3_1
X_09392_ _00587_ _00588_ _00667_ VGND VGND VPWR VPWR _00668_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_65_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08343_ _04240_ _04317_ _04328_ VGND VGND VPWR VPWR _04338_ sky130_fd_sc_hd__nand3_1
XFILLER_0_47_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08274_ _03561_ _03572_ VGND VGND VPWR VPWR _03583_ sky130_fd_sc_hd__nor2_1
XFILLER_0_104_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_131_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout133 net135 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__buf_4
Xfanout144 net9 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__buf_2
XFILLER_0_100_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout155 net158 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__clkbuf_4
Xfanout166 net168 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__buf_2
Xfanout177 net178 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__clkbuf_4
Xfanout188 net192 VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__clkbuf_4
Xfanout199 net73 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09728_ _00926_ _00999_ VGND VGND VPWR VPWR _01000_ sky130_fd_sc_hd__xnor2_2
X_09659_ _00930_ _00921_ _00922_ VGND VGND VPWR VPWR _00932_ sky130_fd_sc_hd__nor3_2
X_12670_ net216 net206 net718 net725 VGND VGND VPWR VPWR _04050_ sky130_fd_sc_hd__and4_1
XFILLER_0_37_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11621_ net721 net729 net463 net453 VGND VGND VPWR VPWR _02907_ sky130_fd_sc_hd__and4_1
XFILLER_0_108_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14340_ _05864_ _05867_ VGND VGND VPWR VPWR _05868_ sky130_fd_sc_hd__nor2_1
XFILLER_0_92_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11552_ net705 net711 net485 net480 VGND VGND VPWR VPWR _02832_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_767 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10503_ net516 net616 net420 net412 VGND VGND VPWR VPWR _01729_ sky130_fd_sc_hd__and4_1
X_11483_ _02747_ _02756_ VGND VGND VPWR VPWR _02758_ sky130_fd_sc_hd__xnor2_2
X_14271_ _05714_ _05733_ VGND VGND VPWR VPWR _05794_ sky130_fd_sc_hd__and2_1
XFILLER_0_33_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16010_ _07621_ _07691_ VGND VGND VPWR VPWR _07692_ sky130_fd_sc_hd__xnor2_2
X_10434_ net516 net726 net529 net935 VGND VGND VPWR VPWR _01660_ sky130_fd_sc_hd__and4_1
X_13222_ _04555_ _04557_ _04652_ VGND VGND VPWR VPWR _04653_ sky130_fd_sc_hd__a21o_1
XFILLER_0_33_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_122_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10365_ net129 _01593_ _01594_ _01595_ VGND VGND VPWR VPWR _00053_ sky130_fd_sc_hd__a31o_1
X_13153_ _04465_ _04467_ _04466_ VGND VGND VPWR VPWR _04579_ sky130_fd_sc_hd__a21bo_1
X_12104_ _03412_ _03432_ VGND VGND VPWR VPWR _03433_ sky130_fd_sc_hd__xnor2_1
X_13084_ _04500_ _04501_ _04499_ VGND VGND VPWR VPWR _04504_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_20_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10296_ net113 _01535_ net133 VGND VGND VPWR VPWR _01536_ sky130_fd_sc_hd__mux2_1
X_12035_ net314 net467 VGND VGND VPWR VPWR _03358_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13986_ _05411_ _05414_ _05412_ VGND VGND VPWR VPWR _05485_ sky130_fd_sc_hd__o21ba_1
X_15725_ _07380_ _07381_ VGND VGND VPWR VPWR _07382_ sky130_fd_sc_hd__nor2_1
X_12937_ _04319_ VGND VGND VPWR VPWR _04343_ sky130_fd_sc_hd__inv_2
XFILLER_0_125_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15656_ net155 net649 net657 net304 VGND VGND VPWR VPWR _07307_ sky130_fd_sc_hd__a22oi_2
X_12868_ net739 net162 net310 net749 VGND VGND VPWR VPWR _04268_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_146_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14607_ _06160_ _06161_ VGND VGND VPWR VPWR _06162_ sky130_fd_sc_hd__nor2_1
X_11819_ _03120_ _03121_ _03102_ VGND VGND VPWR VPWR _03123_ sky130_fd_sc_hd__a21oi_1
X_15587_ _07157_ _07223_ _07231_ VGND VGND VPWR VPWR _07232_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_139_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12799_ net170 net744 VGND VGND VPWR VPWR _04192_ sky130_fd_sc_hd__nand2_1
XFILLER_0_141_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14538_ _06084_ _06085_ VGND VGND VPWR VPWR _06086_ sky130_fd_sc_hd__and2b_1
XFILLER_0_141_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14469_ _05960_ _05965_ VGND VGND VPWR VPWR _06010_ sky130_fd_sc_hd__or2b_1
X_16208_ _07904_ _07905_ VGND VGND VPWR VPWR _07906_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_113_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_16139_ _07820_ _07819_ VGND VGND VPWR VPWR _07831_ sky130_fd_sc_hd__or2b_1
XFILLER_0_3_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08961_ net666 net675 net383 net374 VGND VGND VPWR VPWR _00242_ sky130_fd_sc_hd__nand4_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08892_ _00171_ _00172_ net850 net884 VGND VGND VPWR VPWR _00174_ sky130_fd_sc_hd__a211o_1
X_09513_ _00705_ _00718_ _00787_ VGND VGND VPWR VPWR _00788_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_149_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_768 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09444_ _00704_ _00719_ VGND VGND VPWR VPWR _00720_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_91_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09375_ _00562_ _00651_ VGND VGND VPWR VPWR _00652_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08326_ _04097_ _04130_ _04141_ VGND VGND VPWR VPWR _04152_ sky130_fd_sc_hd__and3_1
XFILLER_0_19_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_117_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08257_ _03355_ _03377_ _03388_ VGND VGND VPWR VPWR _03399_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08188_ _02637_ _02604_ VGND VGND VPWR VPWR _02648_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_132_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10150_ Q_sin\[5\] D_cos\[5\] VGND VGND VPWR VPWR _01410_ sky130_fd_sc_hd__or2b_1
XFILLER_0_112_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10081_ _01251_ _01329_ _01328_ VGND VGND VPWR VPWR _01347_ sky130_fd_sc_hd__a21o_1
X_13840_ net317 net424 net289 net280 VGND VGND VPWR VPWR _05326_ sky130_fd_sc_hd__and4_1
XFILLER_0_97_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13771_ _05151_ _05154_ _05152_ VGND VGND VPWR VPWR _05251_ sky130_fd_sc_hd__o21ba_1
X_10983_ net756 net492 net481 net765 VGND VGND VPWR VPWR _02213_ sky130_fd_sc_hd__a22oi_1
X_15510_ _07147_ _07058_ _07060_ VGND VGND VPWR VPWR _07148_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12722_ _04103_ _04106_ VGND VGND VPWR VPWR _04107_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15441_ _07016_ _07071_ VGND VGND VPWR VPWR _07073_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_133_Right_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12653_ _04029_ _04030_ VGND VGND VPWR VPWR _04032_ sky130_fd_sc_hd__and2b_1
XFILLER_0_139_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11604_ _02794_ _02889_ VGND VGND VPWR VPWR _02890_ sky130_fd_sc_hd__xnor2_2
X_15372_ _04538_ net592 _06915_ _06996_ VGND VGND VPWR VPWR _06997_ sky130_fd_sc_hd__o31ai_2
X_12584_ _03951_ _03952_ _03812_ _03907_ VGND VGND VPWR VPWR _03956_ sky130_fd_sc_hd__a211o_1
XFILLER_0_93_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_142_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14323_ _05814_ _05849_ VGND VGND VPWR VPWR _05851_ sky130_fd_sc_hd__xnor2_1
X_11535_ _02812_ _02813_ VGND VGND VPWR VPWR _02814_ sky130_fd_sc_hd__nor2_2
XFILLER_0_41_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14254_ _05771_ _05775_ VGND VGND VPWR VPWR _05776_ sky130_fd_sc_hd__xor2_1
X_11466_ _02644_ _02646_ VGND VGND VPWR VPWR _02739_ sky130_fd_sc_hd__nand2_2
Xmax_cap119 _04854_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__buf_6
XFILLER_0_150_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13205_ _04632_ _04634_ _04454_ _04542_ VGND VGND VPWR VPWR _04636_ sky130_fd_sc_hd__a211oi_2
X_10417_ _01641_ _01642_ VGND VGND VPWR VPWR _01643_ sky130_fd_sc_hd__or2_1
X_11397_ _02655_ _02663_ VGND VGND VPWR VPWR _02664_ sky130_fd_sc_hd__xor2_2
X_14185_ _05699_ _05700_ VGND VGND VPWR VPWR _05701_ sky130_fd_sc_hd__or2_1
XFILLER_0_104_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13136_ _04558_ _04559_ VGND VGND VPWR VPWR _04560_ sky130_fd_sc_hd__xor2_1
X_10348_ net132 net102 VGND VGND VPWR VPWR _01581_ sky130_fd_sc_hd__and2b_1
X_10279_ _01519_ _01520_ VGND VGND VPWR VPWR _01521_ sky130_fd_sc_hd__nand2_1
X_13067_ net615 net191 net180 net708 VGND VGND VPWR VPWR _04485_ sky130_fd_sc_hd__a22o_1
X_12018_ net703 _00191_ VGND VGND VPWR VPWR _03339_ sky130_fd_sc_hd__or2_1
X_13969_ _05442_ _05443_ _05465_ VGND VGND VPWR VPWR _05467_ sky130_fd_sc_hd__nor3_1
X_15708_ _07272_ _07362_ VGND VGND VPWR VPWR _07364_ sky130_fd_sc_hd__or2_1
X_15639_ net165 net639 VGND VGND VPWR VPWR _07288_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_146_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09160_ _00434_ _00437_ _00438_ VGND VGND VPWR VPWR _00439_ sky130_fd_sc_hd__and3_1
XFILLER_0_28_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09091_ _00368_ _00369_ _00337_ VGND VGND VPWR VPWR _00371_ sky130_fd_sc_hd__a21o_1
XFILLER_0_142_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_114_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09993_ _01258_ _01259_ _01260_ VGND VGND VPWR VPWR _01261_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08944_ net900 net506 VGND VGND VPWR VPWR _00225_ sky130_fd_sc_hd__and2_1
X_08875_ _00154_ _00155_ _00156_ VGND VGND VPWR VPWR _00157_ sky130_fd_sc_hd__or3_1
XFILLER_0_99_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09427_ _00701_ _00702_ VGND VGND VPWR VPWR _00703_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09358_ _00622_ _00623_ _00632_ _00633_ VGND VGND VPWR VPWR _00635_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_35_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08309_ net558 net567 net351 net504 VGND VGND VPWR VPWR _03965_ sky130_fd_sc_hd__and4_1
XFILLER_0_35_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_145_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09289_ Q_cos\[6\] _00566_ _02181_ VGND VGND VPWR VPWR _00567_ sky130_fd_sc_hd__mux2_1
X_11320_ _02401_ VGND VGND VPWR VPWR _02580_ sky130_fd_sc_hd__inv_2
XFILLER_0_50_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11251_ net732 net491 net480 net740 VGND VGND VPWR VPWR _02504_ sky130_fd_sc_hd__a22o_1
XFILLER_0_105_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10202_ _01453_ _01454_ VGND VGND VPWR VPWR _01455_ sky130_fd_sc_hd__nor2_1
XFILLER_0_120_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11182_ _02426_ _02427_ _02418_ VGND VGND VPWR VPWR _02429_ sky130_fd_sc_hd__a21o_1
X_10133_ D_cos\[3\] Q_sin\[3\] VGND VGND VPWR VPWR _01395_ sky130_fd_sc_hd__or2b_1
XFILLER_0_100_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15990_ _07668_ _07669_ VGND VGND VPWR VPWR _07670_ sky130_fd_sc_hd__and2b_1
X_10064_ _01328_ _01330_ VGND VGND VPWR VPWR _01331_ sky130_fd_sc_hd__xnor2_1
X_14941_ _06081_ _06083_ VGND VGND VPWR VPWR _06528_ sky130_fd_sc_hd__nand2_1
X_14872_ _06430_ _06452_ VGND VGND VPWR VPWR _06453_ sky130_fd_sc_hd__or2_1
X_13823_ _05190_ _05205_ _05206_ VGND VGND VPWR VPWR _05309_ sky130_fd_sc_hd__and3_1
XFILLER_0_106_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13754_ _05224_ _05229_ _05223_ VGND VGND VPWR VPWR _05233_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_58_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10966_ _01758_ _01762_ _01818_ _01819_ VGND VGND VPWR VPWR _02194_ sky130_fd_sc_hd__o211a_1
X_12705_ _04084_ _04087_ _04085_ VGND VGND VPWR VPWR _04089_ sky130_fd_sc_hd__a21o_1
X_13685_ _05156_ _05157_ VGND VGND VPWR VPWR _05158_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10897_ _02105_ _02104_ VGND VGND VPWR VPWR _02123_ sky130_fd_sc_hd__and2b_1
X_15424_ net211 net201 net872 net623 VGND VGND VPWR VPWR _07055_ sky130_fd_sc_hd__nand4_1
X_12636_ _04010_ _04011_ _03953_ _03957_ VGND VGND VPWR VPWR _04013_ sky130_fd_sc_hd__o211a_1
XFILLER_0_122_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15355_ _06894_ _06978_ VGND VGND VPWR VPWR _06980_ sky130_fd_sc_hd__or2_1
X_12567_ _03797_ _03801_ _03798_ VGND VGND VPWR VPWR _03937_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_142_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14306_ _05825_ _05831_ VGND VGND VPWR VPWR _05832_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_41_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11518_ _02794_ _02795_ VGND VGND VPWR VPWR _02796_ sky130_fd_sc_hd__or2_1
X_15286_ net265 net565 net575 net932 VGND VGND VPWR VPWR _06904_ sky130_fd_sc_hd__a22o_1
X_12498_ _03845_ _03859_ _03860_ VGND VGND VPWR VPWR _03861_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_80_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14237_ _05662_ _05756_ VGND VGND VPWR VPWR _05757_ sky130_fd_sc_hd__xor2_1
X_11449_ _02632_ _02635_ _02633_ VGND VGND VPWR VPWR _02720_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_0_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14168_ _05628_ _05682_ VGND VGND VPWR VPWR _05683_ sky130_fd_sc_hd__xnor2_2
X_13119_ net800 _04540_ VGND VGND VPWR VPWR _04541_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14099_ _05591_ _05607_ VGND VGND VPWR VPWR _05608_ sky130_fd_sc_hd__and2b_1
XFILLER_0_147_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08660_ _07781_ VGND VGND VPWR VPWR _07792_ sky130_fd_sc_hd__inv_2
X_08591_ _06966_ _07009_ _06998_ VGND VGND VPWR VPWR _07042_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_76_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09212_ net556 net564 net458 net449 VGND VGND VPWR VPWR _00490_ sky130_fd_sc_hd__and4_1
XFILLER_0_146_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_659 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09143_ net682 net934 net348 net501 VGND VGND VPWR VPWR _00422_ sky130_fd_sc_hd__nand4_2
XFILLER_0_56_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09074_ net621 net520 net432 VGND VGND VPWR VPWR _00354_ sky130_fd_sc_hd__and3_1
XFILLER_0_115_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_796 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_824 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09976_ _01236_ _01243_ VGND VGND VPWR VPWR _01244_ sky130_fd_sc_hd__nand2_1
X_08927_ _08044_ _08136_ _08135_ VGND VGND VPWR VPWR _00208_ sky130_fd_sc_hd__a21boi_1
X_08858_ _08088_ _08090_ _08089_ VGND VGND VPWR VPWR _00140_ sky130_fd_sc_hd__o21bai_1
X_08789_ _08096_ _08097_ _08098_ VGND VGND VPWR VPWR _08100_ sky130_fd_sc_hd__a21o_1
X_10820_ _01999_ _02002_ _02001_ VGND VGND VPWR VPWR _02046_ sky130_fd_sc_hd__a21o_1
XFILLER_0_67_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_9_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10751_ _01968_ _01974_ _01976_ VGND VGND VPWR VPWR _01977_ sky130_fd_sc_hd__a21oi_2
X_13470_ net194 net152 VGND VGND VPWR VPWR _04924_ sky130_fd_sc_hd__and2_1
XFILLER_0_54_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10682_ _01627_ _01907_ VGND VGND VPWR VPWR _01908_ sky130_fd_sc_hd__and2b_1
XFILLER_0_109_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12421_ _03738_ _03743_ _03775_ VGND VGND VPWR VPWR _03776_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_50_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15140_ _06742_ _06743_ _06646_ _06738_ VGND VGND VPWR VPWR _06745_ sky130_fd_sc_hd__a211o_1
XFILLER_0_90_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_854 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12352_ _03697_ _03698_ _03696_ VGND VGND VPWR VPWR _03700_ sky130_fd_sc_hd__a21o_1
XFILLER_0_23_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_133_662 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11303_ _02558_ _02559_ _02466_ _02525_ VGND VGND VPWR VPWR _02562_ sky130_fd_sc_hd__o211a_1
X_15071_ _06667_ _06668_ _06566_ _06586_ VGND VGND VPWR VPWR _06670_ sky130_fd_sc_hd__o211ai_2
X_12283_ _03621_ _03625_ VGND VGND VPWR VPWR _03627_ sky130_fd_sc_hd__nand2_1
X_14022_ net157 net306 net795 VGND VGND VPWR VPWR _05524_ sky130_fd_sc_hd__and3_1
X_11234_ _02483_ _02484_ _02388_ VGND VGND VPWR VPWR _02487_ sky130_fd_sc_hd__a21o_1
X_11165_ _02330_ _02366_ _02367_ VGND VGND VPWR VPWR _02411_ sky130_fd_sc_hd__nor3_1
X_10116_ D_cos\[0\] VGND VGND VPWR VPWR _01381_ sky130_fd_sc_hd__inv_2
X_15973_ _07649_ _07650_ VGND VGND VPWR VPWR _07652_ sky130_fd_sc_hd__nor2_2
X_11096_ net614 net707 net376 net367 VGND VGND VPWR VPWR _02336_ sky130_fd_sc_hd__nand4_1
XFILLER_0_117_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14924_ _06507_ _06509_ VGND VGND VPWR VPWR _06510_ sky130_fd_sc_hd__xnor2_1
X_10047_ _01307_ _01313_ VGND VGND VPWR VPWR _01314_ sky130_fd_sc_hd__or2_1
XFILLER_0_89_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14855_ net221 net605 _06415_ _06416_ VGND VGND VPWR VPWR _06435_ sky130_fd_sc_hd__a22o_1
X_13806_ _05192_ _05195_ _05193_ VGND VGND VPWR VPWR _05290_ sky130_fd_sc_hd__o21ba_1
X_14786_ _06335_ _06358_ VGND VGND VPWR VPWR _06359_ sky130_fd_sc_hd__xnor2_1
X_11998_ _03247_ _03317_ VGND VGND VPWR VPWR _03318_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_147_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13737_ _05211_ _05214_ VGND VGND VPWR VPWR _05215_ sky130_fd_sc_hd__xnor2_1
X_10949_ _02168_ _02151_ VGND VGND VPWR VPWR _02177_ sky130_fd_sc_hd__nand2_1
XFILLER_0_73_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_805 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13668_ _05061_ _05076_ VGND VGND VPWR VPWR _05139_ sky130_fd_sc_hd__nand2_1
XFILLER_0_128_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15407_ _07018_ _07034_ _07035_ VGND VGND VPWR VPWR _07036_ sky130_fd_sc_hd__and3_1
XFILLER_0_54_741 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12619_ _03945_ _03944_ VGND VGND VPWR VPWR _03994_ sky130_fd_sc_hd__or2b_1
X_16387_ clknet_4_13_0_clk _00100_ net344 VGND VGND VPWR VPWR Q_sin\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_109_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13599_ net721 net729 net267 net257 VGND VGND VPWR VPWR _05064_ sky130_fd_sc_hd__and4_1
XFILLER_0_53_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15338_ _06860_ _06960_ VGND VGND VPWR VPWR _06961_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_53_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_124_684 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15269_ _06885_ _06776_ VGND VGND VPWR VPWR _06886_ sky130_fd_sc_hd__nor2_1
XFILLER_0_111_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09830_ _01043_ _01027_ _01099_ _01100_ VGND VGND VPWR VPWR _01101_ sky130_fd_sc_hd__a211o_1
Xfanout507 net508 VGND VGND VPWR VPWR net507 sky130_fd_sc_hd__clkbuf_4
Xfanout518 net519 VGND VGND VPWR VPWR net518 sky130_fd_sc_hd__buf_4
XFILLER_0_10_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout529 net39 VGND VGND VPWR VPWR net529 sky130_fd_sc_hd__clkbuf_4
X_09761_ _01031_ _01032_ VGND VGND VPWR VPWR _01033_ sky130_fd_sc_hd__xnor2_1
X_08712_ _07857_ _08023_ _08022_ VGND VGND VPWR VPWR _08024_ sky130_fd_sc_hd__a21oi_1
X_09692_ _00887_ _00888_ _00890_ _00891_ _00893_ VGND VGND VPWR VPWR _00965_ sky130_fd_sc_hd__a32oi_4
Xrebuffer12 _06112_ VGND VGND VPWR VPWR net818 sky130_fd_sc_hd__clkbuf_1
X_08643_ net598 net416 VGND VGND VPWR VPWR _07608_ sky130_fd_sc_hd__nand2_1
Xrebuffer23 net828 VGND VGND VPWR VPWR net829 sky130_fd_sc_hd__clkbuf_1
Xrebuffer34 _04349_ VGND VGND VPWR VPWR net840 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer45 _06663_ VGND VGND VPWR VPWR net851 sky130_fd_sc_hd__clkbuf_1
Xrebuffer56 _04447_ VGND VGND VPWR VPWR net862 sky130_fd_sc_hd__clkbuf_1
Xrebuffer67 _03767_ VGND VGND VPWR VPWR net939 sky130_fd_sc_hd__clkbuf_1
X_08574_ _06835_ _06846_ VGND VGND VPWR VPWR _06857_ sky130_fd_sc_hd__and2_1
Xrebuffer78 _08110_ VGND VGND VPWR VPWR net884 sky130_fd_sc_hd__buf_1
XFILLER_0_77_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer89 net670 VGND VGND VPWR VPWR net895 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_147_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_847 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer102 _06115_ VGND VGND VPWR VPWR net941 sky130_fd_sc_hd__dlymetal6s2s_1
X_09126_ _00402_ _00404_ VGND VGND VPWR VPWR _00405_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_711 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09057_ _00317_ _00336_ VGND VGND VPWR VPWR _00337_ sky130_fd_sc_hd__xor2_2
XFILLER_0_115_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09959_ _01106_ _01116_ _01173_ VGND VGND VPWR VPWR _01228_ sky130_fd_sc_hd__o21ai_1
X_12970_ _04357_ _04358_ _04377_ _04378_ VGND VGND VPWR VPWR _04379_ sky130_fd_sc_hd__o211ai_2
X_11921_ _03152_ _03154_ _03233_ VGND VGND VPWR VPWR _03234_ sky130_fd_sc_hd__a21oi_2
X_14640_ _06196_ _06197_ VGND VGND VPWR VPWR _06198_ sky130_fd_sc_hd__nor2_1
X_11852_ _03063_ _03086_ _03158_ VGND VGND VPWR VPWR _03159_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_95_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10803_ _01971_ _01970_ VGND VGND VPWR VPWR _02029_ sky130_fd_sc_hd__nor2_1
X_14571_ _05901_ _06121_ VGND VGND VPWR VPWR _06122_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_68_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11783_ _03072_ _03080_ _03070_ VGND VGND VPWR VPWR _03084_ sky130_fd_sc_hd__o21ba_1
X_16310_ clknet_4_14_0_clk _00023_ net342 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dfrtp_1
X_13522_ _04961_ _04979_ VGND VGND VPWR VPWR _04980_ sky130_fd_sc_hd__xor2_1
X_10734_ _01955_ _01959_ VGND VGND VPWR VPWR _01960_ sky130_fd_sc_hd__nor2_1
XFILLER_0_138_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16241_ _07822_ _07886_ VGND VGND VPWR VPWR _07942_ sky130_fd_sc_hd__nand2_1
X_13453_ _04903_ _04904_ VGND VGND VPWR VPWR _04906_ sky130_fd_sc_hd__nand2_1
X_10665_ net760 net380 net372 net769 VGND VGND VPWR VPWR _01891_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_137_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12404_ _03696_ _03698_ _03697_ VGND VGND VPWR VPWR _03758_ sky130_fd_sc_hd__a21bo_1
X_16172_ _07865_ _07866_ VGND VGND VPWR VPWR _07867_ sky130_fd_sc_hd__nor2_1
XFILLER_0_106_640 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13384_ _04708_ _04728_ _04727_ VGND VGND VPWR VPWR _04831_ sky130_fd_sc_hd__a21boi_1
X_10596_ _01695_ _01820_ _01821_ VGND VGND VPWR VPWR _01822_ sky130_fd_sc_hd__and3_1
XFILLER_0_35_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15123_ _06723_ _06724_ _06708_ VGND VGND VPWR VPWR _06727_ sky130_fd_sc_hd__a21o_1
X_12335_ _03608_ _03609_ _03607_ VGND VGND VPWR VPWR _03683_ sky130_fd_sc_hd__o21a_1
XFILLER_0_50_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15054_ _06647_ _06648_ _06649_ VGND VGND VPWR VPWR _06652_ sky130_fd_sc_hd__a21o_1
X_12266_ _03606_ _03607_ VGND VGND VPWR VPWR _03608_ sky130_fd_sc_hd__or2b_1
X_14005_ _05483_ _05504_ VGND VGND VPWR VPWR _05506_ sky130_fd_sc_hd__nor2_1
XFILLER_0_121_698 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11217_ _02448_ _02466_ _02467_ VGND VGND VPWR VPWR _02468_ sky130_fd_sc_hd__and3_1
XFILLER_0_120_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12197_ _03533_ VGND VGND VPWR VPWR _00073_ sky130_fd_sc_hd__clkbuf_1
Xoutput81 net81 VGND VGND VPWR VPWR alpha[11] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput92 net92 VGND VGND VPWR VPWR alpha[4] sky130_fd_sc_hd__buf_2
X_11148_ net490 _02309_ _02313_ _02311_ VGND VGND VPWR VPWR _02392_ sky130_fd_sc_hd__a22o_1
XFILLER_0_128_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15956_ _07631_ _07632_ VGND VGND VPWR VPWR _07633_ sky130_fd_sc_hd__xnor2_1
X_11079_ net740 net498 VGND VGND VPWR VPWR _02317_ sky130_fd_sc_hd__and2_1
X_14907_ net697 _06490_ VGND VGND VPWR VPWR _06491_ sky130_fd_sc_hd__nand2_2
XFILLER_0_144_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15887_ net155 net304 net628 net619 VGND VGND VPWR VPWR _07558_ sky130_fd_sc_hd__and4_1
XFILLER_0_78_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14838_ net325 net589 net597 net240 VGND VGND VPWR VPWR _06416_ sky130_fd_sc_hd__a22o_1
XFILLER_0_77_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14769_ _06253_ _06241_ _06252_ VGND VGND VPWR VPWR _06340_ sky130_fd_sc_hd__nand3_1
XFILLER_0_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08290_ _03637_ _03648_ _03745_ VGND VGND VPWR VPWR _03756_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_129_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_128_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_774 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_679 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout304 net307 VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__clkbuf_4
Xfanout315 net317 VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__buf_2
Xfanout326 net59 VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__clkbuf_4
X_09813_ net348 net501 net620 VGND VGND VPWR VPWR _01084_ sky130_fd_sc_hd__o21a_1
Xfanout337 net339 VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__clkbuf_2
Xfanout348 net57 VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__buf_4
Xfanout359 net56 VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__buf_2
X_09744_ _01014_ _01015_ VGND VGND VPWR VPWR _01016_ sky130_fd_sc_hd__xnor2_2
X_09675_ _00946_ _00947_ VGND VGND VPWR VPWR _00948_ sky130_fd_sc_hd__xor2_1
XFILLER_0_69_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08626_ _06693_ _07412_ VGND VGND VPWR VPWR _07423_ sky130_fd_sc_hd__or2_1
XFILLER_0_96_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08557_ _06650_ _06661_ VGND VGND VPWR VPWR _06672_ sky130_fd_sc_hd__or2_1
XFILLER_0_64_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08488_ _05904_ _04785_ _04807_ VGND VGND VPWR VPWR _05915_ sky130_fd_sc_hd__and3_1
XFILLER_0_9_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_135_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_99_Left_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10450_ net751 net353 net507 net761 VGND VGND VPWR VPWR _01676_ sky130_fd_sc_hd__a22oi_2
X_09109_ _00294_ VGND VGND VPWR VPWR _00388_ sky130_fd_sc_hd__inv_2
XFILLER_0_33_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10381_ _01601_ _01606_ _01602_ VGND VGND VPWR VPWR _01609_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_60_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12120_ _03350_ _03448_ VGND VGND VPWR VPWR _03450_ sky130_fd_sc_hd__or2_1
XFILLER_0_103_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12051_ _03256_ _03280_ _03255_ VGND VGND VPWR VPWR _03375_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11002_ _02231_ _02232_ VGND VGND VPWR VPWR _02233_ sky130_fd_sc_hd__nand2_1
X_15810_ net155 net304 net637 net629 VGND VGND VPWR VPWR _07474_ sky130_fd_sc_hd__and4_1
X_15741_ _07282_ _07294_ VGND VGND VPWR VPWR _07399_ sky130_fd_sc_hd__nand2_1
X_12953_ net758 net293 net283 net767 VGND VGND VPWR VPWR _04361_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_99_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11904_ _03140_ _03142_ _03215_ VGND VGND VPWR VPWR _03216_ sky130_fd_sc_hd__a21o_1
X_15672_ _07235_ _07237_ VGND VGND VPWR VPWR _07324_ sky130_fd_sc_hd__nand2_1
X_12884_ net170 net736 _04283_ _04285_ VGND VGND VPWR VPWR _04286_ sky130_fd_sc_hd__a22o_1
XFILLER_0_87_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14623_ net169 net590 _05865_ _05866_ VGND VGND VPWR VPWR _06180_ sky130_fd_sc_hd__a22o_1
X_11835_ _03044_ _03047_ _03045_ VGND VGND VPWR VPWR _03141_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_142_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14554_ _06100_ _06101_ _06093_ VGND VGND VPWR VPWR _06104_ sky130_fd_sc_hd__a21o_1
XFILLER_0_23_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11766_ _02987_ _03065_ VGND VGND VPWR VPWR _03066_ sky130_fd_sc_hd__xnor2_1
X_13505_ _04890_ _04907_ VGND VGND VPWR VPWR _04962_ sky130_fd_sc_hd__nor2_1
X_10717_ _01934_ _01935_ VGND VGND VPWR VPWR _01943_ sky130_fd_sc_hd__or2b_1
X_14485_ _06010_ _06011_ _06027_ VGND VGND VPWR VPWR _06028_ sky130_fd_sc_hd__a21o_2
X_11697_ _02850_ _02856_ _02926_ VGND VGND VPWR VPWR _02990_ sky130_fd_sc_hd__and3_1
XFILLER_0_126_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16224_ _07921_ _07923_ VGND VGND VPWR VPWR _07924_ sky130_fd_sc_hd__nor2_1
XFILLER_0_130_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13436_ _04830_ _04831_ VGND VGND VPWR VPWR _04887_ sky130_fd_sc_hd__nor2_1
X_10648_ net742 net418 net410 net751 VGND VGND VPWR VPWR _01874_ sky130_fd_sc_hd__a22o_1
XFILLER_0_51_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer3 _06674_ VGND VGND VPWR VPWR net809 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16155_ _07786_ _07787_ VGND VGND VPWR VPWR _07849_ sky130_fd_sc_hd__or2_1
XFILLER_0_134_790 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13367_ net185 _04810_ _04811_ VGND VGND VPWR VPWR _04812_ sky130_fd_sc_hd__a21bo_1
X_10579_ _01802_ _01803_ _01801_ VGND VGND VPWR VPWR _01805_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_140_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15106_ _06627_ _06635_ _06634_ VGND VGND VPWR VPWR _06708_ sky130_fd_sc_hd__a21o_1
X_12318_ _03601_ _03663_ VGND VGND VPWR VPWR _03664_ sky130_fd_sc_hd__xnor2_1
X_16086_ net261 net647 net656 net252 VGND VGND VPWR VPWR _07774_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_11_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13298_ _04734_ _04735_ _04624_ _04674_ VGND VGND VPWR VPWR _04737_ sky130_fd_sc_hd__a211o_1
XFILLER_0_139_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15037_ net166 net534 _06630_ _06631_ VGND VGND VPWR VPWR _06633_ sky130_fd_sc_hd__nand4_1
X_12249_ _03536_ _03589_ VGND VGND VPWR VPWR _03590_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_139_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_147_Right_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15939_ _07530_ _07533_ VGND VGND VPWR VPWR _07615_ sky130_fd_sc_hd__or2_1
XFILLER_0_64_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09460_ _00649_ _00735_ VGND VGND VPWR VPWR _00736_ sky130_fd_sc_hd__xor2_2
X_08411_ _04894_ _05057_ _05068_ VGND VGND VPWR VPWR _05079_ sky130_fd_sc_hd__a21o_1
XFILLER_0_149_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09391_ _00584_ _00586_ VGND VGND VPWR VPWR _00667_ sky130_fd_sc_hd__or2b_1
XFILLER_0_19_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08342_ _04284_ _04295_ _04306_ VGND VGND VPWR VPWR _04328_ sky130_fd_sc_hd__a21o_1
XFILLER_0_129_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08273_ net686 net404 net393 net695 VGND VGND VPWR VPWR _03572_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_104_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout134 net135 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__buf_2
Xfanout145 net147 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__clkbuf_4
Xfanout156 net158 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__buf_2
Xfanout167 net168 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__clkbuf_4
Xfanout178 net181 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__clkbuf_4
Xfanout189 net190 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_114_Right_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09727_ net622 net357 _00851_ _00769_ VGND VGND VPWR VPWR _00999_ sky130_fd_sc_hd__a31o_2
XFILLER_0_69_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09658_ _00921_ _00922_ _00930_ VGND VGND VPWR VPWR _00931_ sky130_fd_sc_hd__o21a_1
X_08609_ _06157_ _06146_ _06135_ VGND VGND VPWR VPWR _07238_ sky130_fd_sc_hd__o21ai_1
X_09589_ _00776_ _00778_ VGND VGND VPWR VPWR _00863_ sky130_fd_sc_hd__and2_1
XFILLER_0_49_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11620_ net720 net463 net453 net729 VGND VGND VPWR VPWR _02906_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_92_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_806 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11551_ net705 net485 net480 net711 VGND VGND VPWR VPWR _02831_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_64_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_699 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10502_ _01725_ _01726_ _01727_ VGND VGND VPWR VPWR _01728_ sky130_fd_sc_hd__nand3_4
XFILLER_0_18_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14270_ _05790_ _05792_ VGND VGND VPWR VPWR _05793_ sky130_fd_sc_hd__xnor2_1
X_11482_ _02754_ _02755_ VGND VGND VPWR VPWR _02756_ sky130_fd_sc_hd__and2b_1
X_13221_ net783 net250 _04558_ VGND VGND VPWR VPWR _04652_ sky130_fd_sc_hd__and3_1
X_10433_ _01646_ _01658_ _01641_ VGND VGND VPWR VPWR _01659_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_122_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_122_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_714 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13152_ _04575_ _04573_ _04574_ VGND VGND VPWR VPWR _04577_ sky130_fd_sc_hd__nand3_1
X_10364_ net129 net104 VGND VGND VPWR VPWR _01595_ sky130_fd_sc_hd__and2b_1
X_12103_ _03429_ _03430_ VGND VGND VPWR VPWR _03432_ sky130_fd_sc_hd__nand2_1
X_13083_ _04499_ _04500_ _04501_ VGND VGND VPWR VPWR _04503_ sky130_fd_sc_hd__or3_1
X_10295_ _01533_ _01534_ VGND VGND VPWR VPWR _01535_ sky130_fd_sc_hd__xnor2_1
X_12034_ net227 net145 net485 net475 VGND VGND VPWR VPWR _03357_ sky130_fd_sc_hd__and4_1
XFILLER_0_109_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout690 net692 VGND VGND VPWR VPWR net690 sky130_fd_sc_hd__buf_2
X_13985_ _05409_ _05338_ _05428_ VGND VGND VPWR VPWR _05484_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_125_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15724_ net286 net277 net665 net672 VGND VGND VPWR VPWR _07381_ sky130_fd_sc_hd__and4_1
XFILLER_0_87_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12936_ _04234_ _04324_ _04325_ VGND VGND VPWR VPWR _04342_ sky130_fd_sc_hd__and3b_1
X_15655_ _07304_ _07305_ VGND VGND VPWR VPWR _07306_ sky130_fd_sc_hd__xnor2_1
X_12867_ net302 net757 VGND VGND VPWR VPWR _04267_ sky130_fd_sc_hd__nand2_1
XFILLER_0_140_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14606_ net187 net581 net590 net177 VGND VGND VPWR VPWR _06161_ sky130_fd_sc_hd__a22oi_2
X_11818_ _03102_ _03120_ _03121_ VGND VGND VPWR VPWR _03122_ sky130_fd_sc_hd__and3_1
X_15586_ _07224_ _07230_ VGND VGND VPWR VPWR _07231_ sky130_fd_sc_hd__xnor2_1
X_12798_ _04090_ _04092_ VGND VGND VPWR VPWR _04191_ sky130_fd_sc_hd__nor2_4
XFILLER_0_141_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14537_ _06082_ _06083_ _06078_ VGND VGND VPWR VPWR _06085_ sky130_fd_sc_hd__a21o_1
XFILLER_0_55_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11749_ net729 net445 VGND VGND VPWR VPWR _03047_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_688 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14468_ _06007_ _06006_ _05975_ _05956_ VGND VGND VPWR VPWR _06009_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_70_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16207_ _07855_ _07859_ _07856_ VGND VGND VPWR VPWR _07905_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_70_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13419_ net739 net267 net257 net748 VGND VGND VPWR VPWR _04868_ sky130_fd_sc_hd__a22oi_2
X_14399_ _05912_ _05913_ _05919_ VGND VGND VPWR VPWR _05933_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16138_ _07822_ _07824_ _07829_ VGND VGND VPWR VPWR _07830_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_11_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08960_ net666 net383 net374 net675 VGND VGND VPWR VPWR _00241_ sky130_fd_sc_hd__a22o_1
X_16069_ _07752_ _07753_ _07754_ _07755_ VGND VGND VPWR VPWR _07756_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_121_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08891_ net850 net884 _00171_ _00172_ VGND VGND VPWR VPWR _00173_ sky130_fd_sc_hd__o211ai_2
X_09512_ _00719_ _00704_ VGND VGND VPWR VPWR _00787_ sky130_fd_sc_hd__or2b_1
XFILLER_0_148_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09443_ _00705_ _00718_ VGND VGND VPWR VPWR _00719_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_149_657 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09374_ _00649_ _00650_ VGND VGND VPWR VPWR _00651_ sky130_fd_sc_hd__and2_1
XFILLER_0_148_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08325_ net550 net360 _04108_ _04119_ VGND VGND VPWR VPWR _04141_ sky130_fd_sc_hd__nand4_1
XFILLER_0_129_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08256_ _03290_ _03344_ _03301_ VGND VGND VPWR VPWR _03388_ sky130_fd_sc_hd__nand3_1
XFILLER_0_7_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08187_ _02463_ _02561_ VGND VGND VPWR VPWR _02637_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_18_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10080_ _01339_ _01343_ _01337_ VGND VGND VPWR VPWR _01346_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13770_ _05248_ _05249_ VGND VGND VPWR VPWR _05250_ sky130_fd_sc_hd__xnor2_1
X_10982_ _01786_ _01793_ _01792_ VGND VGND VPWR VPWR _02211_ sky130_fd_sc_hd__a21o_1
X_12721_ _04104_ _04105_ VGND VGND VPWR VPWR _04106_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_27_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_739 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15440_ _07016_ _07071_ VGND VGND VPWR VPWR _07072_ sky130_fd_sc_hd__nor2_1
XFILLER_0_139_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12652_ net163 net773 net776 net311 VGND VGND VPWR VPWR _04030_ sky130_fd_sc_hd__a22o_1
XFILLER_0_37_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11603_ _02802_ _02887_ VGND VGND VPWR VPWR _02889_ sky130_fd_sc_hd__xor2_2
XFILLER_0_38_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15371_ _06912_ _06914_ VGND VGND VPWR VPWR _06996_ sky130_fd_sc_hd__or2b_1
X_12583_ _03774_ _03776_ VGND VGND VPWR VPWR _03955_ sky130_fd_sc_hd__nor2_1
X_14322_ _05835_ _05848_ VGND VGND VPWR VPWR _05849_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_92_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_108_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11534_ net730 net738 net463 net453 VGND VGND VPWR VPWR _02813_ sky130_fd_sc_hd__and4_1
XFILLER_0_136_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14253_ net263 net148 _05772_ _05773_ VGND VGND VPWR VPWR _05775_ sky130_fd_sc_hd__a31o_1
X_11465_ _02718_ _02737_ VGND VGND VPWR VPWR _02738_ sky130_fd_sc_hd__xor2_2
XFILLER_0_80_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_708 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13204_ _04454_ _04542_ _04632_ _04634_ VGND VGND VPWR VPWR _04635_ sky130_fd_sc_hd__o211a_1
XFILLER_0_150_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10416_ net787 net490 net481 net801 VGND VGND VPWR VPWR _01642_ sky130_fd_sc_hd__a22oi_1
XPHY_EDGE_ROW_36_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14184_ net271 net137 _05697_ VGND VGND VPWR VPWR _05700_ sky130_fd_sc_hd__and3_1
X_11396_ _02656_ _02662_ VGND VGND VPWR VPWR _02663_ sky130_fd_sc_hd__xor2_2
XFILLER_0_0_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13135_ net783 net250 VGND VGND VPWR VPWR _04559_ sky130_fd_sc_hd__nand2_1
X_10347_ _01569_ _01575_ _01578_ VGND VGND VPWR VPWR _01580_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_0_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13066_ _04395_ _04397_ _04396_ VGND VGND VPWR VPWR _04484_ sky130_fd_sc_hd__o21bai_1
X_10278_ Q_cos\[4\] D_sin\[4\] VGND VGND VPWR VPWR _01520_ sky130_fd_sc_hd__or2b_1
X_12017_ _03334_ _03337_ VGND VGND VPWR VPWR _03338_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_136_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_45_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmax_cap1 _06577_ VGND VGND VPWR VPWR net930 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13968_ _05442_ _05443_ _05465_ VGND VGND VPWR VPWR _05466_ sky130_fd_sc_hd__o21a_1
X_15707_ _07272_ _07362_ VGND VGND VPWR VPWR _07363_ sky130_fd_sc_hd__nand2_1
X_12919_ _04321_ _04322_ _04323_ VGND VGND VPWR VPWR _04324_ sky130_fd_sc_hd__or3_4
X_13899_ _05388_ _05389_ _05320_ _05300_ VGND VGND VPWR VPWR _05391_ sky130_fd_sc_hd__o211a_1
XFILLER_0_146_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15638_ _07285_ _07286_ VGND VGND VPWR VPWR _07287_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_145_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15569_ _07195_ _07210_ VGND VGND VPWR VPWR _07212_ sky130_fd_sc_hd__or2_1
XFILLER_0_90_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_127_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09090_ _00337_ _00368_ _00369_ VGND VGND VPWR VPWR _00370_ sky130_fd_sc_hd__nand3_1
XFILLER_0_43_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_126_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_872 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_141_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09992_ net646 net636 net457 net448 VGND VGND VPWR VPWR _01260_ sky130_fd_sc_hd__and4_1
X_08943_ net694 net535 net357 net351 VGND VGND VPWR VPWR _00224_ sky130_fd_sc_hd__nand4_2
XFILLER_0_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_15_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_15_0_clk sky130_fd_sc_hd__clkbuf_8
X_08874_ net640 net631 net520 net433 VGND VGND VPWR VPWR _00156_ sky130_fd_sc_hd__and4_1
XFILLER_0_79_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09426_ _00623_ _00635_ VGND VGND VPWR VPWR _00702_ sky130_fd_sc_hd__nor2_1
XFILLER_0_149_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09357_ _00622_ _00623_ _00632_ _00633_ VGND VGND VPWR VPWR _00634_ sky130_fd_sc_hd__a2bb2oi_1
XFILLER_0_19_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08308_ net558 net351 net504 net567 VGND VGND VPWR VPWR _03954_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_118_874 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09288_ _00479_ _00565_ VGND VGND VPWR VPWR _00566_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_90_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08239_ _03138_ _03181_ _03192_ VGND VGND VPWR VPWR _03203_ sky130_fd_sc_hd__nand3_1
XFILLER_0_15_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11250_ net732 net740 net491 VGND VGND VPWR VPWR _02503_ sky130_fd_sc_hd__and3_1
XFILLER_0_120_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10201_ D_cos\[12\] Q_sin\[12\] VGND VGND VPWR VPWR _01454_ sky130_fd_sc_hd__and2b_1
X_11181_ _02418_ _02426_ _02427_ VGND VGND VPWR VPWR _02428_ sky130_fd_sc_hd__nand3_2
X_10132_ net135 _01392_ _01393_ _01394_ VGND VGND VPWR VPWR _00021_ sky130_fd_sc_hd__a31o_1
X_10063_ _01251_ _01329_ VGND VGND VPWR VPWR _01330_ sky130_fd_sc_hd__nand2_1
X_14940_ _06087_ _06106_ _06107_ VGND VGND VPWR VPWR _06527_ sky130_fd_sc_hd__nand3_2
X_14871_ _06428_ _06429_ _06423_ VGND VGND VPWR VPWR _06452_ sky130_fd_sc_hd__a21oi_1
X_13822_ _05304_ _05306_ VGND VGND VPWR VPWR _05307_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13753_ _05231_ VGND VGND VPWR VPWR _00086_ sky130_fd_sc_hd__clkbuf_1
X_10965_ _02192_ _01659_ _02191_ VGND VGND VPWR VPWR _02193_ sky130_fd_sc_hd__or3b_1
XFILLER_0_97_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12704_ _04084_ _04085_ _04087_ VGND VGND VPWR VPWR _04088_ sky130_fd_sc_hd__nand3_1
X_13684_ _05110_ _05114_ _05111_ VGND VGND VPWR VPWR _05157_ sky130_fd_sc_hd__o21ba_1
X_10896_ net770 net438 VGND VGND VPWR VPWR _02122_ sky130_fd_sc_hd__nand2_1
XFILLER_0_128_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15423_ net201 net632 net624 net211 VGND VGND VPWR VPWR _07054_ sky130_fd_sc_hd__a22o_1
X_12635_ _03953_ _03957_ _04010_ _04011_ VGND VGND VPWR VPWR _04012_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_109_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15354_ _06894_ _06978_ VGND VGND VPWR VPWR _06979_ sky130_fd_sc_hd__nand2_1
X_12566_ _03931_ _03934_ _03933_ VGND VGND VPWR VPWR _03936_ sky130_fd_sc_hd__a21o_1
XFILLER_0_25_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_108_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11517_ _02694_ _02696_ _02793_ VGND VGND VPWR VPWR _02795_ sky130_fd_sc_hd__and3_1
X_14305_ _05827_ _05830_ VGND VGND VPWR VPWR _05831_ sky130_fd_sc_hd__xnor2_1
X_15285_ net265 net932 net575 VGND VGND VPWR VPWR _06903_ sky130_fd_sc_hd__and3_1
XFILLER_0_123_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12497_ _03853_ _03858_ _03847_ VGND VGND VPWR VPWR _03860_ sky130_fd_sc_hd__a21o_1
XFILLER_0_124_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14236_ _05697_ _05755_ VGND VGND VPWR VPWR _05756_ sky130_fd_sc_hd__xor2_1
X_11448_ _02631_ _02646_ _02647_ _02651_ VGND VGND VPWR VPWR _02719_ sky130_fd_sc_hd__a31o_1
XFILLER_0_111_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14167_ _05680_ _05681_ VGND VGND VPWR VPWR _05682_ sky130_fd_sc_hd__xor2_2
XFILLER_0_1_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11379_ _02641_ _02642_ _02643_ VGND VGND VPWR VPWR _02644_ sky130_fd_sc_hd__nand3_2
X_13118_ _04539_ VGND VGND VPWR VPWR _04540_ sky130_fd_sc_hd__clkbuf_8
X_14098_ _05509_ _05606_ VGND VGND VPWR VPWR _05607_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_147_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13049_ net722 net161 net312 net731 VGND VGND VPWR VPWR _04465_ sky130_fd_sc_hd__a22o_1
XFILLER_0_147_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_53_Left_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08590_ _07020_ VGND VGND VPWR VPWR _07031_ sky130_fd_sc_hd__inv_2
XFILLER_0_49_706 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_886 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09211_ net556 net458 net449 net564 VGND VGND VPWR VPWR _00489_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_134_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09142_ net682 net348 net501 net934 VGND VGND VPWR VPWR _00421_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_62_Left_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09073_ _00254_ _00255_ net631 net432 VGND VGND VPWR VPWR _00353_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_126_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_674 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout3 net256 VGND VGND VPWR VPWR net932 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_102_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_130_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09975_ _01074_ _01242_ VGND VGND VPWR VPWR _01243_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_110_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08926_ _00205_ _00206_ VGND VGND VPWR VPWR _00207_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_71_Left_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08857_ _08081_ _08083_ VGND VGND VPWR VPWR _00139_ sky130_fd_sc_hd__nand2_1
X_08788_ _08096_ _08097_ _08098_ VGND VGND VPWR VPWR _08099_ sky130_fd_sc_hd__nand3_1
XFILLER_0_98_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_823 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10750_ _01917_ _01975_ VGND VGND VPWR VPWR _01976_ sky130_fd_sc_hd__or2_1
XFILLER_0_149_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09409_ _00668_ _00684_ VGND VGND VPWR VPWR _00685_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_80_Left_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10681_ net773 net362 _01625_ _01626_ VGND VGND VPWR VPWR _01907_ sky130_fd_sc_hd__a22o_1
XFILLER_0_137_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12420_ net805 _03730_ _03744_ VGND VGND VPWR VPWR _03775_ sky130_fd_sc_hd__and3_1
XFILLER_0_124_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12351_ _03696_ _03697_ _03698_ VGND VGND VPWR VPWR _03699_ sky130_fd_sc_hd__nand3_1
XFILLER_0_62_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11302_ _02466_ _02525_ _02558_ _02559_ VGND VGND VPWR VPWR _02560_ sky130_fd_sc_hd__a211oi_4
X_15070_ _06566_ _06586_ _06667_ _06668_ VGND VGND VPWR VPWR _06669_ sky130_fd_sc_hd__a211o_4
X_12282_ _03353_ _03624_ VGND VGND VPWR VPWR _03625_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_132_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14021_ _05418_ _05420_ VGND VGND VPWR VPWR _05523_ sky130_fd_sc_hd__nor2_1
X_11233_ _02388_ _02483_ _02484_ VGND VGND VPWR VPWR _02486_ sky130_fd_sc_hd__nand3_1
X_11164_ _02407_ _02409_ VGND VGND VPWR VPWR _02410_ sky130_fd_sc_hd__xor2_1
X_10115_ _01380_ VGND VGND VPWR VPWR _00018_ sky130_fd_sc_hd__clkbuf_1
X_15972_ _07280_ _07573_ VGND VGND VPWR VPWR _07650_ sky130_fd_sc_hd__and2_1
X_11095_ net614 net376 net367 net707 VGND VGND VPWR VPWR _02335_ sky130_fd_sc_hd__a22o_1
X_14923_ net276 net594 VGND VGND VPWR VPWR _06509_ sky130_fd_sc_hd__nand2_1
X_10046_ _01311_ _01312_ VGND VGND VPWR VPWR _01313_ sky130_fd_sc_hd__nor2_1
X_14854_ _06395_ _06408_ _06431_ VGND VGND VPWR VPWR _06434_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_58_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13805_ _05282_ _05288_ VGND VGND VPWR VPWR _05289_ sky130_fd_sc_hd__xnor2_1
X_14785_ _06271_ _06336_ VGND VGND VPWR VPWR _06358_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11997_ _03248_ _03316_ VGND VGND VPWR VPWR _03317_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_119_Left_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10948_ _02081_ _02173_ _02174_ _02175_ VGND VGND VPWR VPWR _02176_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_85_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13736_ _05078_ _05212_ _05213_ VGND VGND VPWR VPWR _05214_ sky130_fd_sc_hd__o21a_1
XFILLER_0_42_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13667_ _05138_ VGND VGND VPWR VPWR _00085_ sky130_fd_sc_hd__clkbuf_1
X_10879_ net778 net786 net418 net411 VGND VGND VPWR VPWR _02105_ sky130_fd_sc_hd__and4_1
XFILLER_0_54_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15406_ _07032_ _07033_ _07024_ VGND VGND VPWR VPWR _07035_ sky130_fd_sc_hd__a21o_1
XFILLER_0_116_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12618_ _03937_ _03942_ VGND VGND VPWR VPWR _03993_ sky130_fd_sc_hd__or2b_1
X_16386_ clknet_4_15_0_clk _00099_ net344 VGND VGND VPWR VPWR Q_sin\[3\] sky130_fd_sc_hd__dfrtp_1
X_13598_ net721 net267 net257 net729 VGND VGND VPWR VPWR _05063_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_26_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15337_ _06959_ _06858_ net220 VGND VGND VPWR VPWR _06960_ sky130_fd_sc_hd__mux2_1
X_12549_ net329 net244 net709 net717 VGND VGND VPWR VPWR _03917_ sky130_fd_sc_hd__and4_1
XFILLER_0_101_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_124_663 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_1 _00311_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_15268_ _06685_ _06667_ _06772_ _06773_ VGND VGND VPWR VPWR _06885_ sky130_fd_sc_hd__o211a_1
XFILLER_0_123_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14219_ _05736_ _05737_ _05670_ _05673_ VGND VGND VPWR VPWR _05738_ sky130_fd_sc_hd__o211ai_2
X_15199_ _06806_ _06808_ VGND VGND VPWR VPWR _06809_ sky130_fd_sc_hd__and2_1
XFILLER_0_22_694 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout508 net509 VGND VGND VPWR VPWR net508 sky130_fd_sc_hd__clkbuf_2
Xfanout519 net4 VGND VGND VPWR VPWR net519 sky130_fd_sc_hd__clkbuf_4
X_09760_ _00933_ _00934_ _00958_ VGND VGND VPWR VPWR _01032_ sky130_fd_sc_hd__a21bo_1
X_08711_ _08000_ _08020_ _08021_ _08022_ VGND VGND VPWR VPWR _08023_ sky130_fd_sc_hd__a211o_1
X_09691_ _00961_ _00963_ VGND VGND VPWR VPWR _00964_ sky130_fd_sc_hd__xor2_1
X_08642_ _07271_ _07260_ _07249_ VGND VGND VPWR VPWR _07597_ sky130_fd_sc_hd__o21ai_1
Xrebuffer13 _06112_ VGND VGND VPWR VPWR net819 sky130_fd_sc_hd__clkbuf_2
Xrebuffer24 _06110_ VGND VGND VPWR VPWR net830 sky130_fd_sc_hd__clkbuf_1
Xrebuffer35 _04763_ VGND VGND VPWR VPWR net841 sky130_fd_sc_hd__clkbuf_1
Xrebuffer46 _04321_ VGND VGND VPWR VPWR net852 sky130_fd_sc_hd__buf_1
XFILLER_0_77_801 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08573_ _06813_ _06824_ _06781_ VGND VGND VPWR VPWR _06846_ sky130_fd_sc_hd__a21o_1
Xrebuffer57 net862 VGND VGND VPWR VPWR net863 sky130_fd_sc_hd__clkbuf_1
Xrebuffer68 _06511_ VGND VGND VPWR VPWR net874 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_107_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer79 net884 VGND VGND VPWR VPWR net885 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_146_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer103 _06558_ VGND VGND VPWR VPWR net942 sky130_fd_sc_hd__dlymetal6s2s_1
X_09125_ _00403_ VGND VGND VPWR VPWR _00404_ sky130_fd_sc_hd__inv_2
XFILLER_0_72_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09056_ _00334_ _00335_ VGND VGND VPWR VPWR _00336_ sky130_fd_sc_hd__nor2_1
XFILLER_0_114_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09958_ _01171_ _01226_ VGND VGND VPWR VPWR _01227_ sky130_fd_sc_hd__xnor2_2
X_08909_ net48 VGND VGND VPWR VPWR _00190_ sky130_fd_sc_hd__inv_2
X_09889_ _01071_ _01092_ _01069_ VGND VGND VPWR VPWR _01159_ sky130_fd_sc_hd__o21ai_1
X_11920_ _03157_ _03155_ VGND VGND VPWR VPWR _03233_ sky130_fd_sc_hd__and2b_1
X_11851_ _03155_ _03157_ VGND VGND VPWR VPWR _03158_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_68_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10802_ net777 net389 _02020_ _02019_ VGND VGND VPWR VPWR _02028_ sky130_fd_sc_hd__a31o_1
X_14570_ _06119_ _06120_ VGND VGND VPWR VPWR _06121_ sky130_fd_sc_hd__or2_4
XFILLER_0_67_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11782_ _03082_ VGND VGND VPWR VPWR _00067_ sky130_fd_sc_hd__clkbuf_1
X_10733_ _01948_ _01949_ _01940_ _01942_ VGND VGND VPWR VPWR _01959_ sky130_fd_sc_hd__o211a_1
X_13521_ _04963_ _04978_ VGND VGND VPWR VPWR _04979_ sky130_fd_sc_hd__xor2_1
XFILLER_0_55_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_859 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16240_ _07939_ _07940_ VGND VGND VPWR VPWR _07941_ sky130_fd_sc_hd__nor2_1
X_13452_ _04900_ _04901_ _04902_ VGND VGND VPWR VPWR _04904_ sky130_fd_sc_hd__a21o_1
X_10664_ net760 net769 net380 net370 VGND VGND VPWR VPWR _01890_ sky130_fd_sc_hd__and4_1
XFILLER_0_137_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_125_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12403_ _03753_ _03754_ _03755_ VGND VGND VPWR VPWR _03757_ sky130_fd_sc_hd__nand3_1
XFILLER_0_23_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16171_ _07782_ _07780_ VGND VGND VPWR VPWR _07866_ sky130_fd_sc_hd__and2b_1
X_13383_ _04816_ _04828_ VGND VGND VPWR VPWR _04830_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_51_723 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10595_ _01818_ _01819_ _01758_ _01762_ VGND VGND VPWR VPWR _01821_ sky130_fd_sc_hd__a211o_1
X_15122_ _06708_ _06723_ _06724_ VGND VGND VPWR VPWR _06725_ sky130_fd_sc_hd__nand3_1
X_12334_ _03636_ _03638_ _03681_ VGND VGND VPWR VPWR _03682_ sky130_fd_sc_hd__a21o_1
X_15053_ _06647_ _06648_ _06649_ VGND VGND VPWR VPWR _06651_ sky130_fd_sc_hd__nand3_1
X_12265_ _03499_ _03542_ _03605_ VGND VGND VPWR VPWR _03607_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_120_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_128_Right_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14004_ _05483_ _05504_ VGND VGND VPWR VPWR _05505_ sky130_fd_sc_hd__and2_1
XFILLER_0_121_677 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11216_ _02462_ _02464_ _02465_ VGND VGND VPWR VPWR _02467_ sky130_fd_sc_hd__a21o_1
X_12196_ D_cos\[15\] _03532_ _03242_ VGND VGND VPWR VPWR _03533_ sky130_fd_sc_hd__mux2_1
Xoutput82 net82 VGND VGND VPWR VPWR alpha[12] sky130_fd_sc_hd__clkbuf_4
Xoutput93 net93 VGND VGND VPWR VPWR alpha[5] sky130_fd_sc_hd__clkbuf_4
X_11147_ _02308_ _02324_ _02325_ _02328_ VGND VGND VPWR VPWR _02391_ sky130_fd_sc_hd__a31o_1
XFILLER_0_128_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15955_ net247 net681 VGND VGND VPWR VPWR _07632_ sky130_fd_sc_hd__nand2_1
X_11078_ net724 net732 net354 net509 VGND VGND VPWR VPWR _02316_ sky130_fd_sc_hd__nand4_1
X_10029_ _01074_ _01295_ VGND VGND VPWR VPWR _01296_ sky130_fd_sc_hd__xnor2_1
X_14906_ net266 net256 net601 VGND VGND VPWR VPWR _06490_ sky130_fd_sc_hd__and3_1
X_15886_ net304 net628 net619 net155 VGND VGND VPWR VPWR _07557_ sky130_fd_sc_hd__a22oi_1
X_14837_ net325 net240 net589 net597 VGND VGND VPWR VPWR _06415_ sky130_fd_sc_hd__nand4_2
XFILLER_0_144_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14768_ _06269_ _06281_ _06280_ VGND VGND VPWR VPWR _06339_ sky130_fd_sc_hd__o21ai_1
X_13719_ net729 net250 VGND VGND VPWR VPWR _05195_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_720 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14699_ net221 net561 _06142_ _06141_ VGND VGND VPWR VPWR _06263_ sky130_fd_sc_hd__a22o_1
XFILLER_0_144_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16369_ clknet_4_11_0_clk _00082_ net341 VGND VGND VPWR VPWR D_sin\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_41_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout305 net307 VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__buf_2
Xfanout316 net317 VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__clkbuf_4
X_09812_ net626 net493 VGND VGND VPWR VPWR _01083_ sky130_fd_sc_hd__nand2_1
Xfanout327 net331 VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__clkbuf_4
Xfanout338 net339 VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__clkbuf_4
Xfanout349 net57 VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__clkbuf_4
X_09743_ net689 net441 VGND VGND VPWR VPWR _01015_ sky130_fd_sc_hd__nand2_1
X_09674_ _00870_ _00873_ _00871_ VGND VGND VPWR VPWR _00947_ sky130_fd_sc_hd__o21ba_1
X_08625_ _06617_ _06682_ _06672_ VGND VGND VPWR VPWR _07412_ sky130_fd_sc_hd__o21a_1
XFILLER_0_49_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_631 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08556_ net699 net352 _06628_ _06639_ VGND VGND VPWR VPWR _06661_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_49_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08487_ _04774_ _04763_ _04513_ _03822_ VGND VGND VPWR VPWR _05904_ sky130_fd_sc_hd__a211o_1
XFILLER_0_37_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_848 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09108_ _00381_ _00379_ VGND VGND VPWR VPWR _00387_ sky130_fd_sc_hd__and2b_1
X_10380_ _01608_ VGND VGND VPWR VPWR _00055_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09039_ net548 net557 net488 VGND VGND VPWR VPWR _00319_ sky130_fd_sc_hd__and3_1
XFILLER_0_20_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12050_ _03350_ _03373_ VGND VGND VPWR VPWR _03374_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_102_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_130_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11001_ _02229_ _02230_ _02209_ _02210_ VGND VGND VPWR VPWR _02232_ sky130_fd_sc_hd__a211o_1
XFILLER_0_99_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15740_ _07060_ _07219_ VGND VGND VPWR VPWR _07398_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12952_ _04281_ _04289_ _04288_ VGND VGND VPWR VPWR _04359_ sky130_fd_sc_hd__a21o_1
X_11903_ _03133_ _03139_ VGND VGND VPWR VPWR _03215_ sky130_fd_sc_hd__and2_1
X_15671_ _07321_ _07322_ VGND VGND VPWR VPWR _07323_ sky130_fd_sc_hd__or2_1
XFILLER_0_87_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12883_ net716 net191 net180 net725 VGND VGND VPWR VPWR _04285_ sky130_fd_sc_hd__nand4_2
X_14622_ net196 net571 _06132_ _06131_ VGND VGND VPWR VPWR _06178_ sky130_fd_sc_hd__a31o_1
X_11834_ _03133_ _03139_ VGND VGND VPWR VPWR _03140_ sky130_fd_sc_hd__xor2_2
XFILLER_0_67_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14553_ _06093_ _06100_ _06101_ VGND VGND VPWR VPWR _06103_ sky130_fd_sc_hd__nand3_2
X_11765_ _03063_ _03064_ VGND VGND VPWR VPWR _03065_ sky130_fd_sc_hd__or2_1
XFILLER_0_83_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_138_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_138_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10716_ _01923_ _01940_ _01941_ VGND VGND VPWR VPWR _01942_ sky130_fd_sc_hd__nand3_1
X_13504_ net766 _04538_ _04880_ _04960_ VGND VGND VPWR VPWR _04961_ sky130_fd_sc_hd__o31ai_2
XFILLER_0_71_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14484_ _06019_ _06026_ VGND VGND VPWR VPWR _06027_ sky130_fd_sc_hd__xnor2_1
X_11696_ _02923_ _02971_ VGND VGND VPWR VPWR _02989_ sky130_fd_sc_hd__nand2_1
XFILLER_0_71_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16223_ _07658_ _07920_ VGND VGND VPWR VPWR _07923_ sky130_fd_sc_hd__nor2_1
XFILLER_0_125_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10647_ net734 net438 VGND VGND VPWR VPWR _01873_ sky130_fd_sc_hd__and2_1
X_13435_ _04863_ _04885_ VGND VGND VPWR VPWR _04886_ sky130_fd_sc_hd__xor2_2
XFILLER_0_3_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_113_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer4 net809 VGND VGND VPWR VPWR net810 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_140_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16154_ _07845_ _07847_ VGND VGND VPWR VPWR _07848_ sky130_fd_sc_hd__or2_1
X_13366_ net319 net185 net175 net427 VGND VGND VPWR VPWR _04811_ sky130_fd_sc_hd__a22o_1
X_10578_ _01801_ _01802_ _01803_ VGND VGND VPWR VPWR _01804_ sky130_fd_sc_hd__or3_1
XFILLER_0_2_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15105_ _06616_ _06619_ VGND VGND VPWR VPWR _06707_ sky130_fd_sc_hd__nand2_1
X_12317_ _03661_ _03662_ VGND VGND VPWR VPWR _03663_ sky130_fd_sc_hd__xor2_1
XFILLER_0_133_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16085_ _07735_ _07739_ _07736_ VGND VGND VPWR VPWR _07773_ sky130_fd_sc_hd__o21ba_1
X_13297_ _04624_ _04674_ _04734_ _04735_ VGND VGND VPWR VPWR _04736_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_23_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15036_ net166 net534 _06630_ _06631_ VGND VGND VPWR VPWR _06632_ sky130_fd_sc_hd__a22o_1
X_12248_ _03537_ _03588_ VGND VGND VPWR VPWR _03589_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_48_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12179_ _03348_ _03450_ _03512_ VGND VGND VPWR VPWR _03514_ sky130_fd_sc_hd__a21o_1
X_15938_ _07611_ _07613_ VGND VGND VPWR VPWR _07614_ sky130_fd_sc_hd__xor2_1
X_15869_ _07460_ _07538_ VGND VGND VPWR VPWR _07539_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_149_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08410_ _05036_ _05047_ VGND VGND VPWR VPWR _05068_ sky130_fd_sc_hd__and2b_1
X_09390_ _00573_ _00590_ _00665_ VGND VGND VPWR VPWR _00666_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_148_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08341_ _04284_ _04295_ _04306_ VGND VGND VPWR VPWR _04317_ sky130_fd_sc_hd__nand3_1
XFILLER_0_80_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08272_ net686 net695 net404 net393 VGND VGND VPWR VPWR _03561_ sky130_fd_sc_hd__and4_1
XFILLER_0_74_678 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_129_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_144_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_116_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_125_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_120_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout135 state VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__clkbuf_4
Xfanout146 net147 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__clkbuf_2
Xfanout157 net158 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__clkbuf_4
Xfanout168 net76 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__clkbuf_4
Xfanout179 net181 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__clkbuf_4
X_09726_ _00766_ _00927_ _00764_ VGND VGND VPWR VPWR _00998_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_97_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09657_ _00928_ _00929_ VGND VGND VPWR VPWR _00930_ sky130_fd_sc_hd__xnor2_1
X_08608_ _06157_ _06135_ _06146_ VGND VGND VPWR VPWR _07227_ sky130_fd_sc_hd__or3_1
X_09588_ _00860_ _00847_ _00848_ VGND VGND VPWR VPWR _00862_ sky130_fd_sc_hd__or3_2
X_08539_ _06212_ _06245_ _06223_ VGND VGND VPWR VPWR _06476_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_148_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_656 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_11550_ _02761_ _02769_ _02829_ VGND VGND VPWR VPWR _02830_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_107_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10501_ _01670_ _01671_ VGND VGND VPWR VPWR _01727_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_52_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11481_ _02751_ _02752_ _02753_ VGND VGND VPWR VPWR _02755_ sky130_fd_sc_hd__a21o_1
XFILLER_0_107_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13220_ _04561_ _04562_ _04650_ VGND VGND VPWR VPWR _04651_ sky130_fd_sc_hd__a21o_1
X_10432_ _01652_ _01656_ _01657_ _01646_ VGND VGND VPWR VPWR _01658_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_150_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13151_ _04573_ _04574_ _04575_ VGND VGND VPWR VPWR _04576_ sky130_fd_sc_hd__a21o_1
XFILLER_0_150_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10363_ _01583_ _01586_ _01592_ VGND VGND VPWR VPWR _01594_ sky130_fd_sc_hd__o21ai_1
X_12102_ _03427_ _03428_ VGND VGND VPWR VPWR _03430_ sky130_fd_sc_hd__or2_1
X_13082_ net327 net242 net153 net143 VGND VGND VPWR VPWR _04501_ sky130_fd_sc_hd__and4_2
X_10294_ _01525_ _01528_ _01526_ VGND VGND VPWR VPWR _01534_ sky130_fd_sc_hd__a21bo_1
X_12033_ net145 net485 net475 net227 VGND VGND VPWR VPWR _03356_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_18_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout680 net688 VGND VGND VPWR VPWR net680 sky130_fd_sc_hd__buf_4
Xfanout691 net692 VGND VGND VPWR VPWR net691 sky130_fd_sc_hd__clkbuf_2
X_13984_ _05461_ _05462_ _05482_ VGND VGND VPWR VPWR _05483_ sky130_fd_sc_hd__o21ai_1
X_15723_ net290 net665 net671 net281 VGND VGND VPWR VPWR _07380_ sky130_fd_sc_hd__a22oi_2
X_12935_ _04321_ _04322_ _04323_ VGND VGND VPWR VPWR _04341_ sky130_fd_sc_hd__nor3_2
XFILLER_0_88_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15654_ net272 net690 VGND VGND VPWR VPWR _07305_ sky130_fd_sc_hd__nand2_1
X_12866_ _04264_ _04265_ VGND VGND VPWR VPWR _04266_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14605_ net187 net177 net581 net590 VGND VGND VPWR VPWR _06160_ sky130_fd_sc_hd__and4_1
XFILLER_0_8_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11817_ _03118_ _03119_ _03103_ VGND VGND VPWR VPWR _03121_ sky130_fd_sc_hd__a21o_1
X_15585_ _07228_ _07229_ VGND VGND VPWR VPWR _07230_ sky130_fd_sc_hd__xnor2_1
X_12797_ _04103_ _04105_ _04104_ VGND VGND VPWR VPWR _04190_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_56_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14536_ _06078_ _06082_ _06083_ VGND VGND VPWR VPWR _06084_ sky130_fd_sc_hd__and3_1
XFILLER_0_138_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11748_ _03044_ _03045_ VGND VGND VPWR VPWR _03046_ sky130_fd_sc_hd__nor2_1
XFILLER_0_126_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14467_ _05956_ _05975_ _06006_ _06007_ VGND VGND VPWR VPWR _06008_ sky130_fd_sc_hd__a211o_1
XFILLER_0_24_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11679_ _02968_ _02970_ VGND VGND VPWR VPWR _02971_ sky130_fd_sc_hd__xnor2_2
X_16206_ _07902_ _07903_ VGND VGND VPWR VPWR _07904_ sky130_fd_sc_hd__or2b_1
X_13418_ _04789_ _04792_ _04790_ VGND VGND VPWR VPWR _04867_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_24_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14398_ _05928_ _05930_ _05931_ VGND VGND VPWR VPWR _05932_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_113_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16137_ _07828_ _07821_ VGND VGND VPWR VPWR _07829_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13349_ net738 net275 VGND VGND VPWR VPWR _04792_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16068_ _07680_ _07647_ _07648_ VGND VGND VPWR VPWR _07755_ sky130_fd_sc_hd__nor3_1
X_15019_ _06610_ _06611_ _06612_ VGND VGND VPWR VPWR _06613_ sky130_fd_sc_hd__a21o_1
X_08890_ _00169_ _00170_ _00137_ VGND VGND VPWR VPWR _00172_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_79_704 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09511_ _00681_ _00682_ _00785_ VGND VGND VPWR VPWR _00786_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09442_ _00710_ _00717_ VGND VGND VPWR VPWR _00718_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_149_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09373_ _00568_ _00569_ _00648_ VGND VGND VPWR VPWR _00650_ sky130_fd_sc_hd__nand3_1
XFILLER_0_137_809 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08324_ net550 net360 _04108_ _04119_ VGND VGND VPWR VPWR _04130_ sky130_fd_sc_hd__a22o_1
X_08255_ _02735_ _03366_ VGND VGND VPWR VPWR _03377_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_753 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08186_ net699 net489 VGND VGND VPWR VPWR _02626_ sky130_fd_sc_hd__nand2_1
XFILLER_0_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_120_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_113_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_112_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09709_ net645 net483 net473 net654 VGND VGND VPWR VPWR _00981_ sky130_fd_sc_hd__a22oi_2
X_10981_ _01772_ _01779_ VGND VGND VPWR VPWR _02210_ sky130_fd_sc_hd__and2_1
X_12720_ net191 net736 net744 net180 VGND VGND VPWR VPWR _04105_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_139_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12651_ net163 net311 net773 net775 VGND VGND VPWR VPWR _04029_ sky130_fd_sc_hd__and4_1
XFILLER_0_38_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11602_ _02804_ _02886_ VGND VGND VPWR VPWR _02887_ sky130_fd_sc_hd__xnor2_2
X_15370_ _06899_ _06918_ _06994_ VGND VGND VPWR VPWR _06995_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_93_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12582_ _03812_ net126 _03951_ _03952_ VGND VGND VPWR VPWR _03953_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_26_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14321_ _05800_ _05847_ VGND VGND VPWR VPWR _05848_ sky130_fd_sc_hd__xnor2_1
X_11533_ net729 net463 net453 net738 VGND VGND VPWR VPWR _02812_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_37_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11464_ _02719_ _02736_ VGND VGND VPWR VPWR _02737_ sky130_fd_sc_hd__xnor2_2
X_14252_ net148 net254 net138 net263 VGND VGND VPWR VPWR _05773_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_52_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10415_ net787 net801 net490 net481 VGND VGND VPWR VPWR _01641_ sky130_fd_sc_hd__and4_1
X_13203_ _04630_ _04631_ _04543_ _04522_ VGND VGND VPWR VPWR _04634_ sky130_fd_sc_hd__a211o_1
XFILLER_0_123_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11395_ _02660_ _02661_ VGND VGND VPWR VPWR _02662_ sky130_fd_sc_hd__xor2_2
X_14183_ net271 net138 _05697_ VGND VGND VPWR VPWR _05699_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_21_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10346_ _01569_ _01575_ _01578_ VGND VGND VPWR VPWR _01579_ sky130_fd_sc_hd__or3_1
X_13134_ _04555_ _04557_ VGND VGND VPWR VPWR _04558_ sky130_fd_sc_hd__xor2_1
XFILLER_0_131_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13065_ _04387_ _04389_ VGND VGND VPWR VPWR _04483_ sky130_fd_sc_hd__nand2_1
X_10277_ D_sin\[4\] Q_cos\[4\] VGND VGND VPWR VPWR _01519_ sky130_fd_sc_hd__or2b_1
X_12016_ _03335_ _03336_ VGND VGND VPWR VPWR _03337_ sky130_fd_sc_hd__nor2_1
XFILLER_0_136_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13967_ _05445_ _05464_ VGND VGND VPWR VPWR _05465_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_100_Left_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15706_ _07359_ _07361_ VGND VGND VPWR VPWR _07362_ sky130_fd_sc_hd__xor2_1
XFILLER_0_76_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12918_ _04232_ _04236_ _04231_ VGND VGND VPWR VPWR _04323_ sky130_fd_sc_hd__a21oi_1
X_13898_ _05320_ _05300_ _05388_ _05389_ VGND VGND VPWR VPWR _05390_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_0_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15637_ net182 net172 net632 net623 VGND VGND VPWR VPWR _07286_ sky130_fd_sc_hd__and4_1
XFILLER_0_61_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12849_ net800 net267 _04246_ VGND VGND VPWR VPWR _04247_ sky130_fd_sc_hd__and3_1
XFILLER_0_84_740 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_131_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_807 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15568_ _07195_ _07210_ VGND VGND VPWR VPWR _07211_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14519_ net159 net308 net557 net566 VGND VGND VPWR VPWR _06065_ sky130_fd_sc_hd__and4_1
XFILLER_0_4_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15499_ _07133_ _07134_ _07119_ VGND VGND VPWR VPWR _07136_ sky130_fd_sc_hd__a21o_1
XFILLER_0_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_709 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09991_ net636 net457 VGND VGND VPWR VPWR _01259_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08942_ net694 net357 net351 net535 VGND VGND VPWR VPWR _00223_ sky130_fd_sc_hd__a22o_1
XFILLER_0_110_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08873_ net630 net520 net432 net640 VGND VGND VPWR VPWR _00155_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_149_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09425_ _00691_ _00700_ VGND VGND VPWR VPWR _00701_ sky130_fd_sc_hd__xor2_1
XFILLER_0_137_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09356_ _00630_ _00631_ _00624_ VGND VGND VPWR VPWR _00633_ sky130_fd_sc_hd__a21o_1
XFILLER_0_47_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_853 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08307_ net577 net497 VGND VGND VPWR VPWR _03943_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09287_ _00480_ _00564_ VGND VGND VPWR VPWR _00565_ sky130_fd_sc_hd__xor2_1
XFILLER_0_117_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_117_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08238_ net902 _03127_ _03116_ VGND VGND VPWR VPWR _03192_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_62_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_862 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_132_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08169_ net587 net595 net352 net504 VGND VGND VPWR VPWR _02441_ sky130_fd_sc_hd__and4_1
X_10200_ Q_sin\[12\] D_cos\[12\] VGND VGND VPWR VPWR _01453_ sky130_fd_sc_hd__and2b_1
X_11180_ _02423_ _02424_ _02425_ VGND VGND VPWR VPWR _02427_ sky130_fd_sc_hd__a21o_1
X_10131_ net135 net90 VGND VGND VPWR VPWR _01394_ sky130_fd_sc_hd__and2b_1
X_10062_ _01279_ VGND VGND VPWR VPWR _01329_ sky130_fd_sc_hd__inv_2
XFILLER_0_100_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14870_ _06444_ _06448_ _06450_ VGND VGND VPWR VPWR _06451_ sky130_fd_sc_hd__o21a_1
X_13821_ _05183_ _05184_ _05305_ VGND VGND VPWR VPWR _05306_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_15_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13752_ D_sin\[9\] _05230_ _04752_ VGND VGND VPWR VPWR _05231_ sky130_fd_sc_hd__mux2_1
XFILLER_0_97_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10964_ _01822_ _01823_ _01854_ VGND VGND VPWR VPWR _02192_ sky130_fd_sc_hd__o21a_1
X_12703_ _04081_ _04083_ _04082_ VGND VGND VPWR VPWR _04087_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_85_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13683_ _05153_ _05154_ VGND VGND VPWR VPWR _05156_ sky130_fd_sc_hd__xnor2_1
X_10895_ _02118_ _02120_ VGND VGND VPWR VPWR _02121_ sky130_fd_sc_hd__nor2_1
X_15422_ _07051_ _06960_ VGND VGND VPWR VPWR _07052_ sky130_fd_sc_hd__nor2_2
X_12634_ _04007_ _04008_ _03914_ VGND VGND VPWR VPWR _04011_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_53_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15353_ _06896_ _06976_ VGND VGND VPWR VPWR _06978_ sky130_fd_sc_hd__xor2_1
X_12565_ _03931_ _03933_ _03934_ VGND VGND VPWR VPWR _03935_ sky130_fd_sc_hd__nand3_2
XFILLER_0_80_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14304_ _05760_ _05829_ VGND VGND VPWR VPWR _05830_ sky130_fd_sc_hd__xnor2_1
X_11516_ _02694_ _02696_ _02793_ VGND VGND VPWR VPWR _02794_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_80_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15284_ net273 net565 _06821_ _06820_ net555 VGND VGND VPWR VPWR _06902_ sky130_fd_sc_hd__a32o_1
XFILLER_0_124_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12496_ _03847_ _03853_ _03858_ VGND VGND VPWR VPWR _03859_ sky130_fd_sc_hd__nand3_1
XFILLER_0_135_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14235_ net271 net795 VGND VGND VPWR VPWR _05755_ sky130_fd_sc_hd__nand2_1
X_11447_ _02623_ _02624_ _02717_ VGND VGND VPWR VPWR _02718_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_150_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11378_ _02509_ _02511_ _02510_ VGND VGND VPWR VPWR _02643_ sky130_fd_sc_hd__a21bo_1
X_14166_ _05616_ _05619_ _05617_ VGND VGND VPWR VPWR _05681_ sky130_fd_sc_hd__o21ba_1
X_10329_ D_sin\[11\] Q_cos\[11\] VGND VGND VPWR VPWR _01564_ sky130_fd_sc_hd__and2b_1
X_13117_ _04538_ VGND VGND VPWR VPWR _04539_ sky130_fd_sc_hd__buf_6
X_14097_ _05593_ _05605_ VGND VGND VPWR VPWR _05606_ sky130_fd_sc_hd__xnor2_1
X_13048_ _04462_ _04463_ VGND VGND VPWR VPWR _04464_ sky130_fd_sc_hd__xnor2_1
X_14999_ _06589_ _06590_ VGND VGND VPWR VPWR _06591_ sky130_fd_sc_hd__xor2_1
XFILLER_0_72_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_119_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09210_ _00416_ _00419_ _00417_ VGND VGND VPWR VPWR _00488_ sky130_fd_sc_hd__o21bai_2
X_09141_ _00418_ _00419_ VGND VGND VPWR VPWR _00420_ sky130_fd_sc_hd__xor2_1
XFILLER_0_146_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09072_ _00350_ _00351_ VGND VGND VPWR VPWR _00352_ sky130_fd_sc_hd__xor2_2
XFILLER_0_142_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_832 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout4 net184 VGND VGND VPWR VPWR net933 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_13_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09974_ _01206_ _01241_ VGND VGND VPWR VPWR _01242_ sky130_fd_sc_hd__xor2_1
XFILLER_0_0_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08925_ net698 net442 _08132_ _08131_ VGND VGND VPWR VPWR _00206_ sky130_fd_sc_hd__a31oi_2
X_08856_ _08087_ _08104_ net860 VGND VGND VPWR VPWR _00138_ sky130_fd_sc_hd__nand3_2
XFILLER_0_99_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08787_ _04251_ _04273_ _04262_ VGND VGND VPWR VPWR _08098_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_79_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09408_ _00669_ _00683_ VGND VGND VPWR VPWR _00684_ sky130_fd_sc_hd__xnor2_1
X_10680_ net753 net389 _01866_ _01865_ VGND VGND VPWR VPWR _01906_ sky130_fd_sc_hd__a31o_1
XFILLER_0_35_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_784 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09339_ net630 net383 _00614_ _00615_ VGND VGND VPWR VPWR _00616_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_109_Right_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_754 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12350_ net328 net735 net743 net243 VGND VGND VPWR VPWR _03698_ sky130_fd_sc_hd__a22o_1
X_11301_ _02556_ _02557_ _02537_ VGND VGND VPWR VPWR _02559_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_16_692 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12281_ _03505_ _03623_ VGND VGND VPWR VPWR _03624_ sky130_fd_sc_hd__xor2_1
XFILLER_0_132_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11232_ _02481_ _02482_ _02374_ _02377_ VGND VGND VPWR VPWR _02484_ sky130_fd_sc_hd__o211ai_2
X_14020_ _05520_ _05521_ VGND VGND VPWR VPWR _05522_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11163_ _02200_ _02297_ _02298_ _02196_ VGND VGND VPWR VPWR _02409_ sky130_fd_sc_hd__and4b_1
X_10114_ Q_cos\[18\] _01378_ _01379_ VGND VGND VPWR VPWR _01380_ sky130_fd_sc_hd__mux2_1
X_15971_ _07398_ _07573_ VGND VGND VPWR VPWR _07649_ sky130_fd_sc_hd__nor2_2
X_11094_ _02247_ _02249_ _02248_ VGND VGND VPWR VPWR _02334_ sky130_fd_sc_hd__o21bai_1
X_14922_ _06505_ _06506_ VGND VGND VPWR VPWR _06507_ sky130_fd_sc_hd__nor2_1
X_10045_ net647 net442 _01310_ VGND VGND VPWR VPWR _01312_ sky130_fd_sc_hd__and3_1
XFILLER_0_117_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14853_ _06395_ _06408_ _06431_ VGND VGND VPWR VPWR _06433_ sky130_fd_sc_hd__and3_1
XFILLER_0_89_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13804_ _05285_ _05287_ VGND VGND VPWR VPWR _05288_ sky130_fd_sc_hd__xnor2_1
X_14784_ _06340_ _06341_ _06354_ VGND VGND VPWR VPWR _06357_ sky130_fd_sc_hd__nand3_1
XFILLER_0_86_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11996_ _03313_ _03315_ VGND VGND VPWR VPWR _03316_ sky130_fd_sc_hd__xnor2_1
X_13735_ _05121_ _05124_ VGND VGND VPWR VPWR _05213_ sky130_fd_sc_hd__nand2_1
XFILLER_0_133_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10947_ _02095_ _02167_ VGND VGND VPWR VPWR _02175_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_762 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13666_ D_sin\[8\] _05137_ _04752_ VGND VGND VPWR VPWR _05138_ sky130_fd_sc_hd__mux2_1
XFILLER_0_42_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10878_ net778 net418 net411 net786 VGND VGND VPWR VPWR _02104_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15405_ _07024_ _07032_ _07033_ VGND VGND VPWR VPWR _07034_ sky130_fd_sc_hd__nand3_1
X_12617_ _03990_ _03989_ _03958_ _03935_ VGND VGND VPWR VPWR _03992_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_6_829 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16385_ clknet_4_14_0_clk _00098_ net342 VGND VGND VPWR VPWR Q_sin\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_38_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_4_14_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_14_0_clk sky130_fd_sc_hd__clkbuf_8
X_13597_ _04984_ _04987_ _04985_ VGND VGND VPWR VPWR _05062_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_143_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_765 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15336_ net323 net238 net624 VGND VGND VPWR VPWR _06959_ sky130_fd_sc_hd__and3_1
XFILLER_0_54_787 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12548_ _03914_ _03915_ VGND VGND VPWR VPWR _03916_ sky130_fd_sc_hd__nor2_1
XFILLER_0_123_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15267_ _06793_ _06883_ VGND VGND VPWR VPWR _06884_ sky130_fd_sc_hd__xor2_2
XANTENNA_2 _01559_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_12479_ _03825_ _03826_ _03839_ VGND VGND VPWR VPWR _03840_ sky130_fd_sc_hd__and3_1
X_14218_ _05710_ _05735_ VGND VGND VPWR VPWR _05737_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15198_ _06694_ _06696_ _06807_ VGND VGND VPWR VPWR _06808_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_67_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14149_ _05526_ _05599_ _05653_ VGND VGND VPWR VPWR _05662_ sky130_fd_sc_hd__a21o_2
XFILLER_0_1_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout509 net510 VGND VGND VPWR VPWR net509 sky130_fd_sc_hd__clkbuf_4
X_08710_ _07401_ _07423_ VGND VGND VPWR VPWR _08022_ sky130_fd_sc_hd__xnor2_1
X_09690_ _00962_ _00885_ VGND VGND VPWR VPWR _00963_ sky130_fd_sc_hd__or2_1
X_08641_ _07271_ _07249_ _07260_ VGND VGND VPWR VPWR _07586_ sky130_fd_sc_hd__or3_1
XFILLER_0_83_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer14 _06671_ VGND VGND VPWR VPWR net820 sky130_fd_sc_hd__clkbuf_1
Xrebuffer25 _06110_ VGND VGND VPWR VPWR net831 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_83_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer36 _03539_ VGND VGND VPWR VPWR net842 sky130_fd_sc_hd__clkbuf_1
Xrebuffer47 _08122_ VGND VGND VPWR VPWR net853 sky130_fd_sc_hd__dlygate4sd3_1
X_08572_ _06781_ _06813_ _06824_ VGND VGND VPWR VPWR _06835_ sky130_fd_sc_hd__nand3_2
Xrebuffer58 _04720_ VGND VGND VPWR VPWR net864 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_95_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer69 _03225_ VGND VGND VPWR VPWR net875 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_846 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_107_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_146_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer104 _06117_ VGND VGND VPWR VPWR net943 sky130_fd_sc_hd__clkbuf_2
X_09124_ _00301_ _00302_ _00300_ VGND VGND VPWR VPWR _00403_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09055_ _00332_ _00333_ _00318_ VGND VGND VPWR VPWR _00335_ sky130_fd_sc_hd__o21a_1
XFILLER_0_60_746 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09957_ _01224_ _01225_ VGND VGND VPWR VPWR _01226_ sky130_fd_sc_hd__xnor2_2
X_08908_ _00181_ _00182_ VGND VGND VPWR VPWR _00189_ sky130_fd_sc_hd__nand2_1
X_09888_ _01071_ _01157_ VGND VGND VPWR VPWR _01158_ sky130_fd_sc_hd__xor2_1
X_08839_ net586 net472 VGND VGND VPWR VPWR _00121_ sky130_fd_sc_hd__and2_1
X_11850_ _03039_ _03059_ _03156_ VGND VGND VPWR VPWR _03157_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_68_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10801_ _02010_ _02025_ _02024_ VGND VGND VPWR VPWR _02027_ sky130_fd_sc_hd__a21o_1
X_11781_ D_cos\[9\] _03081_ _01379_ VGND VGND VPWR VPWR _03082_ sky130_fd_sc_hd__mux2_1
XFILLER_0_95_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13520_ _04976_ _04977_ VGND VGND VPWR VPWR _04978_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_138_734 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10732_ _01856_ _01957_ VGND VGND VPWR VPWR _01958_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_103_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_137_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13451_ _04900_ _04901_ _04902_ VGND VGND VPWR VPWR _04903_ sky130_fd_sc_hd__nand3_1
XFILLER_0_138_789 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10663_ net777 net362 VGND VGND VPWR VPWR _01889_ sky130_fd_sc_hd__nand2_1
XFILLER_0_125_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12402_ net329 net727 net735 net244 VGND VGND VPWR VPWR _03755_ sky130_fd_sc_hd__a22o_1
XFILLER_0_36_776 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16170_ _07773_ _07779_ VGND VGND VPWR VPWR _07865_ sky130_fd_sc_hd__and2b_1
X_10594_ _01758_ _01762_ _01818_ _01819_ VGND VGND VPWR VPWR _01820_ sky130_fd_sc_hd__o211ai_1
X_13382_ _04826_ _04827_ VGND VGND VPWR VPWR _04828_ sky130_fd_sc_hd__xor2_1
XFILLER_0_23_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15121_ _06721_ _06722_ _06713_ VGND VGND VPWR VPWR _06724_ sky130_fd_sc_hd__a21o_1
XFILLER_0_50_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12333_ _03641_ _03639_ VGND VGND VPWR VPWR _03681_ sky130_fd_sc_hd__and2b_1
XFILLER_0_23_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15052_ _06545_ _06547_ _06546_ VGND VGND VPWR VPWR _06649_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_10_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12264_ _03499_ _03542_ _03605_ VGND VGND VPWR VPWR _03606_ sky130_fd_sc_hd__nor3_1
X_14003_ _05501_ _05502_ VGND VGND VPWR VPWR _05504_ sky130_fd_sc_hd__nor2_1
X_11215_ _02462_ _02464_ _02465_ VGND VGND VPWR VPWR _02466_ sky130_fd_sc_hd__nand3_4
X_12195_ _03527_ _03531_ VGND VGND VPWR VPWR _03532_ sky130_fd_sc_hd__xnor2_1
Xoutput83 net83 VGND VGND VPWR VPWR alpha[13] sky130_fd_sc_hd__clkbuf_4
X_11146_ _02269_ _02271_ _02368_ _02369_ VGND VGND VPWR VPWR _02390_ sky130_fd_sc_hd__o211a_1
Xoutput94 net94 VGND VGND VPWR VPWR alpha[6] sky130_fd_sc_hd__clkbuf_4
X_15954_ _07628_ _07630_ VGND VGND VPWR VPWR _07631_ sky130_fd_sc_hd__nor2_1
X_11077_ net724 net354 net509 net732 VGND VGND VPWR VPWR _02315_ sky130_fd_sc_hd__a22o_1
XFILLER_0_37_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10028_ _01206_ _01294_ VGND VGND VPWR VPWR _01295_ sky130_fd_sc_hd__xor2_1
X_14905_ net266 net601 net697 net932 VGND VGND VPWR VPWR _06489_ sky130_fd_sc_hd__a22o_1
X_15885_ _07554_ _07555_ VGND VGND VPWR VPWR _07556_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_144_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14836_ _06413_ _06375_ _06411_ VGND VGND VPWR VPWR _06414_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_148_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14767_ _06269_ _06280_ _06281_ VGND VGND VPWR VPWR _06338_ sky130_fd_sc_hd__or3_1
XFILLER_0_59_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11979_ _03205_ _03210_ VGND VGND VPWR VPWR _03297_ sky130_fd_sc_hd__and2b_1
X_13718_ _05192_ _05193_ VGND VGND VPWR VPWR _05194_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_687 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14698_ _06242_ _06244_ _06243_ VGND VGND VPWR VPWR _06262_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_58_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_743 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13649_ _05104_ _05118_ VGND VGND VPWR VPWR _05119_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_54_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_143_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16368_ clknet_4_11_0_clk _00081_ net340 VGND VGND VPWR VPWR D_sin\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_42_735 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15319_ _06938_ _06939_ VGND VGND VPWR VPWR _06940_ sky130_fd_sc_hd__nor2_1
XFILLER_0_124_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16299_ clknet_4_3_0_clk _00012_ net332 VGND VGND VPWR VPWR Q_cos\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_2_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout306 net307 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__clkbuf_4
X_09811_ net626 _00987_ VGND VGND VPWR VPWR _01082_ sky130_fd_sc_hd__and2_1
Xfanout317 net6 VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__clkbuf_2
Xfanout328 net331 VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__clkbuf_4
Xfanout339 net58 VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__clkbuf_4
X_09742_ _01012_ _01013_ VGND VGND VPWR VPWR _01014_ sky130_fd_sc_hd__nor2_1
XFILLER_0_94_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09673_ _00940_ _00945_ VGND VGND VPWR VPWR _00946_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_118_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08624_ _07151_ _07379_ _07390_ VGND VGND VPWR VPWR _07401_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_68_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08555_ _06628_ _06639_ net699 net352 VGND VGND VPWR VPWR _06650_ sky130_fd_sc_hd__o211a_1
XFILLER_0_77_643 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08486_ _05395_ _05882_ VGND VGND VPWR VPWR _05893_ sky130_fd_sc_hd__or2b_1
XFILLER_0_147_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_721 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_135_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_134_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_135_759 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_138_Left_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09107_ _00386_ VGND VGND VPWR VPWR _00004_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_150_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_681 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_115_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_634 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09038_ _00239_ _00246_ _00245_ VGND VGND VPWR VPWR _00318_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_13_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11000_ _02209_ _02210_ _02229_ _02230_ VGND VGND VPWR VPWR _02231_ sky130_fd_sc_hd__o211ai_2
XPHY_EDGE_ROW_147_Left_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12951_ _04266_ _04274_ VGND VGND VPWR VPWR _04358_ sky130_fd_sc_hd__and2_1
XFILLER_0_87_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11902_ _03211_ _03212_ VGND VGND VPWR VPWR _03213_ sky130_fd_sc_hd__xnor2_2
X_15670_ _07297_ _07320_ VGND VGND VPWR VPWR _07322_ sky130_fd_sc_hd__nor2_2
XFILLER_0_59_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12882_ net716 net191 net180 net725 VGND VGND VPWR VPWR _04283_ sky130_fd_sc_hd__a22o_1
XFILLER_0_68_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14621_ _06173_ _06175_ _06174_ VGND VGND VPWR VPWR _06177_ sky130_fd_sc_hd__a21o_1
X_11833_ _03136_ _03137_ VGND VGND VPWR VPWR _03139_ sky130_fd_sc_hd__nor2_1
XFILLER_0_23_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14552_ _06097_ _06098_ _06099_ VGND VGND VPWR VPWR _06101_ sky130_fd_sc_hd__a21o_1
X_11764_ _02988_ _02989_ _03061_ VGND VGND VPWR VPWR _03064_ sky130_fd_sc_hd__and3_1
XFILLER_0_95_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13503_ _04877_ _04879_ VGND VGND VPWR VPWR _04960_ sky130_fd_sc_hd__or2b_1
XFILLER_0_83_646 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10715_ _01939_ _01938_ _01927_ _01914_ VGND VGND VPWR VPWR _01941_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_55_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14483_ _06020_ _06024_ VGND VGND VPWR VPWR _06026_ sky130_fd_sc_hd__xor2_1
X_11695_ _02970_ _02968_ VGND VGND VPWR VPWR _02988_ sky130_fd_sc_hd__or2b_1
X_16222_ _07658_ _07920_ VGND VGND VPWR VPWR _07921_ sky130_fd_sc_hd__and2_1
X_13434_ _04866_ _04884_ VGND VGND VPWR VPWR _04885_ sky130_fd_sc_hd__xor2_2
X_10646_ _01860_ _01859_ _01858_ VGND VGND VPWR VPWR _01872_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_141_707 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer5 _00273_ VGND VGND VPWR VPWR net811 sky130_fd_sc_hd__clkbuf_1
X_16153_ _07649_ _07832_ _07844_ VGND VGND VPWR VPWR _07847_ sky130_fd_sc_hd__o21a_1
XFILLER_0_141_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13365_ net319 net427 net175 VGND VGND VPWR VPWR _04810_ sky130_fd_sc_hd__and3_1
XFILLER_0_2_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10577_ net429 net415 net412 net516 VGND VGND VPWR VPWR _01803_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_24_779 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15104_ _06625_ _06660_ _06662_ VGND VGND VPWR VPWR _06706_ sky130_fd_sc_hd__nor3_1
XFILLER_0_11_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12316_ net792 net460 VGND VGND VPWR VPWR _03662_ sky130_fd_sc_hd__nand2_1
X_16084_ _07658_ _07744_ _07771_ VGND VGND VPWR VPWR _07772_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_23_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13296_ _04732_ _04733_ _04697_ VGND VGND VPWR VPWR _04735_ sky130_fd_sc_hd__a21o_1
X_15035_ net183 net173 net685 net693 VGND VGND VPWR VPWR _06631_ sky130_fd_sc_hd__nand4_1
X_12247_ _03586_ _03587_ VGND VGND VPWR VPWR _03588_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_48_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12178_ _03348_ _03450_ _03512_ VGND VGND VPWR VPWR _03513_ sky130_fd_sc_hd__and3_1
X_11129_ _02306_ _02370_ _02371_ VGND VGND VPWR VPWR _02372_ sky130_fd_sc_hd__and3_2
X_15937_ _07504_ _07526_ _07612_ VGND VGND VPWR VPWR _07613_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_64_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15868_ _07535_ _07537_ VGND VGND VPWR VPWR _07538_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_59_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14819_ _06392_ _06393_ _06394_ VGND VGND VPWR VPWR _06395_ sky130_fd_sc_hd__or3_4
XFILLER_0_148_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15799_ _07461_ VGND VGND VPWR VPWR _07462_ sky130_fd_sc_hd__inv_2
X_08340_ _03474_ _03485_ _03464_ VGND VGND VPWR VPWR _04306_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_80_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08271_ net537 net384 VGND VGND VPWR VPWR _03550_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_117_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_116_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_140_773 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_637 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout136 net137 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__buf_2
Xfanout147 net154 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__buf_2
XFILLER_0_129_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout158 net164 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__buf_4
Xfanout169 net76 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__clkbuf_4
X_09725_ _00977_ _00978_ _00995_ VGND VGND VPWR VPWR _00997_ sky130_fd_sc_hd__nor3_1
X_09656_ _00766_ _00857_ _00764_ VGND VGND VPWR VPWR _00929_ sky130_fd_sc_hd__o21ai_1
X_08607_ _07129_ _07205_ VGND VGND VPWR VPWR _07216_ sky130_fd_sc_hd__xnor2_2
X_09587_ _00847_ _00848_ _00860_ VGND VGND VPWR VPWR _00861_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_49_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08538_ _06344_ _06443_ _06454_ VGND VGND VPWR VPWR _06465_ sky130_fd_sc_hd__nor3_1
XFILLER_0_147_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08469_ _05242_ _05264_ _05253_ VGND VGND VPWR VPWR _05709_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_9_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_108_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10500_ _01712_ _01724_ _01723_ VGND VGND VPWR VPWR _01726_ sky130_fd_sc_hd__a21o_1
XFILLER_0_107_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11480_ _02751_ _02752_ _02753_ VGND VGND VPWR VPWR _02754_ sky130_fd_sc_hd__and3_1
XFILLER_0_33_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10431_ _01623_ _01630_ _01645_ VGND VGND VPWR VPWR _01657_ sky130_fd_sc_hd__and3_1
XFILLER_0_123_729 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_781 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13150_ net723 net312 VGND VGND VPWR VPWR _04575_ sky130_fd_sc_hd__and2_1
X_10362_ _01583_ _01586_ _01592_ VGND VGND VPWR VPWR _01593_ sky130_fd_sc_hd__or3_1
X_12101_ _03427_ _03428_ VGND VGND VPWR VPWR _03429_ sky130_fd_sc_hd__nand2_1
X_10293_ _01531_ _01532_ VGND VGND VPWR VPWR _01533_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13081_ net242 net152 net143 net327 VGND VGND VPWR VPWR _04500_ sky130_fd_sc_hd__a22oi_2
X_12032_ _03353_ VGND VGND VPWR VPWR _03354_ sky130_fd_sc_hd__inv_2
Xfanout670 net24 VGND VGND VPWR VPWR net670 sky130_fd_sc_hd__buf_6
Xfanout681 net688 VGND VGND VPWR VPWR net681 sky130_fd_sc_hd__buf_2
Xfanout692 net21 VGND VGND VPWR VPWR net692 sky130_fd_sc_hd__clkbuf_4
X_13983_ _05456_ _05459_ VGND VGND VPWR VPWR _05482_ sky130_fd_sc_hd__or2_1
X_15722_ _07283_ _07293_ VGND VGND VPWR VPWR _07378_ sky130_fd_sc_hd__or2b_1
X_12934_ _04334_ _04335_ _04339_ VGND VGND VPWR VPWR _04340_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_125_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15653_ _07301_ _07302_ VGND VGND VPWR VPWR _07304_ sky130_fd_sc_hd__nor2_1
X_12865_ net274 net783 _04263_ VGND VGND VPWR VPWR _04265_ sky130_fd_sc_hd__and3_1
X_14604_ net169 net599 VGND VGND VPWR VPWR _06159_ sky130_fd_sc_hd__nand2_1
X_11816_ _03103_ _03118_ _03119_ VGND VGND VPWR VPWR _03120_ sky130_fd_sc_hd__nand3_1
X_15584_ net165 net649 VGND VGND VPWR VPWR _07229_ sky130_fd_sc_hd__nand2_1
XFILLER_0_55_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12796_ _04184_ _04187_ _04186_ VGND VGND VPWR VPWR _04189_ sky130_fd_sc_hd__a21o_1
XFILLER_0_83_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_873 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14535_ net169 net550 _06079_ _06081_ VGND VGND VPWR VPWR _06083_ sky130_fd_sc_hd__nand4_2
X_11747_ net711 net720 net461 net451 VGND VGND VPWR VPWR _03045_ sky130_fd_sc_hd__and4_1
XFILLER_0_126_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14466_ _05994_ _05995_ _06005_ VGND VGND VPWR VPWR _06007_ sky130_fd_sc_hd__and3_1
XFILLER_0_83_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11678_ _02849_ _02878_ _02969_ VGND VGND VPWR VPWR _02970_ sky130_fd_sc_hd__a21oi_2
X_16205_ _07834_ _07839_ _07901_ VGND VGND VPWR VPWR _07903_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_126_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13417_ _04786_ _04864_ _04865_ VGND VGND VPWR VPWR _04866_ sky130_fd_sc_hd__o21bai_2
X_10629_ _01824_ _01854_ VGND VGND VPWR VPWR _01855_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14397_ _05921_ _05927_ _05922_ VGND VGND VPWR VPWR _05931_ sky130_fd_sc_hd__nand3_1
XFILLER_0_52_863 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_716 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16136_ _07767_ VGND VGND VPWR VPWR _07828_ sky130_fd_sc_hd__inv_2
X_13348_ _04789_ _04790_ VGND VGND VPWR VPWR _04791_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_738 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_16067_ _07677_ _07679_ VGND VGND VPWR VPWR _07754_ sky130_fd_sc_hd__and2_1
X_13279_ net327 net242 net799 VGND VGND VPWR VPWR _04716_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_20_771 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15018_ net300 net557 VGND VGND VPWR VPWR _06612_ sky130_fd_sc_hd__and2_1
XFILLER_0_75_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09510_ _00678_ _00680_ VGND VGND VPWR VPWR _00785_ sky130_fd_sc_hd__nor2_1
X_09441_ _00715_ _00716_ VGND VGND VPWR VPWR _00717_ sky130_fd_sc_hd__xor2_1
XFILLER_0_78_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09372_ _00568_ _00569_ _00648_ VGND VGND VPWR VPWR _00649_ sky130_fd_sc_hd__a21o_1
XFILLER_0_93_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08323_ net534 net541 net378 net369 VGND VGND VPWR VPWR _04119_ sky130_fd_sc_hd__nand4_2
XFILLER_0_46_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_819 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08254_ net552 net387 _02713_ _02724_ VGND VGND VPWR VPWR _03366_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_117_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08185_ _02463_ _02561_ _02604_ VGND VGND VPWR VPWR _02615_ sky130_fd_sc_hd__or3_1
XFILLER_0_144_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09708_ _00923_ _00926_ _00979_ VGND VGND VPWR VPWR _00980_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_97_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10980_ _01778_ _01777_ VGND VGND VPWR VPWR _02209_ sky130_fd_sc_hd__and2b_1
XFILLER_0_97_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09639_ net635 net627 net347 net500 VGND VGND VPWR VPWR _00912_ sky130_fd_sc_hd__and4_1
XFILLER_0_38_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12650_ net301 net784 VGND VGND VPWR VPWR _04028_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_139_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11601_ _02883_ _02885_ VGND VGND VPWR VPWR _02886_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_26_808 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12581_ _03949_ _03950_ _03916_ VGND VGND VPWR VPWR _03952_ sky130_fd_sc_hd__a21o_1
XFILLER_0_136_821 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_860 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14320_ _05836_ _05846_ VGND VGND VPWR VPWR _05847_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_92_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11532_ net729 net470 _02744_ _02743_ VGND VGND VPWR VPWR _02810_ sky130_fd_sc_hd__a31o_2
XFILLER_0_37_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_111_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14251_ net254 net138 VGND VGND VPWR VPWR _05772_ sky130_fd_sc_hd__and2_1
X_11463_ _02733_ _02734_ VGND VGND VPWR VPWR _02736_ sky130_fd_sc_hd__xnor2_2
X_13202_ _04543_ _04522_ _04630_ _04631_ VGND VGND VPWR VPWR _04632_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_150_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10414_ _01635_ _01639_ VGND VGND VPWR VPWR _01640_ sky130_fd_sc_hd__xor2_1
X_14182_ _05695_ _05696_ VGND VGND VPWR VPWR _05697_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11394_ net515 net359 VGND VGND VPWR VPWR _02661_ sky130_fd_sc_hd__nand2_1
XFILLER_0_150_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_13133_ _04346_ _04449_ _04448_ VGND VGND VPWR VPWR _04557_ sky130_fd_sc_hd__a21boi_1
X_10345_ _01576_ _01577_ VGND VGND VPWR VPWR _01578_ sky130_fd_sc_hd__nor2_1
X_13064_ _04394_ _04412_ _04413_ VGND VGND VPWR VPWR _04482_ sky130_fd_sc_hd__nand3_2
X_10276_ net134 net920 _01517_ _01518_ VGND VGND VPWR VPWR _00041_ sky130_fd_sc_hd__o22a_1
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12015_ _03295_ _03294_ VGND VGND VPWR VPWR _03336_ sky130_fd_sc_hd__and2b_1
X_13966_ _05446_ _05463_ VGND VGND VPWR VPWR _05464_ sky130_fd_sc_hd__xnor2_1
X_15705_ _07191_ _07267_ _07360_ VGND VGND VPWR VPWR _07361_ sky130_fd_sc_hd__a21oi_1
X_12917_ _04319_ _04320_ _04254_ VGND VGND VPWR VPWR _04322_ sky130_fd_sc_hd__a21oi_2
X_13897_ _05386_ _05387_ _05278_ _05303_ VGND VGND VPWR VPWR _05389_ sky130_fd_sc_hd__a211oi_1
X_15636_ net172 net632 net623 net182 VGND VGND VPWR VPWR _07285_ sky130_fd_sc_hd__a22oi_2
X_12848_ net274 net800 _04215_ _04216_ VGND VGND VPWR VPWR _04246_ sky130_fd_sc_hd__a31o_1
XFILLER_0_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_146_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_810 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15567_ _07208_ _07209_ VGND VGND VPWR VPWR _07210_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_28_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12779_ net327 net242 net320 net429 VGND VGND VPWR VPWR _04170_ sky130_fd_sc_hd__and4_1
X_14518_ net159 net559 net566 net308 VGND VGND VPWR VPWR _06064_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_83_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15498_ _07119_ _07133_ _07134_ VGND VGND VPWR VPWR _07135_ sky130_fd_sc_hd__nand3_1
XFILLER_0_127_865 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_813 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14449_ _05986_ _05987_ VGND VGND VPWR VPWR _05988_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_682 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16119_ _07808_ _07809_ VGND VGND VPWR VPWR _07810_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09990_ net645 net448 VGND VGND VPWR VPWR _01258_ sky130_fd_sc_hd__nand2_1
X_08941_ _00218_ _00221_ VGND VGND VPWR VPWR _00222_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_86_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08872_ net839 net413 VGND VGND VPWR VPWR _00154_ sky130_fd_sc_hd__nand2_1
XFILLER_0_149_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09424_ _00692_ _00699_ VGND VGND VPWR VPWR _00700_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09355_ _00624_ _00630_ _00631_ VGND VGND VPWR VPWR _00632_ sky130_fd_sc_hd__nand3_1
XFILLER_0_75_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08306_ _03910_ _03921_ VGND VGND VPWR VPWR _03932_ sky130_fd_sc_hd__nor2_1
X_09286_ _00562_ _00563_ VGND VGND VPWR VPWR _00564_ sky130_fd_sc_hd__or2_1
XFILLER_0_90_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_118_887 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_145_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08237_ _03149_ _03160_ _03170_ VGND VGND VPWR VPWR _03181_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_133_835 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_857 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08168_ _02386_ _02419_ VGND VGND VPWR VPWR _02430_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_132_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10130_ _01390_ _01386_ _01391_ VGND VGND VPWR VPWR _01393_ sky130_fd_sc_hd__or3_1
XFILLER_0_100_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10061_ _01303_ _01327_ VGND VGND VPWR VPWR _01328_ sky130_fd_sc_hd__xnor2_1
X_13820_ _05185_ _05209_ VGND VGND VPWR VPWR _05305_ sky130_fd_sc_hd__or2_1
XFILLER_0_106_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13751_ _05225_ net938 VGND VGND VPWR VPWR _05230_ sky130_fd_sc_hd__xnor2_4
X_10963_ _01822_ _01823_ _01854_ VGND VGND VPWR VPWR _02191_ sky130_fd_sc_hd__or3_1
XFILLER_0_85_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12702_ _04043_ _04044_ _04041_ VGND VGND VPWR VPWR _04085_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_57_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13682_ net425 net299 VGND VGND VPWR VPWR _05154_ sky130_fd_sc_hd__nand2_1
X_10894_ _02118_ _02119_ net778 net438 VGND VGND VPWR VPWR _02120_ sky130_fd_sc_hd__and4b_1
XFILLER_0_38_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15421_ _04715_ _06858_ _06859_ VGND VGND VPWR VPWR _07051_ sky130_fd_sc_hd__and3_1
X_12633_ _03914_ _04007_ _04008_ VGND VGND VPWR VPWR _04010_ sky130_fd_sc_hd__and3_2
XFILLER_0_127_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_127_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15352_ _06898_ _06975_ VGND VGND VPWR VPWR _06976_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_26_638 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12564_ _03924_ _03930_ _03929_ VGND VGND VPWR VPWR _03934_ sky130_fd_sc_hd__a21o_1
XFILLER_0_53_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_744 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14303_ net148 net249 VGND VGND VPWR VPWR _05829_ sky130_fd_sc_hd__nand2_1
XFILLER_0_142_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11515_ _02716_ _02792_ VGND VGND VPWR VPWR _02793_ sky130_fd_sc_hd__xnor2_1
X_15283_ _06818_ _06839_ _06837_ VGND VGND VPWR VPWR _06901_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_135_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12495_ _03856_ _03857_ VGND VGND VPWR VPWR _03858_ sky130_fd_sc_hd__or2b_1
XFILLER_0_123_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_14234_ _05662_ _05701_ _05653_ VGND VGND VPWR VPWR _05754_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_80_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11446_ _02620_ _02622_ VGND VGND VPWR VPWR _02717_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_705 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14165_ _05678_ _05679_ VGND VGND VPWR VPWR _05680_ sky130_fd_sc_hd__xor2_2
X_11377_ _02638_ _02639_ _02640_ VGND VGND VPWR VPWR _02642_ sky130_fd_sc_hd__nand3_1
XFILLER_0_150_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13116_ _04537_ VGND VGND VPWR VPWR _04538_ sky130_fd_sc_hd__buf_6
X_10328_ Q_cos\[11\] D_sin\[11\] VGND VGND VPWR VPWR _01563_ sky130_fd_sc_hd__and2b_1
X_14096_ _05564_ _05604_ VGND VGND VPWR VPWR _05605_ sky130_fd_sc_hd__xnor2_1
X_13047_ net766 net275 VGND VGND VPWR VPWR _04463_ sky130_fd_sc_hd__and2_1
X_10259_ _01502_ _01503_ VGND VGND VPWR VPWR _01504_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_811 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14998_ net251 net697 VGND VGND VPWR VPWR _06590_ sky130_fd_sc_hd__nand2_1
X_13949_ _05380_ _05381_ _05444_ VGND VGND VPWR VPWR _05445_ sky130_fd_sc_hd__o21ai_1
X_15619_ _07265_ _07266_ VGND VGND VPWR VPWR _07267_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_9_849 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09140_ net556 net469 VGND VGND VPWR VPWR _00419_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09071_ net658 net384 VGND VGND VPWR VPWR _00351_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_660 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_800 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout5 net691 VGND VGND VPWR VPWR net934 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_12_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09973_ _01239_ _01240_ VGND VGND VPWR VPWR _01241_ sky130_fd_sc_hd__xor2_1
X_08924_ _00198_ _00204_ VGND VGND VPWR VPWR _00205_ sky130_fd_sc_hd__xor2_1
XFILLER_0_0_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08855_ _00135_ _00136_ VGND VGND VPWR VPWR _00137_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_137_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08786_ _08094_ _08095_ _08093_ VGND VGND VPWR VPWR _08097_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_67_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09407_ _00681_ _00682_ VGND VGND VPWR VPWR _00683_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_94_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_149_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09338_ net402 net392 net621 VGND VGND VPWR VPWR _00615_ sky130_fd_sc_hd__o21a_4
XFILLER_0_145_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09269_ _00534_ _00546_ VGND VGND VPWR VPWR _00547_ sky130_fd_sc_hd__xor2_2
XFILLER_0_118_695 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11300_ _02537_ _02556_ _02557_ VGND VGND VPWR VPWR _02558_ sky130_fd_sc_hd__and3_1
X_12280_ _03540_ _03622_ VGND VGND VPWR VPWR _03623_ sky130_fd_sc_hd__xor2_1
XFILLER_0_121_827 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11231_ _02374_ _02377_ _02481_ _02482_ VGND VGND VPWR VPWR _02483_ sky130_fd_sc_hd__a211o_1
X_11162_ _02391_ _02406_ VGND VGND VPWR VPWR _02407_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10113_ _02170_ VGND VGND VPWR VPWR _01379_ sky130_fd_sc_hd__clkbuf_8
X_15970_ _07625_ _07646_ VGND VGND VPWR VPWR _07648_ sky130_fd_sc_hd__nor2_1
X_11093_ _02239_ _02241_ VGND VGND VPWR VPWR _02333_ sky130_fd_sc_hd__nand2_1
X_14921_ net292 net285 net576 net585 VGND VGND VPWR VPWR _06506_ sky130_fd_sc_hd__and4_1
X_10044_ net647 net442 _01310_ VGND VGND VPWR VPWR _01311_ sky130_fd_sc_hd__a21oi_1
X_14852_ _06386_ _06409_ _06427_ _06430_ VGND VGND VPWR VPWR _06431_ sky130_fd_sc_hd__a31o_1
X_13803_ net721 net248 VGND VGND VPWR VPWR _05287_ sky130_fd_sc_hd__nand2_1
X_14783_ _06340_ _06341_ _06354_ VGND VGND VPWR VPWR _06356_ sky130_fd_sc_hd__and3_1
X_11995_ _03229_ _03231_ _03314_ VGND VGND VPWR VPWR _03315_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_97_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13734_ _05121_ _05124_ VGND VGND VPWR VPWR _05212_ sky130_fd_sc_hd__nor2_1
X_10946_ _02164_ _02166_ VGND VGND VPWR VPWR _02174_ sky130_fd_sc_hd__or2b_1
X_13665_ _05054_ _05136_ VGND VGND VPWR VPWR _05137_ sky130_fd_sc_hd__xor2_2
X_10877_ _02102_ _02061_ _02100_ VGND VGND VPWR VPWR _02103_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_39_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15404_ _07028_ _07029_ _07030_ VGND VGND VPWR VPWR _07033_ sky130_fd_sc_hd__a21o_1
X_12616_ _03935_ _03958_ _03989_ _03990_ VGND VGND VPWR VPWR _03991_ sky130_fd_sc_hd__a211o_1
X_16384_ clknet_4_14_0_clk _00097_ net343 VGND VGND VPWR VPWR Q_sin\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_54_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13596_ _04983_ _04997_ _04998_ _05001_ VGND VGND VPWR VPWR _05061_ sky130_fd_sc_hd__a31o_1
XFILLER_0_115_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_673 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15335_ _06956_ _06957_ VGND VGND VPWR VPWR _06958_ sky130_fd_sc_hd__xor2_1
XFILLER_0_53_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12547_ _03908_ _03909_ _03913_ VGND VGND VPWR VPWR _03915_ sky130_fd_sc_hd__and3_1
XFILLER_0_53_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15266_ _06881_ _06882_ VGND VGND VPWR VPWR _06883_ sky130_fd_sc_hd__xnor2_2
X_12478_ _03829_ _03837_ _03838_ VGND VGND VPWR VPWR _03839_ sky130_fd_sc_hd__a21o_1
XANTENNA_3 _01588_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14217_ _05710_ _05735_ VGND VGND VPWR VPWR _05736_ sky130_fd_sc_hd__and2_1
X_11429_ _02696_ _02697_ _02603_ _02605_ VGND VGND VPWR VPWR _02699_ sky130_fd_sc_hd__a211o_1
X_15197_ _06687_ _06692_ VGND VGND VPWR VPWR _06807_ sky130_fd_sc_hd__nand2_1
XFILLER_0_123_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14148_ _05659_ _05660_ VGND VGND VPWR VPWR _05661_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14079_ _05565_ _05566_ _05584_ VGND VGND VPWR VPWR _05586_ sky130_fd_sc_hd__and3_1
XFILLER_0_83_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08640_ _07553_ _07564_ VGND VGND VPWR VPWR _07575_ sky130_fd_sc_hd__nor2_1
Xrebuffer15 _06553_ VGND VGND VPWR VPWR net821 sky130_fd_sc_hd__buf_6
Xrebuffer26 _06111_ VGND VGND VPWR VPWR net832 sky130_fd_sc_hd__clkbuf_1
X_08571_ _06802_ _06791_ _06595_ _06574_ VGND VGND VPWR VPWR _06824_ sky130_fd_sc_hd__o211ai_2
Xrebuffer37 net192 VGND VGND VPWR VPWR net843 sky130_fd_sc_hd__buf_2
Xrebuffer48 _08112_ VGND VGND VPWR VPWR net854 sky130_fd_sc_hd__clkbuf_1
Xrebuffer59 net644 VGND VGND VPWR VPWR net865 sky130_fd_sc_hd__buf_1
XFILLER_0_77_825 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_147_713 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_839 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_722 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_123_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09123_ _00396_ _00401_ VGND VGND VPWR VPWR _00402_ sky130_fd_sc_hd__xor2_1
XFILLER_0_72_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer105 _06565_ VGND VGND VPWR VPWR net944 sky130_fd_sc_hd__buf_2
XFILLER_0_96_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_127_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_114_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09054_ _00318_ _00332_ _00333_ VGND VGND VPWR VPWR _00334_ sky130_fd_sc_hd__nor3_1
XFILLER_0_142_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_882 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09956_ _01166_ _01169_ _01167_ VGND VGND VPWR VPWR _01225_ sky130_fd_sc_hd__o21bai_2
X_08907_ next_state _00185_ _00188_ VGND VGND VPWR VPWR _00002_ sky130_fd_sc_hd__a21oi_1
X_09887_ _01155_ _01156_ VGND VGND VPWR VPWR _01157_ sky130_fd_sc_hd__or2_1
X_08838_ net488 _00118_ _00119_ VGND VGND VPWR VPWR _00120_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_142_Right_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08769_ net693 net374 net365 net534 VGND VGND VPWR VPWR _08080_ sky130_fd_sc_hd__a22o_1
XFILLER_0_68_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10800_ _02010_ _02024_ _02025_ VGND VGND VPWR VPWR _02026_ sky130_fd_sc_hd__nand3_2
X_11780_ _03072_ _03080_ VGND VGND VPWR VPWR _03081_ sky130_fd_sc_hd__xor2_1
XFILLER_0_68_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10731_ _01950_ _01955_ _01956_ VGND VGND VPWR VPWR _01957_ sky130_fd_sc_hd__o21a_1
XFILLER_0_137_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_757 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13450_ _04794_ _04797_ _04795_ VGND VGND VPWR VPWR _04902_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_733 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10662_ net760 net389 _01881_ _01880_ VGND VGND VPWR VPWR _01888_ sky130_fd_sc_hd__a31o_1
X_12401_ net223 net743 VGND VGND VPWR VPWR _03754_ sky130_fd_sc_hd__and2_1
XFILLER_0_137_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13381_ _04714_ _04723_ _04722_ VGND VGND VPWR VPWR _04827_ sky130_fd_sc_hd__a21bo_1
X_10593_ _01783_ _01784_ _01816_ _01817_ VGND VGND VPWR VPWR _01819_ sky130_fd_sc_hd__a22o_1
XFILLER_0_91_872 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_632 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15120_ _06713_ _06721_ _06722_ VGND VGND VPWR VPWR _06723_ sky130_fd_sc_hd__nand3_2
X_12332_ _03670_ _03678_ VGND VGND VPWR VPWR _03679_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_106_665 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15051_ _06645_ net886 _06644_ VGND VGND VPWR VPWR _06648_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_120_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12263_ _03600_ _03603_ VGND VGND VPWR VPWR _03605_ sky130_fd_sc_hd__xor2_1
X_14002_ _05425_ _05484_ _05500_ VGND VGND VPWR VPWR _05502_ sky130_fd_sc_hd__and3_1
X_11214_ _02349_ _02357_ _02356_ VGND VGND VPWR VPWR _02465_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_31_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_12194_ _03403_ _03528_ _03530_ VGND VGND VPWR VPWR _03531_ sky130_fd_sc_hd__a21o_1
XFILLER_0_120_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11145_ _02203_ _02303_ _02304_ VGND VGND VPWR VPWR _02389_ sky130_fd_sc_hd__o21a_1
Xoutput84 net84 VGND VGND VPWR VPWR alpha[14] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput95 net95 VGND VGND VPWR VPWR alpha[7] sky130_fd_sc_hd__clkbuf_4
X_15953_ net261 net252 net664 net672 VGND VGND VPWR VPWR _07630_ sky130_fd_sc_hd__and4_1
X_11076_ _02312_ _02313_ VGND VGND VPWR VPWR _02314_ sky130_fd_sc_hd__xnor2_2
X_10027_ _01239_ _01293_ VGND VGND VPWR VPWR _01294_ sky130_fd_sc_hd__xor2_1
X_14904_ _05901_ net826 _06120_ VGND VGND VPWR VPWR _06488_ sky130_fd_sc_hd__nor3_4
X_15884_ net270 net664 VGND VGND VPWR VPWR _07555_ sky130_fd_sc_hd__nand2_1
X_14835_ _06376_ VGND VGND VPWR VPWR _06413_ sky130_fd_sc_hd__inv_2
XFILLER_0_53_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14766_ _06271_ _06335_ _06336_ VGND VGND VPWR VPWR _06337_ sky130_fd_sc_hd__and3_1
XFILLER_0_86_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_11978_ _03294_ _03295_ VGND VGND VPWR VPWR _03296_ sky130_fd_sc_hd__xor2_2
XFILLER_0_129_724 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10929_ net783 net434 VGND VGND VPWR VPWR _02155_ sky130_fd_sc_hd__nand2_1
X_13717_ net711 net720 net264 net257 VGND VGND VPWR VPWR _05193_ sky130_fd_sc_hd__and4_1
X_14697_ _06142_ _06140_ _06141_ VGND VGND VPWR VPWR _06261_ sky130_fd_sc_hd__nand3_1
XFILLER_0_128_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13648_ _05109_ _05117_ VGND VGND VPWR VPWR _05118_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_27_766 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_144_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16367_ clknet_4_13_0_clk _00080_ net344 VGND VGND VPWR VPWR D_sin\[3\] sky130_fd_sc_hd__dfrtp_1
X_13579_ _04955_ _04956_ _05041_ VGND VGND VPWR VPWR _05043_ sky130_fd_sc_hd__nand3_1
XFILLER_0_5_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_799 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15318_ _06936_ _06937_ _06921_ VGND VGND VPWR VPWR _06939_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_81_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16298_ clknet_4_2_0_clk _00011_ net332 VGND VGND VPWR VPWR Q_cos\[11\] sky130_fd_sc_hd__dfrtp_1
X_15249_ _06862_ _06860_ _06861_ VGND VGND VPWR VPWR _06864_ sky130_fd_sc_hd__nand3_1
XFILLER_0_2_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_09810_ _01079_ _01080_ VGND VGND VPWR VPWR _01081_ sky130_fd_sc_hd__or2_1
Xfanout307 net60 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__buf_4
Xfanout318 net319 VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__clkbuf_4
Xfanout329 net330 VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__clkbuf_2
X_09741_ net671 net680 net455 net446 VGND VGND VPWR VPWR _01013_ sky130_fd_sc_hd__and4_1
X_09672_ _00943_ _00944_ VGND VGND VPWR VPWR _00945_ sky130_fd_sc_hd__xnor2_1
X_08623_ _07325_ _07369_ _07162_ _07173_ VGND VGND VPWR VPWR _07390_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08554_ _06355_ _06432_ VGND VGND VPWR VPWR _06639_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_59_Left_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_147_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08485_ _05850_ _05871_ VGND VGND VPWR VPWR _05882_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_134_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_119_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09106_ Q_cos\[4\] _00385_ _02181_ VGND VGND VPWR VPWR _00386_ sky130_fd_sc_hd__mux2_1
XFILLER_0_150_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_143_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09037_ _00229_ _00231_ VGND VGND VPWR VPWR _00317_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_780 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09939_ _01074_ _01207_ VGND VGND VPWR VPWR _01208_ sky130_fd_sc_hd__xnor2_1
Xclkbuf_4_13_0_clk clknet_0_clk VGND VGND VPWR VPWR clknet_4_13_0_clk sky130_fd_sc_hd__clkbuf_8
X_12950_ _04272_ _04271_ VGND VGND VPWR VPWR _04357_ sky130_fd_sc_hd__and2b_1
X_11901_ _03135_ _03137_ VGND VGND VPWR VPWR _03212_ sky130_fd_sc_hd__or2_2
X_12881_ _04179_ _04181_ _04180_ VGND VGND VPWR VPWR _04282_ sky130_fd_sc_hd__o21bai_1
X_14620_ _06173_ _06174_ _06175_ VGND VGND VPWR VPWR _06176_ sky130_fd_sc_hd__nand3_2
X_11832_ _03134_ _03135_ net720 net443 VGND VGND VPWR VPWR _03137_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_68_633 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_114_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14551_ _06097_ _06098_ _06099_ VGND VGND VPWR VPWR _06100_ sky130_fd_sc_hd__nand3_2
XFILLER_0_95_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11763_ _02988_ _02989_ _03061_ VGND VGND VPWR VPWR _03063_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_83_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_138_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10714_ _01914_ _01927_ _01938_ _01939_ VGND VGND VPWR VPWR _01940_ sky130_fd_sc_hd__a211o_1
X_13502_ _04863_ _04885_ _04957_ VGND VGND VPWR VPWR _04958_ sky130_fd_sc_hd__a21o_1
X_14482_ _06021_ _06023_ VGND VGND VPWR VPWR _06024_ sky130_fd_sc_hd__nand2_1
X_11694_ _02902_ _02922_ _02986_ VGND VGND VPWR VPWR _02987_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_36_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16221_ _07801_ _07919_ VGND VGND VPWR VPWR _07920_ sky130_fd_sc_hd__xor2_1
X_13433_ _04880_ _04882_ VGND VGND VPWR VPWR _04884_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_126_749 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10645_ _01860_ _01858_ _01859_ VGND VGND VPWR VPWR _01871_ sky130_fd_sc_hd__or3_1
XFILLER_0_130_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16152_ _07649_ _07832_ _07844_ VGND VGND VPWR VPWR _07845_ sky130_fd_sc_hd__nor3_1
X_13364_ net319 net194 _04711_ _04710_ net204 VGND VGND VPWR VPWR _04809_ sky130_fd_sc_hd__a32o_1
Xrebuffer6 _04415_ VGND VGND VPWR VPWR net812 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_10576_ net429 net516 net415 net405 VGND VGND VPWR VPWR _01802_ sky130_fd_sc_hd__and4_1
X_15103_ _06702_ _06703_ VGND VGND VPWR VPWR _06705_ sky130_fd_sc_hd__xor2_1
X_12315_ net227 net443 _03602_ _03660_ VGND VGND VPWR VPWR _03661_ sky130_fd_sc_hd__a31o_1
XFILLER_0_140_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16083_ _07734_ _07745_ VGND VGND VPWR VPWR _07771_ sky130_fd_sc_hd__or2b_1
X_13295_ _04697_ _04732_ _04733_ VGND VGND VPWR VPWR _04734_ sky130_fd_sc_hd__nand3_2
XFILLER_0_133_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15034_ net183 net684 net693 net173 VGND VGND VPWR VPWR _06630_ sky130_fd_sc_hd__a22o_1
XFILLER_0_32_791 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12246_ _03521_ _03523_ _03520_ VGND VGND VPWR VPWR _03587_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_139_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12177_ _03510_ _03511_ VGND VGND VPWR VPWR _03512_ sky130_fd_sc_hd__nand2_1
X_11128_ _02368_ _02369_ _02269_ _02271_ VGND VGND VPWR VPWR _02371_ sky130_fd_sc_hd__a211o_1
XFILLER_0_3_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15936_ _07506_ _07523_ _07524_ VGND VGND VPWR VPWR _07612_ sky130_fd_sc_hd__and3_1
X_11059_ net801 net444 VGND VGND VPWR VPWR _02295_ sky130_fd_sc_hd__nand2_1
X_15867_ _07450_ _07451_ _07536_ VGND VGND VPWR VPWR _07537_ sky130_fd_sc_hd__o21a_1
X_14818_ _06353_ _06372_ _06387_ VGND VGND VPWR VPWR _06394_ sky130_fd_sc_hd__a21oi_1
X_15798_ _07422_ _07439_ _07440_ VGND VGND VPWR VPWR _07461_ sky130_fd_sc_hd__and3_1
X_14749_ _06296_ net125 _06316_ _06317_ VGND VGND VPWR VPWR _06318_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_86_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_636 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08270_ _03496_ _03518_ _03507_ VGND VGND VPWR VPWR _03539_ sky130_fd_sc_hd__a21o_1
XFILLER_0_73_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_129_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_736 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_691 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_112_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_140_752 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_685 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout137 net140 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__clkbuf_2
Xfanout148 net154 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__clkbuf_4
Xfanout159 net160 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__buf_6
X_09724_ _00977_ _00978_ _00995_ VGND VGND VPWR VPWR _00996_ sky130_fd_sc_hd__o21a_1
X_09655_ _00766_ _00927_ VGND VGND VPWR VPWR _00928_ sky130_fd_sc_hd__xor2_1
X_08606_ net604 net388 VGND VGND VPWR VPWR _07205_ sky130_fd_sc_hd__nand2_1
XFILLER_0_145_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09586_ _00858_ _00859_ VGND VGND VPWR VPWR _00860_ sky130_fd_sc_hd__xnor2_1
X_08537_ _06322_ _06333_ _06201_ VGND VGND VPWR VPWR _06454_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_49_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08468_ _05579_ _05677_ _05688_ VGND VGND VPWR VPWR _05698_ sky130_fd_sc_hd__nand3_1
XFILLER_0_148_885 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08399_ _02343_ _04938_ VGND VGND VPWR VPWR _04949_ sky130_fd_sc_hd__and2b_1
XFILLER_0_45_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_820 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10430_ _01653_ _01655_ VGND VGND VPWR VPWR _01656_ sky130_fd_sc_hd__or2b_1
XFILLER_0_123_719 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_116_760 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_122_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10361_ _01590_ _01591_ VGND VGND VPWR VPWR _01592_ sky130_fd_sc_hd__nor2_1
X_12100_ net610 _00192_ VGND VGND VPWR VPWR _03428_ sky130_fd_sc_hd__or2_1
XFILLER_0_60_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_13080_ net235 net225 VGND VGND VPWR VPWR _04499_ sky130_fd_sc_hd__nand2_1
X_10292_ Q_cos\[6\] D_sin\[6\] VGND VGND VPWR VPWR _01532_ sky130_fd_sc_hd__or2b_1
X_12031_ _03189_ _03252_ _03261_ VGND VGND VPWR VPWR _03353_ sky130_fd_sc_hd__a21boi_4
XFILLER_0_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_109_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout660 net661 VGND VGND VPWR VPWR net660 sky130_fd_sc_hd__buf_6
Xfanout671 net674 VGND VGND VPWR VPWR net671 sky130_fd_sc_hd__buf_4
Xfanout682 net688 VGND VGND VPWR VPWR net682 sky130_fd_sc_hd__buf_4
Xfanout693 net694 VGND VGND VPWR VPWR net693 sky130_fd_sc_hd__buf_6
X_13982_ _05474_ _05475_ VGND VGND VPWR VPWR _05480_ sky130_fd_sc_hd__and2b_1
X_15721_ _07306_ _07313_ VGND VGND VPWR VPWR _07377_ sky130_fd_sc_hd__and2_1
X_12933_ _04327_ _04167_ _04242_ VGND VGND VPWR VPWR _04339_ sky130_fd_sc_hd__or3_1
X_15652_ net290 net281 net674 net681 VGND VGND VPWR VPWR _07302_ sky130_fd_sc_hd__and4_1
X_12864_ net274 net783 _04263_ VGND VGND VPWR VPWR _04264_ sky130_fd_sc_hd__a21oi_1
X_14603_ _06147_ _06150_ _06148_ VGND VGND VPWR VPWR _06158_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_68_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11815_ _03115_ _03117_ _03109_ VGND VGND VPWR VPWR _03119_ sky130_fd_sc_hd__a21o_1
X_15583_ _07225_ _07226_ VGND VGND VPWR VPWR _07228_ sky130_fd_sc_hd__nor2_1
X_12795_ _04184_ _04186_ _04187_ VGND VGND VPWR VPWR _04188_ sky130_fd_sc_hd__nand3_4
XFILLER_0_139_841 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14534_ net169 net550 _06079_ _06081_ VGND VGND VPWR VPWR _06082_ sky130_fd_sc_hd__a22o_1
X_11746_ net712 net463 net453 net720 VGND VGND VPWR VPWR _03044_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_37_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14465_ _05994_ _05995_ _06005_ VGND VGND VPWR VPWR _06006_ sky130_fd_sc_hd__a21oi_2
X_11677_ _02873_ _02876_ VGND VGND VPWR VPWR _02969_ sky130_fd_sc_hd__nor2_1
XFILLER_0_64_680 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16204_ _07834_ _07839_ _07901_ VGND VGND VPWR VPWR _07902_ sky130_fd_sc_hd__nor3_1
X_10628_ _01850_ _01852_ _01853_ VGND VGND VPWR VPWR _01854_ sky130_fd_sc_hd__a21boi_2
X_13416_ _04788_ _04804_ VGND VGND VPWR VPWR _04865_ sky130_fd_sc_hd__nor2_1
XFILLER_0_141_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14396_ _05855_ _05929_ VGND VGND VPWR VPWR _05930_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_107_793 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16135_ _07827_ VGND VGND VPWR VPWR _00111_ sky130_fd_sc_hd__clkbuf_1
X_13347_ net722 net730 net295 net284 VGND VGND VPWR VPWR _04790_ sky130_fd_sc_hd__and4_1
XFILLER_0_141_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10559_ _01745_ _01746_ _01755_ VGND VGND VPWR VPWR _01785_ sky130_fd_sc_hd__nand3_2
X_16066_ _07751_ _07730_ _07731_ VGND VGND VPWR VPWR _07753_ sky130_fd_sc_hd__or3_1
X_13278_ net331 net246 VGND VGND VPWR VPWR _04715_ sky130_fd_sc_hd__or2_4
XFILLER_0_121_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_121_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15017_ net160 net308 net541 net548 VGND VGND VPWR VPWR _06611_ sky130_fd_sc_hd__nand4_2
X_12229_ _03566_ _03567_ VGND VGND VPWR VPWR _03568_ sky130_fd_sc_hd__nor2_1
X_15919_ _07591_ _07592_ VGND VGND VPWR VPWR _07593_ sky130_fd_sc_hd__xor2_1
X_09440_ _00600_ _00602_ VGND VGND VPWR VPWR _00716_ sky130_fd_sc_hd__nand2_1
XFILLER_0_149_649 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09371_ _00571_ _00647_ VGND VGND VPWR VPWR _00648_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_115_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08322_ net534 net378 net369 net541 VGND VGND VPWR VPWR _04108_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_145_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08253_ _03290_ _03301_ _03344_ VGND VGND VPWR VPWR _03355_ sky130_fd_sc_hd__a21o_1
XFILLER_0_7_777 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08184_ _02572_ _02594_ VGND VGND VPWR VPWR _02604_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_113_785 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09707_ _00768_ _00925_ VGND VGND VPWR VPWR _00979_ sky130_fd_sc_hd__or2_1
X_09638_ net627 net347 net500 net635 VGND VGND VPWR VPWR _00911_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_69_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09569_ _00841_ _00842_ VGND VGND VPWR VPWR _00843_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_772 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_139_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11600_ _02738_ _02788_ _02884_ VGND VGND VPWR VPWR _02885_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12580_ _03916_ _03949_ _03950_ VGND VGND VPWR VPWR _03951_ sky130_fd_sc_hd__nand3_4
XFILLER_0_38_669 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_148_693 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_11531_ _02807_ _02759_ _02808_ VGND VGND VPWR VPWR _02809_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_135_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_108_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_136_877 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14250_ net230 net249 VGND VGND VPWR VPWR _05771_ sky130_fd_sc_hd__nand2_1
X_11462_ net765 net937 VGND VGND VPWR VPWR _02734_ sky130_fd_sc_hd__nor2_1
XFILLER_0_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13201_ _04628_ _04629_ _04563_ VGND VGND VPWR VPWR _04631_ sky130_fd_sc_hd__a21o_1
X_10413_ _01636_ _01638_ VGND VGND VPWR VPWR _01639_ sky130_fd_sc_hd__or2_1
X_14181_ net288 net279 net793 VGND VGND VPWR VPWR _05696_ sky130_fd_sc_hd__o21ai_1
X_11393_ net376 _02657_ _02658_ VGND VGND VPWR VPWR _02660_ sky130_fd_sc_hd__a21bo_1
X_13132_ _04553_ _04554_ VGND VGND VPWR VPWR _04555_ sky130_fd_sc_hd__xnor2_1
X_10344_ D_sin\[13\] Q_cos\[13\] VGND VGND VPWR VPWR _01577_ sky130_fd_sc_hd__and2b_1
XFILLER_0_103_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_13063_ _04478_ _04479_ VGND VGND VPWR VPWR _04481_ sky130_fd_sc_hd__or2_1
X_10275_ _01513_ _01516_ net133 VGND VGND VPWR VPWR _01518_ sky130_fd_sc_hd__a21bo_1
X_12014_ _03287_ _03293_ VGND VGND VPWR VPWR _03335_ sky130_fd_sc_hd__and2b_1
Xfanout490 net491 VGND VGND VPWR VPWR net490 sky130_fd_sc_hd__clkbuf_4
X_13965_ _05461_ _05462_ VGND VGND VPWR VPWR _05463_ sky130_fd_sc_hd__xnor2_1
X_15704_ _07266_ _07265_ VGND VGND VPWR VPWR _07360_ sky130_fd_sc_hd__and2b_1
X_12916_ _04254_ _04319_ _04320_ VGND VGND VPWR VPWR _04321_ sky130_fd_sc_hd__and3_1
X_13896_ _05278_ _05303_ _05386_ _05387_ VGND VGND VPWR VPWR _05388_ sky130_fd_sc_hd__o211a_1
XFILLER_0_69_761 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15635_ net193 _07142_ _07141_ VGND VGND VPWR VPWR _07284_ sky130_fd_sc_hd__a21oi_4
X_12847_ _04161_ _04166_ _04244_ VGND VGND VPWR VPWR _04245_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_14_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_647 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15566_ _04881_ net566 VGND VGND VPWR VPWR _07209_ sky130_fd_sc_hd__nor2_1
XFILLER_0_68_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12778_ _04099_ _04100_ _04110_ VGND VGND VPWR VPWR _04169_ sky130_fd_sc_hd__nand3_2
XFILLER_0_145_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14517_ net303 net576 VGND VGND VPWR VPWR _06063_ sky130_fd_sc_hd__nand2_1
XFILLER_0_138_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11729_ _03021_ _03022_ _03023_ VGND VGND VPWR VPWR _03025_ sky130_fd_sc_hd__a21o_1
X_15497_ _07131_ _07132_ _07124_ VGND VGND VPWR VPWR _07134_ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_126_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_126_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14448_ net210 net687 net693 net200 VGND VGND VPWR VPWR _05987_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_4_725 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_114_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_864 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_141_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14379_ _05902_ _05905_ _05903_ VGND VGND VPWR VPWR _05911_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_101_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_141_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_16118_ _07806_ _07807_ VGND VGND VPWR VPWR _07809_ sky130_fd_sc_hd__nand2_1
XFILLER_0_122_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_23_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08940_ net488 _00219_ _00220_ VGND VGND VPWR VPWR _00221_ sky130_fd_sc_hd__a21bo_1
X_16049_ _07665_ _07672_ _07733_ VGND VGND VPWR VPWR _07734_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_86_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_110_788 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_08871_ _00151_ _00152_ VGND VGND VPWR VPWR _00153_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_79_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09423_ _00693_ _00698_ VGND VGND VPWR VPWR _00699_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_32_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_149_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09354_ _00628_ _00629_ _00625_ VGND VGND VPWR VPWR _00631_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08305_ net602 net469 _03899_ VGND VGND VPWR VPWR _03921_ sky130_fd_sc_hd__and3_1
XFILLER_0_90_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_117_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09285_ _00559_ _00561_ VGND VGND VPWR VPWR _00563_ sky130_fd_sc_hd__and2_1
XFILLER_0_145_641 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_142_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_745 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_133_803 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08236_ net677 net686 net526 net437 VGND VGND VPWR VPWR _03170_ sky130_fd_sc_hd__and4_1
XFILLER_0_105_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_132_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_144_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_08167_ _02397_ _02408_ VGND VGND VPWR VPWR _02419_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_120_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_41_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_867 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10060_ _01304_ _01326_ VGND VGND VPWR VPWR _01327_ sky130_fd_sc_hd__xor2_1
X_10962_ _01856_ _01956_ VGND VGND VPWR VPWR _02190_ sky130_fd_sc_hd__nor2_1
X_13750_ net119 _05226_ _05227_ _05228_ VGND VGND VPWR VPWR _05229_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_97_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12701_ _04081_ _04082_ _04083_ VGND VGND VPWR VPWR _04084_ sky130_fd_sc_hd__or3_1
X_10893_ net791 net419 net411 net806 VGND VGND VPWR VPWR _02119_ sky130_fd_sc_hd__a22o_1
X_13681_ _05151_ _05152_ VGND VGND VPWR VPWR _05153_ sky130_fd_sc_hd__nor2_1
X_15420_ _07040_ _07049_ VGND VGND VPWR VPWR _07050_ sky130_fd_sc_hd__xor2_1
XFILLER_0_128_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12632_ _04006_ _04005_ _03951_ _03949_ VGND VGND VPWR VPWR _04008_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_109_833 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_15351_ _06973_ _06974_ VGND VGND VPWR VPWR _06975_ sky130_fd_sc_hd__xnor2_1
X_12563_ _03802_ _03803_ _03796_ VGND VGND VPWR VPWR _03933_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_66_797 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11514_ _02789_ _02791_ VGND VGND VPWR VPWR _02792_ sky130_fd_sc_hd__xor2_2
X_14302_ _05508_ _05826_ _05507_ VGND VGND VPWR VPWR _05827_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_108_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15282_ _06811_ _06812_ _06810_ VGND VGND VPWR VPWR _06899_ sky130_fd_sc_hd__a21o_1
X_12494_ _03849_ _03852_ VGND VGND VPWR VPWR _03857_ sky130_fd_sc_hd__xor2_1
XFILLER_0_18_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_136_696 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_150_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11445_ _02609_ _02627_ _02715_ VGND VGND VPWR VPWR _02716_ sky130_fd_sc_hd__a21o_1
X_14233_ _05738_ _05741_ _05739_ VGND VGND VPWR VPWR _05753_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_124_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_150_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14164_ _05585_ _05588_ VGND VGND VPWR VPWR _05679_ sky130_fd_sc_hd__nor2_1
X_11376_ _02638_ _02639_ _02640_ VGND VGND VPWR VPWR _02641_ sky130_fd_sc_hd__a21o_1
X_10327_ _01557_ _01558_ VGND VGND VPWR VPWR _01562_ sky130_fd_sc_hd__and2b_1
X_13115_ net68 VGND VGND VPWR VPWR _04537_ sky130_fd_sc_hd__clkinv_4
X_14095_ _05598_ _05603_ VGND VGND VPWR VPWR _05604_ sky130_fd_sc_hd__xor2_1
X_13046_ net293 _04460_ _04461_ VGND VGND VPWR VPWR _04462_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_147_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10258_ _01500_ _01501_ _01498_ VGND VGND VPWR VPWR _01503_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_56_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_10189_ net80 _01443_ net130 VGND VGND VPWR VPWR _01444_ sky130_fd_sc_hd__mux2_1
X_14997_ net592 _06490_ _06588_ VGND VGND VPWR VPWR _06589_ sky130_fd_sc_hd__a21bo_1
X_13948_ _05376_ _05379_ VGND VGND VPWR VPWR _05444_ sky130_fd_sc_hd__or2_1
X_13879_ net611 net704 net264 net255 VGND VGND VPWR VPWR _05369_ sky130_fd_sc_hd__and4_1
XFILLER_0_9_817 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15618_ _07116_ _07172_ _07171_ VGND VGND VPWR VPWR _07266_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_84_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15549_ _07098_ _07114_ VGND VGND VPWR VPWR _07190_ sky130_fd_sc_hd__nand2_1
XFILLER_0_17_639 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09070_ net392 _00348_ _00349_ VGND VGND VPWR VPWR _00350_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_44_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_126_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_141_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_112_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_142_666 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout6 net400 VGND VGND VPWR VPWR net935 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_97_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09972_ net626 net465 VGND VGND VPWR VPWR _01240_ sky130_fd_sc_hd__nand2_1
XFILLER_0_110_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_123_Right_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08923_ _00199_ _00203_ VGND VGND VPWR VPWR _00204_ sky130_fd_sc_hd__xor2_1
X_08854_ _00133_ _00134_ _00116_ VGND VGND VPWR VPWR _00136_ sky130_fd_sc_hd__a21oi_1
X_08785_ _08093_ _08094_ _08095_ VGND VGND VPWR VPWR _08096_ sky130_fd_sc_hd__or3_4
XFILLER_0_94_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_149_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09406_ net564 _00192_ VGND VGND VPWR VPWR _00682_ sky130_fd_sc_hd__nor2_1
XFILLER_0_137_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09337_ net621 net402 net392 VGND VGND VPWR VPWR _00614_ sky130_fd_sc_hd__nand3_2
XFILLER_0_47_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_09268_ _00544_ _00545_ VGND VGND VPWR VPWR _00546_ sky130_fd_sc_hd__nand2_1
XFILLER_0_117_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_778 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_661 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_08219_ _02920_ _02975_ VGND VGND VPWR VPWR _02985_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_869 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09199_ _00477_ VGND VGND VPWR VPWR _00005_ sky130_fd_sc_hd__clkbuf_1
X_11230_ _02479_ _02480_ _02389_ VGND VGND VPWR VPWR _02482_ sky130_fd_sc_hd__o21a_1
XFILLER_0_132_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_132_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11161_ _02404_ _02405_ VGND VGND VPWR VPWR _02406_ sky130_fd_sc_hd__xor2_1
XFILLER_0_31_697 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10112_ _01346_ _01377_ VGND VGND VPWR VPWR _01378_ sky130_fd_sc_hd__xnor2_1
X_11092_ _02246_ _02264_ _02265_ VGND VGND VPWR VPWR _02331_ sky130_fd_sc_hd__nand3_2
X_14920_ net292 net576 net585 net285 VGND VGND VPWR VPWR _06505_ sky130_fd_sc_hd__a22oi_1
X_10043_ _01259_ _01308_ _01309_ VGND VGND VPWR VPWR _01310_ sky130_fd_sc_hd__o21a_1
X_14851_ _06423_ _06428_ _06429_ VGND VGND VPWR VPWR _06430_ sky130_fd_sc_hd__and3_1
X_13802_ _05283_ _05284_ VGND VGND VPWR VPWR _05285_ sky130_fd_sc_hd__nor2_1
X_14782_ _06349_ _06353_ VGND VGND VPWR VPWR _06354_ sky130_fd_sc_hd__nand2_1
X_11994_ _03222_ _03223_ _03228_ VGND VGND VPWR VPWR _03314_ sky130_fd_sc_hd__and3_1
XFILLER_0_86_826 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13733_ _05185_ _05209_ VGND VGND VPWR VPWR _05211_ sky130_fd_sc_hd__xor2_1
X_10945_ _02079_ _02172_ _02072_ VGND VGND VPWR VPWR _02173_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_85_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13664_ _05042_ _05135_ VGND VGND VPWR VPWR _05136_ sky130_fd_sc_hd__xnor2_2
X_10876_ _02062_ VGND VGND VPWR VPWR _02102_ sky130_fd_sc_hd__inv_2
XFILLER_0_128_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15403_ _07028_ _07029_ _07030_ VGND VGND VPWR VPWR _07032_ sky130_fd_sc_hd__nand3_1
XFILLER_0_54_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_109_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_12615_ _03977_ _03988_ _03978_ VGND VGND VPWR VPWR _03990_ sky130_fd_sc_hd__and3_1
X_16383_ clknet_4_14_0_clk _00096_ net342 VGND VGND VPWR VPWR Q_sin\[0\] sky130_fd_sc_hd__dfrtp_1
X_13595_ net757 _04539_ _04976_ _05059_ VGND VGND VPWR VPWR _05060_ sky130_fd_sc_hd__o31ai_2
XFILLER_0_26_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_15334_ net193 net651 VGND VGND VPWR VPWR _06957_ sky130_fd_sc_hd__nand2_1
X_12546_ _03908_ _03909_ _03913_ VGND VGND VPWR VPWR _03914_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_26_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_124_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15265_ _06769_ _06772_ VGND VGND VPWR VPWR _06882_ sky130_fd_sc_hd__nand2_1
XFILLER_0_124_655 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12477_ _03830_ _03831_ _03836_ VGND VGND VPWR VPWR _03838_ sky130_fd_sc_hd__and3_1
XFILLER_0_22_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_4 net12 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_123_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_14216_ _05712_ _05734_ VGND VGND VPWR VPWR _05735_ sky130_fd_sc_hd__xnor2_1
X_11428_ _02603_ _02605_ _02696_ _02697_ VGND VGND VPWR VPWR _02698_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_123_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_653 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15196_ _06804_ _06805_ VGND VGND VPWR VPWR _06806_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11359_ _02577_ _02578_ _02621_ VGND VGND VPWR VPWR _02622_ sky130_fd_sc_hd__o21a_1
X_14147_ net271 net146 _05658_ VGND VGND VPWR VPWR _05660_ sky130_fd_sc_hd__and3_1
XFILLER_0_120_861 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_14078_ _05565_ _05566_ _05584_ VGND VGND VPWR VPWR _05585_ sky130_fd_sc_hd__a21oi_1
X_13029_ net775 net783 net268 net258 VGND VGND VPWR VPWR _04443_ sky130_fd_sc_hd__and4_1
Xrebuffer16 _06745_ VGND VGND VPWR VPWR net822 sky130_fd_sc_hd__clkbuf_1
X_08570_ _06574_ _06595_ _06791_ _06802_ VGND VGND VPWR VPWR _06813_ sky130_fd_sc_hd__a211o_1
Xrebuffer27 net209 VGND VGND VPWR VPWR net833 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_107_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer38 net843 VGND VGND VPWR VPWR net844 sky130_fd_sc_hd__clkbuf_1
Xrebuffer49 _06669_ VGND VGND VPWR VPWR net855 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_88_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_119_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_146_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_119_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_123_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_147_769 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_09122_ _00399_ _00400_ VGND VGND VPWR VPWR _00401_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer106 _06561_ VGND VGND VPWR VPWR net945 sky130_fd_sc_hd__dlygate4sd1_1
X_09053_ _00330_ _00331_ _00323_ VGND VGND VPWR VPWR _00333_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_44_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_130_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09955_ _01222_ _01223_ VGND VGND VPWR VPWR _01224_ sky130_fd_sc_hd__nand2_1
X_08906_ net928 _00187_ VGND VGND VPWR VPWR _00188_ sky130_fd_sc_hd__nor2_1
X_09886_ _01087_ _01144_ _01154_ VGND VGND VPWR VPWR _01156_ sky130_fd_sc_hd__nor3_1
X_08837_ net564 net488 net478 net574 VGND VGND VPWR VPWR _00119_ sky130_fd_sc_hd__a22o_1
X_08768_ _04196_ _04218_ _04207_ VGND VGND VPWR VPWR _08079_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_68_837 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_08699_ _08001_ _08010_ VGND VGND VPWR VPWR _08011_ sky130_fd_sc_hd__and2_1
XFILLER_0_67_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_10730_ _01954_ _01951_ VGND VGND VPWR VPWR _01956_ sky130_fd_sc_hd__or2b_1
XFILLER_0_94_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_667 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_138_747 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_701 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_10661_ _01870_ _01885_ _01884_ VGND VGND VPWR VPWR _01887_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_137_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12400_ net329 net244 net726 net735 VGND VGND VPWR VPWR _03753_ sky130_fd_sc_hd__nand4_1
X_13380_ _04822_ _04825_ VGND VGND VPWR VPWR _04826_ sky130_fd_sc_hd__xnor2_1
X_10592_ _01783_ _01784_ _01816_ _01817_ VGND VGND VPWR VPWR _01818_ sky130_fd_sc_hd__nand4_4
XFILLER_0_51_715 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_12331_ _03671_ _03677_ VGND VGND VPWR VPWR _03678_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_51_737 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_748 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_15050_ _06644_ _06645_ _06646_ VGND VGND VPWR VPWR _06647_ sky130_fd_sc_hd__or3_4
X_12262_ _03559_ _03601_ _03602_ VGND VGND VPWR VPWR _03603_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_120_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11213_ _02460_ _02461_ _02455_ VGND VGND VPWR VPWR _02464_ sky130_fd_sc_hd__a21o_1
X_14001_ _05425_ _05484_ _05500_ VGND VGND VPWR VPWR _05501_ sky130_fd_sc_hd__a21oi_1
X_12193_ _03407_ _03395_ _03467_ VGND VGND VPWR VPWR _03530_ sky130_fd_sc_hd__o21a_1
X_11144_ net801 _00193_ VGND VGND VPWR VPWR _02388_ sky130_fd_sc_hd__nor2_1
Xoutput85 net85 VGND VGND VPWR VPWR alpha[15] sky130_fd_sc_hd__clkbuf_4
Xoutput96 net96 VGND VGND VPWR VPWR alpha[8] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_128_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15952_ net261 net664 net672 net252 VGND VGND VPWR VPWR _07628_ sky130_fd_sc_hd__a22oi_1
X_11075_ net768 net471 VGND VGND VPWR VPWR _02313_ sky130_fd_sc_hd__and2_1
X_10026_ net620 net465 VGND VGND VPWR VPWR _01293_ sky130_fd_sc_hd__nand2_1
X_14903_ _06236_ _06479_ _06484_ _06485_ VGND VGND VPWR VPWR _06487_ sky130_fd_sc_hd__a211oi_2
X_15883_ _07551_ _07552_ VGND VGND VPWR VPWR _07554_ sky130_fd_sc_hd__nor2_1
X_14834_ _06376_ _06411_ _06375_ VGND VGND VPWR VPWR _06412_ sky130_fd_sc_hd__or3b_1
XFILLER_0_59_815 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_14765_ net188 net605 net700 net178 VGND VGND VPWR VPWR _06336_ sky130_fd_sc_hd__a22o_1
XFILLER_0_58_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_11977_ _03206_ _03209_ _03207_ VGND VGND VPWR VPWR _03295_ sky130_fd_sc_hd__o21ba_1
X_13716_ net712 net267 net257 net720 VGND VGND VPWR VPWR _05192_ sky130_fd_sc_hd__a22oi_2
X_10928_ net775 VGND VGND VPWR VPWR _02154_ sky130_fd_sc_hd__inv_2
X_14696_ _06258_ _06259_ VGND VGND VPWR VPWR _06260_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_74_818 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_712 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_881 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_13647_ _05115_ _05116_ VGND VGND VPWR VPWR _05117_ sky130_fd_sc_hd__xor2_2
X_10859_ _02049_ _02083_ _02084_ VGND VGND VPWR VPWR _02085_ sky130_fd_sc_hd__and3_1
XFILLER_0_144_717 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_16366_ clknet_4_13_0_clk _00079_ net344 VGND VGND VPWR VPWR D_sin\[2\] sky130_fd_sc_hd__dfrtp_2
X_13578_ _04955_ _04956_ _05041_ VGND VGND VPWR VPWR _05042_ sky130_fd_sc_hd__a21o_1
XFILLER_0_109_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_143_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15317_ _06921_ _06936_ _06937_ VGND VGND VPWR VPWR _06938_ sky130_fd_sc_hd__and3_1
XFILLER_0_26_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_12529_ net330 net245 net788 net804 VGND VGND VPWR VPWR _03895_ sky130_fd_sc_hd__and4_1
X_16297_ clknet_4_2_0_clk _00010_ net333 VGND VGND VPWR VPWR Q_cos\[10\] sky130_fd_sc_hd__dfrtp_1
X_15248_ _06860_ _06861_ _06862_ VGND VGND VPWR VPWR _06863_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_845 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_111_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_15179_ _06785_ _06787_ VGND VGND VPWR VPWR _06788_ sky130_fd_sc_hd__xor2_1
XFILLER_0_78_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_645 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout308 net60 VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__clkbuf_4
Xfanout319 net321 VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_689 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_09740_ net671 net455 net446 net680 VGND VGND VPWR VPWR _01012_ sky130_fd_sc_hd__a22oi_2
.ends
