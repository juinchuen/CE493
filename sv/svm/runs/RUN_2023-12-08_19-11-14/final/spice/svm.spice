* NGSPICE file created from svm.ext - technology: sky130A

.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
X0 X a_35_297# a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.26 ps=2.52 w=1 l=0.15
X1 X B a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.25 pd=1.42 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_117_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 VPWR B a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.25 ps=1.42 w=0.65 l=0.15
X7 a_285_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A a_117_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
X0 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X5 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X7 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
X0 a_27_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_560_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X2 VGND B a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0991 ps=0.955 w=0.65 l=0.15
X3 Y B a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_297# a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_474_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X7 VGND A a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# B a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X12 a_474_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_560_47# a_27_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X14 VPWR A a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X15 Y a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X16 VPWR a_27_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X17 a_560_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
X0 Y a_53_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.192 ps=1.38 w=1 l=0.15
X1 a_232_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.192 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A_N a_53_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A_N a_53_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_316_47# B a_232_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y a_53_93# a_316_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.125 ps=1.03 w=0.65 l=0.15
X7 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=2.89
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=2.89
.ends

.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0683 ps=0.86 w=0.65 l=0.15
X1 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=2.1 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A1 a_114_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
X3 a_114_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.185 ps=1.87 w=0.65 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.28 ps=2.56 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X10 a_285_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.091 ps=0.93 w=0.65 l=0.15
X11 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.05
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.05
.ends

.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.97
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.97
.ends

.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
X0 VPWR a_75_212# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 a_75_212# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 a_75_212# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND a_75_212# X VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X3 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X4 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X5 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.301 ps=2.66 w=1 l=0.15
X7 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X8 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X10 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X12 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X13 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X14 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X15 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X16 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X17 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X18 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X20 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X21 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X22 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.209 ps=2.02 w=0.65 l=0.15
X23 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X24 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X25 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X26 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X27 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_806_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_47# B1 a_1314_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=2.09 as=0.104 ps=0.97 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X17 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.0943 ps=0.94 w=0.65 l=0.15
X19 Y C1 a_978_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_27_47# B1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 a_806_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.675 pd=3.35 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.091 ps=0.93 w=0.65 l=0.15
X27 a_978_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.091 ps=0.93 w=0.65 l=0.15
X28 a_1314_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X31 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A a_113_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_113_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
X0 a_377_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.365 ps=1.73 w=1 l=0.15
X1 a_47_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.3 ps=2.6 w=1 l=0.15
X2 a_129_47# B a_47_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_285_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 Y a_47_47# a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_129_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0683 ps=0.86 w=0.65 l=0.15
X6 VPWR A a_47_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.365 pd=1.73 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_47_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.165 ps=1.33 w=1 l=0.15
X8 Y B a_377_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.149 ps=1.33 w=1 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.149 pd=1.33 as=0.166 ps=1.8 w=0.64 l=0.15
X3 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X4 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=0.59
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=0.59
.ends

.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_197_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0798 pd=0.8 as=0.0609 ps=0.71 w=0.42 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.312 ps=1.68 w=1 l=0.15
X3 a_303_47# C a_197_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0798 ps=0.8 w=0.42 l=0.15
X4 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.68 as=0.0588 ps=0.7 w=0.42 l=0.15
X6 VGND D a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.196 pd=1.33 as=0.0693 ps=0.75 w=0.42 l=0.15
X7 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X8 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.196 ps=1.33 w=0.65 l=0.15
X9 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.42 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0703 pd=0.755 as=0.111 ps=1.37 w=0.42 l=0.15
X6 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.14 ps=1.28 w=1 l=0.15
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0703 ps=0.755 w=0.42 l=0.15
X8 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.165 ps=1.33 w=1 l=0.15
X9 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
X0 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_161_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X2 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_161_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A a_161_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_161_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VPWR C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 a_181_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VGND C a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.132 pd=1.14 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 a_27_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X6 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.132 ps=1.14 w=0.65 l=0.15
X7 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 a_81_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.257 ps=1.44 w=0.65 l=0.15
X1 a_299_297# B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_299_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 a_384_47# A1 a_81_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
X0 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.165 ps=1.33 w=1 l=0.15
X2 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_193_47# C a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_277_47# B a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X3 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X4 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X5 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=2.61 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X8 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X9 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X12 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X14 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X15 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X16 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X17 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X18 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X19 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X20 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X21 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X23 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X24 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X25 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X28 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X29 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X30 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X31 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X32 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
X33 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.16 ps=1.32 w=1 l=0.15
X1 a_27_297# B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X2 VGND A2 a_373_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.114 ps=1 w=0.65 l=0.15
X3 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X4 a_27_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.253 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.253 ps=2.52 w=1 l=0.15
X6 a_373_47# A1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.96 w=0.65 l=0.15
X8 a_109_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 Y B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X1 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.135 ps=1.27 w=1 l=0.15
X3 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_381_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_109_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VGND A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0683 ps=0.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X2 a_193_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y A a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X4 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 a_109_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_465_47# A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.157 ps=1.32 w=1 l=0.15
X2 a_109_297# B1 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 a_193_297# B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.102 ps=0.965 w=0.65 l=0.15
X5 a_205_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X6 VPWR A2 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.165 ps=1.33 w=1 l=0.15
X7 a_193_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X8 a_27_47# B1 a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X9 a_109_297# C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 VGND C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND A2 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_109_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
X0 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.157 ps=1.17 w=0.42 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.157 pd=1.17 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X6 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VGND A1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
X1 a_510_47# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.143 ps=1.09 w=0.65 l=0.15
X2 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.175 ps=1.35 w=1 l=0.15
X3 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.22 ps=1.44 w=1 l=0.15
X4 a_79_21# A2 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.22 pd=1.44 as=0.162 ps=1.33 w=1 l=0.15
X5 a_297_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X6 a_79_21# C1 a_510_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.114 ps=1 w=0.65 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X8 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
X9 a_215_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.106 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.35 as=0.265 ps=2.53 w=1 l=0.15
X1 a_209_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.172 ps=1.35 w=1 l=0.15
X2 a_303_47# A2 a_209_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.104 ps=0.97 w=0.65 l=0.15
X3 a_209_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.112 ps=0.995 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.172 ps=1.83 w=0.65 l=0.15
X5 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.107 ps=0.98 w=0.65 l=0.15
X6 a_80_21# A1 a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X7 VPWR A2 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.16 ps=1.32 w=1 l=0.15
X8 a_80_21# B1 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X9 a_209_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
X0 VPWR B a_59_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 X a_59_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.475 pd=2.95 as=0.167 ps=1.39 w=1 l=0.15
X2 VGND B a_145_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_59_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X4 X a_59_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.112 ps=1.04 w=0.65 l=0.15
X5 a_145_75# A a_59_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_300_297# a_27_413# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X3 Y a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.102 ps=0.99 w=0.65 l=0.15
X4 VPWR A1 a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 a_384_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.143 ps=1.09 w=0.65 l=0.15
X6 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.111 ps=1.37 w=0.42 l=0.15
X7 a_300_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_470_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_470_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_470_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.106 ps=0.975 w=0.65 l=0.15
X6 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X8 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X10 a_470_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.162 ps=1.33 w=1 l=0.15
X11 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 VPWR B a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X13 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X16 X a_112_47# a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 a_470_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X18 X B a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_382_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X1 a_297_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X2 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.327 pd=1.65 as=0.28 ps=2.56 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.327 ps=1.65 w=1 l=0.15
X6 a_382_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.195 ps=1.39 w=1 l=0.15
X7 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
X0 VGND A a_68_297# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_68_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_68_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR A a_150_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 X a_68_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.34 pd=2.68 as=0.146 ps=1.34 w=1 l=0.15
X5 a_150_297# B a_68_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_27_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_277_297# B a_205_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VPWR A a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X5 a_205_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X6 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X7 VGND C a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0693 ps=0.75 w=0.42 l=0.15
X8 a_109_297# D a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X9 VGND A a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_286_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X2 a_286_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X3 Y A2 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 VGND A1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X6 VGND A2 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X7 a_487_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# B1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR A1 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_27_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X13 a_487_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X14 a_286_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_222_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X1 VPWR A1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.105 ps=1.21 w=1 l=0.15
X2 VGND a_79_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_222_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.186 ps=1.41 w=0.42 l=0.15
X4 VGND A2 a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_448_47# a_222_93# a_79_199# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_79_199# a_222_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.3 ps=2.6 w=1 l=0.15
X7 a_544_297# A2 a_79_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X8 a_448_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.186 pd=1.41 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
X0 VPWR A a_94_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.198 pd=1.39 as=0.305 ps=2.61 w=1 l=0.15
X1 a_294_47# B a_185_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.128 ps=1.04 w=0.65 l=0.15
X2 a_185_47# A a_94_47# VNB sky130_fd_pr__nfet_01v8 ad=0.128 pd=1.04 as=0.198 ps=1.91 w=0.65 l=0.15
X3 VPWR a_94_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND C a_294_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 a_94_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.198 ps=1.39 w=1 l=0.15
X6 X a_94_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X7 X a_94_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 VPWR C a_94_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X9 X a_94_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X10 VGND a_94_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X11 VPWR a_94_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND a_94_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 X a_94_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X8 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X11 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=1.37 as=0.0588 ps=0.7 w=0.42 l=0.15
X18 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X20 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X21 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X22 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X23 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X25 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X26 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X27 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X28 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X29 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X30 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X31 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X32 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X33 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X34 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X35 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X36 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X37 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X38 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X39 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0578 ps=0.695 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_467_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_467_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_109_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A2 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_109_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_226_47# A2_N a_226_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_489_413# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_226_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.167 ps=1.43 w=0.42 l=0.15
X3 VPWR B2 a_489_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_489_413# a_226_47# a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_76_199# a_226_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.139 ps=1.08 w=0.42 l=0.15
X6 VGND B1 a_556_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_556_47# B2 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VGND A2_N a_226_47# VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.08 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_226_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.12 ps=1.09 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.43 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.09 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.745 as=0.111 ps=1.37 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.162 ps=1.33 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
X0 a_109_93# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_215_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 VGND a_109_93# a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND A a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 VPWR A a_369_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_369_297# B a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_215_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X7 a_297_297# a_109_93# a_215_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_109_93# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 X a_215_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.1 ps=0.985 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
X0 VGND C a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 a_277_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_47# B a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.135 ps=1.27 w=1 l=0.15
X8 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_277_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.221 pd=1.98 as=0.198 ps=1.26 w=0.65 l=0.15
X1 Y A3 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.393 pd=1.78 as=0.135 ps=1.27 w=1 l=0.15
X2 a_193_297# A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.393 ps=1.78 w=1 l=0.15
X5 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X1 a_80_21# C1 a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X2 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_300_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.26 ps=1.45 w=0.65 l=0.15
X6 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_80_21# A1 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 a_472_297# B1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X9 a_80_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_298_297# a_27_413# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.265 ps=2.53 w=1 l=0.15
X1 a_215_297# a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.136 ps=1.1 w=0.65 l=0.15
X2 a_298_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.258 ps=1.45 w=0.65 l=0.15
X4 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X6 a_382_47# A1 a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.136 pd=1.1 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VPWR A1 a_298_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND A2 a_382_47# VNB sky130_fd_pr__nfet_01v8 ad=0.258 pd=1.45 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
X0 a_297_47# a_27_47# a_193_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_369_47# B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0441 ps=0.63 w=0.42 l=0.15
X2 VPWR D a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.0662 ps=0.735 w=0.42 l=0.15
X3 X a_193_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.103 ps=1 w=0.65 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND D a_469_47# VNB sky130_fd_pr__nfet_01v8 ad=0.103 pd=1 as=0.0609 ps=0.71 w=0.42 l=0.15
X6 X a_193_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR B a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.128 pd=1.03 as=0.0987 ps=0.89 w=0.42 l=0.15
X8 a_193_413# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.128 ps=1.03 w=0.42 l=0.15
X9 a_193_413# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0987 pd=0.89 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 a_469_47# C a_369_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.0735 ps=0.77 w=0.42 l=0.15
X11 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 Y a_61_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.183 ps=1.24 w=0.65 l=0.15
X1 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_217_297# a_61_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_479_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X4 a_217_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X5 Y a_61_47# a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 VPWR A1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_61_47# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VGND A2 a_637_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_61_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A1 a_479_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0683 ps=0.86 w=0.65 l=0.15
X11 VGND B1_N a_61_47# VNB sky130_fd_pr__nfet_01v8 ad=0.183 pd=1.24 as=0.126 ps=1.44 w=0.42 l=0.15
X12 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X13 a_637_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
X0 VPWR A a_49_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VGND a_285_47# a_391_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.5
X2 X a_391_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VGND A a_49_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR a_285_47# a_391_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.5
X5 a_285_47# a_49_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X6 a_285_47# a_49_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X7 X a_391_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
X0 X a_29_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.148 ps=1.34 w=1 l=0.15
X1 a_111_297# C a_29_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_29_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.102 ps=0.99 w=0.65 l=0.15
X3 a_183_297# B a_111_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 VPWR A a_183_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X5 a_29_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VGND C a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_199_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_113_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.147 ps=1.29 w=1 l=0.15
X2 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X3 VPWR A1 a_113_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.29 as=0.14 ps=1.28 w=1 l=0.15
X4 a_113_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A2 a_199_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0959 ps=0.945 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VGND A2 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR A1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_37_297# B1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_485_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_292_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VPWR A2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X8 a_485_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X11 a_37_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 Y A1 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X13 Y C1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_292_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X15 a_292_297# B1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 VGND a_415_21# a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_415_21# A2_N a_717_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_717_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VGND A2_N a_415_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_193_47# a_415_21# a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR a_193_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_193_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_193_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_415_21# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X11 a_415_21# A2_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_193_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_193_47# B2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VGND a_193_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND A1_N a_415_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND a_193_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_109_47# B2 a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_193_47# a_415_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR a_193_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_27_297# a_415_21# a_193_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X23 X a_193_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 VPWR A1_N a_717_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X26 a_717_297# A2_N a_415_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_109_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
X0 VPWR B a_207_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.228 pd=1.74 as=0.0609 ps=0.71 w=0.42 l=0.15
X1 X a_207_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.228 ps=1.74 w=1 l=0.15
X2 a_297_47# a_27_413# a_207_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0504 pd=0.66 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_207_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.99 w=0.65 l=0.15
X4 a_207_413# a_27_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0609 pd=0.71 as=0.0714 ps=0.76 w=0.42 l=0.15
X5 VPWR A_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0714 pd=0.76 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VGND B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.99 as=0.0504 ps=0.66 w=0.42 l=0.15
X7 a_27_413# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_75_199# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.135 ps=1.07 w=0.65 l=0.15
X1 a_208_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.112 ps=0.995 w=0.65 l=0.15
X2 a_315_47# A2 a_208_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.17 as=0.125 ps=1.03 w=0.65 l=0.15
X3 VGND B1 a_75_199# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.07 as=0.106 ps=0.975 w=0.65 l=0.15
X4 a_75_199# A1 a_315_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.17 w=0.65 l=0.15
X5 a_75_199# C1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.207 ps=1.41 w=1 l=0.15
X6 a_544_297# B1 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.207 pd=1.41 as=0.162 ps=1.33 w=1 l=0.15
X7 VPWR a_75_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.285 ps=2.57 w=1 l=0.15
X8 a_201_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.142 ps=1.28 w=1 l=0.15
X9 VPWR A2 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.165 ps=1.33 w=1 l=0.15
X10 a_201_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.305 ps=1.61 w=1 l=0.15
X11 VGND a_75_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
X0 a_558_47# a_381_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X1 VGND X a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_841_47# a_664_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VPWR A a_62_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A a_62_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_558_47# a_381_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X6 X a_62_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR X a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_841_47# a_664_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X9 X a_62_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X10 VPWR a_558_47# a_664_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND a_558_47# a_664_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_56_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A2 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_139_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.266 ps=2.12 w=0.65 l=0.15
X4 a_311_297# B1 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X5 Y C1 a_311_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X7 Y A1 a_139_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
X0 a_27_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y A a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y A a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_445_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X12 a_445_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_445_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X17 a_445_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X23 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
X0 Y C a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 a_281_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X6 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X10 a_281_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_297# B a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
X0 VPWR a_315_380# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_315_380# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X2 a_315_380# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND C_N a_27_410# VNB sky130_fd_pr__nfet_01v8 ad=0.0619 pd=0.715 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR C_N a_27_410# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.123 pd=1.32 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VPWR A a_583_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_27_410# a_315_380# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X7 a_583_297# B a_499_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_315_380# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_397_297# a_205_93# a_315_380# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.258 ps=2.52 w=1 l=0.15
X10 X a_315_380# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X11 X a_315_380# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_499_297# a_27_410# a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.18 ps=1.36 w=1 l=0.15
X13 VPWR a_315_380# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 a_205_93# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0619 ps=0.715 w=0.42 l=0.15
X15 a_205_93# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.4 as=0.123 ps=1.32 w=0.42 l=0.15
X16 VGND a_315_380# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND a_315_380# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_315_380# a_205_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.169 ps=1.82 w=0.65 l=0.15
X19 X a_315_380# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_206_369# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.146 ps=1.34 w=0.42 l=0.15
X1 a_206_369# A2_N a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 VGND B2 a_489_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_585_369# B2 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0672 ps=0.74 w=0.42 l=0.15
X4 a_489_47# a_206_369# a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_489_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VPWR A2_N a_206_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.209 pd=1.35 as=0.129 ps=1.18 w=0.42 l=0.15
X7 a_76_199# a_206_369# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.74 as=0.209 ps=1.35 w=0.42 l=0.15
X8 a_205_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0662 pd=0.735 as=0.0986 ps=0.98 w=0.42 l=0.15
X9 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.26 ps=2.52 w=1 l=0.15
X10 VPWR B1 a_585_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0986 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 Y A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.174 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.182 pd=1.92 as=0.174 ps=1.39 w=0.7 l=0.15
X2 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X3 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
X0 VGND a_652_21# a_586_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0882 pd=0.84 as=0.0671 ps=0.75 w=0.42 l=0.15
X1 a_956_413# a_476_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0483 pd=0.65 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 VPWR a_476_47# a_652_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_586_47# a_193_47# a_476_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0671 pd=0.75 as=0.072 ps=0.76 w=0.36 l=0.15
X4 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X5 a_476_47# a_27_47# a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.072 pd=0.76 as=0.0935 ps=0.965 w=0.36 l=0.15
X6 a_1056_47# a_476_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X7 a_381_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.125 pd=1.17 as=0.218 ps=2.2 w=0.84 l=0.15
X8 a_652_21# SET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0798 ps=0.8 w=0.42 l=0.15
X9 a_1224_47# a_27_47# a_1032_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X10 a_562_413# a_27_47# a_476_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0945 pd=0.87 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 VGND a_1032_413# a_1602_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X12 VPWR a_1182_261# a_1140_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X13 Q a_1602_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.149 ps=1.33 w=1 l=0.15
X14 a_1032_413# a_193_47# a_1056_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X15 a_476_47# a_193_47# a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.125 ps=1.17 w=0.42 l=0.15
X16 a_1296_47# a_1182_261# a_1224_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0483 pd=0.65 as=0.0441 ps=0.63 w=0.42 l=0.15
X17 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X18 VPWR a_652_21# a_562_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0798 pd=0.8 as=0.0945 ps=0.87 w=0.42 l=0.15
X19 VPWR SET_B a_1032_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.123 pd=1.17 as=0.109 ps=1.36 w=0.42 l=0.15
X20 a_1032_413# a_27_47# a_956_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0483 ps=0.65 w=0.42 l=0.15
X21 a_1182_261# a_1032_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.218 pd=2.2 as=0.123 ps=1.17 w=0.84 l=0.15
X22 Q a_1602_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X23 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X24 a_1140_413# a_193_47# a_1032_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0819 ps=0.81 w=0.42 l=0.15
X25 VPWR a_1032_413# a_1602_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.149 pd=1.33 as=0.166 ps=1.8 w=0.64 l=0.15
X26 a_796_47# SET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0882 ps=0.84 w=0.42 l=0.15
X27 a_381_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0935 pd=0.965 as=0.166 ps=1.8 w=0.64 l=0.15
X28 a_1182_261# a_1032_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.6 as=0.114 ps=1.01 w=0.54 l=0.15
X29 a_652_21# a_476_47# a_796_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X30 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X31 VGND SET_B a_1296_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1.01 as=0.0483 ps=0.65 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.172 ps=1.83 w=0.65 l=0.15
X2 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X3 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X5 a_326_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.127 ps=1.04 w=0.65 l=0.15
X6 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.635 pd=3.27 as=0.195 ps=1.39 w=1 l=0.15
X7 Y C1 a_326_47# VNB sky130_fd_pr__nfet_01v8 ad=0.393 pd=2.51 as=0.0683 ps=0.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.26 ps=1.45 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.4 ps=1.8 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.205 pd=1.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.135 ps=1.27 w=1 l=0.15
X5 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_109_297# C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.16 ps=1.32 w=1 l=0.15
X1 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.4 ps=1.8 w=1 l=0.15
X2 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0894 ps=0.925 w=0.65 l=0.15
X3 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_470_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.138 ps=1.27 w=1 l=0.15
X6 a_384_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 a_384_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.104 ps=0.97 w=0.65 l=0.15
X8 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_93_21# A1 a_346_47# VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.146 ps=1.1 w=0.65 l=0.15
X1 a_93_21# B1 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.185 ps=1.37 w=1 l=0.15
X2 a_584_47# B1 a_93_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.143 ps=1.09 w=0.65 l=0.15
X3 VPWR a_93_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.243 pd=1.49 as=0.33 ps=2.66 w=1 l=0.15
X4 VGND B2 a_584_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 a_256_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.167 ps=1.16 w=0.65 l=0.15
X6 a_250_297# B2 a_93_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 VGND a_93_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.167 pd=1.16 as=0.214 ps=1.96 w=0.65 l=0.15
X8 a_250_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.243 ps=1.49 w=1 l=0.15
X9 VPWR A2 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.225 pd=1.45 as=0.165 ps=1.33 w=1 l=0.15
X10 a_250_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.225 ps=1.45 w=1 l=0.15
X11 a_346_47# A2 a_256_47# VNB sky130_fd_pr__nfet_01v8 ad=0.146 pd=1.1 as=0.0975 ps=0.95 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
X0 VGND C a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y a_27_47# a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y a_27_47# a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_633_47# B a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_633_47# B a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_215_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 a_215_47# B a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_215_47# B a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 a_633_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X17 a_633_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X20 a_215_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X23 VGND C a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X25 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_388_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.127 pd=1.25 as=0.153 ps=1.3 w=1 l=0.15
X1 a_105_352# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_297_47# a_105_352# Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A1 a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.127 ps=1.25 w=1 l=0.15
X5 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X6 VPWR B1_N a_105_352# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.178 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 Y a_105_352# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.178 ps=1.4 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfstp_2 CLK D SET_B VGND VNB VPB VPWR Q
X0 VGND a_652_21# a_586_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0882 pd=0.84 as=0.0671 ps=0.75 w=0.42 l=0.15
X1 a_956_413# a_476_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_1136_413# a_193_47# a_1028_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0819 ps=0.81 w=0.42 l=0.15
X3 VPWR a_476_47# a_652_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_586_47# a_193_47# a_476_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0671 pd=0.75 as=0.072 ps=0.76 w=0.36 l=0.15
X5 a_1228_47# a_27_47# a_1028_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0735 ps=0.77 w=0.42 l=0.15
X6 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X7 a_476_47# a_27_47# a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.072 pd=0.76 as=0.0935 ps=0.965 w=0.36 l=0.15
X8 a_1056_47# a_476_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_381_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.125 pd=1.17 as=0.218 ps=2.2 w=0.84 l=0.15
X10 a_652_21# SET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0798 ps=0.8 w=0.42 l=0.15
X11 VPWR a_1602_47# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X12 a_562_413# a_27_47# a_476_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0945 pd=0.87 as=0.0567 ps=0.69 w=0.42 l=0.15
X13 VGND a_1028_413# a_1602_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X14 VGND a_1602_47# Q VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 Q a_1602_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 a_1028_413# a_193_47# a_1056_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0441 ps=0.63 w=0.42 l=0.15
X17 a_476_47# a_193_47# a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.125 ps=1.17 w=0.42 l=0.15
X18 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X19 VPWR a_1028_413# a_1602_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X20 VPWR a_652_21# a_562_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0798 pd=0.8 as=0.0945 ps=0.87 w=0.42 l=0.15
X21 Q a_1602_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 a_1028_413# a_27_47# a_956_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0441 ps=0.63 w=0.42 l=0.15
X23 VPWR a_1178_261# a_1136_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X24 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X25 a_1178_261# a_1028_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.223 pd=2.21 as=0.121 ps=1.16 w=0.84 l=0.15
X26 a_796_47# SET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0882 ps=0.84 w=0.42 l=0.15
X27 a_1300_47# a_1178_261# a_1228_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0441 ps=0.63 w=0.42 l=0.15
X28 a_381_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0935 pd=0.965 as=0.166 ps=1.8 w=0.64 l=0.15
X29 a_1178_261# a_1028_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.6 as=0.114 ps=1.01 w=0.54 l=0.15
X30 a_652_21# a_476_47# a_796_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X31 VPWR SET_B a_1028_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.121 pd=1.16 as=0.109 ps=1.36 w=0.42 l=0.15
X32 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X33 VGND SET_B a_1300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1.01 as=0.0441 ps=0.63 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
X0 VPWR a_505_21# a_535_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_505_21# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.0693 ps=0.75 w=0.42 l=0.15
X2 a_218_374# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0767 pd=0.785 as=0.158 ps=1.39 w=0.42 l=0.15
X3 VGND a_505_21# a_439_47# VNB sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.11 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 a_76_199# A0 a_218_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.193 pd=1.34 as=0.0767 ps=0.785 w=0.42 l=0.15
X5 a_505_21# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.145 ps=1.11 w=0.42 l=0.15
X6 a_439_47# A0 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0997 ps=0.895 w=0.42 l=0.15
X7 a_535_374# A1 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.193 ps=1.34 w=0.42 l=0.15
X8 a_76_199# A1 a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0997 pd=0.895 as=0.0693 ps=0.75 w=0.42 l=0.15
X9 a_218_47# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.113 ps=1.04 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.158 pd=1.39 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.04 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
X0 VPWR A a_304_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X1 a_304_297# B a_220_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND C a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X3 a_220_297# C a_114_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X4 a_32_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_32_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X11 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X13 a_114_297# D a_32_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.26 ps=2.52 w=1 l=0.15
X14 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X21 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_475_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A1 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X9 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.27 pd=1.48 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X12 a_475_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 Y A2 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X14 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.27 ps=1.48 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 VPWR a_82_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.186 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X1 a_646_47# B2 a_82_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_574_369# a_313_47# a_82_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0976 pd=0.945 as=0.166 ps=1.8 w=0.64 l=0.15
X3 a_574_369# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X4 VGND a_82_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.09 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR B2 a_574_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.0976 ps=0.945 w=0.64 l=0.15
X6 X a_82_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.172 ps=1.83 w=0.65 l=0.15
X7 X a_82_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.265 ps=2.53 w=1 l=0.15
X8 a_313_47# A2_N a_313_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.17 pd=1.81 as=0.0672 ps=0.85 w=0.64 l=0.15
X9 a_313_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.12 ps=1.09 w=0.42 l=0.15
X10 a_313_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.85 as=0.186 ps=1.43 w=0.64 l=0.15
X11 VGND A2_N a_313_47# VNB sky130_fd_pr__nfet_01v8 ad=0.142 pd=1.1 as=0.0567 ps=0.69 w=0.42 l=0.15
X12 a_82_21# a_313_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.142 ps=1.1 w=0.42 l=0.15
X13 VGND B1 a_646_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
X0 VPWR a_219_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.295 pd=2.59 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.202 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.17 pd=1.34 as=0.105 ps=1.21 w=1 l=0.15
X3 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.111 ps=0.99 w=0.65 l=0.15
X5 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X6 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=0.99 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_219_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND a_219_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.17 ps=1.34 w=1 l=0.15
X11 VGND a_219_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.214 pd=1.96 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.202 ps=1.4 w=0.65 l=0.15
X13 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_240_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_51_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A1 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_51_297# B2 a_245_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.412 pd=1.83 as=0.105 ps=1.21 w=1 l=0.15
X4 a_149_47# C1 a_51_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.201 ps=1.92 w=0.65 l=0.15
X5 a_240_47# B1 a_149_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0991 ps=0.955 w=0.65 l=0.15
X6 VPWR A1 a_512_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X7 X a_51_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.165 ps=1.33 w=1 l=0.15
X8 a_149_47# B2 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_245_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X10 VPWR C1 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.34 ps=2.68 w=1 l=0.15
X11 a_512_297# A2 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.412 ps=1.83 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 Y A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.109 ps=0.985 w=0.65 l=0.15
X4 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_949_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 Y C1 a_949_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.15 ps=1.3 w=1 l=0.15
X10 a_781_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_27_297# B1 a_781_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_781_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_1301_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.15 ps=1.3 w=1 l=0.15
X16 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 Y C1 a_781_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.14 ps=1.28 w=1 l=0.15
X18 a_109_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_109_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_109_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.091 ps=0.93 w=0.65 l=0.15
X27 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X28 a_27_297# B1 a_1301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X29 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0894 ps=0.925 w=0.65 l=0.15
X30 a_109_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X31 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
X0 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X1 a_471_47# B a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.42 pd=2.84 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_47# C a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=1.67 w=1 l=0.15
X8 a_277_47# B a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X9 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.335 pd=1.67 as=0.135 ps=1.27 w=1 l=0.15
X10 Y A a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_277_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X13 a_471_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_585_47# B1 a_266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.119 ps=1.01 w=0.65 l=0.15
X1 VGND A2 a_266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.137 pd=1.07 as=0.117 ps=1.01 w=0.65 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.62 as=0.26 ps=2.52 w=1 l=0.15
X3 a_81_21# C1 a_585_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.203 pd=1.27 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_266_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.312 ps=1.62 w=1 l=0.15
X6 a_368_297# A2 a_266_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.21 pd=1.42 as=0.18 ps=1.36 w=1 l=0.15
X7 a_266_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.137 ps=1.07 w=0.65 l=0.15
X8 a_266_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.203 ps=1.27 w=0.65 l=0.15
X9 a_81_21# A3 a_368_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.21 ps=1.42 w=1 l=0.15
X10 a_81_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.15 ps=1.3 w=1 l=0.15
X11 VPWR B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.138 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
X0 a_109_93# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_209_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X2 a_109_93# A_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_296_53# a_109_93# a_209_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.108 ps=1.36 w=0.42 l=0.15
X4 VPWR C a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0744 ps=0.815 w=0.42 l=0.15
X5 a_368_53# B a_296_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_209_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.122 ps=1.08 w=0.65 l=0.15
X7 a_209_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VPWR a_109_93# a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.108 ps=1.36 w=0.42 l=0.15
X9 VGND C a_368_53# VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.08 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X1 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0926 ps=0.935 w=0.65 l=0.15
X2 VPWR A1 a_307_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.105 ps=1.21 w=1 l=0.15
X3 a_307_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.233 ps=1.47 w=1 l=0.15
X4 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.233 pd=1.47 as=0.112 ps=1.23 w=1 l=0.15
X6 a_109_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.112 pd=1.23 as=0.26 ps=2.52 w=1 l=0.15
X7 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 a_103_199# B1 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.107 ps=0.98 w=0.65 l=0.15
X1 VPWR a_103_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.36 ps=2.72 w=1 l=0.15
X2 a_337_297# A2 a_253_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_103_199# A3 a_337_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.165 ps=1.33 w=1 l=0.15
X4 a_253_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.195 ps=1.39 w=1 l=0.15
X5 VPWR B1 a_103_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.345 pd=2.69 as=0.213 ps=1.42 w=1 l=0.15
X6 VGND a_103_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.234 ps=2.02 w=0.65 l=0.15
X7 a_253_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X8 a_253_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X9 VGND A2 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
X0 a_27_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_27_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_277_297# B a_205_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VPWR A a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 a_205_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X6 VPWR a_27_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=2.61 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND a_27_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.91 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X9 VGND C a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0693 ps=0.75 w=0.42 l=0.15
X10 a_109_297# D a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND A a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
X0 VPWR S a_591_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.0672 ps=0.85 w=0.64 l=0.15
X1 a_591_369# A0 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.85 as=0.131 ps=1.05 w=0.64 l=0.15
X2 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.178 pd=1.41 as=0.135 ps=1.27 w=1 l=0.15
X3 a_79_21# A1 a_306_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.131 pd=1.05 as=0.229 ps=1.36 w=0.64 l=0.15
X4 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND S a_578_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0578 ps=0.695 w=0.42 l=0.15
X6 a_306_369# a_257_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.229 pd=1.36 as=0.178 ps=1.41 w=0.64 l=0.15
X7 a_79_21# A0 a_288_47# VNB sky130_fd_pr__nfet_01v8 ad=0.173 pd=1.25 as=0.0683 ps=0.745 w=0.42 l=0.15
X8 a_288_47# a_257_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.745 as=0.097 ps=0.975 w=0.42 l=0.15
X9 a_257_199# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 a_578_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.173 ps=1.25 w=0.42 l=0.15
X11 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X12 a_257_199# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.173 pd=1.82 as=0.0864 ps=0.91 w=0.64 l=0.15
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X4 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X5 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X6 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X8 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.301 ps=2.66 w=1 l=0.15
X9 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X10 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X11 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X12 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X13 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X14 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X15 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X16 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X17 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X18 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X19 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X20 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X21 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X22 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X23 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X24 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.209 ps=2.02 w=0.65 l=0.15
X25 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X26 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X27 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X28 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X29 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X7 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X11 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X12 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X14 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X15 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X16 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.155 ps=1.31 w=1 l=0.15
X20 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_223_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 Y A1 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X3 a_223_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X4 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 VGND A2 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_223_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X7 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.123 ps=1.03 w=0.65 l=0.15
X8 VPWR A2 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 a_658_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.201 ps=1.27 w=0.65 l=0.15
X10 VPWR A1 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_223_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 a_658_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 Y a_27_47# a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_223_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X15 VPWR A2 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.155 ps=1.31 w=1 l=0.15
X16 VPWR A1 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 a_658_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VGND B1_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.27 ps=2.13 w=0.65 l=0.15
X19 a_223_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X20 a_658_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 VGND A2 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.27 as=0.091 ps=0.93 w=0.65 l=0.15
X23 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X24 Y A1 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X25 Y a_27_47# a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
X0 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X1 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND B a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_77_199# B2 a_227_47# VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.127 ps=1.04 w=0.65 l=0.15
X1 a_323_297# A2 a_227_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.165 ps=1.33 w=1 l=0.15
X2 a_227_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_227_47# B1 a_77_199# VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.133 ps=1.06 w=0.65 l=0.15
X4 VGND a_77_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR B1 a_539_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.205 ps=1.41 w=1 l=0.15
X6 a_227_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X7 VPWR a_77_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=2.67 w=1 l=0.15
X8 a_77_199# A3 a_323_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X9 VGND A2 a_227_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 a_227_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_539_297# B2 a_77_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=1.41 as=0.195 ps=1.39 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
X0 VPWR A a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_218_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.156 ps=1.16 w=0.42 l=0.15
X2 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.156 pd=1.16 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_300_297# a_27_53# a_218_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_218_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 VPWR a_218_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_218_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X7 VGND a_218_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 VGND A a_218_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
X0 a_204_297# A1 a_396_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.16 ps=1.32 w=1 l=0.15
X1 VPWR a_396_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_396_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR S a_314_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_204_297# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.162 ps=1.33 w=1 l=0.15
X5 a_396_47# A0 a_314_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.26 ps=2.52 w=1 l=0.15
X6 a_206_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.109 ps=0.985 w=0.65 l=0.15
X7 X a_396_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_396_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_396_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_490_47# A1 a_396_47# VNB sky130_fd_pr__nfet_01v8 ad=0.275 pd=1.5 as=0.104 ps=0.97 w=0.65 l=0.15
X11 VGND S a_490_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.275 ps=1.5 w=0.65 l=0.15
X12 VGND a_396_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_396_47# A0 a_206_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.26 ps=1.45 w=0.65 l=0.15
X14 VGND a_396_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR S a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X16 X a_396_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND S a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 a_78_199# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 VPWR A1 a_493_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X2 a_493_297# A2 a_78_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.235 ps=1.47 w=1 l=0.15
X3 VPWR a_78_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.373 pd=1.75 as=0.28 ps=2.56 w=1 l=0.15
X4 VGND A2 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X5 a_78_199# B2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.235 pd=1.47 as=0.117 ps=1.24 w=1 l=0.15
X6 a_215_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_215_47# B2 a_78_199# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_292_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.117 pd=1.24 as=0.373 ps=1.75 w=1 l=0.15
X9 VGND a_78_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
X0 VPWR D a_343_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.46 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_223_47# B_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.5 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 a_515_93# a_223_47# a_429_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 a_223_47# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.134 pd=1.48 as=0.0588 ps=0.7 w=0.42 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.168 ps=1.64 w=0.42 l=0.15
X5 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.168 ps=1.64 w=0.42 l=0.15
X6 X a_343_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.172 ps=1.46 w=1 l=0.15
X7 a_429_93# a_27_47# a_343_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.118 ps=1.4 w=0.42 l=0.15
X8 VGND D a_615_93# VNB sky130_fd_pr__nfet_01v8 ad=0.126 pd=1.11 as=0.0777 ps=0.79 w=0.42 l=0.15
X9 a_343_93# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X10 a_343_93# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.122 ps=1.42 w=0.42 l=0.15
X11 a_615_93# C a_515_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X12 X a_343_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.82 as=0.126 ps=1.11 w=0.65 l=0.15
X13 VPWR a_223_47# a_343_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
X0 a_176_21# a_27_47# a_626_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X1 a_626_297# B a_542_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_542_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X8 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X12 a_176_21# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X13 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor4_2 A B C D VGND VNB VPB VPWR Y
X0 a_281_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_475_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y D a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND D Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X9 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X12 a_475_297# C a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_281_297# C a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X14 a_27_297# B a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X15 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.091 ps=0.93 w=0.65 l=0.15
X1 Y B1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.175 ps=1.35 w=1 l=0.15
X4 a_29_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y A2 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND A1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 a_112_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X8 a_112_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.14 ps=1.28 w=1 l=0.15
X9 a_29_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X11 a_29_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 X a_79_204# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A1 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_473_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.195 ps=1.39 w=1 l=0.15
X3 X a_79_204# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X4 VGND C1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.104 ps=0.97 w=0.65 l=0.15
X5 a_79_204# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0926 ps=0.935 w=0.65 l=0.15
X6 VPWR a_79_204# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X7 a_473_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X8 a_473_297# B1 a_727_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.16 ps=1.32 w=1 l=0.15
X9 X a_79_204# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X10 VGND B1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.127 ps=1.04 w=0.65 l=0.15
X11 a_79_204# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.109 ps=0.985 w=0.65 l=0.15
X12 VGND a_79_204# X VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.0959 ps=0.945 w=0.65 l=0.15
X13 a_1123_47# A1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_555_297# B1 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X15 VPWR A2 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X16 VGND A2 a_1123_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.091 ps=0.93 w=0.65 l=0.15
X17 a_951_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.14 ps=1.08 w=0.65 l=0.15
X18 VPWR a_79_204# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_79_204# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X20 a_79_204# A1 a_951_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 a_79_204# C1 a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 a_727_297# C1 a_79_204# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X23 X a_79_204# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
X0 a_27_47# C a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# C a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_445_47# B a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_445_47# B a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y A a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X14 Y A a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_803_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X17 a_803_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_445_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 a_803_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X23 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X24 a_445_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_803_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X30 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X31 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.117 ps=1.01 w=0.65 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.41 pd=1.82 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.175 ps=1.35 w=1 l=0.15
X4 a_277_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.41 ps=1.82 w=1 l=0.15
X10 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.18 ps=1.36 w=1 l=0.15
X11 a_277_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.114 ps=1 w=0.65 l=0.15
X13 Y A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.0975 ps=0.95 w=0.65 l=0.15
X14 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_39_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=1 w=0.65 l=0.15
X2 VPWR a_39_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_39_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.156 ps=1.36 w=1 l=0.15
X4 VGND a_39_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.156 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VGND A a_39_297# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=1 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_39_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311a_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.305 ps=1.61 w=1 l=0.15
X1 a_467_47# C1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_467_47# B1 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND A1 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.135 ps=1.27 w=1 l=0.15
X6 a_79_21# C1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_717_47# B1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VGND A3 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.27 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_1147_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR A1 a_1147_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_1147_297# A2 a_875_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X18 a_79_21# A3 a_875_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X19 a_875_297# A3 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 a_875_297# A2 a_1147_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 a_717_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.201 ps=1.27 w=0.65 l=0.15
X23 a_717_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_717_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X26 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3b_2 A B C_N VGND VNB VPB VPWR Y
X0 a_281_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND a_531_21# Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR C_N a_531_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X7 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X9 a_281_297# a_531_21# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X10 Y a_531_21# a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X11 VGND C_N a_531_21# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X12 a_27_297# B a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X13 Y a_531_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
X0 a_408_47# B a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_408_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y a_27_47# a_408_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.176 pd=1.39 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND C a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X6 a_218_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.12 ps=1.04 w=0.65 l=0.15
X7 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_218_47# B a_408_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X11 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.176 ps=1.39 w=1 l=0.15
X12 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.04 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.28 ps=2.56 w=1 l=0.15
X1 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X4 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.177 ps=1.36 w=1 l=0.15
X7 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.105 ps=1.21 w=1 l=0.15
X9 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
X0 a_388_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.148 ps=1.34 w=0.42 l=0.15
X1 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X4 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X7 a_176_21# a_27_47# a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 a_472_297# B a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.102 ps=0.99 w=0.42 l=0.15
X10 a_176_21# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
X0 VPWR a_29_311# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_29_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.151 ps=1.35 w=1 l=0.15
X2 VPWR A a_29_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND a_29_311# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_184_53# B a_112_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X5 VPWR C a_29_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.151 pd=1.35 as=0.0744 ps=0.815 w=0.42 l=0.15
X6 X a_29_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.13 ps=1.11 w=0.65 l=0.15
X7 a_112_53# A a_29_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_29_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 VGND C a_184_53# VNB sky130_fd_pr__nfet_01v8 ad=0.13 pd=1.11 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor4_4 A B C D VGND VNB VPB VPWR Y
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_807_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y D a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X9 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X13 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 a_807_297# C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 VGND D Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 VGND D Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_807_297# C a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X22 a_449_297# C a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_449_297# C a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X26 a_27_297# B a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_807_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X28 a_449_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 Y D a_807_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
X0 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X5 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X17 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X21 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X23 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X36 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X39 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_277_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_277_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_277_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X5 a_277_47# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X6 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND a_277_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND a_277_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_193_47# A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_361_47# A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 X a_277_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A3 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X15 X a_277_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X16 a_277_47# A1 a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_445_47# A2 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND B1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_27_297# B1 a_277_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X21 VPWR a_277_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.5 pd=3 as=0.135 ps=1.27 w=1 l=0.15
X22 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X23 a_277_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
X0 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.107 ps=0.98 w=0.65 l=0.15
X1 VGND D a_304_47# VNB sky130_fd_pr__nfet_01v8 ad=0.175 pd=1.26 as=0.0693 ps=0.75 w=0.42 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.28 ps=1.62 w=1 l=0.15
X3 a_198_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0798 pd=0.8 as=0.0619 ps=0.715 w=0.42 l=0.15
X4 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0777 ps=0.79 w=0.42 l=0.15
X5 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.165 ps=1.33 w=1 l=0.15
X6 a_304_47# C a_198_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0798 ps=0.8 w=0.42 l=0.15
X7 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0746 pd=0.775 as=0.109 ps=1.36 w=0.42 l=0.15
X8 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=1.62 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.175 ps=1.26 w=0.65 l=0.15
X10 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0746 ps=0.775 w=0.42 l=0.15
X11 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0619 pd=0.715 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_397_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR B1_N a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X2 Y A2 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VGND A2 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND A1 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_28_297# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X6 Y a_28_297# a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VPWR a_28_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_397_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X9 a_229_47# a_28_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y a_28_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X11 a_229_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_229_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A1 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
D0 VNB DIODE sky130_fd_pr__diode_pw2nd_05v5 pj=2.64e+06 area=4.347e+11
.ends

.subckt sky130_fd_sc_hd__o311a_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 X a_91_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.32 ps=2.64 w=1 l=0.15
X1 a_91_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.15 ps=1.3 w=1 l=0.15
X2 a_360_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.137 ps=1.07 w=0.65 l=0.15
X3 VPWR B1 a_91_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.138 ps=1.27 w=1 l=0.15
X4 a_360_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.312 ps=1.62 w=1 l=0.15
X5 VGND A2 a_360_47# VNB sky130_fd_pr__nfet_01v8 ad=0.137 pd=1.07 as=0.114 ps=1 w=0.65 l=0.15
X6 a_360_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.203 ps=1.27 w=0.65 l=0.15
X7 VPWR a_91_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.62 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND a_91_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.203 pd=1.27 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 X a_91_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.208 ps=1.94 w=0.65 l=0.15
X10 a_677_47# B1 a_360_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.119 ps=1.01 w=0.65 l=0.15
X11 a_460_297# A2 a_360_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.21 pd=1.42 as=0.175 ps=1.35 w=1 l=0.15
X12 a_91_21# C1 a_677_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X13 a_91_21# A3 a_460_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.21 ps=1.42 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 a_465_47# A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND A4 a_561_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X2 VPWR A3 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X3 a_297_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X4 a_297_297# A4 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X5 VPWR A1 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_381_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.184 ps=1.22 w=0.65 l=0.15
X7 a_297_297# B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X8 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X9 a_79_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.184 pd=1.22 as=0.161 ps=1.14 w=0.65 l=0.15
X10 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.161 pd=1.14 as=0.169 ps=1.82 w=0.65 l=0.15
X11 a_561_47# A3 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt svm VGND VPWR clk halt in_valid periodTop[0] periodTop[10] periodTop[11] periodTop[12]
+ periodTop[13] periodTop[14] periodTop[15] periodTop[1] periodTop[2] periodTop[3]
+ periodTop[4] periodTop[5] periodTop[6] periodTop[7] periodTop[8] periodTop[9] pwmA
+ pwmB pwmC ready rstb vA[0] vA[10] vA[11] vA[12] vA[13] vA[14] vA[15] vA[1] vA[2]
+ vA[3] vA[4] vA[5] vA[6] vA[7] vA[8] vA[9] vB[0] vB[10] vB[11] vB[12] vB[13] vB[14]
+ vB[15] vB[1] vB[2] vB[3] vB[4] vB[5] vB[6] vB[7] vB[8] vB[9] vC[0] vC[10] vC[11]
+ vC[12] vC[13] vC[14] vC[15] vC[1] vC[2] vC[3] vC[4] vC[5] vC[6] vC[7] vC[8] vC[9]
X_3086_ _0694_ _0639_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__xor2_1
X_3155_ _0762_ _0763_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__nor2_2
X_2037_ _1374_ _1375_ VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__xnor2_2
X_2106_ net90 state\[4\] net60 VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_27_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2939_ _0544_ _0545_ _0546_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_49_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer7 _1760_ VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3842_ net195 _0110_ net136 VGND VGND VPWR VPWR tC\[15\] sky130_fd_sc_hd__dfrtp_1
X_3911_ net264 _0179_ net136 VGND VGND VPWR VPWR tB\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_13_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2655_ _0232_ net76 _0262_ _0263_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__o211ai_4
X_2724_ net126 _1327_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__nand2_1
X_3207_ _0814_ _0815_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__xnor2_1
Xfanout105 net7 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__buf_1
Xfanout116 net5 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__buf_2
Xfanout149 net15 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__buf_2
XFILLER_0_38_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2586_ net97 net170 _1433_ _1431_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__and4_1
XFILLER_0_1_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout138 net139 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__clkbuf_4
Xfanout127 net2 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__buf_6
XFILLER_0_69_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3138_ _0685_ _0705_ _0706_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__and3_1
X_3069_ net111 _1418_ _0625_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__and3_1
XFILLER_0_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3751__22 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__inv_2
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2440_ _1538_ _1547_ _1546_ VGND VGND VPWR VPWR _1779_ sky130_fd_sc_hd__a21o_1
XFILLER_0_51_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2371_ net161 net158 _1433_ _1431_ VGND VGND VPWR VPWR _1710_ sky130_fd_sc_hd__nand4_1
XFILLER_0_46_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3825_ net178 _0000_ net133 VGND VGND VPWR VPWR state\[3\] sky130_fd_sc_hd__dfrtp_4
XFILLER_0_71_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3687_ _1204_ _1206_ _1210_ _1227_ VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__a22o_1
X_2638_ _0241_ _0242_ _0245_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__a21o_1
X_2569_ net277 _1293_ _1327_ net99 VGND VGND VPWR VPWR _1908_ sky130_fd_sc_hd__a22oi_1
X_2707_ _0305_ _0309_ _0306_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__nand3_1
XFILLER_0_4_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1940_ _1278_ VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__buf_4
X_3610_ _0975_ tC\[6\] tC\[5\] _1145_ _1152_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__a221o_1
XFILLER_0_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2423_ _1761_ _1730_ VGND VGND VPWR VPWR _1762_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3472_ _1002_ _1038_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3541_ _1054_ _1091_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__or2b_1
X_2285_ _1609_ _1610_ _1623_ VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__a21o_1
X_2354_ _1662_ _1663_ _1691_ _1692_ VGND VGND VPWR VPWR _1693_ sky130_fd_sc_hd__o211a_1
XFILLER_0_47_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2070_ net172 _1278_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__nand2_1
X_2972_ net146 _1343_ _0580_ _0513_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__a31o_1
XFILLER_0_48_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1923_ net102 _1261_ VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__and2_1
XFILLER_0_24_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2406_ _1735_ _1740_ _1736_ VGND VGND VPWR VPWR _1745_ sky130_fd_sc_hd__nand3_1
X_3455_ _1002_ _1027_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__nor2_1
X_3524_ _1057_ _1082_ _1083_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__a21boi_1
X_3386_ net126 net98 VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__nor2_1
X_2268_ _1591_ _1606_ VGND VGND VPWR VPWR _1607_ sky130_fd_sc_hd__xnor2_2
X_2199_ _1536_ _1537_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__xnor2_2
X_2337_ _1673_ _1675_ VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__xor2_2
XFILLER_0_62_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3240_ _0846_ _0825_ _0828_ _0848_ _0805_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__a221o_1
XFILLER_0_21_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3171_ _0762_ _0779_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__nor2_1
X_2122_ net172 _1298_ VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__nand2_1
X_2053_ _1309_ _1349_ VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__and2_1
X_2955_ _1770_ _1836_ _1699_ _1767_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__a22o_1
XFILLER_0_8_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2886_ net272 _1765_ _1731_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__o21a_1
XFILLER_0_4_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3507_ delta\[2\] counter\[2\] VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__nor2_1
X_3369_ net143 _0944_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3438_ net77 net78 _1011_ _1012_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__or4_1
XFILLER_0_67_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_392 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2671_ _1713_ _0278_ _0275_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__and3_1
XFILLER_0_26_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2740_ _0346_ _0348_ net125 _0193_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__o211ai_2
X_3223_ _0810_ _0816_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__xor2_1
XFILLER_0_1_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3154_ _0760_ _0761_ _0719_ _0724_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__o211a_1
X_3085_ net123 _1279_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__nand2_1
X_2036_ _1335_ _1338_ _1336_ VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__o21ba_1
X_2105_ _1443_ VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2938_ _0544_ _0545_ _0546_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__and3_4
XFILLER_0_17_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2869_ _0472_ _0473_ _0457_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__a21o_1
Xclkbuf_3_6__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_6__leaf_clk sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_39_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer8 net297 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_48_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3910_ net263 _0178_ net137 VGND VGND VPWR VPWR tB\[14\] sky130_fd_sc_hd__dfrtp_1
X_3841_ net194 _0109_ net136 VGND VGND VPWR VPWR tC\[14\] sky130_fd_sc_hd__dfrtp_1
X_2723_ _0235_ _0329_ _0328_ _0319_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__o211a_1
XFILLER_0_54_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2654_ _0248_ _0249_ _0261_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__a21o_1
XFILLER_0_22_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2585_ net97 _1433_ _0193_ net170 VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_1_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3137_ _0727_ _0680_ _0743_ _0744_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__a2bb2o_1
X_3206_ net143 _1260_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__nand2_1
Xfanout106 net7 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__clkbuf_4
Xfanout117 net118 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__clkbuf_4
Xfanout128 net139 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__clkbuf_4
Xfanout139 net18 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__clkbuf_2
X_3068_ _0629_ _0606_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__nor2_2
XFILLER_0_64_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2019_ _1323_ _1324_ _1325_ VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__or3b_1
XFILLER_0_60_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2370_ _1705_ _1708_ VGND VGND VPWR VPWR _1709_ sky130_fd_sc_hd__nand2_1
XFILLER_0_42_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3824_ net177 net87 net136 VGND VGND VPWR VPWR state\[2\] sky130_fd_sc_hd__dfrtp_4
X_3686_ _1208_ counter\[13\] counter\[12\] _1211_ _1226_ VGND VGND VPWR VPWR _1227_
+ sky130_fd_sc_hd__a221o_1
X_2706_ _0311_ _0314_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__xnor2_1
X_2499_ _1768_ _1837_ VGND VGND VPWR VPWR _1838_ sky130_fd_sc_hd__nor2_1
X_2568_ net277 net99 _1293_ _1327_ VGND VGND VPWR VPWR _1907_ sky130_fd_sc_hd__and4_1
X_2637_ _0241_ _0242_ _0245_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3811__82 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3540_ _0932_ _1093_ _1097_ _1098_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__o31ai_1
X_2353_ _1680_ _1685_ _1686_ _1687_ VGND VGND VPWR VPWR _1692_ sky130_fd_sc_hd__a211o_1
X_2422_ _1410_ _1466_ VGND VGND VPWR VPWR _1761_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_24_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3471_ delta\[7\] _1037_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__xor2_1
XFILLER_0_10_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2284_ _1617_ _1621_ _1622_ VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1999_ net119 _1256_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__nand2_1
XFILLER_0_42_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3669_ _1206_ _1207_ _1209_ _1204_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__and4b_1
XFILLER_0_27_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3788__59 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__inv_2
XFILLER_0_18_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3736__7 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__inv_2
XFILLER_0_21_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2971_ net142 _1457_ _1360_ net123 VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__a22o_1
XFILLER_0_56_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1922_ _1260_ VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_21_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3523_ delta\[9\] counter\[9\] VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__nand2_1
X_2336_ _1642_ _1674_ VGND VGND VPWR VPWR _1675_ sky130_fd_sc_hd__xnor2_1
X_2405_ _1742_ _1743_ VGND VGND VPWR VPWR _1744_ sky130_fd_sc_hd__xnor2_1
X_3454_ delta\[13\] _1026_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__xor2_1
XFILLER_0_12_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3385_ _0958_ _0960_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__xnor2_1
X_2198_ net172 _1255_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__nand2_1
XFILLER_0_46_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2267_ _1600_ _1604_ _1605_ VGND VGND VPWR VPWR _1606_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold20 net68 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3170_ _0766_ _0767_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__and2_1
X_2052_ _1389_ _1390_ VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__or2_1
X_2121_ net99 _1343_ _1458_ _1459_ VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__a31o_1
XFILLER_0_16_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2954_ _1770_ _1836_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__or2_1
X_2885_ _0477_ _0478_ _0487_ _0493_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__a31o_1
XFILLER_0_29_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3506_ delta\[3\] counter\[3\] VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3299_ _0892_ _0896_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__nor2_1
X_2319_ _1654_ _1656_ _1657_ VGND VGND VPWR VPWR _1658_ sky130_fd_sc_hd__a21oi_2
X_3368_ net149 net147 _0943_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__or3_1
X_3437_ net79 net80 counter\[11\] counter\[10\] VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__or4_1
XPHY_EDGE_ROW_11_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3758__29 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2670_ _1713_ _0275_ _0278_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__a21oi_1
X_3772__43 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__inv_2
XFILLER_0_5_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3222_ _0745_ _0746_ _0747_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__and3_1
X_3153_ _0719_ _0724_ _0760_ _0761_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__a211oi_2
X_2104_ _1250_ net29 _1441_ _1442_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__a2bb2o_4
X_3084_ _0689_ _0690_ _0692_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__nand3_2
X_2035_ _1357_ _1373_ VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__and2b_1
X_2937_ _1879_ _1880_ _1888_ _1887_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__a31o_1
XFILLER_0_57_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2868_ _0340_ _0343_ _0456_ _0474_ _0476_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__a311o_1
XFILLER_0_17_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2799_ _0407_ _0379_ _0405_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_67_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer9 _1763_ VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_23_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3840_ net193 _0108_ net136 VGND VGND VPWR VPWR tC\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_14_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2722_ _0319_ _0328_ _0329_ _0235_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__a211oi_1
X_2584_ _1426_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__buf_4
XFILLER_0_59_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout107 net7 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__buf_2
Xfanout118 net4 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__buf_6
X_2653_ _0248_ _0249_ _0261_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__nand3_4
XFILLER_0_1_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout129 net139 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3067_ _0622_ _0655_ _0656_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__nor3_2
X_3136_ _0727_ _0680_ _0743_ _0744_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__or4bb_4
X_3205_ _0811_ _0813_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__xnor2_1
X_2018_ _1334_ _1340_ VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3742__13 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__inv_2
XFILLER_0_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3823_ net176 _0002_ net133 VGND VGND VPWR VPWR state\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_61_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3685_ _1213_ _1225_ _1211_ counter\[12\] VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__o2bb2a_1
X_2636_ _0243_ _0244_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__xnor2_2
X_2705_ _0182_ _0312_ _0313_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__o21a_1
XFILLER_0_42_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2498_ _1770_ _1836_ VGND VGND VPWR VPWR _1837_ sky130_fd_sc_hd__xnor2_2
X_2567_ _1903_ _1905_ VGND VGND VPWR VPWR _1906_ sky130_fd_sc_hd__xor2_2
XFILLER_0_10_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3119_ net124 _1268_ _1279_ net120 VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_67_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2283_ _1611_ _1616_ _1612_ VGND VGND VPWR VPWR _1622_ sky130_fd_sc_hd__nand3_1
X_2352_ _1688_ _1689_ _1472_ _1690_ VGND VGND VPWR VPWR _1691_ sky130_fd_sc_hd__or4bb_4
X_2421_ _1691_ _1758_ net73 _1754_ VGND VGND VPWR VPWR _1760_ sky130_fd_sc_hd__a211o_1
XFILLER_0_24_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3470_ net273 _1005_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1998_ _1335_ _1336_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__nor2_1
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3599_ tC\[14\] VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__inv_2
XFILLER_0_30_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3668_ _1208_ net79 VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__or2_1
X_2619_ _0181_ _0226_ _0227_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__o21a_1
XFILLER_0_65_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2970_ _0575_ _0576_ _0577_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_56_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1921_ _1259_ VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__buf_4
XFILLER_0_29_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3453_ net273 _1009_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__nand2_1
X_3522_ delta\[8\] counter\[8\] _1081_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2266_ _1594_ _1599_ _1595_ VGND VGND VPWR VPWR _1605_ sky130_fd_sc_hd__nand3_1
X_2335_ net145 _1444_ VGND VGND VPWR VPWR _1674_ sky130_fd_sc_hd__nand2_1
X_2404_ _1674_ _1703_ _1702_ VGND VGND VPWR VPWR _1743_ sky130_fd_sc_hd__o21a_1
X_3384_ _0941_ _0959_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__nand2_1
X_2197_ _1534_ _1489_ _1535_ VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__o21a_1
XFILLER_0_47_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold21 net71 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_42_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2120_ net172 net168 _1318_ _1322_ VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__and4_1
XFILLER_0_21_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2051_ _1352_ _1388_ VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__and2_1
X_2953_ _0499_ _0559_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2884_ _0479_ _0486_ _0490_ _0492_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__a22o_1
XFILLER_0_8_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3505_ _1063_ _1064_ VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__nor2_1
X_3436_ counter\[5\] counter\[4\] counter\[1\] _1010_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__or4_1
X_3298_ _0567_ _0775_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__nor2_1
X_2318_ _1648_ _1653_ _1631_ _1630_ VGND VGND VPWR VPWR _1657_ sky130_fd_sc_hd__a211oi_1
X_2249_ net294 net101 _1572_ _1585_ VGND VGND VPWR VPWR _1588_ sky130_fd_sc_hd__and4_1
X_3367_ net154 _0942_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__or2_1
XFILLER_0_35_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3221_ net147 _1309_ _0753_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__nand3_1
X_3152_ _0758_ _0759_ _0725_ _0726_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__o211a_1
X_3083_ net123 _1343_ _0691_ _0631_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__a31o_1
X_2103_ state\[2\] net45 state\[3\] VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_27_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2034_ _1365_ _1372_ VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2936_ _0542_ _0543_ _0532_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__a21o_1
XFILLER_0_57_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2867_ _0302_ _0303_ _0475_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__and3_1
XFILLER_0_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2798_ _0380_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__inv_2
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3419_ _0992_ _0994_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__xnor2_1
X_3818__89 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__inv_2
XFILLER_0_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2652_ _0251_ _0260_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_6_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2721_ _0319_ _0328_ _0329_ _0235_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__a211o_1
Xfanout108 net109 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__clkbuf_4
Xfanout119 net120 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__buf_2
X_3204_ _1367_ _0694_ _0812_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_38_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2583_ net125 _1418_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3135_ _0742_ _0740_ _0741_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__nand3_1
X_3066_ _0673_ _0674_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__nor2_1
X_2017_ _1346_ _1355_ VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2919_ _0525_ _0526_ _0527_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_60_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3899_ net252 _0167_ net132 VGND VGND VPWR VPWR tB\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_70_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3822_ net175 _0001_ net133 VGND VGND VPWR VPWR state\[0\] sky130_fd_sc_hd__dfstp_1
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3684_ _1222_ _1224_ _1212_ VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__or3b_1
X_2635_ _1703_ _0226_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__xor2_1
X_2704_ net166 _1700_ _1701_ net161 VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__a22o_1
XFILLER_0_49_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2566_ _1771_ _1835_ _1904_ VGND VGND VPWR VPWR _1905_ sky130_fd_sc_hd__a21oi_2
X_2497_ _1771_ _1835_ VGND VGND VPWR VPWR _1836_ sky130_fd_sc_hd__xor2_2
XFILLER_0_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3049_ _0655_ _0656_ _0622_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__o21ai_1
X_3118_ net107 _0255_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__and2_1
XFILLER_0_60_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2420_ _1754_ net74 _1758_ net265 VGND VGND VPWR VPWR _1759_ sky130_fd_sc_hd__o211ai_1
X_3802__73 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__inv_2
Xfanout90 state\[2\] VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2282_ _1620_ _1619_ VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__and2b_1
X_2351_ _1470_ _1471_ _1464_ _1469_ VGND VGND VPWR VPWR _1690_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_59_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1997_ net114 net111 _1268_ _1279_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__and4_1
XFILLER_0_19_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2549_ _1886_ _1818_ _1578_ VGND VGND VPWR VPWR _1888_ sky130_fd_sc_hd__or3_4
XFILLER_0_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3667_ tA\[13\] VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__inv_2
X_3598_ tC\[15\] VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__inv_2
X_2618_ net157 _1700_ _1701_ net153 VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__a22o_1
XFILLER_0_65_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1920_ _1251_ net25 _1258_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__o21a_2
X_2403_ net153 _1601_ VGND VGND VPWR VPWR _1742_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3452_ net95 _1020_ _1024_ net293 _1025_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__a32o_1
X_3521_ _1058_ _1059_ _1060_ _1080_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__and4_1
X_3383_ net126 net98 net171 net167 VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__o31ai_1
X_2265_ _1602_ _1603_ VGND VGND VPWR VPWR _1604_ sky130_fd_sc_hd__xnor2_2
X_2196_ net169 _1267_ _1279_ net164 VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__a22o_1
X_2334_ net148 _1601_ VGND VGND VPWR VPWR _1673_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3793__64 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__inv_2
X_3719_ _1244_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold22 state\[0\] VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2050_ _1352_ _1388_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__nor2_1
X_2952_ _1906_ _0494_ _0497_ _0560_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__and4_1
XFILLER_0_8_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2883_ net267 _0491_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3504_ delta\[4\] counter\[4\] VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3435_ counter\[9\] counter\[8\] counter\[7\] counter\[6\] VGND VGND VPWR VPWR _1010_
+ sky130_fd_sc_hd__or4_1
X_3366_ net163 net158 _0941_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__or3_1
X_2179_ net99 _1260_ VGND VGND VPWR VPWR _1518_ sky130_fd_sc_hd__nand2_1
X_2317_ _1510_ _1655_ VGND VGND VPWR VPWR _1656_ sky130_fd_sc_hd__xnor2_2
X_2248_ net294 _1572_ _1586_ net101 VGND VGND VPWR VPWR _1587_ sky130_fd_sc_hd__a22o_1
X_3297_ _0895_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_35_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput67 net67 VGND VGND VPWR VPWR halt sky130_fd_sc_hd__clkbuf_4
XFILLER_0_66_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3220_ _0703_ _0706_ _0752_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3151_ _0725_ _0726_ _0758_ _0759_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__a211oi_2
X_3082_ net120 _1293_ _1327_ net115 VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__a22o_1
X_2033_ _1365_ _1370_ _1371_ VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__nand3_1
X_2102_ net90 net81 net61 VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__nand3b_4
XFILLER_0_27_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2935_ _0532_ _0542_ _0543_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__nand3_1
XFILLER_0_43_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2797_ _0380_ _0405_ _0379_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__or3b_1
X_3763__34 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__inv_2
XFILLER_0_17_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2866_ _0342_ _0341_ _0339_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__o21bai_1
X_3349_ _0928_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__clkbuf_1
X_3418_ _0946_ _0993_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2651_ _0253_ _0259_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__xor2_2
XFILLER_0_22_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2720_ _0232_ _0233_ _0234_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__o21ba_1
X_2582_ _0185_ _0190_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__and2b_1
Xfanout109 net6 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__clkbuf_4
X_3203_ net143 _1256_ _0729_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__and3_1
XFILLER_0_1_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3134_ _0740_ _0741_ _0742_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__a21o_1
X_3065_ _0668_ _0672_ _0661_ _0662_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_54_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2016_ _1345_ _1332_ _1341_ VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__and3_1
XFILLER_0_70_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2918_ _1860_ _1862_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__nand2_1
XFILLER_0_64_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3898_ net251 _0166_ net132 VGND VGND VPWR VPWR tB\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_9_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2849_ _0285_ _0286_ _0297_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__nand3_1
XFILLER_0_13_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3821_ net174 _0094_ net128 VGND VGND VPWR VPWR delta\[0\] sky130_fd_sc_hd__dfstp_2
XFILLER_0_49_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2565_ _1832_ _1834_ VGND VGND VPWR VPWR _1904_ sky130_fd_sc_hd__nor2_1
X_3683_ tA\[10\] _1155_ _1223_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__a21o_1
X_2634_ net157 _1601_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2703_ net166 _1701_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__nand2_1
X_3117_ net151 _1309_ _0714_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__nand3_1
XFILLER_0_49_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2496_ _1832_ _1834_ VGND VGND VPWR VPWR _1835_ sky130_fd_sc_hd__xor2_2
XFILLER_0_4_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3048_ _0622_ _0655_ _0656_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__or3_1
XFILLER_0_33_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout91 net92 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__clkbuf_4
X_3799__70 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__inv_2
Xfanout80 counter\[12\] VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__buf_2
XFILLER_0_24_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2281_ net140 _1439_ _1527_ _1618_ VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__a22o_1
X_2350_ _1687_ _1686_ _1685_ _1680_ VGND VGND VPWR VPWR _1689_ sky130_fd_sc_hd__o211a_1
XFILLER_0_19_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1996_ net114 _1268_ _1279_ net110 VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_42_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2548_ _1818_ _1578_ _1886_ VGND VGND VPWR VPWR _1887_ sky130_fd_sc_hd__o21a_1
XFILLER_0_42_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3666_ _1205_ counter\[14\] VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__or2_1
X_2617_ net153 _1700_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__nand2_1
X_3597_ _1140_ _1016_ _1003_ net285 VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__a22o_1
X_2479_ _1814_ _1815_ _1817_ VGND VGND VPWR VPWR _1818_ sky130_fd_sc_hd__and3_1
XFILLER_0_65_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3520_ delta\[7\] counter\[7\] _1079_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__a21o_1
X_2333_ _1665_ _1666_ _1671_ VGND VGND VPWR VPWR _1672_ sky130_fd_sc_hd__a21o_1
X_2402_ _1735_ _1736_ _1740_ VGND VGND VPWR VPWR _1741_ sky130_fd_sc_hd__a21o_1
X_3451_ _1019_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__inv_2
X_3382_ counter\[3\] VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__inv_2
X_2264_ _1554_ _1553_ VGND VGND VPWR VPWR _1603_ sky130_fd_sc_hd__and2b_1
X_2195_ net164 _1268_ VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__nand2_1
XFILLER_0_62_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1979_ _1291_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__clkbuf_4
X_3649_ tB\[8\] _1161_ _1144_ tB\[7\] VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__a22o_1
X_3718_ tC\[1\] _0910_ net81 VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold23 delta\[4\] VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__dlygate4sd3_1
X_3769__40 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__inv_2
XFILLER_0_67_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2951_ _0499_ _0559_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__xor2_2
XFILLER_0_32_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2882_ _1759_ net271 _1762_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__a21oi_1
X_3503_ delta\[4\] counter\[4\] VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__and2_1
XFILLER_0_12_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2316_ _1511_ _1509_ VGND VGND VPWR VPWR _1655_ sky130_fd_sc_hd__nand2_1
X_3296_ tB\[5\] _0894_ net92 VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__mux2_1
X_3434_ delta\[12\] _1008_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3365_ net126 net98 net171 net167 VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__or4_4
X_2178_ _1515_ _1516_ VGND VGND VPWR VPWR _1517_ sky130_fd_sc_hd__nor2_1
X_2247_ _1585_ VGND VGND VPWR VPWR _1586_ sky130_fd_sc_hd__buf_8
Xoutput68 net68 VGND VGND VPWR VPWR pwmA sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_3150_ _0756_ _0757_ _0709_ _0718_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__o211a_1
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3081_ _0686_ _0687_ _0688_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__o21ai_1
X_2032_ _1358_ _1359_ _1364_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__a21o_1
X_2101_ _1439_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2934_ _0541_ _0539_ _0540_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__nand3_1
X_2865_ _0457_ _0472_ _0473_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__and3_1
XFILLER_0_68_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2796_ net170 _0239_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_15_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3279_ _0876_ _0880_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__nor2_1
X_3348_ tA\[2\] _0907_ net86 VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__mux2_1
X_3417_ net124 _0945_ net120 VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_0_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3739__10 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__inv_2
XFILLER_0_31_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2650_ _0254_ _0258_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__xnor2_2
X_2581_ _0186_ _0189_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3133_ _0693_ _0699_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__nand2_1
X_3202_ _0742_ _0740_ _0741_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__a21bo_1
X_3064_ _0661_ _0662_ _0668_ _0672_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__o211a_1
XFILLER_0_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2015_ _1352_ _1353_ VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__nand2_1
X_2917_ _0524_ _0522_ _0523_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__and3_1
XFILLER_0_60_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3897_ net250 _0165_ net132 VGND VGND VPWR VPWR tB\[1\] sky130_fd_sc_hd__dfrtp_1
X_2848_ _0200_ _0301_ _0300_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_9_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2779_ _0363_ _0358_ _0362_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__a21o_1
XFILLER_0_13_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3682_ tA\[11\] _0992_ _1160_ tA\[9\] VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__a22o_1
XFILLER_0_27_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2702_ net171 _1601_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2564_ _1840_ _1902_ VGND VGND VPWR VPWR _1903_ sky130_fd_sc_hd__xnor2_2
X_2495_ _1519_ _1659_ _1833_ VGND VGND VPWR VPWR _1834_ sky130_fd_sc_hd__a21oi_2
X_2633_ _0237_ _0240_ _0238_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__a21o_1
X_3116_ _0649_ _0652_ _0713_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__a21o_1
XFILLER_0_65_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3047_ _0653_ _0654_ _0607_ _0610_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__o211a_1
XFILLER_0_65_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_36_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_18_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_54_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout92 net93 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__buf_4
XFILLER_0_28_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout81 state\[4\] VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_51_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_63_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2280_ net140 _1439_ _1527_ _1618_ VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__and4_1
XFILLER_0_35_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1995_ _1332_ _1333_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__and2_1
X_3665_ _1203_ counter\[15\] counter\[14\] _1205_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__a22o_1
X_2616_ net162 _1601_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__nand2_1
X_2547_ _1882_ _1885_ VGND VGND VPWR VPWR _1886_ sky130_fd_sc_hd__xnor2_1
X_2478_ net101 _1816_ _1577_ VGND VGND VPWR VPWR _1817_ sky130_fd_sc_hd__and3_1
X_3596_ _0939_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__inv_2
XFILLER_0_65_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_3_Left_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2332_ _1667_ _1668_ _1670_ VGND VGND VPWR VPWR _1671_ sky130_fd_sc_hd__a21bo_1
X_2401_ _1737_ _1738_ _1739_ VGND VGND VPWR VPWR _1740_ sky130_fd_sc_hd__a21bo_1
X_3381_ net78 _0952_ _0956_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__a21oi_1
X_3450_ delta\[13\] _1009_ delta\[14\] VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__o21ai_1
X_2263_ net121 _1601_ VGND VGND VPWR VPWR _1602_ sky130_fd_sc_hd__nand2_1
X_2194_ _1521_ _1532_ _1531_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_46_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1978_ _1284_ _1300_ VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__xnor2_1
X_3648_ tB\[9\] _1160_ _1161_ tB\[8\] VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__o22ai_2
X_3717_ _1243_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__clkbuf_1
X_3579_ counter\[4\] _1127_ net94 VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold24 delta\[2\] VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_38_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3784__55 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__inv_2
XFILLER_0_61_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2950_ _0501_ _0558_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_32_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2881_ _0488_ _0485_ _0489_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3433_ delta\[11\] delta\[10\] _1007_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__or3_1
X_3502_ delta\[5\] counter\[5\] VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__nor2_1
X_3295_ _0675_ _0893_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__xnor2_1
X_2315_ _1630_ _1631_ _1653_ _1648_ VGND VGND VPWR VPWR _1654_ sky130_fd_sc_hd__o211ai_2
X_2246_ _1250_ net19 _1583_ _1584_ VGND VGND VPWR VPWR _1585_ sky130_fd_sc_hd__a2bb2o_4
X_3364_ rising VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__inv_2
X_2177_ _1509_ _1512_ _1514_ VGND VGND VPWR VPWR _1516_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput69 net69 VGND VGND VPWR VPWR pwmB sky130_fd_sc_hd__clkbuf_4
XFILLER_0_1_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3080_ _0686_ _0687_ _0688_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__or3_1
X_2100_ _1251_ net30 _1437_ _1438_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__a2bb2o_2
XFILLER_0_27_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2031_ _1368_ _1369_ VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_43_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2933_ _0539_ _0540_ _0541_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2864_ _0470_ _0471_ _0295_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2795_ _0345_ _0398_ _0403_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__o21a_1
XFILLER_0_40_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3416_ counter\[11\] VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__inv_2
X_2229_ _1566_ _1567_ VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__and2b_1
X_3278_ _0840_ _0782_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__nor2_1
X_3347_ _0927_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_67_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3754__25 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__inv_2
XFILLER_0_16_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2580_ _0187_ _0188_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__xor2_1
XFILLER_0_22_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3201_ _0745_ _0809_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__xor2_1
X_3063_ _0669_ _0671_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__or2b_4
X_3132_ _0683_ _0738_ _0739_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__nand3_1
X_2014_ _1317_ _1351_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__or2_1
XFILLER_0_70_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2916_ _0522_ _0523_ _0524_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_45_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3896_ net249 _0164_ net132 VGND VGND VPWR VPWR tB\[0\] sky130_fd_sc_hd__dfrtp_1
X_2778_ _0363_ _0358_ _0362_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__nand3_1
X_2847_ _0442_ _0449_ _0452_ _0454_ _0455_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__a32o_1
XFILLER_0_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3681_ tA\[9\] _1160_ _1161_ tA\[8\] _1221_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__o221a_1
XFILLER_0_27_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2632_ _0237_ _0238_ _0240_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__nand3_1
X_2701_ _0305_ _0306_ _0309_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2563_ _1899_ _1901_ VGND VGND VPWR VPWR _1902_ sky130_fd_sc_hd__xor2_2
X_2494_ _1658_ _1629_ VGND VGND VPWR VPWR _1833_ sky130_fd_sc_hd__and2b_1
XFILLER_0_4_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3046_ _0607_ _0610_ _0653_ _0654_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__a211oi_4
X_3115_ _0720_ _0721_ _0722_ _0723_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__a211o_1
XFILLER_0_60_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3879_ net232 _0147_ net138 VGND VGND VPWR VPWR calc_ready sky130_fd_sc_hd__dfrtp_1
XFILLER_0_51_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout93 state\[2\] VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__clkbuf_4
Xfanout82 net83 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1994_ _1331_ _1323_ _1329_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__or3_1
XFILLER_0_70_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3664_ tA\[14\] VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__inv_2
XFILLER_0_30_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2615_ _0221_ _0222_ _0217_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__a21o_1
X_3595_ counter\[0\] _1139_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__xnor2_1
X_2546_ _1883_ _1884_ VGND VGND VPWR VPWR _1885_ sky130_fd_sc_hd__and2b_1
X_2477_ net104 _1573_ VGND VGND VPWR VPWR _1816_ sky130_fd_sc_hd__nand2_1
X_3029_ _0634_ _0635_ _0637_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__nand3_1
XFILLER_0_65_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2400_ net141 net280 _1579_ _1669_ VGND VGND VPWR VPWR _1739_ sky130_fd_sc_hd__nand4_1
XFILLER_0_24_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2262_ _1439_ VGND VGND VPWR VPWR _1601_ sky130_fd_sc_hd__clkbuf_4
X_2331_ net280 net118 _1579_ _1669_ VGND VGND VPWR VPWR _1670_ sky130_fd_sc_hd__nand4_2
X_3380_ net110 net106 _0947_ _0953_ _0955_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__o311a_1
X_2193_ _1530_ _1531_ VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1977_ _1271_ _1315_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__or2b_1
X_3716_ tC\[2\] _0907_ net83 VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2529_ _1848_ _1867_ VGND VGND VPWR VPWR _1868_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_30_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3647_ _1186_ _1187_ _1188_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__and3b_1
X_3578_ _1065_ _1126_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__xnor2_1
Xhold25 tB\[0\] VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_38_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2880_ _0482_ _0484_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__nor2_1
X_3363_ _0932_ net82 _0939_ net282 VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__a22o_1
X_3432_ delta\[9\] _1006_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__or2_1
X_3501_ delta\[6\] counter\[6\] VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3294_ _0773_ _0892_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__nor2_1
X_2176_ _1509_ _1512_ _1514_ VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__and3_1
X_2314_ _1648_ _1649_ _1652_ VGND VGND VPWR VPWR _1653_ sky130_fd_sc_hd__nand3_1
X_2245_ net89 net35 net85 VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_20_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2030_ net123 _1255_ VGND VGND VPWR VPWR _1369_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2932_ _1871_ _1872_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2863_ _0295_ _0470_ _0471_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__nand3_1
XFILLER_0_25_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2794_ net125 _1700_ _1701_ net97 VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__a22o_1
XFILLER_0_40_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3346_ tA\[3\] _0905_ net86 VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__mux2_1
X_3415_ _0985_ _0987_ _0988_ _0990_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__or4_1
XFILLER_0_4_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2228_ net112 net298 _1501_ net108 VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__a22o_1
X_2159_ _1495_ _1496_ _1497_ VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__nand3b_1
X_3277_ _0879_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3200_ _0788_ _0789_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3131_ _0738_ _0739_ _0683_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__a21o_1
X_3062_ net165 _1309_ _0505_ _0670_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__a31o_1
XFILLER_0_54_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2013_ _1317_ _1351_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2915_ _1878_ _1876_ _1877_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_57_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3895_ net248 _0163_ net137 VGND VGND VPWR VPWR tA\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_60_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2777_ _0382_ _0384_ _0385_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__a21bo_1
X_2846_ _0395_ _0441_ _0451_ _0453_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_13_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3329_ _0918_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3814__85 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__inv_2
XFILLER_0_6_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2562_ _1778_ _1831_ _1900_ VGND VGND VPWR VPWR _1901_ sky130_fd_sc_hd__a21oi_2
X_3680_ tA\[8\] _1161_ _1144_ tA\[7\] _1220_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__a221o_1
X_2631_ net144 _0239_ _1739_ _1738_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2700_ net161 _0239_ _0307_ _0308_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__a31o_1
XFILLER_0_65_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2493_ _1778_ _1831_ VGND VGND VPWR VPWR _1832_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_4_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3114_ _0718_ _0717_ _0676_ _0655_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__a211oi_1
X_3045_ _0651_ _0652_ _0630_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__a21oi_2
X_3878_ net231 _0146_ net134 VGND VGND VPWR VPWR rising sky130_fd_sc_hd__dfstp_1
XFILLER_0_60_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2829_ _0425_ _0428_ _0433_ _0437_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__o31a_1
XFILLER_0_68_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout83 net84 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__buf_4
XFILLER_0_24_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout94 net96 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_19_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_7__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_7__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_3731__2 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__inv_2
X_1993_ _1323_ _1329_ _1331_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_27_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2545_ net104 net298 _1501_ net101 VGND VGND VPWR VPWR _1884_ sky130_fd_sc_hd__a22o_1
XFILLER_0_42_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3663_ _1203_ net77 VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__or2_1
X_2614_ _0217_ _0221_ _0222_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__nand3_1
X_3594_ net94 delta\[0\] VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__nand2_1
X_2476_ _1811_ _1813_ _1812_ VGND VGND VPWR VPWR _1815_ sky130_fd_sc_hd__o21ai_1
X_3028_ net142 _1343_ _0636_ _0575_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__a31o_1
XFILLER_0_18_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2192_ _1525_ _1529_ _1526_ VGND VGND VPWR VPWR _1531_ sky130_fd_sc_hd__and3_1
X_2261_ _1594_ _1595_ _1599_ VGND VGND VPWR VPWR _1600_ sky130_fd_sc_hd__a21o_1
X_2330_ _1585_ VGND VGND VPWR VPWR _1669_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_1_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1976_ _1273_ _1308_ _1310_ _1314_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__o31a_1
X_3715_ _1242_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2528_ _1865_ _1866_ VGND VGND VPWR VPWR _1867_ sky130_fd_sc_hd__nor2_1
X_3646_ tB\[10\] _1155_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__nand2_1
X_3577_ _1066_ _1074_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2459_ _1780_ _1797_ VGND VGND VPWR VPWR _1798_ sky130_fd_sc_hd__xnor2_2
Xhold26 delta\[12\] VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_69_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3775__46 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__inv_2
X_3500_ delta\[7\] counter\[7\] VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__or2_1
X_2313_ _1494_ _1651_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__xor2_2
X_3431_ delta\[8\] delta\[7\] _1005_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__or3_1
XFILLER_0_12_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3362_ rising _0931_ _0933_ _0938_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__or4_2
XPHY_EDGE_ROW_69_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3293_ _0567_ _0775_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__and2_1
X_2175_ _1489_ _1490_ _1513_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__o21ba_1
X_2244_ net89 net81 net51 VGND VGND VPWR VPWR _1583_ sky130_fd_sc_hd__nand3b_4
XFILLER_0_7_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1959_ _1297_ VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__clkbuf_4
X_3629_ net78 _1142_ _1143_ net79 _1171_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__o221a_1
XFILLER_0_3_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2931_ _0536_ _0538_ _0537_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__nand3_1
XFILLER_0_57_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_40_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2862_ _0468_ _0469_ _0285_ _0458_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_4_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2793_ _0400_ _0401_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3276_ tB\[9\] _0878_ net92 VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__mux2_1
X_3345_ _0926_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__clkbuf_1
X_3414_ counter\[10\] _0989_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2227_ net112 net108 net298 _1501_ VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__and4_1
X_2089_ net160 net156 _1421_ _1425_ VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__and4_1
X_2158_ net152 net145 _1422_ _1426_ VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__nand4_2
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3745__16 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__inv_2
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3130_ _0736_ _0737_ _0731_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3061_ _0502_ _0504_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__nor2_1
XFILLER_0_54_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2012_ _1349_ _1350_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__xnor2_1
X_2914_ _0520_ _0521_ _0512_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__a21o_1
XFILLER_0_45_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3894_ net247 _0162_ net137 VGND VGND VPWR VPWR tA\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_9_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2845_ _0451_ _0453_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2776_ _0381_ _0377_ _0378_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__nand3_1
XFILLER_0_13_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3259_ tB\[13\] _0865_ net91 VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__mux2_2
X_3328_ tA\[12\] _0867_ net87 VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2561_ _1830_ _1828_ VGND VGND VPWR VPWR _1900_ sky130_fd_sc_hd__and2b_1
X_2492_ _1828_ _1830_ VGND VGND VPWR VPWR _1831_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_40_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2630_ _1580_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__clkbuf_4
X_3113_ _0655_ _0676_ _0717_ _0718_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__o211a_1
XFILLER_0_65_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3044_ _0630_ _0651_ _0652_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__and3_4
XFILLER_0_65_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2828_ net125 _1701_ _0432_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__a21o_1
X_3877_ net230 _0145_ net133 VGND VGND VPWR VPWR delta\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_18_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2759_ _0312_ _0360_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__nor2_1
XFILLER_0_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout84 state\[4\] VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__buf_2
Xfanout95 net96 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_35_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_32_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1992_ _1294_ _1299_ _1330_ VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_41_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3662_ tA\[15\] VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__inv_2
XFILLER_0_27_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2544_ net104 net101 net298 _1501_ VGND VGND VPWR VPWR _1883_ sky130_fd_sc_hd__and4_1
XFILLER_0_55_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2475_ _1811_ _1812_ _1813_ VGND VGND VPWR VPWR _1814_ sky130_fd_sc_hd__or3_1
X_2613_ _0219_ _0220_ _0218_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__a21o_1
X_3593_ _1138_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_50_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3027_ net123 _1293_ _1327_ net119 VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__a22o_1
XFILLER_0_61_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2191_ _1525_ _1526_ _1529_ VGND VGND VPWR VPWR _1530_ sky130_fd_sc_hd__a21oi_1
X_2260_ _1596_ _1597_ _1598_ VGND VGND VPWR VPWR _1599_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_20_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1975_ _1311_ _1313_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__or2b_1
X_3645_ tB\[11\] _0992_ VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__nand2_1
X_3714_ tC\[3\] _0905_ net83 VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2527_ _1864_ _1862_ _1863_ VGND VGND VPWR VPWR _1866_ sky130_fd_sc_hd__and3_1
X_2458_ _1786_ _1796_ VGND VGND VPWR VPWR _1797_ sky130_fd_sc_hd__xnor2_2
Xhold27 tC\[0\] VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_11_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3576_ _1125_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__clkbuf_1
X_2389_ _1709_ _1716_ _1717_ VGND VGND VPWR VPWR _1728_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_7_Left_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2312_ _1650_ _1506_ VGND VGND VPWR VPWR _1651_ sky130_fd_sc_hd__nor2_2
X_3292_ _0891_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__clkbuf_1
X_3430_ delta\[6\] delta\[5\] delta\[4\] _1004_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__or4_1
X_3361_ _0934_ _0935_ _0936_ _0937_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__or4_1
X_2243_ _1578_ _1581_ VGND VGND VPWR VPWR _1582_ sky130_fd_sc_hd__nor2_1
X_2174_ net99 _1256_ _1491_ VGND VGND VPWR VPWR _1513_ sky130_fd_sc_hd__and3_1
XFILLER_0_25_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1958_ _1251_ net21 _1295_ _1296_ VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_43_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3628_ _1154_ _1167_ _1170_ VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_7_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3559_ counter\[9\] _1112_ net96 VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__mux2_1
XFILLER_0_66_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2930_ _0536_ _0537_ _0538_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2861_ _0285_ _0458_ _0468_ _0469_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__a211o_1
XFILLER_0_9_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3413_ net124 _0945_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__xor2_1
XFILLER_0_4_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2792_ _0385_ _0382_ _0384_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__a21o_1
X_2226_ net117 _1440_ VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__nand2_1
X_3275_ _0844_ _0877_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__xnor2_2
X_3344_ tA\[4\] _0897_ net86 VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2088_ net160 _1422_ _1426_ net156 VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__a22o_1
X_2157_ net152 _1421_ _1426_ net145 VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__a22o_1
XFILLER_0_71_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3060_ _0664_ _0666_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2011_ net114 _1260_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2913_ _0512_ _0520_ _0521_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__nand3_2
XFILLER_0_57_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3893_ net246 _0161_ net137 VGND VGND VPWR VPWR tA\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_5_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2844_ _0443_ _0447_ _0446_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__a21oi_1
X_2775_ _0383_ _0347_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__xnor2_2
X_3189_ _0784_ _0796_ _0797_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__nor3_1
X_2209_ _1546_ _1547_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__or2b_1
X_3258_ _0855_ _0864_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__xnor2_2
X_3327_ _0917_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3805__76 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__inv_2
X_2560_ _1847_ _1898_ VGND VGND VPWR VPWR _1899_ sky130_fd_sc_hd__xnor2_2
X_2491_ _1551_ _1628_ _1829_ VGND VGND VPWR VPWR _1830_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_35_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3112_ net156 _1261_ _0620_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__nand3_1
X_3043_ _0650_ _0648_ _0649_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__nand3_1
XFILLER_0_65_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3876_ net229 _0144_ net133 VGND VGND VPWR VPWR delta\[14\] sky130_fd_sc_hd__dfrtp_2
X_2827_ _0429_ _0433_ _0435_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__a21oi_1
X_2758_ _0350_ _0365_ _0364_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__a21oi_1
X_2689_ _0285_ _0286_ _0297_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__and3_1
XFILLER_0_64_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout85 state\[3\] VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__buf_4
Xfanout96 state\[1\] VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__buf_2
XFILLER_0_51_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1991_ net103 _1293_ _1298_ net107 VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__a22o_1
XFILLER_0_27_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3661_ _1175_ _1201_ _1202_ net281 _0932_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__a32o_1
X_2612_ _0218_ _0219_ _0220_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__nand3_1
X_3592_ counter\[1\] _1137_ net94 VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__mux2_1
X_2543_ net108 _1440_ VGND VGND VPWR VPWR _1882_ sky130_fd_sc_hd__nand2_1
X_2474_ net108 net298 _1501_ net104 VGND VGND VPWR VPWR _1813_ sky130_fd_sc_hd__a22oi_2
X_3026_ _0631_ _0632_ _0633_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_46_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3796__67 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__inv_2
XFILLER_0_33_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3859_ net212 _0127_ net133 VGND VGND VPWR VPWR counter\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_56_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2190_ net140 _1440_ _1527_ _1528_ VGND VGND VPWR VPWR _1529_ sky130_fd_sc_hd__a31o_1
XFILLER_0_46_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1974_ _1308_ _1312_ VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_28_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3644_ tB\[11\] _0992_ _1155_ tB\[10\] VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__o22ai_1
X_3713_ _1241_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__clkbuf_1
X_3575_ counter\[5\] _1124_ net96 VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2526_ _1862_ _1863_ _1864_ VGND VGND VPWR VPWR _1865_ sky130_fd_sc_hd__a21oi_1
X_2457_ _1794_ _1795_ VGND VGND VPWR VPWR _1796_ sky130_fd_sc_hd__nand2_1
X_2388_ _1466_ _1726_ VGND VGND VPWR VPWR _1727_ sky130_fd_sc_hd__or2b_1
Xhold17 net69 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__dlygate4sd3_1
Xhold28 tA\[0\] VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__dlygate4sd3_1
X_3009_ net156 _1256_ _0584_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__and3_1
XFILLER_0_46_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2311_ _1498_ _1499_ _1504_ VGND VGND VPWR VPWR _1650_ sky130_fd_sc_hd__a21oi_1
X_2242_ net101 _1579_ _1580_ net294 VGND VGND VPWR VPWR _1581_ sky130_fd_sc_hd__a22oi_2
X_3291_ tB\[6\] _0890_ net92 VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3360_ counter\[7\] counter\[6\] counter\[5\] counter\[4\] VGND VGND VPWR VPWR _0937_
+ sky130_fd_sc_hd__or4_1
X_2173_ _1510_ _1511_ _1509_ VGND VGND VPWR VPWR _1512_ sky130_fd_sc_hd__nand3_1
X_1957_ net93 net37 net88 VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_7_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3766__37 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__inv_2
X_2509_ _1786_ _1795_ _1794_ VGND VGND VPWR VPWR _1848_ sky130_fd_sc_hd__a21bo_1
X_3627_ net79 _1143_ _1164_ _1168_ _1169_ VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__a221o_1
X_3558_ _1111_ _1082_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3489_ delta\[1\] delta\[0\] net273 VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__nand3_1
XFILLER_0_66_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3780__51 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__inv_2
X_2860_ _0462_ _0463_ _0467_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__o21a_1
X_2791_ _0385_ _0382_ _0384_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__nand3_1
X_3412_ _0945_ _0986_ counter\[9\] VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__a21oi_1
X_2225_ _1552_ _1563_ VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__xnor2_2
X_3274_ _0875_ _0839_ _0876_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__a21oi_4
X_3343_ _0925_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2087_ _1425_ VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__buf_4
XFILLER_0_48_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2156_ net156 _1416_ VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2989_ _0595_ _0596_ _0597_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_33_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_10_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2010_ _1346_ _1348_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__xor2_1
X_2912_ _0516_ _0517_ _0519_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__a21o_1
XFILLER_0_57_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3892_ net245 _0160_ net136 VGND VGND VPWR VPWR tA\[12\] sky130_fd_sc_hd__dfrtp_1
X_2774_ net125 _0180_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__nand2_1
X_2843_ _0446_ _0451_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__or2b_1
XFILLER_0_13_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3326_ tA\[13\] _0865_ net87 VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__mux2_2
X_2208_ _1542_ _1543_ _1545_ VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__a21o_1
X_3188_ _1356_ _1378_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__xor2_1
X_3257_ _1397_ net276 _1395_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__a21boi_4
X_2139_ net277 _1309_ _1477_ _1476_ VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__a31o_1
XFILLER_0_63_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3750__21 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__inv_2
XFILLER_0_54_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2490_ _1608_ _1627_ VGND VGND VPWR VPWR _1829_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3042_ _0648_ _0649_ _0650_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__a21o_1
X_3111_ _0591_ _0594_ _0619_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__a21o_1
XFILLER_0_65_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3875_ net228 _0143_ net133 VGND VGND VPWR VPWR delta\[13\] sky130_fd_sc_hd__dfrtp_2
XFILLER_0_60_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2688_ _0295_ _0296_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2826_ _0404_ _0434_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__xnor2_1
X_2757_ _0350_ _0364_ _0365_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__and3_1
XFILLER_0_39_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3309_ tB\[3\] _0905_ net92 VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__mux2_1
XFILLER_0_68_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout86 net88 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__buf_4
Xfanout97 net98 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_19_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1990_ _1324_ _1325_ _1328_ VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__and3b_1
XFILLER_0_27_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2542_ _1879_ _1880_ VGND VGND VPWR VPWR _1881_ sky130_fd_sc_hd__and2_1
XFILLER_0_42_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3660_ _1176_ net77 VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__or2_1
X_2611_ net144 _1579_ _1669_ net141 VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__a22o_1
X_3591_ _1136_ _1069_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__xnor2_1
X_2473_ net112 _1439_ VGND VGND VPWR VPWR _1812_ sky130_fd_sc_hd__nand2_1
X_3025_ _0631_ _0632_ _0633_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__or3_1
XFILLER_0_61_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3858_ net211 _0126_ net134 VGND VGND VPWR VPWR counter\[11\] sky130_fd_sc_hd__dfrtp_4
X_2809_ _0400_ _0401_ _0416_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__and3_1
XFILLER_0_5_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1973_ _1273_ _1310_ VGND VGND VPWR VPWR _1312_ sky130_fd_sc_hd__nor2_1
X_3712_ tC\[4\] _0897_ net83 VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2525_ _1800_ _1808_ _1807_ VGND VGND VPWR VPWR _1864_ sky130_fd_sc_hd__a21o_1
XFILLER_0_60_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3643_ tB\[7\] _1144_ _0975_ tB\[6\] _1184_ VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__o221a_1
X_3574_ _1123_ _1075_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2456_ _1790_ _1791_ _1793_ VGND VGND VPWR VPWR _1795_ sky130_fd_sc_hd__a21o_1
X_2387_ _1721_ _1724_ VGND VGND VPWR VPWR _1726_ sky130_fd_sc_hd__xor2_1
Xhold18 calc_ready VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__dlygate4sd3_1
Xhold29 delta\[14\] VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__dlygate4sd3_1
X_3008_ _0592_ _0593_ _0591_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_34_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3290_ _0885_ _0889_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__nor2_1
X_2172_ _1493_ _1508_ _1507_ VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__a21o_1
X_2310_ _1632_ _1647_ _1646_ VGND VGND VPWR VPWR _1649_ sky130_fd_sc_hd__a21o_1
X_2241_ _1576_ VGND VGND VPWR VPWR _1580_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_29_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1956_ net93 net84 net53 VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2508_ _1845_ _1846_ VGND VGND VPWR VPWR _1847_ sky130_fd_sc_hd__xnor2_2
X_3626_ tC\[12\] net80 VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__and2b_1
X_3488_ net94 _1045_ _1049_ net288 _1025_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__a32o_1
X_3557_ _1083_ _1057_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2439_ _1776_ _1777_ VGND VGND VPWR VPWR _1778_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_19_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmax_cap72 _0549_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_57_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2790_ _0345_ _0398_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__nor2_1
XFILLER_0_68_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3342_ tA\[5\] _0894_ net86 VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3411_ counter\[9\] _0945_ _0986_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__and3_1
X_2224_ _1561_ _1562_ VGND VGND VPWR VPWR _1563_ sky130_fd_sc_hd__and2b_1
X_3273_ _0840_ net274 VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__and2_4
X_2155_ _1434_ _1435_ VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__nand2_1
X_2086_ _1250_ net31 _1423_ _1424_ VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__a2bb2o_2
XFILLER_0_71_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2988_ net109 net105 _0255_ _0193_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__nand4_1
X_1939_ _1251_ net22 _1276_ _1277_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_31_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3609_ _1145_ tC\[5\] tC\[4\] _1146_ _1151_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__o221a_1
XFILLER_0_16_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3734__5 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2911_ _0516_ _0517_ _0519_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__nand3_2
XFILLER_0_57_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3891_ net244 _0159_ net135 VGND VGND VPWR VPWR tA\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_60_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2773_ _0377_ _0378_ _0381_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__a21o_1
XFILLER_0_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2842_ _0336_ _0450_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__nand2_2
X_3256_ _0863_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__clkbuf_1
X_3325_ _0916_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3187_ _0794_ _0795_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__xor2_2
X_2207_ _1542_ _1543_ _1545_ VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__and3_1
X_2069_ net127 _1254_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__nand2_1
X_2138_ _1475_ _1476_ VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3110_ _0655_ _0676_ _0717_ _0718_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__o211ai_2
X_3041_ _0582_ _0588_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2825_ _0415_ _0414_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__or2b_1
X_3874_ net227 _0142_ net134 VGND VGND VPWR VPWR delta\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_60_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2687_ _0287_ _0288_ _0294_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__and3_1
X_2756_ _0316_ _0310_ _0315_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__a21o_1
X_3239_ _0843_ _0847_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__nand2_1
X_3308_ _0560_ _0904_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__xnor2_2
Xfanout87 net88 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__buf_2
X_3810__81 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__inv_2
XFILLER_0_24_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout98 net100 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__buf_2
XFILLER_0_17_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2541_ _1878_ _1876_ _1877_ VGND VGND VPWR VPWR _1880_ sky130_fd_sc_hd__nand3_1
X_2472_ net108 net104 _1443_ _1447_ VGND VGND VPWR VPWR _1811_ sky130_fd_sc_hd__and4_1
X_2610_ net144 net141 _0209_ _0202_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__nand4_2
X_3590_ _1070_ _1068_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__nor2_1
X_3024_ net123 _1298_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__nand2_1
X_2808_ _0402_ _0416_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__xnor2_1
X_3857_ net210 _0125_ net134 VGND VGND VPWR VPWR counter\[10\] sky130_fd_sc_hd__dfrtp_4
X_2739_ net125 _0180_ _0347_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__and3_1
XFILLER_0_64_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3787__58 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__inv_2
XFILLER_0_20_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1972_ _1269_ _1280_ _1301_ _1305_ _1275_ VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__o32a_1
X_3711_ _1240_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__clkbuf_1
X_3642_ tB\[6\] _0975_ _1145_ tB\[5\] _1183_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__a221o_1
XFILLER_0_70_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2524_ _1860_ _1861_ _1852_ VGND VGND VPWR VPWR _1863_ sky130_fd_sc_hd__a21o_1
X_2455_ _1790_ _1791_ _1793_ VGND VGND VPWR VPWR _1794_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3573_ _1076_ _1062_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2386_ _1721_ _1724_ VGND VGND VPWR VPWR _1725_ sky130_fd_sc_hd__nand2_1
Xhold19 net70 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__dlygate4sd3_1
X_3007_ _0612_ _0614_ _0615_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__nor3_2
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3909_ net262 _0177_ net137 VGND VGND VPWR VPWR tB\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_69_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2171_ _1406_ _1413_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__or2b_2
X_2240_ _1572_ VGND VGND VPWR VPWR _1579_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_20_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1955_ net106 _1293_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3625_ _1159_ _1165_ _1162_ _1157_ _1156_ VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__a32o_1
XFILLER_0_3_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2507_ net168 _1260_ VGND VGND VPWR VPWR _1846_ sky130_fd_sc_hd__nand2_1
X_2438_ net173 _1260_ VGND VGND VPWR VPWR _1777_ sky130_fd_sc_hd__nand2_1
X_3487_ delta\[1\] delta\[0\] delta\[2\] VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__o21ai_1
X_3556_ _1110_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__clkbuf_1
X_2369_ _1706_ _1707_ VGND VGND VPWR VPWR _1708_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_2_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3757__28 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__inv_2
Xmax_cap73 net74 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__buf_1
XFILLER_0_4_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3272_ _0838_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__inv_2
X_3341_ _0924_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__clkbuf_1
X_3410_ net143 _0944_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3771__42 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__inv_2
X_2223_ _1559_ _1560_ _1555_ VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__a21o_1
X_2085_ net90 net47 net85 VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__a21oi_1
X_2154_ _1486_ _1487_ _1492_ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__nand3_1
X_2987_ net109 _0255_ _0193_ net104 VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__a22o_1
XFILLER_0_56_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1938_ net91 net38 net86 VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__a21oi_1
X_3608_ _1146_ tC\[4\] tC\[3\] _0958_ _1150_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__a221o_1
XFILLER_0_3_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3539_ _0932_ net78 VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_57_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_66_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2910_ net150 _1298_ _0518_ _1853_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__a31o_1
XFILLER_0_57_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3890_ net243 _0158_ net135 VGND VGND VPWR VPWR tA\[10\] sky130_fd_sc_hd__dfrtp_1
X_2841_ _0331_ _0332_ _0335_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_5_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2772_ net170 _0239_ _0379_ _0380_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__a31o_1
X_2206_ net164 _1342_ _1544_ _1479_ VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__a31o_1
X_3255_ tB\[14\] _0862_ net92 VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__mux2_4
X_3324_ tA\[14\] _0862_ net87 VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__mux2_4
XFILLER_0_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3186_ net124 _1261_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__nand2_1
X_2068_ _1401_ _1405_ _1404_ VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__a21oi_1
X_2137_ _1456_ _1472_ _1474_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3741__12 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__inv_2
X_3040_ _0645_ _0647_ _0646_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__nand3_2
XFILLER_0_58_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3873_ net226 _0141_ net134 VGND VGND VPWR VPWR delta\[11\] sky130_fd_sc_hd__dfrtp_2
X_2824_ _1701_ _0432_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__and2_1
XFILLER_0_14_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2686_ _0287_ _0288_ _0294_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__a21oi_1
X_2755_ _0358_ _0362_ _0363_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__a21bo_1
X_3238_ _0842_ _0838_ _0839_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__or3b_1
X_3169_ _0768_ _0673_ _0764_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__or3b_1
X_3307_ _1903_ _1905_ _0899_ _0903_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__o22a_1
XFILLER_0_64_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout88 state\[3\] VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__buf_2
Xfanout99 net100 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__clkbuf_4
Xfanout77 counter\[15\] VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2540_ _1876_ _1877_ _1878_ VGND VGND VPWR VPWR _1879_ sky130_fd_sc_hd__a21o_1
X_2471_ _1800_ _1809_ VGND VGND VPWR VPWR _1810_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_2_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3023_ net119 _1457_ _1327_ net114 VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_58_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3856_ net209 _0124_ net129 VGND VGND VPWR VPWR counter\[9\] sky130_fd_sc_hd__dfrtp_4
X_2807_ _0404_ _0414_ _0415_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__a21o_1
X_2738_ _0344_ _0345_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__xor2_2
XFILLER_0_14_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2669_ net158 _1440_ _0276_ _0277_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__a31o_1
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1971_ net102 _1257_ _1309_ net106 VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__a22oi_2
X_3710_ tC\[5\] _0894_ net83 VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__mux2_1
X_3641_ tB\[5\] _1145_ _1146_ tB\[4\] _1182_ VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__o221a_1
XFILLER_0_7_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3572_ _1122_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2523_ _1852_ _1860_ _1861_ VGND VGND VPWR VPWR _1862_ sky130_fd_sc_hd__nand3_2
X_2454_ net159 _1298_ _1792_ _1539_ VGND VGND VPWR VPWR _1793_ sky130_fd_sc_hd__a31o_1
X_2385_ _1722_ _1723_ VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__xnor2_1
X_3006_ _0610_ _0611_ _0547_ net72 VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_36_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput1 in_valid VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_1
XFILLER_0_52_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3908_ net261 _0176_ net135 VGND VGND VPWR VPWR tB\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_61_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3839_ net192 _0107_ net135 VGND VGND VPWR VPWR tC\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_6_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_27_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2170_ _1493_ _1507_ _1508_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__nand3_1
X_1954_ _1292_ VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_7_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3624_ _1159_ _1166_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3555_ counter\[10\] _1109_ net95 VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__mux2_1
X_2506_ _1842_ _1844_ VGND VGND VPWR VPWR _1845_ sky130_fd_sc_hd__xor2_2
X_2368_ _1428_ _1427_ VGND VGND VPWR VPWR _1707_ sky130_fd_sc_hd__and2b_1
X_2437_ _1773_ _1775_ VGND VGND VPWR VPWR _1776_ sky130_fd_sc_hd__xor2_2
X_3486_ _1048_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2299_ _1635_ _1636_ _1637_ VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_2_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmax_cap74 _1757_ VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_65_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2222_ _1555_ _1559_ _1560_ VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__and3_1
X_3340_ tA\[6\] _0890_ net86 VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__mux2_1
X_3271_ _0874_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__clkbuf_1
X_2084_ net90 net81 net63 VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_48_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2153_ _1488_ _1491_ VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__xnor2_1
X_2986_ net113 _1417_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__nand2_1
X_1937_ net91 net82 net54 VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__nand3b_1
X_3607_ _0958_ tC\[3\] tC\[2\] _1014_ _1149_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__o221a_1
X_3538_ _1053_ _1092_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__and2_1
XFILLER_0_58_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3469_ delta\[8\] _1025_ _1036_ net96 VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__a22o_1
XFILLER_0_39_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3817__88 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__inv_2
XFILLER_0_62_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2840_ _0443_ _0448_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__or2_1
X_2771_ net166 net161 _1579_ _1669_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3185_ _0791_ _0793_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__xor2_2
X_2205_ net159 _1292_ _1326_ net155 VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__a22o_1
X_3254_ _0861_ _0857_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__xnor2_2
X_3323_ _1251_ _1263_ _0859_ _0915_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__o31a_1
XFILLER_0_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2067_ _1401_ _1404_ _1405_ VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__and3_1
XFILLER_0_44_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2136_ _1456_ _1472_ _1474_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__and3_1
XFILLER_0_8_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2969_ _0575_ _0576_ _0577_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__or3_1
XFILLER_0_60_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3872_ net225 _0140_ net134 VGND VGND VPWR VPWR delta\[10\] sky130_fd_sc_hd__dfrtp_2
X_2823_ _0209_ _0202_ _0430_ _0431_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__and4_1
XFILLER_0_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2754_ _0353_ _0357_ _0354_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__nand3_1
X_3306_ _0901_ _1837_ _0902_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__o21a_1
X_2685_ _0292_ _0293_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__or2_1
XFILLER_0_55_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3237_ _0806_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__inv_2
X_3168_ _0674_ _0773_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__nor2_1
X_2119_ net172 _1457_ _1360_ net169 VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__a22o_1
X_3099_ _0705_ _0706_ _0685_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__a21o_1
Xfanout89 net90 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__buf_2
XFILLER_0_29_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout78 counter\[14\] VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_4_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3801__72 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__inv_2
XFILLER_0_27_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2470_ _1807_ _1808_ VGND VGND VPWR VPWR _1809_ sky130_fd_sc_hd__or2b_1
XFILLER_0_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3022_ net119 net114 _1318_ _1322_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__and4_1
XFILLER_0_25_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2668_ net154 net149 _1444_ _1448_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__and4_1
X_2737_ _0344_ _0345_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__nor2_1
X_2806_ _0406_ _0408_ _0413_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__and3_1
X_3855_ net208 _0123_ net134 VGND VGND VPWR VPWR counter\[8\] sky130_fd_sc_hd__dfrtp_4
X_2599_ net153 _1573_ _1669_ net148 VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1970_ _1261_ VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__buf_4
X_3778__49 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__inv_2
X_2522_ _1856_ _1857_ _1859_ VGND VGND VPWR VPWR _1861_ sky130_fd_sc_hd__a21o_1
XFILLER_0_55_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3640_ tB\[4\] _1146_ _0958_ tB\[3\] _1181_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__a221o_1
XFILLER_0_23_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3571_ counter\[6\] _1121_ net96 VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__mux2_1
X_2453_ net155 _1318_ _1322_ net151 VGND VGND VPWR VPWR _1792_ sky130_fd_sc_hd__a22o_1
X_2384_ _1459_ _1458_ VGND VGND VPWR VPWR _1723_ sky130_fd_sc_hd__and2b_1
X_3005_ _0573_ _0613_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__xor2_1
XFILLER_0_39_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput2 periodTop[0] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_46_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3838_ net191 _0106_ net135 VGND VGND VPWR VPWR tC\[11\] sky130_fd_sc_hd__dfrtp_1
X_3907_ net260 _0175_ net138 VGND VGND VPWR VPWR tB\[11\] sky130_fd_sc_hd__dfrtp_1
X_3792__63 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__inv_2
XFILLER_0_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_2_Left_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1953_ _1291_ VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__buf_4
X_2505_ net168 _1257_ _1784_ _1843_ VGND VGND VPWR VPWR _1844_ sky130_fd_sc_hd__a31o_1
X_3623_ _1162_ _1163_ _1164_ _1165_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__and4bb_1
X_3485_ _1003_ _1046_ _1047_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__and3_1
X_3554_ _1084_ _1108_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2436_ net172 _1257_ _1536_ _1774_ VGND VGND VPWR VPWR _1775_ sky130_fd_sc_hd__a31o_1
X_2367_ net12 _1417_ VGND VGND VPWR VPWR _1706_ sky130_fd_sc_hd__nand2_1
X_2298_ net118 net113 _1573_ _1586_ VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__nand4_2
XFILLER_0_11_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3748__19 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__inv_2
Xmax_cap75 _0373_ VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2221_ _1557_ _1558_ _1556_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__a21bo_1
X_2152_ _1489_ _1490_ VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__xor2_1
X_3270_ tB\[10\] _0873_ net91 VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__mux2_2
X_2083_ _1421_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_71_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2985_ _0591_ _0592_ _0593_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__nand3_2
X_1936_ net110 VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__inv_2
XFILLER_0_16_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput60 vC[3] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_1
X_3606_ _1014_ tC\[2\] tC\[1\] _1147_ _1148_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__a221o_1
X_3468_ _1033_ _1035_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3762__33 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__inv_2
X_3537_ net77 _1096_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__xnor2_1
X_2419_ _1688_ net278 _1472_ _1690_ VGND VGND VPWR VPWR _1758_ sky130_fd_sc_hd__a2bb2o_2
X_3399_ counter\[6\] VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__inv_2
XFILLER_0_66_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2770_ net166 _0209_ _0202_ net161 VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__a22o_1
X_3322_ tA\[15\] net87 VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3184_ _1366_ _1367_ _0792_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__o21ba_1
X_2204_ _1539_ _1541_ _1540_ VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__o21ai_1
X_2135_ _1409_ _1410_ _1473_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__o21ba_1
X_3253_ _0858_ _1316_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__or2b_1
XFILLER_0_28_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2066_ _1398_ _1400_ _1399_ VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_36_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2899_ net150 _1267_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__nand2_1
X_2968_ net142 _1342_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1919_ net91 net41 net57 _1252_ net87 VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__a221o_1
XFILLER_0_44_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3871_ net224 _0139_ net134 VGND VGND VPWR VPWR delta\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_14_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2684_ _1907_ _0291_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__nor2_1
XFILLER_0_26_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2753_ _0359_ _0361_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__xnor2_1
X_2822_ net126 net98 VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__and2_1
X_3305_ _0563_ _0564_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__nand2_1
X_3098_ _0685_ _0705_ _0706_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__nand3_2
X_2118_ _1291_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__clkbuf_4
X_3236_ _0840_ _0844_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__and2_1
X_3167_ _0764_ _0769_ _0775_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__and3_1
XFILLER_0_49_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2049_ _1308_ _1387_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__nand2_1
XFILLER_0_71_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout79 counter\[13\] VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__buf_2
XFILLER_0_35_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3021_ _0629_ _0606_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__xor2_2
X_2805_ _0406_ _0408_ _0413_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__a21o_1
X_3854_ net207 _0122_ net134 VGND VGND VPWR VPWR counter\[7\] sky130_fd_sc_hd__dfrtp_4
X_2667_ net154 _1444_ _1448_ net148 VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__a22o_1
X_2736_ net97 _1700_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__nand2_2
X_3219_ _0807_ _0827_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2598_ net157 _1580_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2521_ _1856_ _1857_ _1859_ VGND VGND VPWR VPWR _1860_ sky130_fd_sc_hd__nand3_2
XFILLER_0_23_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3570_ _1077_ _1120_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__xor2_1
XFILLER_0_11_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2452_ _1788_ _1789_ _1787_ VGND VGND VPWR VPWR _1791_ sky130_fd_sc_hd__o21ai_1
X_2383_ net100 _1343_ VGND VGND VPWR VPWR _1722_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3004_ net160 _1260_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 periodTop[10] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_2
X_3837_ net190 _0105_ net135 VGND VGND VPWR VPWR tC\[10\] sky130_fd_sc_hd__dfrtp_1
X_3906_ net259 _0174_ net135 VGND VGND VPWR VPWR tB\[10\] sky130_fd_sc_hd__dfrtp_1
X_3699_ _1234_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2719_ _0326_ _0327_ _0319_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__or3b_4
XFILLER_0_69_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3737__8 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__inv_2
XFILLER_0_20_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1952_ _1250_ net20 _1289_ _1290_ VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_68_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3622_ _1160_ tC\[9\] VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2504_ _1781_ _1782_ VGND VGND VPWR VPWR _1843_ sky130_fd_sc_hd__nor2_1
X_2435_ _1534_ _1489_ VGND VGND VPWR VPWR _1774_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3484_ delta\[3\] _1045_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__nand2_1
X_3553_ _1056_ _1085_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__and2b_1
X_2297_ net118 _1572_ _1586_ net113 VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__a22o_1
X_2366_ net153 _1601_ _1702_ _1704_ VGND VGND VPWR VPWR _1705_ sky130_fd_sc_hd__a31o_1
XFILLER_0_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmax_cap76 _0235_ VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_4_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2082_ _1251_ net32 _1419_ _1420_ VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__a2bb2o_4
X_2220_ _1556_ _1557_ _1558_ VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__nand3b_1
X_2151_ net172 _1267_ VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__nand2_1
X_2984_ _0588_ _0590_ _0589_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__a21o_1
XFILLER_0_8_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput50 vB[9] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput61 vC[4] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__buf_6
X_1935_ _1264_ _1269_ VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__and2_1
X_3605_ _1147_ tC\[1\] tC\[0\] _0933_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__o211a_1
XFILLER_0_3_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2418_ _1754_ _1755_ _1756_ _1729_ VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__nor4_2
X_3467_ delta\[7\] _1005_ delta\[8\] VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__o21a_1
X_3536_ delta\[15\] _1094_ _1095_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__o21ai_1
X_3398_ _0942_ _0972_ counter\[5\] VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__a21oi_1
X_2349_ _1680_ _1685_ _1686_ _1687_ VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_47_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_35_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3808__79 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__inv_2
XFILLER_0_65_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_44_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3321_ _0914_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__clkbuf_1
X_3252_ _1249_ _1263_ _0859_ _0860_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__o31a_1
XFILLER_0_21_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3183_ net124 _1257_ _1368_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__and3_1
X_2203_ _1539_ _1540_ _1541_ VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__or3_1
XPHY_EDGE_ROW_53_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2065_ net172 _1342_ _1402_ _1403_ VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__a31o_1
X_2134_ net277 _1256_ _1411_ VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__and3_1
XFILLER_0_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2967_ net123 _1457_ _1360_ net119 VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_8_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_62_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2898_ _0505_ _0506_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1918_ _1256_ VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_71_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3519_ _1061_ _1077_ _1078_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_35_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3870_ net223 _0138_ net134 VGND VGND VPWR VPWR delta\[8\] sky130_fd_sc_hd__dfrtp_2
X_2821_ net170 _0239_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_41_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2683_ _1907_ _0291_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__and2_1
X_2752_ _0312_ _0360_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__xor2_1
X_3235_ _0842_ _0843_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__and2b_1
X_3304_ _1768_ _0900_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__or2_1
X_3097_ _0704_ _0702_ _0703_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__nand3_2
X_3166_ _0773_ _0774_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__nor2_1
X_2117_ _1413_ _1454_ _1455_ VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__nand3_1
X_2048_ _1270_ _1274_ _1307_ VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3020_ _0627_ _0628_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__xor2_2
XFILLER_0_58_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2804_ net97 _0239_ _0409_ _0412_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__a31o_1
X_3853_ net206 _0121_ net129 VGND VGND VPWR VPWR counter\[6\] sky130_fd_sc_hd__dfrtp_2
XFILLER_0_14_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2666_ _1710_ _1712_ _1711_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__a21bo_1
X_2597_ _0203_ _0204_ _0201_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__a21o_1
X_2735_ net170 _1701_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3149_ _0709_ _0718_ _0756_ _0757_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__a211oi_2
X_3218_ _0825_ _0826_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__nor2_2
XFILLER_0_64_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2520_ net155 _1298_ _1858_ _1788_ VGND VGND VPWR VPWR _1859_ sky130_fd_sc_hd__a31o_1
X_2451_ _1787_ _1788_ _1789_ VGND VGND VPWR VPWR _1790_ sky130_fd_sc_hd__or3_1
XFILLER_0_23_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3003_ _0547_ net72 _0610_ _0611_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__o211a_1
X_2382_ net127 _1343_ _1719_ _1720_ VGND VGND VPWR VPWR _1721_ sky130_fd_sc_hd__a31o_1
Xinput4 periodTop[11] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3905_ net258 _0173_ net135 VGND VGND VPWR VPWR tB\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_61_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3836_ net189 _0104_ net135 VGND VGND VPWR VPWR tC\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_14_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2718_ _0304_ _0318_ _0317_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__a21oi_1
X_3698_ tC\[11\] _0871_ net82 VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__mux2_4
X_2649_ _0256_ _0187_ _0257_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__o21a_1
XFILLER_0_52_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3783__54 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__inv_2
X_1951_ net93 net36 net88 VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_28_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3621_ net80 tC\[12\] VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__or2b_1
XFILLER_0_7_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3552_ _1107_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__clkbuf_1
X_2503_ _1779_ _1798_ _1841_ VGND VGND VPWR VPWR _1842_ sky130_fd_sc_hd__a21o_1
X_2434_ _1520_ _1550_ _1772_ VGND VGND VPWR VPWR _1773_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2365_ _1674_ _1703_ VGND VGND VPWR VPWR _1704_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3483_ delta\[3\] _1045_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2296_ net122 _1577_ VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__and2_1
XFILLER_0_2_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2081_ net90 net48 net85 VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__a21oi_1
X_2150_ net168 _1278_ VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__nand2_1
XFILLER_0_17_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2983_ _0520_ _0522_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1934_ _1270_ _1272_ _1263_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput62 vC[5] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__clkbuf_1
Xinput40 vB[14] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_1
Xinput51 vC[0] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__buf_6
XFILLER_0_3_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3535_ delta\[15\] _1094_ _0932_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__a21oi_1
X_3604_ counter\[1\] VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__inv_2
X_2348_ _1648_ _1649_ _1652_ VGND VGND VPWR VPWR _1687_ sky130_fd_sc_hd__and3_1
X_2417_ _1728_ _1718_ _1725_ _1727_ VGND VGND VPWR VPWR _1756_ sky130_fd_sc_hd__o211a_1
X_3466_ _1002_ _1034_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__nor2_1
X_3397_ counter\[5\] _0942_ _0972_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__and3_1
X_2279_ net121 net117 _1444_ _1448_ VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__nand4_1
XFILLER_0_39_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3753__24 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__inv_2
XFILLER_0_22_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3182_ _0788_ _0789_ _0790_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__o21a_1
X_2202_ net155 _1292_ _1326_ net151 VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__a22oi_1
X_3320_ net289 _0913_ net90 VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__mux2_1
X_3251_ tB\[15\] net91 VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__or2_1
XFILLER_0_21_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2064_ net168 net164 _1292_ _1326_ VGND VGND VPWR VPWR _1403_ sky130_fd_sc_hd__and4_1
XFILLER_0_44_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2133_ _1464_ _1469_ _1470_ _1471_ VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__a211o_4
X_2966_ net123 net119 _1318_ _1322_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__and4_1
X_2897_ net165 _1260_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1917_ _1255_ VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_71_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3518_ delta\[6\] counter\[6\] VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__nand2_1
X_3449_ _1023_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_67_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2820_ _0425_ _0428_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__and2_1
XFILLER_0_14_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2751_ net170 _1700_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__nand2_1
X_2682_ _0289_ _0290_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3234_ _0833_ _0836_ _0841_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__o21ai_1
X_3165_ _0770_ _0771_ _0772_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__and3_1
X_3303_ _0494_ _0497_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__nand2_1
X_3096_ _0702_ _0703_ _0704_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__a21o_1
X_2047_ _1382_ _1385_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__and2_1
X_2116_ _1406_ _1407_ _1412_ VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__o21bai_1
X_2949_ _0555_ _0557_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__xor2_2
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3789__60 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__inv_2
X_2803_ _0410_ _0411_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__nor2_1
X_3852_ net205 _0120_ net129 VGND VGND VPWR VPWR counter\[5\] sky130_fd_sc_hd__dfrtp_4
X_2734_ _0339_ _0341_ _0342_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_41_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2665_ net173 _1418_ _0257_ _0273_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__a31o_1
X_2596_ _0201_ _0203_ _0204_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__nand3_1
X_3148_ _0748_ _0749_ _0755_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__a21oi_1
X_3217_ _0819_ _0823_ _0824_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__nor3_1
XFILLER_0_5_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3079_ net119 _1298_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2450_ net151 _1318_ _1322_ net146 VGND VGND VPWR VPWR _1789_ sky130_fd_sc_hd__a22oi_2
X_2381_ net99 net172 _1457_ _1360_ VGND VGND VPWR VPWR _1720_ sky130_fd_sc_hd__and4_1
XFILLER_0_23_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3002_ _0607_ _0608_ _0609_ _0594_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__a22o_1
Xinput5 periodTop[12] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3904_ net257 _0172_ net130 VGND VGND VPWR VPWR tB\[8\] sky130_fd_sc_hd__dfrtp_1
X_3835_ net188 _0103_ net130 VGND VGND VPWR VPWR tC\[8\] sky130_fd_sc_hd__dfrtp_1
X_3697_ _1233_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2717_ _0320_ _0325_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__xnor2_1
X_2648_ net167 _1433_ _1431_ net162 VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__a22o_1
X_2579_ net170 _1433_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1950_ net93 net84 net52 VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__nand3b_4
X_3759__30 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__inv_2
X_2502_ _1780_ _1797_ VGND VGND VPWR VPWR _1841_ sky130_fd_sc_hd__and2b_1
XFILLER_0_43_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3620_ _1161_ tC\[8\] tC\[7\] _1144_ VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__a22o_1
X_3551_ counter\[11\] _1106_ net95 VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__mux2_1
X_2433_ _1533_ _1549_ VGND VGND VPWR VPWR _1772_ sky130_fd_sc_hd__and2b_1
X_2364_ net148 _1701_ VGND VGND VPWR VPWR _1703_ sky130_fd_sc_hd__nand2_1
X_3482_ delta\[2\] delta\[1\] delta\[0\] _1019_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__o31a_1
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2295_ net118 _1580_ _1615_ _1614_ VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__a22o_1
XFILLER_0_59_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_6_Left_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2080_ net90 net81 net64 VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2982_ _0588_ _0589_ _0590_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__nand3_2
XFILLER_0_56_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1933_ _1268_ VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__inv_2
XFILLER_0_71_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput52 vC[10] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__buf_6
Xinput63 vC[6] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_1
Xinput41 vB[15] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_1
Xinput30 vA[5] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3465_ delta\[9\] _1033_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__xor2_1
X_3534_ delta\[14\] net78 _1093_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__a21o_1
X_3603_ counter\[4\] VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__inv_2
X_2347_ _1648_ _1649_ _1652_ VGND VGND VPWR VPWR _1686_ sky130_fd_sc_hd__a21oi_1
X_2278_ _1611_ _1612_ _1616_ VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__a21o_1
X_2416_ _1753_ _1752_ _1751_ _1748_ VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__o211a_1
XFILLER_0_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3396_ net163 _0941_ net158 VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_66_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3181_ _0785_ _0787_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__nand2_1
X_2201_ net159 _1297_ VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__nand2_1
X_2132_ _1413_ _1454_ _1455_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__and3_1
X_3250_ _1316_ _0857_ _0858_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2063_ net168 _1292_ _1326_ net164 VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__a22o_1
XFILLER_0_48_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2965_ net160 _1261_ _0573_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__nand3_1
X_2896_ _0502_ _0504_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__xor2_2
XFILLER_0_60_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1916_ _1254_ VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_8_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3448_ _1003_ _1021_ _1022_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__and3_1
XFILLER_0_8_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3517_ _1062_ _1075_ _1076_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3379_ net78 _0954_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3813__84 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__inv_2
XFILLER_0_62_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_9_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2681_ _1720_ _1719_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__and2b_1
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2750_ net97 _0180_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__nand2_1
XFILLER_0_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3302_ _1906_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__inv_2
XFILLER_0_1_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3095_ _0638_ _0645_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__nand2_1
X_3233_ _0833_ _0836_ _0841_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__nor3_1
X_3164_ _0770_ _0771_ _0772_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__a21oi_2
X_2115_ _1429_ _1452_ _1453_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__a21o_1
XFILLER_0_71_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2046_ _1383_ _1384_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__nand2_1
X_2948_ _1847_ _1898_ _0556_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_32_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2879_ _0481_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__inv_2
XFILLER_0_17_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3851_ net204 _0119_ net129 VGND VGND VPWR VPWR counter\[4\] sky130_fd_sc_hd__dfrtp_4
XFILLER_0_41_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2664_ _0256_ _0187_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__nor2_1
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2802_ net170 _0202_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__nand2_1
X_2733_ _0333_ _0334_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__or2_1
X_2595_ net148 _1579_ _1669_ net144 VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__a22o_1
XFILLER_0_1_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3147_ _0748_ _0749_ _0755_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__and3_1
X_3078_ net115 _1457_ _1327_ net111 VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__a22oi_2
X_3216_ _0819_ _0823_ _0824_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_59_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2029_ _1366_ _1367_ VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_68_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2380_ net99 _1457_ _1360_ net172 VGND VGND VPWR VPWR _1719_ sky130_fd_sc_hd__a22o_1
X_3001_ _0594_ _0607_ _0608_ _0609_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__nand4_4
Xinput6 periodTop[13] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_36_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3903_ net256 _0171_ net131 VGND VGND VPWR VPWR tB\[7\] sky130_fd_sc_hd__dfrtp_1
X_3834_ net187 _0102_ net130 VGND VGND VPWR VPWR tC\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_61_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2647_ net162 _0255_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__nand2_1
X_3696_ tC\[12\] _0867_ net82 VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__mux2_1
XFILLER_0_14_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2716_ _0322_ _0324_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__xor2_2
X_2578_ net166 _1431_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__nand2_2
Xclkbuf_3_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2501_ net173 _1261_ _1776_ _1839_ VGND VGND VPWR VPWR _1840_ sky130_fd_sc_hd__a31o_1
XFILLER_0_3_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3774__45 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__inv_2
X_3481_ net287 _1025_ _1044_ net94 VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__a22o_1
X_3550_ _1086_ _1105_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2432_ net100 _1309_ _1517_ _1516_ VGND VGND VPWR VPWR _1771_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2294_ _1615_ _1613_ _1614_ VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__nand3_1
X_2363_ net148 _1700_ _1701_ net144 VGND VGND VPWR VPWR _1702_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_22_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3679_ tA\[7\] _1144_ _0975_ tA\[6\] _1219_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__o221a_1
XFILLER_0_2_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3819__90 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__inv_2
Xinput20 vA[10] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2981_ _0582_ _0587_ _0586_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__a21o_1
Xinput31 vA[6] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1932_ _1262_ _1270_ _1263_ VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_33_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3602_ counter\[5\] VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__inv_2
XFILLER_0_8_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput53 vC[11] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput64 vC[7] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__clkbuf_1
X_2415_ _1748_ _1751_ _1752_ _1753_ VGND VGND VPWR VPWR _1754_ sky130_fd_sc_hd__a211oi_4
Xinput42 vB[1] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_1
X_3464_ net273 _1006_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3533_ _1053_ _1092_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2346_ _1680_ _1681_ _1684_ VGND VGND VPWR VPWR _1685_ sky130_fd_sc_hd__nand3_2
X_2277_ _1613_ _1614_ _1615_ VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__a21bo_1
X_3395_ _0961_ _0964_ _0968_ _0970_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__or4_1
XFILLER_0_65_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3744__15 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__inv_2
X_3180_ _0736_ _0738_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__and2_1
X_2200_ net155 net150 _1291_ _1321_ VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__and4_1
X_2062_ _1398_ _1399_ _1400_ VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__or3_4
X_2131_ _1413_ _1455_ _1454_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__a21oi_4
X_2964_ _0572_ _0569_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_48_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2895_ _1781_ _1849_ _0503_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_44_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1915_ _1251_ net24 _1253_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_4_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_31_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3378_ net110 _0947_ net106 VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3447_ delta\[15\] _1020_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__nand2_1
X_3516_ delta\[5\] counter\[5\] VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__and2_1
XFILLER_0_12_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_40_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2329_ net122 _1573_ _1586_ net118 VGND VGND VPWR VPWR _1668_ sky130_fd_sc_hd__a22o_1
XFILLER_0_47_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2680_ net2 _1343_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3232_ _0820_ _0822_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3301_ _0898_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__clkbuf_1
X_3094_ _0699_ _0701_ _0700_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__nand3_2
X_3163_ _0671_ _0669_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__xor2_1
X_2045_ net119 _1309_ _1376_ VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__nand3_1
X_2114_ _1435_ _1451_ _1436_ VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__and3_1
XFILLER_0_71_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2947_ _1897_ _1895_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__and2b_1
XFILLER_0_29_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2878_ _0479_ _0486_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__or2_1
XFILLER_0_58_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2801_ net166 _0209_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__nand2_1
X_3850_ net203 _0118_ net128 VGND VGND VPWR VPWR counter\[3\] sky130_fd_sc_hd__dfrtp_2
XFILLER_0_41_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2663_ _0268_ _0270_ _0269_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__a21o_1
XFILLER_0_26_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2594_ net148 net144 _1579_ _0202_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__nand4_2
XFILLER_0_14_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2732_ _0338_ _0337_ _0336_ _0330_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__o211a_1
XFILLER_0_66_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3215_ _0800_ _0802_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3146_ _0753_ _0754_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__xnor2_1
X_3077_ net115 net111 _1318_ _1322_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__and4_1
X_2028_ net119 _1267_ VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3000_ _0591_ _0593_ _0592_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__a21o_1
Xinput7 periodTop[14] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_2
X_3902_ net255 _0170_ net130 VGND VGND VPWR VPWR tB\[6\] sky130_fd_sc_hd__dfrtp_1
X_3833_ net186 _0101_ net130 VGND VGND VPWR VPWR tC\[6\] sky130_fd_sc_hd__dfrtp_1
X_2646_ _1422_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__buf_4
X_3695_ _1232_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__clkbuf_1
X_2577_ net97 _1418_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__nand2_1
X_2715_ _0192_ _0323_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_14_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3129_ _0731_ _0736_ _0737_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__nand3_1
XFILLER_0_45_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2500_ _1773_ _1775_ VGND VGND VPWR VPWR _1839_ sky130_fd_sc_hd__and2_1
X_2431_ _1478_ _1698_ _1769_ VGND VGND VPWR VPWR _1770_ sky130_fd_sc_hd__a21o_1
X_3480_ delta\[4\] _1004_ _1041_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_11_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2362_ _1501_ VGND VGND VPWR VPWR _1701_ sky130_fd_sc_hd__clkbuf_4
X_2293_ _1622_ _1617_ _1621_ VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__nand3_2
XFILLER_0_63_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3678_ tA\[6\] _0975_ _1145_ tA\[5\] _1218_ VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__a221o_1
X_2629_ _0218_ _0220_ _0219_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_69_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2980_ _0541_ _0539_ _0540_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_71_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput21 vA[11] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
Xinput32 vA[7] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_1
Xinput54 vC[12] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_1
X_1931_ _1264_ _1269_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__nor2_1
Xinput43 vB[2] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__clkbuf_1
X_3601_ counter\[7\] VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__inv_2
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput10 periodTop[2] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_1
Xinput65 vC[8] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_1
X_2414_ _1680_ _1681_ _1684_ VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__and3_1
X_3463_ delta\[10\] _1025_ _1032_ net95 VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__a22o_1
X_3532_ _1054_ _1090_ _1091_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__o21a_1
X_3394_ counter\[4\] _0969_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__xnor2_1
X_2345_ _1429_ _1683_ VGND VGND VPWR VPWR _1684_ sky130_fd_sc_hd__xor2_2
X_2276_ net113 net109 _1573_ _1586_ VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__nand4_2
XFILLER_0_47_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2061_ net164 _1292_ _1326_ net159 VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_44_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2130_ _1465_ _1468_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__or2_1
X_2963_ _0527_ _0571_ _0526_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__a21o_1
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1914_ net91 net40 _1252_ net56 net86 VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__a221o_1
XFILLER_0_71_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2894_ net165 _1257_ _1850_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__and3_1
XFILLER_0_56_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3515_ _1065_ _1066_ _1074_ _1063_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__a31oi_2
X_2328_ net141 _1577_ VGND VGND VPWR VPWR _1667_ sky130_fd_sc_hd__and2_1
X_3377_ net77 net102 VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__xnor2_1
X_3446_ delta\[15\] _1020_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__or2_1
XFILLER_0_67_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2259_ net109 net294 _1573_ _1586_ VGND VGND VPWR VPWR _1598_ sky130_fd_sc_hd__nand4_2
Xclone13 net2 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__clkbuf_2
X_3804__75 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__inv_2
XFILLER_0_26_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3231_ _0838_ _0839_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__xnor2_1
X_3162_ _0501_ _0558_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3300_ tB\[4\] _0897_ net92 VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__mux2_1
X_3093_ _0699_ _0700_ _0701_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__a21o_1
X_2044_ _1375_ _1357_ _1373_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__or3b_1
XFILLER_0_49_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2113_ _1435_ _1436_ _1451_ VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__a21o_1
XFILLER_0_71_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2946_ _0507_ _0554_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_44_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2877_ _0481_ _0485_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_29_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3429_ delta\[3\] delta\[2\] delta\[1\] delta\[0\] VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__or4_2
XFILLER_0_67_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2800_ net170 _0209_ _0202_ net166 VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__a22o_1
X_2731_ _0302_ _0303_ _0339_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__a21o_1
XFILLER_0_41_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2662_ _0268_ _0269_ _0270_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__nand3_2
X_2593_ _1586_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__clkbuf_4
X_3145_ net147 _1259_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__nand2_1
X_3214_ _0820_ _0822_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__and2b_1
X_3076_ _0683_ _0684_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__nor2_1
X_2027_ net114 _1278_ VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2929_ net108 _1601_ _1884_ _1883_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__a31o_1
X_3795__66 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__inv_2
XFILLER_0_32_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput8 periodTop[15] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3901_ net254 _0169_ net131 VGND VGND VPWR VPWR tB\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_54_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3832_ net185 _0100_ net130 VGND VGND VPWR VPWR tC\[5\] sky130_fd_sc_hd__dfrtp_1
X_3694_ tC\[13\] _0865_ net82 VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__mux2_2
X_2714_ _0195_ _0194_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__nor2_1
X_2645_ net173 _1418_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__nand2_1
X_2576_ net166 _0180_ _0183_ _0184_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_10_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3128_ _0732_ _0733_ _0735_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__a21o_1
X_3059_ _0667_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__inv_2
XFILLER_0_60_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2361_ _1500_ VGND VGND VPWR VPWR _1700_ sky130_fd_sc_hd__clkbuf_4
X_2430_ _1660_ _1697_ VGND VGND VPWR VPWR _1769_ sky130_fd_sc_hd__nor2_1
X_2292_ _1626_ _1624_ _1625_ VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_37_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3677_ tA\[5\] _1145_ _1146_ tA\[4\] _1217_ VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__o221a_1
XFILLER_0_6_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3765__36 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__inv_2
X_2559_ _1895_ _1897_ VGND VGND VPWR VPWR _1898_ sky130_fd_sc_hd__xnor2_2
X_2628_ _1739_ _1737_ _1738_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__nand3_1
XFILLER_0_69_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1930_ net102 _1268_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__nand2_2
XFILLER_0_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput66 vC[9] VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__buf_6
Xinput44 vB[3] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_1
Xinput55 vC[13] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_1
Xinput33 vA[8] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_1
Xinput22 vA[12] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
X_3600_ tC\[13\] VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__inv_2
XFILLER_0_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput11 periodTop[3] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_1
X_3531_ delta\[13\] net79 VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__nand2_1
X_2344_ _1682_ _1453_ VGND VGND VPWR VPWR _1683_ sky130_fd_sc_hd__nor2_2
X_2413_ _1680_ _1681_ _1684_ VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__a21oi_2
X_3462_ delta\[10\] _1007_ _1029_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__a21oi_1
X_3393_ net163 _0941_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__xor2_1
XFILLER_0_66_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2275_ net113 _1572_ _1586_ net109 VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__a22o_1
XFILLER_0_70_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3729_ _1001_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__inv_2
XFILLER_0_65_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2060_ net168 _1342_ VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__nand2_1
XFILLER_0_71_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2962_ _0522_ _0523_ _0524_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__a21o_1
X_2893_ _1848_ _1867_ _1866_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1913_ net91 net83 VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__and2b_1
XFILLER_0_29_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3445_ delta\[14\] delta\[13\] _1009_ _1019_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__o31a_1
X_3514_ delta\[3\] counter\[3\] _1073_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2258_ net109 _1572_ _1586_ net294 VGND VGND VPWR VPWR _1597_ sky130_fd_sc_hd__a22o_1
X_2327_ net280 _1580_ _1637_ _1636_ VGND VGND VPWR VPWR _1666_ sky130_fd_sc_hd__a22o_1
X_3376_ net77 net106 net102 _0948_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__and4bb_1
X_2189_ net121 net117 _1444_ _1448_ VGND VGND VPWR VPWR _1528_ sky130_fd_sc_hd__and4_1
XFILLER_0_39_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3230_ _0758_ _0760_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__or2_2
X_3161_ _0555_ _0557_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__or2_1
X_2112_ net148 _1440_ _1449_ _1450_ VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__a31o_1
XFILLER_0_71_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3092_ _0628_ _0627_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__and2b_1
X_2043_ _1354_ _1380_ VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__xor2_1
X_2945_ _0551_ _0553_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_32_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2876_ _0482_ _0484_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__xor2_1
XFILLER_0_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3428_ _1002_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__inv_2
X_3359_ counter\[3\] counter\[2\] counter\[1\] VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__or3_1
XFILLER_0_0_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2661_ _1745_ _1741_ _1744_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__a21o_1
X_2730_ _0330_ _0336_ _0337_ _0338_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__a211oi_1
X_2592_ net153 _1577_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__and2_1
X_3144_ _0750_ _0752_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__xnor2_1
X_3213_ net143 _1309_ _0814_ _0821_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__a31o_1
X_3075_ _0682_ _0623_ _0678_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__nor3_1
XFILLER_0_5_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2026_ _1358_ _1359_ _1364_ VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__nand3_1
X_2928_ _0535_ _0534_ _0533_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_60_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2859_ _0462_ _0463_ _0467_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__nor3_1
XPHY_EDGE_ROW_28_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3732__3 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__inv_2
Xinput9 periodTop[1] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3900_ net253 _0168_ net130 VGND VGND VPWR VPWR tB\[4\] sky130_fd_sc_hd__dfrtp_1
X_3831_ net184 _0099_ net130 VGND VGND VPWR VPWR tC\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_54_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3693_ _1231_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__clkbuf_1
X_2644_ net162 _0180_ _0227_ _0252_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__a31o_1
XFILLER_0_6_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2713_ net171 _0180_ _0313_ _0321_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__a31o_1
X_2575_ _0181_ _0182_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3058_ _0664_ _0666_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__nor2_1
X_3127_ _0732_ _0733_ _0735_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__nand3_1
X_2009_ net114 _1257_ _1286_ _1347_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__a31o_1
XFILLER_0_18_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2291_ _1626_ _1624_ _1625_ VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__and3_1
X_2360_ _1478_ _1698_ VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__xor2_2
XFILLER_0_11_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3676_ tA\[4\] _1146_ _0958_ tA\[3\] _1216_ VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__a221o_1
X_2627_ _0224_ _0229_ _0223_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_2_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2558_ _1799_ _1827_ _1896_ VGND VGND VPWR VPWR _1897_ sky130_fd_sc_hd__a21oi_2
X_2489_ _1799_ _1827_ VGND VGND VPWR VPWR _1828_ sky130_fd_sc_hd__xor2_2
XFILLER_0_10_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput34 vA[9] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
Xinput45 vB[4] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
Xinput23 vA[13] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_1
Xinput56 vC[14] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_26_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3461_ _1030_ _1031_ _1002_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__a21oi_1
Xinput12 periodTop[4] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_2
X_3530_ _1055_ _1088_ _1089_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__o21a_1
XFILLER_0_58_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2343_ _1435_ _1436_ _1451_ VGND VGND VPWR VPWR _1682_ sky130_fd_sc_hd__a21oi_1
X_2274_ net118 _1577_ VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__and2_1
X_2412_ _1748_ _1749_ _1750_ VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__nand3_2
X_3392_ counter\[1\] _0965_ _0967_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__o21bai_1
X_1989_ net107 net102 _1293_ _1327_ VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__nand4_1
X_3659_ _1176_ net77 counter\[14\] _1177_ _1200_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__a221o_1
XFILLER_0_2_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3728_ counter\[0\] _0938_ VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__nor2_1
XFILLER_0_65_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1912_ _1250_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__buf_4
X_2961_ _0526_ _0529_ _0569_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_56_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2892_ net168 _1261_ _1845_ _0500_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__a31o_1
XFILLER_0_4_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3513_ _1067_ _1071_ _1072_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_12_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3444_ rising _0931_ _1015_ _1016_ _1018_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__o311a_4
X_2257_ net112 _1577_ VGND VGND VPWR VPWR _1596_ sky130_fd_sc_hd__and2_1
X_2326_ _1637_ _1635_ _1636_ VGND VGND VPWR VPWR _1665_ sky130_fd_sc_hd__nand3_1
X_3375_ _0948_ _0949_ counter\[13\] VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_18_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2188_ net121 _1500_ _1501_ net117 VGND VGND VPWR VPWR _1527_ sky130_fd_sc_hd__a22o_1
XFILLER_0_47_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3091_ _0693_ _0698_ _0697_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__a21o_1
X_3160_ _0768_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__inv_2
X_2042_ _1354_ _1380_ VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__nor2_1
X_2111_ net144 net140 _1444_ _1448_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__and4_1
XFILLER_0_71_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2944_ _1868_ _1894_ _0552_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__o21a_1
XFILLER_0_44_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2875_ _1757_ _0483_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3358_ net77 net78 net79 net80 VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__or4_1
X_3427_ net95 _1001_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__nor2_2
X_3289_ _0769_ _0883_ _0884_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__nor3_1
X_2309_ _1632_ _1646_ _1647_ VGND VGND VPWR VPWR _1648_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_13_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2660_ _0242_ _0245_ _0241_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_66_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3212_ _0741_ _0744_ _0813_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_22_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2591_ _1909_ _0199_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__and2b_1
XFILLER_0_66_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3143_ _0694_ _0639_ _0751_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__o21ba_1
X_3074_ _0623_ _0678_ _0682_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__o21a_1
X_2025_ _1361_ _1362_ _1363_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__a21bo_1
X_2927_ _0533_ _0534_ _0535_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_49_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2858_ _0292_ _0466_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__xnor2_1
X_2789_ net125 _1701_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__nand2_1
XFILLER_0_63_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3786__57 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__inv_2
XFILLER_0_52_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3830_ net183 _0098_ net132 VGND VGND VPWR VPWR tC\[3\] sky130_fd_sc_hd__dfrtp_1
X_3692_ tC\[14\] _0862_ net82 VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__mux2_4
X_2643_ _0181_ _0226_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__nor2_1
X_2574_ _0181_ _0182_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__xor2_2
XFILLER_0_14_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2712_ _0182_ _0312_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3057_ _0507_ _0554_ _0665_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__a21oi_1
X_3126_ net120 _1343_ _0734_ _0686_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__a31o_1
X_2008_ _1280_ _1285_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__nor2_1
XFILLER_0_45_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_47_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2290_ _1551_ _1628_ VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__xor2_2
XFILLER_0_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_56_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_65_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2557_ _1826_ _1824_ VGND VGND VPWR VPWR _1896_ sky130_fd_sc_hd__and2b_1
XFILLER_0_42_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3675_ tA\[3\] _0958_ _1014_ tA\[2\] _1215_ VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__o221a_1
X_2626_ _0232_ _0233_ _0234_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__nor3b_2
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2488_ _1824_ _1826_ VGND VGND VPWR VPWR _1827_ sky130_fd_sc_hd__xnor2_2
X_3109_ _0709_ _0710_ _0716_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__nand3_2
XFILLER_0_65_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3756__27 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__inv_2
XFILLER_0_18_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_1_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput13 periodTop[5] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_2
Xinput46 vB[5] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_1
Xinput57 vC[15] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_1
Xinput24 vA[14] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_1
X_2411_ _1714_ _1715_ VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__xnor2_1
Xinput35 vB[0] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_1
X_3460_ delta\[11\] _1029_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__or2_1
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3770__41 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__inv_2
X_3391_ counter\[0\] net126 _0965_ counter\[1\] _0966_ VGND VGND VPWR VPWR _0967_
+ sky130_fd_sc_hd__a221o_1
X_2273_ net112 _1580_ _1598_ _1597_ VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__a22o_1
X_2342_ _1664_ _1679_ _1678_ VGND VGND VPWR VPWR _1681_ sky130_fd_sc_hd__a21o_1
XFILLER_0_62_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1988_ _1326_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__clkbuf_4
X_3727_ _1248_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3658_ _1177_ net78 net79 _1178_ _1199_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__o221a_1
X_2609_ net148 _1577_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__and2_1
X_3589_ _1135_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2960_ _0508_ _1849_ _0568_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_56_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1911_ net85 VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__inv_2
X_2891_ _1842_ _1844_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3374_ counter\[13\] _0948_ _0949_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__or3_1
X_3443_ _0931_ state\[0\] _1017_ _1000_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__a211o_1
X_3512_ delta\[2\] counter\[2\] VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__nand2_1
X_2187_ _1524_ _1523_ _1522_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__a21bo_1
X_2256_ _1588_ _1593_ _1592_ VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__o21ai_1
X_2325_ _1645_ _1639_ _1644_ VGND VGND VPWR VPWR _1664_ sky130_fd_sc_hd__nand3_1
XFILLER_0_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclone16 net3 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__buf_2
XFILLER_0_7_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3740__11 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__inv_2
XFILLER_0_1_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3090_ _0693_ _0697_ _0698_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__nand3_2
XFILLER_0_55_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2041_ _1356_ _1379_ VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__nand2_1
X_2110_ net144 _1444_ _1448_ net140 VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__a22o_1
XFILLER_0_71_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2943_ _1890_ _1893_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__or2_1
XFILLER_0_49_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2874_ _1754_ _1755_ _1756_ _1729_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__o22a_1
XFILLER_0_25_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2308_ _1622_ _1617_ _1621_ VGND VGND VPWR VPWR _1647_ sky130_fd_sc_hd__a21o_1
X_3426_ net286 net1 VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__nand2_1
X_3357_ counter\[11\] counter\[10\] counter\[9\] counter\[8\] VGND VGND VPWR VPWR
+ _0934_ sky130_fd_sc_hd__or4_1
X_2239_ net104 net101 _1573_ _1577_ VGND VGND VPWR VPWR _1578_ sky130_fd_sc_hd__and4_1
X_3288_ _0888_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2590_ _0191_ _0198_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__or2_1
XFILLER_0_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3142_ net147 _1256_ _0695_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__and3_1
X_3211_ _0808_ _0818_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__xnor2_1
X_3073_ _0679_ _0680_ _0681_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__o21a_1
X_2024_ net111 net107 _1293_ _1327_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__nand4_1
X_2926_ net113 net108 _0255_ _0193_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__nand4_2
XFILLER_0_45_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2857_ _0464_ _0465_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_9_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2788_ _0389_ _0392_ _0391_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__a21bo_1
X_3409_ _0979_ _0981_ _0983_ _0984_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__or4_1
XFILLER_0_23_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2711_ net125 net97 _0255_ _0193_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__and4_1
X_2642_ _0187_ _0188_ _0250_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__o21ba_1
X_3691_ _1229_ _1263_ _0859_ _1230_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__o31a_1
X_2573_ net161 _1700_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__nand2_2
X_3125_ net115 _1293_ _1327_ net111 VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__a22o_1
XFILLER_0_10_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3056_ _0553_ _0551_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__and2b_1
X_2007_ _1332_ _1341_ _1345_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__a21oi_2
X_2909_ net146 _1457_ _1360_ net142 VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__a22o_1
X_3889_ net242 _0157_ net135 VGND VGND VPWR VPWR tA\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_5_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3674_ tA\[2\] _1014_ _1147_ tA\[1\] _1214_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__a221o_1
XFILLER_0_6_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2556_ _1868_ _1894_ VGND VGND VPWR VPWR _1895_ sky130_fd_sc_hd__xor2_2
X_2487_ _1564_ _1607_ _1825_ VGND VGND VPWR VPWR _1826_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_42_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2625_ _0196_ _0197_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3108_ _0709_ _0710_ _0716_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3039_ _0645_ _0646_ _0647_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__a21o_1
XFILLER_0_65_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput36 vB[10] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
Xinput14 periodTop[6] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_64_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput25 vA[15] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput47 vB[6] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_1
X_2341_ _1664_ _1678_ _1679_ VGND VGND VPWR VPWR _1680_ sky130_fd_sc_hd__nand3_2
Xinput58 vC[1] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
X_2410_ _1734_ _1747_ _1746_ VGND VGND VPWR VPWR _1749_ sky130_fd_sc_hd__a21o_1
X_3390_ counter\[0\] net126 net94 VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__o21ai_1
X_2272_ _1598_ _1596_ net279 VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__nand3_1
XFILLER_0_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1987_ _1321_ VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__buf_2
X_3657_ _1185_ _1195_ _1198_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__o21bai_1
X_3726_ net82 _1247_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__or2_1
X_2539_ _1804_ _1805_ VGND VGND VPWR VPWR _1878_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2608_ _0201_ _0204_ _0203_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__a21bo_1
X_3588_ counter\[2\] _1134_ net94 VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__mux2_1
X_3816__87 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__inv_2
XFILLER_0_3_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2890_ _1840_ _1902_ _0498_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1910_ net91 VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__inv_2
XFILLER_0_71_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3511_ _1068_ _1069_ _1070_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__o21ba_1
X_2324_ _1661_ _1654_ _1656_ VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__a21oi_1
X_3373_ net110 _0947_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__and2_1
X_3442_ rising _0931_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__nor2_1
X_2186_ _1522_ _1523_ _1524_ VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__nand3b_2
X_2255_ _1588_ _1592_ _1593_ VGND VGND VPWR VPWR _1594_ sky130_fd_sc_hd__or3_1
Xclone17 _1443_ VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__clkbuf_16
XFILLER_0_43_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3709_ _1239_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_66_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2040_ _1378_ VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__inv_2
XFILLER_0_71_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2942_ net275 _0550_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__nor2_1
X_2873_ _0462_ _0468_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2307_ _1639_ _1644_ _1645_ VGND VGND VPWR VPWR _1646_ sky130_fd_sc_hd__a21bo_1
X_3287_ tB\[7\] _0887_ net92 VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__mux2_1
X_2238_ _1576_ VGND VGND VPWR VPWR _1577_ sky130_fd_sc_hd__buf_4
XFILLER_0_29_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3425_ _0940_ _1000_ _0939_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__o21ai_1
X_3356_ counter\[0\] VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__inv_2
X_2169_ _1486_ _1487_ _1492_ VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__a21o_1
XFILLER_0_16_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3800__71 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__inv_2
X_3141_ _0704_ _0702_ _0703_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__a21bo_1
X_3210_ _0808_ _0818_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__and2_1
X_3072_ net103 _0255_ _1418_ net107 VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__a22o_1
X_2023_ net114 _1342_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__and2_1
X_2925_ net113 _1433_ _0193_ net108 VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__a22o_1
XFILLER_0_60_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2856_ _1466_ _1726_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__xnor2_1
X_3408_ _0944_ _0982_ counter\[8\] VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__a21oi_1
X_2787_ _0394_ _0395_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3339_ _0923_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3690_ tC\[15\] net82 VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__or2_1
X_3777__48 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__inv_2
XFILLER_0_6_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2710_ _0304_ _0317_ _0318_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__nand3_2
X_2572_ net158 _1448_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__nand2_2
X_2641_ net100 _1418_ _0189_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__and3_1
X_3055_ _0616_ _0663_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__or2_4
X_3124_ net115 _1343_ _1363_ _1361_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__a22o_1
X_2006_ _1288_ _1344_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__xor2_1
XFILLER_0_9_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2908_ _0513_ _0514_ _0515_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__o21ai_1
X_3888_ net241 _0156_ net131 VGND VGND VPWR VPWR tA\[8\] sky130_fd_sc_hd__dfrtp_1
X_3791__62 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__inv_2
X_2839_ _0446_ _0447_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__and2b_1
XFILLER_0_13_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3673_ tA\[1\] _1147_ _0933_ tA\[0\] VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__o211a_1
X_2624_ _0230_ _0231_ _0216_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__a21oi_2
X_2555_ _1890_ _1893_ VGND VGND VPWR VPWR _1894_ sky130_fd_sc_hd__xnor2_2
X_2486_ _1591_ _1606_ VGND VGND VPWR VPWR _1825_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3107_ _0714_ _0715_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__xnor2_1
X_3038_ _0602_ _0600_ _0601_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_65_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput37 vB[11] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_1
Xinput15 periodTop[7] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_64_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput48 vB[7] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__clkbuf_1
X_3747__18 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__inv_2
Xinput26 vA[1] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_1
Xinput59 vC[2] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2271_ _1605_ _1600_ _1604_ VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__a21o_1
X_2340_ _1645_ _1639_ _1644_ VGND VGND VPWR VPWR _1679_ sky130_fd_sc_hd__a21o_1
X_1986_ net107 _1318_ _1322_ net102 VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__a22o_1
XFILLER_0_47_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3656_ _1178_ net79 _1192_ _1196_ _1197_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__a221o_1
X_2607_ _0212_ _0214_ _0215_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__a21bo_1
X_3725_ _0940_ _1015_ _0932_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_2_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3587_ _1071_ _1133_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__xnor2_1
X_3761__32 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__inv_2
X_2538_ _1875_ _1872_ _1873_ VGND VGND VPWR VPWR _1877_ sky130_fd_sc_hd__nand3_1
X_2469_ _1805_ _1806_ _1801_ VGND VGND VPWR VPWR _1808_ sky130_fd_sc_hd__a21o_1
XFILLER_0_48_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout170 net171 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_29_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_4__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_4__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_69_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3510_ delta\[1\] counter\[1\] VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__and2_1
X_3441_ net1 state\[0\] VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__or2b_2
X_2323_ _1661_ _1654_ _1656_ VGND VGND VPWR VPWR _1662_ sky130_fd_sc_hd__and3_1
X_2254_ net294 _1573_ _1586_ net101 VGND VGND VPWR VPWR _1593_ sky130_fd_sc_hd__a22oi_1
X_3372_ net110 _0947_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__nor2_1
X_2185_ net145 net141 _1433_ _1431_ VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__nand4_2
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1969_ _1270_ _1274_ _1307_ VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__or3b_2
XFILLER_0_35_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3639_ tB\[3\] _0958_ _1014_ tB\[2\] _1180_ VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__o221a_1
X_3708_ tC\[6\] _0890_ net83 VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__mux2_1
XFILLER_0_66_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3735__6 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__inv_2
XFILLER_0_39_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2941_ _0528_ _0529_ _0547_ _0548_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__o22a_1
X_2872_ _0292_ _0466_ _0480_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3424_ _0950_ _0951_ _0957_ _0999_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_4_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3286_ _0764_ _0886_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__xnor2_2
X_2306_ _1633_ _1638_ _1634_ VGND VGND VPWR VPWR _1645_ sky130_fd_sc_hd__nand3_1
X_2237_ _1250_ net27 _1574_ _1575_ VGND VGND VPWR VPWR _1576_ sky130_fd_sc_hd__a2bb2o_4
X_3355_ _0931_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_48_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2168_ _1494_ _1505_ _1506_ VGND VGND VPWR VPWR _1507_ sky130_fd_sc_hd__a21o_1
X_2099_ net89 net46 net85 VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_63_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3140_ _0745_ _0746_ _0747_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__a21o_1
X_3071_ net103 _1418_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2022_ net111 _1293_ _1360_ net107 VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2924_ net118 _1417_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__nand2_1
X_2855_ _0274_ _0281_ _0280_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_31_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2786_ _0389_ _0393_ _0373_ _0374_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__a211o_1
XFILLER_0_13_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_17_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3338_ tA\[7\] _0887_ net86 VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__mux2_1
X_3407_ counter\[8\] _0944_ _0982_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__and3_1
X_3269_ _0827_ _0869_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2640_ _0246_ _0247_ _0236_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__a21o_1
X_2571_ _1440_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__buf_4
X_3054_ _0612_ _0615_ _0614_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__o21a_1
X_3123_ _1363_ _1361_ _1362_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__nand3_1
X_2005_ net103 _1294_ _1343_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__and3_1
XFILLER_0_26_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2907_ _0513_ _0514_ _0515_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__or3_1
XFILLER_0_45_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3887_ net240 _0155_ net131 VGND VGND VPWR VPWR tA\[7\] sky130_fd_sc_hd__dfrtp_1
X_2769_ _0356_ _0376_ _0375_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__o21ai_1
X_2838_ _0328_ _0445_ net75 _0366_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__a211o_1
XFILLER_0_51_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2554_ _1810_ _1891_ _1892_ VGND VGND VPWR VPWR _1893_ sky130_fd_sc_hd__a21oi_2
X_3672_ tA\[11\] _0992_ _1212_ VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__a21o_1
X_2623_ _0216_ _0230_ _0231_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__and3_2
XFILLER_0_6_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2485_ _1810_ _1823_ VGND VGND VPWR VPWR _1824_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_34_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3106_ net150 _1260_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__nand2_1
X_3037_ _0638_ _0644_ _0643_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_43_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_52_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_61_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_70_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput16 periodTop[8] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput49 vB[8] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_1
Xinput38 vB[12] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_1
Xinput27 vA[2] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_1
X_2270_ _1605_ _1600_ _1604_ VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__nand3_1
X_1985_ net110 _1298_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__nand2_1
X_3724_ _0939_ _1016_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2537_ _1872_ _1873_ _1875_ VGND VGND VPWR VPWR _1876_ sky130_fd_sc_hd__a21o_1
X_3655_ tB\[12\] counter\[12\] VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__and2b_1
X_2606_ _0211_ _0205_ _0206_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__nand3_1
XFILLER_0_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3586_ _1067_ _1072_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__and2b_1
XFILLER_0_15_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2468_ _1801_ _1805_ _1806_ VGND VGND VPWR VPWR _1807_ sky130_fd_sc_hd__and3_1
XFILLER_0_48_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2399_ net141 _1573_ _1669_ net122 VGND VGND VPWR VPWR _1738_ sky130_fd_sc_hd__a22o_1
XFILLER_0_61_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_5_Left_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout160 net13 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__buf_6
XFILLER_0_44_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3807__78 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__inv_2
Xfanout171 net10 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__buf_2
XFILLER_0_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3371_ net116 _0946_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__or2_2
X_3440_ _1013_ _1014_ _0958_ counter\[0\] VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__and4b_1
X_2184_ net145 _1422_ _1426_ net140 VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__a22o_1
X_2322_ _1648_ _1653_ _1631_ _1630_ VGND VGND VPWR VPWR _1661_ sky130_fd_sc_hd__a211o_1
X_2253_ net108 _1577_ VGND VGND VPWR VPWR _1592_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1968_ _1275_ _1305_ _1306_ VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__o21a_1
X_3707_ _1238_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3638_ tB\[2\] _1014_ _1147_ tB\[1\] _1179_ VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__a221o_1
X_3569_ _1061_ _1078_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__or2b_1
XFILLER_0_38_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2940_ _0528_ _0529_ _0547_ _0548_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__nor4_4
XFILLER_0_57_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2871_ _0464_ _0465_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__and2b_1
XFILLER_0_40_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3423_ _0991_ _0995_ _0997_ _0998_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__or4_4
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3354_ net96 VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__inv_2
X_3285_ _0779_ _0885_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__nor2_1
X_2167_ _1498_ _1504_ _1499_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__and3_1
X_2305_ _1640_ _1643_ VGND VGND VPWR VPWR _1644_ sky130_fd_sc_hd__xnor2_1
X_2236_ net89 net43 net85 VGND VGND VPWR VPWR _1575_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2098_ net89 net81 net62 VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__nand3b_1
X_3798__69 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__inv_2
XFILLER_0_31_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3070_ net107 _0255_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__nand2_1
X_2021_ _1326_ VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_8_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2923_ _0530_ _0531_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2854_ _0461_ _0460_ _0459_ _0271_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__o211a_1
X_2785_ _0373_ _0374_ _0389_ _0393_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3337_ _0922_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__clkbuf_1
X_3406_ net149 _0943_ net147 VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__o21ai_1
X_3199_ _0784_ _0796_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__xor2_1
X_2219_ net140 _1422_ _1426_ net121 VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__a22o_1
X_3268_ _0872_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2570_ _1907_ _1908_ VGND VGND VPWR VPWR _1909_ sky130_fd_sc_hd__or2_1
X_3122_ _0729_ _0730_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__xnor2_1
X_3053_ _0659_ _0660_ _0570_ _0574_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__o211a_1
X_2004_ _1342_ VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__clkbuf_4
X_2906_ net146 _1342_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__nand2_1
X_3886_ net239 _0154_ net131 VGND VGND VPWR VPWR tA\[6\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_33_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3768__39 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__inv_2
X_2768_ _0375_ _0356_ _0376_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__or3_1
X_2837_ _0366_ net75 _0445_ _0328_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__o211a_1
XFILLER_0_13_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2699_ net157 net153 _1579_ _1669_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__and4_1
X_3782__53 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__inv_2
XFILLER_0_59_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2553_ _1820_ _1822_ VGND VGND VPWR VPWR _1892_ sky130_fd_sc_hd__nor2_1
XFILLER_0_50_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3671_ tA\[11\] _0992_ _1155_ tA\[10\] VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__o22a_1
X_2622_ _0223_ _0224_ _0229_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3105_ _0711_ _0713_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__xnor2_1
X_2484_ _1820_ _1822_ VGND VGND VPWR VPWR _1823_ sky130_fd_sc_hd__xnor2_1
X_3036_ _0638_ _0643_ _0644_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__nand3_1
X_3869_ net222 _0137_ net129 VGND VGND VPWR VPWR delta\[7\] sky130_fd_sc_hd__dfrtp_2
XFILLER_0_5_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput17 periodTop[9] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_64_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput39 vB[13] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_1
Xinput28 vA[3] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1984_ net106 net102 _1318_ _1322_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__and4_1
X_3654_ _1189_ _1193_ _1190_ _1187_ _1186_ VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__a32o_1
XPHY_EDGE_ROW_21_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3723_ _1246_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_70_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2467_ _1804_ _1803_ _1802_ VGND VGND VPWR VPWR _1806_ sky130_fd_sc_hd__a21bo_1
X_2536_ net112 _1440_ _1874_ _1811_ VGND VGND VPWR VPWR _1875_ sky130_fd_sc_hd__a31o_1
XFILLER_0_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2605_ _0213_ _0183_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3585_ _1132_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__clkbuf_1
X_2398_ net144 _1577_ VGND VGND VPWR VPWR _1737_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3019_ _0597_ _0598_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__and2_1
XFILLER_0_61_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3752__23 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__inv_2
Xfanout150 net151 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__buf_2
Xfanout172 net173 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__clkbuf_4
Xfanout161 net163 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_71_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2321_ _1519_ _1659_ VGND VGND VPWR VPWR _1660_ sky130_fd_sc_hd__xnor2_2
X_3370_ net124 net120 _0945_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__or3_1
X_2252_ _1569_ _1590_ VGND VGND VPWR VPWR _1591_ sky130_fd_sc_hd__xnor2_2
X_2183_ net152 _1417_ VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1967_ net110 _1261_ _1304_ VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__a21o_1
X_3706_ tC\[7\] _0887_ net83 VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__mux2_1
XFILLER_0_28_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3637_ tB\[1\] _1147_ _0933_ tB\[0\] VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__o211a_1
XFILLER_0_59_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2519_ net150 _1318_ _1322_ net146 VGND VGND VPWR VPWR _1858_ sky130_fd_sc_hd__a22o_1
X_3499_ delta\[8\] counter\[8\] VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__or2_1
X_3568_ _0932_ counter\[7\] _1118_ _1119_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__a22o_1
XFILLER_0_34_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2870_ _0470_ _0472_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__nand2_1
XFILLER_0_52_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3284_ _0883_ _0884_ _0769_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__o21a_1
X_2304_ _1641_ _1642_ _1502_ VGND VGND VPWR VPWR _1643_ sky130_fd_sc_hd__o21a_1
XFILLER_0_29_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3353_ _0930_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__clkbuf_1
X_3422_ _0947_ _0996_ net80 VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2166_ _1498_ _1499_ _1504_ VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__a21o_1
X_2097_ _1434_ _1432_ _1430_ VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__a21bo_1
X_2235_ net89 net81 net59 VGND VGND VPWR VPWR _1574_ sky130_fd_sc_hd__nand3b_1
X_2999_ _0606_ _0605_ _0544_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2020_ _1328_ _1325_ _1324_ VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_15_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2922_ net104 _0180_ _1700_ net101 VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_57_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2853_ _0271_ _0459_ _0460_ _0461_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_25_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2784_ _0391_ _0392_ _0389_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__nand3b_2
XFILLER_0_13_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3267_ tB\[11\] _0871_ net93 VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__mux2_4
X_3336_ tA\[8\] _0881_ net86 VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__mux2_1
X_3405_ counter\[7\] _0980_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__xnor2_1
X_2218_ net140 net121 _1422_ _1426_ VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__nand4_2
X_3198_ _0805_ _0806_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__nor2_1
X_2149_ net99 _1255_ VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__nand2_1
XFILLER_0_16_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3121_ net143 _1256_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__nand2_1
X_3052_ _0570_ _0574_ _0659_ _0660_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__a211oi_2
X_2003_ _1297_ VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__buf_4
X_2905_ net142 _1318_ _1360_ net123 VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_45_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3885_ net238 _0153_ net130 VGND VGND VPWR VPWR tA\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_9_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2836_ _0444_ _0327_ _0326_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__o21ai_1
X_2767_ net161 _0209_ _0202_ net157 VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_13_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2698_ net157 _1579_ _1669_ net153 VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__a22o_1
X_3319_ _0901_ _0912_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__and2_1
XFILLER_0_44_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3670_ tA\[12\] VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__inv_2
XFILLER_0_27_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2552_ _1820_ _1822_ VGND VGND VPWR VPWR _1891_ sky130_fd_sc_hd__nand2_1
X_2483_ _1569_ _1590_ _1821_ VGND VGND VPWR VPWR _1822_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_35_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2621_ _0223_ _0224_ _0229_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__nand3_2
XFILLER_0_10_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3104_ _0639_ _0583_ _0712_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__o21ba_1
X_3035_ _0634_ _0635_ _0637_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__a21o_1
XFILLER_0_53_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3868_ net221 _0136_ net129 VGND VGND VPWR VPWR delta\[6\] sky130_fd_sc_hd__dfrtp_1
X_2819_ _0411_ _0426_ _0427_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_64_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput18 rstb VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_1
Xinput29 vA[4] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1983_ _1321_ VGND VGND VPWR VPWR _1322_ sky130_fd_sc_hd__clkbuf_4
X_3653_ _1189_ _1194_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__nand2_1
X_2604_ net167 _1601_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__nand2_1
X_3722_ delta\[0\] _1002_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__or2_1
XFILLER_0_7_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2466_ _1802_ _1803_ _1804_ VGND VGND VPWR VPWR _1805_ sky130_fd_sc_hd__nand3b_1
X_2535_ net108 _1444_ _1448_ net104 VGND VGND VPWR VPWR _1874_ sky130_fd_sc_hd__a22o_1
XFILLER_0_23_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3584_ counter\[3\] _1131_ net94 VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__mux2_1
XFILLER_0_64_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3018_ _0625_ _0626_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__xnor2_2
X_2397_ net141 _1580_ _1670_ _1668_ VGND VGND VPWR VPWR _1736_ sky130_fd_sc_hd__a22o_1
XFILLER_0_61_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout151 net152 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__clkbuf_2
Xfanout140 net141 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__clkbuf_4
Xfanout173 net10 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__clkbuf_2
Xfanout162 net163 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_29_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2251_ _1582_ _1589_ VGND VGND VPWR VPWR _1590_ sky130_fd_sc_hd__xor2_2
X_2320_ _1629_ _1658_ VGND VGND VPWR VPWR _1659_ sky130_fd_sc_hd__xnor2_2
X_2182_ _1497_ _1498_ VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1966_ _1261_ _1304_ VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3636_ tB\[13\] VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__inv_2
X_3705_ _1237_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__clkbuf_1
X_3567_ _1079_ _1117_ net94 VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__o21a_1
X_2518_ _1853_ _1854_ _1855_ VGND VGND VPWR VPWR _1857_ sky130_fd_sc_hd__o21ai_1
X_2449_ net150 net146 _1292_ _1326_ VGND VGND VPWR VPWR _1788_ sky130_fd_sc_hd__and4_1
X_3498_ delta\[8\] counter\[8\] VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_49_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3812__83 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__inv_2
XFILLER_0_19_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_58_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3421_ net80 _0947_ _0996_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__and3_1
XFILLER_0_4_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3283_ _0567_ _0675_ _0775_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__and3_1
X_2303_ net141 _1448_ VGND VGND VPWR VPWR _1642_ sky130_fd_sc_hd__nand2_1
X_2234_ _1572_ VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__buf_6
X_3352_ net292 _0913_ net85 VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2165_ net145 _1439_ _1502_ _1503_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__a31o_1
X_2096_ _1430_ _1432_ _1434_ VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__nand3b_2
X_2998_ _0544_ _0605_ _0606_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__nand3b_4
XFILLER_0_63_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1949_ _1286_ _1287_ VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__xor2_1
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3619_ _1160_ tC\[9\] tC\[8\] _1161_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_3_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2921_ net104 net101 _1601_ _1700_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__and4_1
XFILLER_0_45_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2852_ _1748_ _1749_ _1750_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__and3_1
XFILLER_0_31_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2783_ _0387_ _0388_ _0386_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__a21o_1
X_3404_ net149 _0943_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__xor2_1
XFILLER_0_0_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2217_ net145 _1417_ VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__nand2_1
X_3197_ _0804_ _0798_ _0803_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__nor3_1
X_3266_ _0807_ _0870_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__xnor2_4
X_3335_ _0921_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2079_ _1417_ VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__clkbuf_4
X_2148_ _1482_ _1483_ _1485_ VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__a21o_1
XFILLER_0_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3051_ _0657_ _0658_ net270 _0616_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__a211oi_2
X_3120_ _1367_ _0694_ _0728_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__o21a_1
X_2002_ _1334_ _1340_ VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2904_ net142 net123 _1292_ _1326_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__and4_1
XFILLER_0_45_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3884_ net237 _0152_ net130 VGND VGND VPWR VPWR tA\[4\] sky130_fd_sc_hd__dfrtp_1
X_2766_ net166 _1580_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2835_ _0319_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__inv_2
X_3318_ _1768_ _0900_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2697_ net157 _0239_ _0210_ _0208_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__a22o_1
X_3249_ _1315_ _1271_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__and2b_1
XFILLER_0_51_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2620_ _0225_ _0228_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__xnor2_2
X_3773__44 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__inv_2
XFILLER_0_12_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2551_ _1881_ _1889_ VGND VGND VPWR VPWR _1890_ sky130_fd_sc_hd__xnor2_2
X_2482_ _1582_ _1589_ VGND VGND VPWR VPWR _1821_ sky130_fd_sc_hd__and2_1
XFILLER_0_2_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3103_ net150 _1256_ _0641_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__and3_1
X_3034_ _0641_ _0642_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_37_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2818_ net125 _0239_ _0411_ _0426_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__o2bb2a_1
X_3867_ net220 _0135_ net129 VGND VGND VPWR VPWR delta\[5\] sky130_fd_sc_hd__dfrtp_2
X_2749_ _0353_ _0354_ _0357_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_30_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput19 vA[0] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_1
X_3738__9 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__inv_2
X_1982_ _1250_ net34 _1319_ _1320_ VGND VGND VPWR VPWR _1321_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_23_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2534_ _1871_ _1870_ _1869_ VGND VGND VPWR VPWR _1873_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_55_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3652_ _1190_ _1191_ _1192_ _1193_ VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__and4bb_1
X_3721_ _1245_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__clkbuf_1
X_2603_ _0205_ _0206_ _0211_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3583_ _1073_ _1130_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2465_ net280 net117 _1422_ _1426_ VGND VGND VPWR VPWR _1804_ sky130_fd_sc_hd__nand4_2
XFILLER_0_48_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2396_ _1670_ _1667_ _1668_ VGND VGND VPWR VPWR _1735_ sky130_fd_sc_hd__nand3_1
X_3017_ net109 _1418_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout152 net15 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__buf_2
Xfanout141 net17 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__clkbuf_4
Xfanout130 net139 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__clkbuf_4
Xfanout163 net12 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3743__14 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__inv_2
X_2250_ net109 _1580_ _1587_ _1588_ VGND VGND VPWR VPWR _1589_ sky130_fd_sc_hd__a31o_1
X_2181_ _1486_ _1493_ VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1965_ _1282_ _1283_ _1302_ _1303_ VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_28_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3704_ tC\[8\] _0881_ net83 VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2517_ _1853_ _1854_ _1855_ VGND VGND VPWR VPWR _1856_ sky130_fd_sc_hd__or3_1
XFILLER_0_43_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3635_ tB\[14\] VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__inv_2
X_3497_ delta\[9\] counter\[9\] VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__or2_1
X_3566_ _1079_ _1117_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__nand2_1
X_2448_ net155 _1342_ VGND VGND VPWR VPWR _1787_ sky130_fd_sc_hd__nand2_1
X_2379_ _1709_ _1716_ _1717_ VGND VGND VPWR VPWR _1718_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_46_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3351_ _0929_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__clkbuf_1
X_3420_ net116 _0946_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3282_ _0673_ _0777_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__nor2_1
X_2164_ net140 net121 _1500_ _1501_ VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__and4_1
X_2302_ net122 _1444_ VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__nand2_1
X_2233_ _1251_ net26 _1570_ _1571_ VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__a2bb2o_4
X_2095_ net156 net152 _1433_ _1431_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__nand4_2
XFILLER_0_24_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2997_ net103 _0180_ _0603_ _0604_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__nand4_4
XFILLER_0_61_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1948_ net114 _1256_ VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3618_ counter\[8\] VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__inv_2
X_3549_ delta\[11\] counter\[11\] VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2920_ _1860_ _1862_ _0525_ _0526_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_57_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2851_ _1748_ _1749_ _1750_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_31_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2782_ _0349_ _0390_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__nand2_1
XFILLER_0_40_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3334_ tA\[9\] _0878_ net86 VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3403_ _0971_ _0973_ _0974_ _0978_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__or4_1
X_3196_ _0798_ _0803_ _0804_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__o21a_1
X_2216_ net121 _1440_ _1553_ _1554_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__a31o_1
X_3265_ _0827_ _0869_ _0825_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__a21oi_4
X_2147_ _1482_ _1483_ _1485_ VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__nand3_1
XFILLER_0_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2078_ _1416_ VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__clkbuf_4
X_3779__50 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__inv_2
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3050_ net269 _0616_ _0657_ _0658_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__o211a_1
X_2001_ _1339_ VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__inv_2
X_2903_ _0510_ _0511_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__xnor2_1
X_3883_ net236 _0151_ net132 VGND VGND VPWR VPWR tA\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_53_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2834_ _0371_ _0369_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__and2b_1
X_2765_ _0366_ _0367_ _0372_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__o21ba_1
X_2696_ _0210_ _0207_ _0208_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__nand3_1
X_3317_ _0911_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__clkbuf_1
X_3179_ _0785_ _0787_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__xnor2_1
X_3248_ _1397_ _0850_ _0855_ _0856_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__a31o_1
XFILLER_0_36_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2550_ _1887_ _1888_ VGND VGND VPWR VPWR _1889_ sky130_fd_sc_hd__and2b_1
X_2481_ _1818_ _1819_ VGND VGND VPWR VPWR _1820_ sky130_fd_sc_hd__or2_1
XFILLER_0_50_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3102_ _0650_ _0648_ _0649_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__a21bo_1
X_3033_ net150 _1255_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3749__20 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__inv_2
X_3866_ net219 _0134_ net129 VGND VGND VPWR VPWR delta\[4\] sky130_fd_sc_hd__dfrtp_2
XFILLER_0_41_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2679_ _0251_ _0260_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__or2b_1
X_2817_ net97 _0209_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2748_ net166 _0239_ _0355_ _0356_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__a31o_1
XFILLER_0_14_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1981_ net93 net50 net88 VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__a21oi_1
X_3720_ net291 _0913_ net81 VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2533_ _1869_ _1870_ _1871_ VGND VGND VPWR VPWR _1872_ sky130_fd_sc_hd__nand3b_1
X_3651_ tB\[9\] _1160_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3582_ _1066_ _1129_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__nand2_1
X_2602_ _0207_ _0208_ _0210_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__a21bo_1
X_2464_ net121 _1421_ _1426_ net117 VGND VGND VPWR VPWR _1803_ sky130_fd_sc_hd__a22o_1
X_2395_ _1677_ _1672_ _1676_ VGND VGND VPWR VPWR _1734_ sky130_fd_sc_hd__nand3_2
XFILLER_0_3_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3016_ _0623_ _0624_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__nor2_2
XFILLER_0_3_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3849_ net202 _0117_ net128 VGND VGND VPWR VPWR counter\[2\] sky130_fd_sc_hd__dfrtp_4
Xfanout131 net132 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__clkbuf_2
Xfanout120 net4 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__clkbuf_2
Xfanout142 net143 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__clkbuf_4
Xfanout164 net165 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__buf_6
Xfanout153 net154 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_64_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2180_ _1517_ _1518_ VGND VGND VPWR VPWR _1519_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_18_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_25_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1964_ _1269_ _1280_ _1301_ VGND VGND VPWR VPWR _1303_ sky130_fd_sc_hd__nor3_1
X_3703_ _1236_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_28_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3634_ tB\[15\] VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__inv_2
X_2516_ net150 _1342_ VGND VGND VPWR VPWR _1855_ sky130_fd_sc_hd__nand2_1
X_2447_ _1784_ _1785_ VGND VGND VPWR VPWR _1786_ sky130_fd_sc_hd__xnor2_2
X_3496_ delta\[10\] counter\[10\] VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__nor2_1
X_3565_ _1116_ _1060_ VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__and2_1
X_2378_ _1465_ _1468_ VGND VGND VPWR VPWR _1717_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_66_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3803__74 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__inv_2
XFILLER_0_25_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2301_ net144 _1440_ VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__nand2_1
X_3350_ tA\[1\] _0910_ net85 VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__mux2_1
X_2163_ net140 _1500_ _1501_ net121 VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__a22o_1
X_2232_ net89 net42 net85 VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_29_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3281_ _0882_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__clkbuf_1
X_2094_ _1421_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_45_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2996_ net103 _0180_ _0603_ _0604_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__a22o_1
X_1947_ _1280_ _1285_ VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__xor2_1
XFILLER_0_43_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3617_ counter\[9\] VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__inv_2
XFILLER_0_9_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3479_ _1042_ _1043_ _1002_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__a21oi_1
X_3548_ _1104_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_66_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2850_ _0271_ _0272_ _0282_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__nand3_1
XFILLER_0_15_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2781_ net125 _0193_ _0346_ _0348_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__a211o_1
XFILLER_0_13_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3264_ _0840_ net274 _0844_ _0848_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__a31o_4
X_3333_ _0920_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3402_ _0975_ _0977_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__xnor2_1
X_2215_ net117 net112 _1500_ _1501_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__and4_1
X_2146_ net168 _1298_ _1484_ _1398_ VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__a31o_1
X_3195_ _1382_ _1385_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__xor2_1
X_2077_ _1251_ net33 _1414_ _1415_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__a2bb2o_1
X_2979_ _0582_ _0586_ _0587_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__nand3_2
XFILLER_0_63_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3794__65 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__inv_2
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_12_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2000_ _1337_ _1338_ VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__xor2_1
X_2902_ net160 _1255_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3882_ net235 _0150_ net132 VGND VGND VPWR VPWR tA\[2\] sky130_fd_sc_hd__dfrtp_1
X_2833_ _0349_ _0396_ _0441_ _0395_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__o211ai_1
X_2695_ _0215_ _0212_ _0214_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__nand3_1
X_2764_ _0366_ _0367_ _0372_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__nor3b_2
XFILLER_0_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3247_ _1395_ _0854_ _0853_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__a21boi_1
X_3316_ tB\[1\] _0910_ net90 VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__mux2_1
XFILLER_0_6_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3178_ _1372_ _0786_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__and2_1
Xrebuffer10 _0782_ VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__buf_6
X_2129_ _1410_ _1466_ _1467_ VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_44_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2480_ _1814_ _1815_ _1817_ VGND VGND VPWR VPWR _1819_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_42_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3101_ _0707_ _0708_ _0677_ _0653_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__a211o_1
XFILLER_0_10_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3032_ _0639_ _0583_ _0640_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__o21a_1
XFILLER_0_53_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2816_ _0423_ _0424_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__xnor2_1
X_3865_ net218 _0133_ net128 VGND VGND VPWR VPWR delta\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_5_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3764__35 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__inv_2
X_2678_ _0253_ _0259_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2747_ net161 net157 _1579_ _1669_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__and4_1
XFILLER_0_64_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1980_ net93 net84 net66 VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__nand3b_4
X_3650_ net80 tB\[12\] VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__or2b_1
XFILLER_0_70_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2463_ net141 _1417_ VGND VGND VPWR VPWR _1802_ sky130_fd_sc_hd__nand2_1
X_2532_ net118 net112 _1422_ _1431_ VGND VGND VPWR VPWR _1871_ sky130_fd_sc_hd__nand4_1
Xrebuffer1 _1691_ VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3581_ delta\[3\] counter\[3\] VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__nand2_1
X_2601_ net153 net148 _0209_ _0202_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__nand4_1
XFILLER_0_64_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3015_ net294 _0255_ _0193_ net103 VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__a22oi_1
X_2394_ _1696_ _1693_ _1695_ VGND VGND VPWR VPWR _1733_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_3_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3809__80 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__inv_2
X_3848_ net201 _0116_ net128 VGND VGND VPWR VPWR counter\[1\] sky130_fd_sc_hd__dfrtp_4
XFILLER_0_14_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout143 net17 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__buf_2
Xfanout110 net6 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__clkbuf_4
Xfanout165 net12 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__buf_4
Xfanout121 net122 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__buf_2
Xfanout154 net14 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__clkbuf_2
Xfanout132 net139 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_69_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Left_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3730__1 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__inv_2
XFILLER_0_70_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1963_ _1269_ _1280_ _1301_ VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__o21a_1
X_3702_ tC\[9\] _0878_ net83 VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__mux2_1
X_3633_ _1173_ _1174_ _1175_ net283 _0932_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__a32o_1
XFILLER_0_59_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2515_ net146 _1292_ _1322_ net142 VGND VGND VPWR VPWR _1854_ sky130_fd_sc_hd__a22oi_2
X_2446_ net168 _1255_ VGND VGND VPWR VPWR _1785_ sky130_fd_sc_hd__nand2_1
X_3564_ delta\[7\] counter\[7\] VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3495_ delta\[12\] net80 VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__nor2_1
XFILLER_0_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2377_ _1714_ _1715_ VGND VGND VPWR VPWR _1716_ sky130_fd_sc_hd__or2b_4
XFILLER_0_46_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2300_ _1633_ _1634_ _1638_ VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__a21o_1
X_2231_ net89 net81 net58 VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__nand3b_1
X_3280_ tB\[8\] _0881_ net92 VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__mux2_1
X_2162_ _1447_ VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__buf_6
X_2093_ net156 _1422_ _1431_ net152 VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__a22o_1
XFILLER_0_45_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2995_ _0602_ _0600_ _0601_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__nand3_2
XFILLER_0_63_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1946_ net110 _1268_ VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__nand2_1
X_3616_ _1156_ _1157_ _1158_ VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__and3b_1
XFILLER_0_3_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3547_ net80 _1103_ net95 VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__mux2_1
X_2429_ _1699_ _1767_ VGND VGND VPWR VPWR _1768_ sky130_fd_sc_hd__xnor2_1
X_3478_ delta\[5\] _1041_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__or2_1
XFILLER_0_15_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3401_ _0943_ _0976_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__nand2_1
X_2780_ _0386_ _0387_ _0388_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__nand3_2
X_3194_ _0800_ _0802_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__and2b_1
X_2214_ net117 _1444_ _1448_ net112 VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__a22o_1
X_3332_ tA\[10\] _0873_ net87 VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__mux2_1
X_3263_ _0868_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2145_ net164 _1457_ _1360_ net159 VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__a22o_1
X_2076_ net89 net49 net85 VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__a21oi_1
Xclkbuf_3_5__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_5__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_2978_ _0578_ _0579_ _0581_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__a21o_1
X_1929_ _1267_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__buf_4
XFILLER_0_8_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout1 net105 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__buf_4
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2901_ _0508_ _1849_ _0509_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__o21a_1
X_3881_ net234 _0149_ net132 VGND VGND VPWR VPWR tA\[1\] sky130_fd_sc_hd__dfrtp_1
X_2832_ _0349_ _0396_ _0420_ _0440_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__a22o_1
X_2763_ _0369_ _0371_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__xnor2_1
X_2694_ _0300_ _0301_ _0200_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer11 _0549_ VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__clkbuf_1
X_3177_ _1365_ _1371_ _1370_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__a21o_1
X_3246_ _0853_ _0854_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__and2_1
X_3315_ _1837_ _0909_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__xnor2_1
X_2059_ net164 net159 _1291_ _1321_ VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__and4_1
X_2128_ net127 _1268_ _1279_ net99 VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__a22o_1
XFILLER_0_44_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3100_ _0677_ _0653_ _0707_ _0708_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__o211ai_4
X_3031_ net146 _1267_ _1278_ net142 VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__a22o_1
XFILLER_0_53_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2815_ _0410_ _0411_ _0409_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__o21a_1
XFILLER_0_5_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3864_ net217 _0132_ net128 VGND VGND VPWR VPWR delta\[2\] sky130_fd_sc_hd__dfrtp_2
X_2746_ net161 _0209_ _0202_ net157 VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__a22o_1
XFILLER_0_68_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2677_ _0283_ _0284_ _0248_ _0262_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_1_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3229_ _0836_ _0837_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__or2_2
XFILLER_0_64_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2600_ _1573_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__buf_6
X_3580_ _1128_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__clkbuf_1
Xrebuffer2 _0325_ VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__clkbuf_1
X_2531_ net117 _1422_ _1426_ net112 VGND VGND VPWR VPWR _1870_ sky130_fd_sc_hd__a22o_1
X_2462_ net117 _1440_ _1567_ _1566_ VGND VGND VPWR VPWR _1801_ sky130_fd_sc_hd__a31o_1
X_2393_ _1696_ _1693_ _1695_ VGND VGND VPWR VPWR _1732_ sky130_fd_sc_hd__or3_4
XFILLER_0_2_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3014_ net294 net103 _1433_ _1431_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__and4_2
XFILLER_0_3_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2729_ _0264_ _0265_ _0266_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__and3_1
X_3847_ net200 _0115_ net128 VGND VGND VPWR VPWR counter\[0\] sky130_fd_sc_hd__dfrtp_4
Xfanout111 net6 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__clkbuf_2
Xfanout155 net156 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__buf_2
Xfanout144 net145 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__clkbuf_4
Xfanout122 net3 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__buf_6
Xfanout166 net167 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__clkbuf_4
Xfanout133 net138 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__clkbuf_4
Xfanout100 net9 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1962_ _1284_ _1300_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__or2b_1
XFILLER_0_70_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3701_ _1235_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__clkbuf_1
X_3632_ calc_ready net95 VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3563_ net95 counter\[8\] _1115_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2514_ net146 net142 _1291_ _1321_ VGND VGND VPWR VPWR _1853_ sky130_fd_sc_hd__and4_1
X_2445_ _1781_ _1782_ _1783_ VGND VGND VPWR VPWR _1784_ sky130_fd_sc_hd__o21a_1
X_2376_ _1705_ _1708_ VGND VGND VPWR VPWR _1715_ sky130_fd_sc_hd__xor2_2
X_3494_ delta\[13\] net79 VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2230_ _1565_ _1568_ VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_29_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2092_ _1425_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__clkbuf_4
X_2161_ _1443_ VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__buf_8
XFILLER_0_71_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2994_ _0600_ _0601_ _0602_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__a21o_1
XFILLER_0_61_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1945_ _1282_ _1283_ VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_9_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3615_ _1155_ tC\[10\] VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__nand2_1
X_3546_ _1088_ _1102_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__xnor2_1
X_2359_ _1660_ _1697_ VGND VGND VPWR VPWR _1698_ sky130_fd_sc_hd__xor2_2
X_2428_ _1731_ _1765_ net297 VGND VGND VPWR VPWR _1767_ sky130_fd_sc_hd__o21bai_2
X_3477_ delta\[5\] _1041_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__nand2_1
XFILLER_0_62_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3331_ _0919_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__clkbuf_1
X_3400_ net154 _0942_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3193_ net124 _1309_ _0794_ _0801_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__a31o_1
X_2213_ _1524_ _1525_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__nand2_2
X_2144_ _1479_ _1481_ _1480_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_37_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3262_ tB\[12\] _0867_ net91 VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_46_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2075_ net89 net81 net65 VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__nand3b_1
X_2977_ _0584_ _0585_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_56_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1928_ _1251_ net23 _1265_ _1266_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_55_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3529_ delta\[12\] net80 VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_64_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3785__56 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__inv_2
X_2900_ net155 _1267_ _1278_ net150 VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__a22o_1
XFILLER_0_26_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3880_ net233 _0148_ net132 VGND VGND VPWR VPWR tA\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_5_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2831_ _0421_ _0422_ _0436_ _0439_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__or4_1
X_2762_ _0320_ _0370_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__or2_1
XFILLER_0_67_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3314_ _1699_ _1767_ _0901_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__a21bo_1
X_2693_ _0200_ _0300_ _0301_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__nand3_1
XFILLER_0_6_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3176_ _0679_ _0680_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__nor2_1
Xrebuffer12 _0850_ VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__buf_6
X_3245_ _1389_ _0852_ _0851_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__o21ai_1
X_2127_ net127 _1279_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__nand2_2
XFILLER_0_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2058_ _1395_ _1396_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__and2_1
XFILLER_0_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput70 net70 VGND VGND VPWR VPWR pwmC sky130_fd_sc_hd__buf_2
X_3030_ net142 _1268_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__nand2_2
XFILLER_0_37_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3863_ net216 _0131_ net129 VGND VGND VPWR VPWR delta\[1\] sky130_fd_sc_hd__dfrtp_2
XFILLER_0_41_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2676_ _0248_ _0262_ _0283_ _0284_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__a211o_1
X_2814_ net97 _0239_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2745_ _0308_ _0352_ _0351_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__o21ai_1
X_3228_ _0829_ _0830_ _0835_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__and3_1
X_3159_ _0766_ _0767_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_64_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3755__26 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__inv_2
X_2530_ net280 _1417_ VGND VGND VPWR VPWR _1869_ sky130_fd_sc_hd__nand2_1
Xrebuffer3 net268 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__clkbuf_1
X_2461_ _1557_ _1559_ VGND VGND VPWR VPWR _1800_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2392_ _1410_ _1466_ _1730_ VGND VGND VPWR VPWR _1731_ sky130_fd_sc_hd__or3_1
X_3013_ _0620_ _0621_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__xor2_2
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3846_ net199 _0114_ net133 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dfstp_1
X_2659_ _1745_ _1741_ _1744_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__nand3_1
X_2728_ _0264_ _0265_ _0266_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__a21oi_1
Xfanout156 net14 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__clkbuf_4
Xfanout101 net103 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__buf_2
Xfanout123 net124 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__buf_2
Xfanout112 net113 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__clkbuf_4
Xfanout145 net16 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__buf_2
Xfanout167 net169 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__buf_2
Xfanout134 net138 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_64_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1961_ _1288_ _1294_ _1299_ VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__a21oi_1
X_3700_ tC\[10\] _0873_ net82 VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__mux2_2
XFILLER_0_28_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2513_ _1850_ _1851_ VGND VGND VPWR VPWR _1852_ sky130_fd_sc_hd__xnor2_1
X_3631_ net77 _1141_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__or2_1
X_3562_ _1081_ _1114_ net95 VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__o21ai_1
X_3493_ delta\[14\] net78 VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__xnor2_1
X_2444_ net165 _1267_ _1278_ net159 VGND VGND VPWR VPWR _1783_ sky130_fd_sc_hd__a22o_1
X_2375_ _1710_ _1713_ VGND VGND VPWR VPWR _1714_ sky130_fd_sc_hd__and2_1
XFILLER_0_66_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3829_ net182 _0097_ net128 VGND VGND VPWR VPWR tC\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_69_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2160_ _1497_ _1496_ _1495_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__a21bo_1
X_2091_ net160 _1417_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2993_ _0535_ _0536_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__nand2_1
X_1944_ net110 _1257_ VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3614_ _0992_ tC\[11\] VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2427_ _1764_ _1763_ _1733_ _1732_ VGND VGND VPWR VPWR _1766_ sky130_fd_sc_hd__o211a_1
X_3476_ delta\[4\] _1004_ _1019_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_9_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3545_ _1055_ _1089_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__and2b_1
X_2289_ _1608_ _1627_ VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__xor2_2
X_2358_ _1693_ _1695_ _1696_ VGND VGND VPWR VPWR _1697_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_19_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3330_ tA\[11\] _0871_ net87 VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__mux2_4
XFILLER_0_0_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3192_ _0791_ _0793_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__nor2_1
X_2143_ _1479_ _1480_ _1481_ VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__or3_1
X_2212_ _1520_ _1550_ VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__xor2_2
X_3261_ _1397_ net276 VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__xor2_2
XFILLER_0_48_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2074_ _1406_ _1407_ _1412_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__or3b_4
X_2976_ net156 _1255_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__nand2_1
X_1927_ net93 net39 net88 VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_31_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3459_ delta\[11\] _1029_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3528_ delta\[11\] counter\[11\] _1087_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_47_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2830_ _0429_ _0438_ _0399_ _0417_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__a2bb2o_1
XANTENNA_1 net294 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2692_ _0298_ _0299_ _0264_ _0267_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__o211ai_2
X_2761_ net126 _0255_ _0193_ net98 VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_67_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3244_ _0851_ _1389_ _0852_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__or3_1
X_3313_ _0908_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__clkbuf_1
X_3175_ _1374_ _0783_ VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__or2_1
X_2057_ _1394_ _1381_ _1386_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__or3_1
X_2126_ _1460_ _1463_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__xnor2_2
Xrebuffer13 _1689_ VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_16_Left_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2959_ net160 _1257_ _0510_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__and3_1
XFILLER_0_8_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput71 net71 VGND VGND VPWR VPWR ready sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2813_ _0399_ _0417_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__nor2_1
X_3862_ net215 _0130_ net138 VGND VGND VPWR VPWR counter\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_41_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2675_ _0271_ _0272_ _0282_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_5_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2744_ _0308_ _0351_ _0352_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__or3_1
X_3227_ _0829_ _0830_ _0835_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__a21oi_1
X_3158_ _0659_ _0661_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__or2_1
X_3089_ _0689_ _0690_ _0692_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2109_ _1447_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__buf_4
XFILLER_0_55_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2460_ _1779_ _1798_ VGND VGND VPWR VPWR _1799_ sky130_fd_sc_hd__xor2_2
Xrebuffer4 net295 VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2391_ _1718_ _1729_ VGND VGND VPWR VPWR _1730_ sky130_fd_sc_hd__nor2_1
X_3012_ net156 _1259_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3845_ net198 _0113_ net136 VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_13_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout113 net116 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__buf_6
Xfanout102 net103 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__clkbuf_4
X_2658_ _0264_ _0265_ _0266_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__nand3_1
X_2589_ _0196_ _0197_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__and2b_1
XFILLER_0_1_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2727_ _0331_ _0332_ _0335_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__or3_4
XFILLER_0_69_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout146 net147 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__clkbuf_4
Xfanout168 net169 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__buf_2
Xfanout135 net138 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__clkbuf_4
Xfanout124 net3 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__clkbuf_4
Xfanout157 net158 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__buf_2
X_3815__86 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_19_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1960_ net102 _1298_ VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3630_ net77 _1141_ _1142_ net78 _1172_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__a221o_1
X_2512_ net165 _1255_ VGND VGND VPWR VPWR _1851_ sky130_fd_sc_hd__nand2_1
X_2443_ net164 _1279_ VGND VGND VPWR VPWR _1782_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3492_ _1052_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__clkbuf_1
X_3561_ _1058_ _1059_ _1060_ _1080_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_11_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2374_ _1711_ _1712_ _1710_ VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__nand3b_1
Xclone9 rising _0931_ _1015_ _1016_ _1018_ VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__o311a_2
XFILLER_0_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3828_ net181 _0096_ net128 VGND VGND VPWR VPWR tC\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_57_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Left_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2090_ net12 _1418_ _1427_ _1428_ VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__a31o_1
XFILLER_0_45_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2992_ _0598_ _0530_ _0599_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__nand3_1
XFILLER_0_0_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1943_ _1269_ _1280_ _1281_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__o21ai_1
X_3613_ _0992_ tC\[11\] tC\[10\] _1155_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__o22ai_1
X_2426_ _1732_ _1733_ _1763_ _1764_ VGND VGND VPWR VPWR _1765_ sky130_fd_sc_hd__a211oi_2
X_3475_ delta\[6\] _1025_ _1040_ net94 VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__a22o_1
X_3544_ _1101_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__clkbuf_1
X_2288_ _1624_ _1625_ _1626_ VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__a21boi_2
X_2357_ _1692_ _1691_ _1663_ _1662_ VGND VGND VPWR VPWR _1696_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_62_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3260_ _0866_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3191_ _0799_ _0797_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__xor2_1
X_2142_ net159 _1457_ _1360_ net155 VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__a22oi_1
X_2211_ _1533_ _1549_ VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__xnor2_2
X_2073_ _1408_ _1411_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__xnor2_1
X_2975_ _0583_ _0508_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1926_ state\[2\] net84 net55 VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_24_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3527_ delta\[11\] counter\[11\] _1086_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__a21o_1
X_2409_ _1734_ _1746_ _1747_ VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__nand3_4
X_3458_ delta\[10\] _1007_ _1019_ VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__o21ai_1
X_3389_ _0431_ _0962_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__nor2_1
XFILLER_0_39_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_2 net124 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_53_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2691_ _0264_ _0267_ _0298_ _0299_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__a211o_1
X_3776__47 clknet_3_1__leaf_clk VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__inv_2
X_2760_ net98 _0180_ _0361_ _0368_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__a31o_1
X_3243_ _1391_ _1393_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__and2b_1
X_3312_ tB\[2\] _0907_ net92 VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__mux2_1
X_3174_ _1357_ _1365_ _1372_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__and3_1
X_2056_ _1381_ _1386_ _1394_ VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__o21ai_1
Xrebuffer14 net296 VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__clkbuf_1
X_2125_ _1460_ _1463_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2958_ _1838_ _0561_ _0562_ _0566_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__a211o_4
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2889_ _1899_ _1901_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__nor2_1
X_3790__61 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__inv_2
XFILLER_0_4_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3733__4 clknet_3_7__leaf_clk VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__inv_2
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2812_ _0393_ _0397_ _0418_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__a21oi_1
X_3861_ net214 _0129_ net133 VGND VGND VPWR VPWR counter\[14\] sky130_fd_sc_hd__dfrtp_1
X_2743_ net157 _0209_ _0202_ net153 VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__a22oi_1
X_2674_ _0271_ _0272_ _0282_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__and3_1
XFILLER_0_26_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3226_ _0833_ _0834_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__or2_1
X_3157_ _0724_ _0765_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__and2_1
X_3088_ _0695_ _0696_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__xnor2_1
X_2039_ _1376_ _1377_ VGND VGND VPWR VPWR _1378_ sky130_fd_sc_hd__xor2_2
X_2108_ _1250_ net28 _1445_ _1446_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_32_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer5 _0612_ VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__clkbuf_1
X_3746__17 clknet_3_6__leaf_clk VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__inv_2
XFILLER_0_2_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3011_ _0617_ _0619_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_64_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2390_ _1725_ _1727_ _1728_ _1718_ VGND VGND VPWR VPWR _1729_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_58_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3844_ net197 _0112_ net136 VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_14_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2726_ _0333_ _0334_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout103 net8 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__buf_4
Xfanout147 net16 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__buf_2
Xfanout114 net116 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__clkbuf_4
Xfanout136 net138 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__clkbuf_4
X_2657_ _0199_ _1909_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__xnor2_1
X_2588_ _0185_ _0190_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout125 net126 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__buf_2
X_3760__31 clknet_3_0__leaf_clk VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__inv_2
X_3209_ _0810_ _0816_ _0817_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__a21o_1
Xfanout169 net11 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__buf_2
Xfanout158 net13 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_64_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3560_ _1113_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__clkbuf_1
X_2442_ net159 _1267_ VGND VGND VPWR VPWR _1781_ sky130_fd_sc_hd__nand2_1
X_2511_ _1781_ _1849_ VGND VGND VPWR VPWR _1850_ sky130_fd_sc_hd__xor2_1
XFILLER_0_59_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2373_ net162 _1433_ _1431_ net158 VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__a22o_1
X_3491_ _1003_ _1050_ _1051_ VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_20_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3689_ net82 VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__inv_2
X_2709_ _0215_ _0212_ _0214_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__a21o_1
X_3827_ net180 _0095_ net128 VGND VGND VPWR VPWR tC\[0\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2991_ _0598_ _0599_ _0530_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__a21o_1
XFILLER_0_56_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1942_ net106 _1268_ _1279_ net102 VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__a22o_1
X_3612_ counter\[10\] VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__inv_2
XFILLER_0_3_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3543_ net79 _1100_ net95 VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__mux2_1
X_2356_ _1694_ _1477_ VGND VGND VPWR VPWR _1695_ sky130_fd_sc_hd__xor2_1
X_2425_ _1754_ net73 _1758_ net265 VGND VGND VPWR VPWR _1764_ sky130_fd_sc_hd__o211a_1
X_3474_ _1037_ _1039_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2287_ _1609_ _1623_ _1610_ VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__nand3_1
XFILLER_0_51_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_3_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3190_ _0784_ _0796_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__nor2_1
X_2210_ _1538_ _1548_ VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_21_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2141_ net164 _1342_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__nand2_1
X_2072_ _1409_ _1410_ VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__xor2_1
X_2974_ net146 _1278_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__nand2_2
XFILLER_0_56_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1925_ net106 _1257_ VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__nand2_1
XFILLER_0_16_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3526_ _1056_ _1084_ _1085_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_12_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2408_ _1677_ _1672_ _1676_ VGND VGND VPWR VPWR _1747_ sky130_fd_sc_hd__a21o_1
X_2339_ _1672_ _1676_ _1677_ VGND VGND VPWR VPWR _1678_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3457_ _1026_ _1028_ net290 _1025_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__a2bb2o_1
X_3388_ counter\[2\] _0963_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_33_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_51_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_3 net154 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3311_ _1906_ _0903_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__xnor2_1
X_2690_ _0285_ _0286_ _0297_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_21_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_60_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3173_ _0567_ _0675_ _0776_ _0781_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__a31o_4
X_2124_ _1461_ _1462_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__xnor2_2
X_3242_ _1313_ _1311_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__xnor2_1
X_2055_ _1391_ _1393_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__xnor2_1
Xrebuffer15 _1597_ VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2888_ _0495_ _0496_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__and2b_1
X_2957_ _1906_ _0563_ _0564_ _0560_ _0565_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__a41o_1
XFILLER_0_32_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3509_ counter\[0\] delta\[0\] VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2811_ _0393_ _0397_ _0419_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__nand3_1
X_2742_ net161 _1580_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__nand2_1
X_3860_ net213 _0128_ net133 VGND VGND VPWR VPWR counter\[13\] sky130_fd_sc_hd__dfrtp_2
X_2673_ _0274_ _0281_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__xor2_1
X_3156_ _0722_ _0723_ _0720_ _0721_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__o211ai_1
X_3225_ _0832_ _0831_ _0756_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__nor3_1
X_3087_ net147 _1255_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__nand2_1
X_2107_ net90 net44 state\[3\] VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_64_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2038_ net119 _1261_ VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer6 net269 VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3010_ _0583_ _0508_ _0618_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_3_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3843_ net196 _0111_ net136 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_61_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2656_ _0262_ _0263_ _0232_ net76 VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__a211o_1
XFILLER_0_14_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2725_ _0322_ _0324_ net266 _0320_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__a22oi_2
Xfanout104 net294 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__buf_4
Xfanout115 net116 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout159 net160 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__buf_4
Xfanout148 net149 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__clkbuf_4
Xfanout137 net138 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__clkbuf_2
X_2587_ _0192_ _0194_ _0195_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__o21ba_1
Xfanout126 net127 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__buf_2
X_3139_ _0745_ _0746_ _0747_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__nand3_1
X_3208_ _0745_ _0809_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__nor2_1
XFILLER_0_49_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3806__77 clknet_3_2__leaf_clk VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__inv_2
XFILLER_0_70_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2510_ net155 _1278_ VGND VGND VPWR VPWR _1849_ sky130_fd_sc_hd__nand2_1
X_3490_ delta\[0\] net273 delta\[1\] VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__a21o_1
X_2441_ _1552_ _1562_ _1561_ VGND VGND VPWR VPWR _1780_ sky130_fd_sc_hd__a21oi_2
X_2372_ net169 _1417_ VGND VGND VPWR VPWR _1711_ sky130_fd_sc_hd__nand2_1
XFILLER_0_61_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3826_ net179 net93 net136 VGND VGND VPWR VPWR state\[4\] sky130_fd_sc_hd__dfrtp_4
X_3820__91 clknet_3_5__leaf_clk VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__inv_2
X_3688_ _0932_ net284 _1175_ _1228_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__a22o_1
X_2639_ _0236_ _0246_ _0247_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__nand3_4
X_2708_ _0310_ _0315_ _0316_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2990_ _0597_ _0596_ _0595_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__a21bo_1
X_1941_ net106 _1279_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__nand2_2
XFILLER_0_28_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3611_ _1144_ tC\[7\] tC\[6\] _0975_ _1153_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__o221a_1
X_3473_ delta\[5\] delta\[4\] _1004_ delta\[6\] VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__o31a_1
XFILLER_0_10_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3542_ _1090_ _1099_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__xor2_1
X_2286_ _1521_ _1532_ VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__xor2_2
X_2355_ net277 _1260_ VGND VGND VPWR VPWR _1694_ sky130_fd_sc_hd__nand2_1
X_2424_ _1759_ _1760_ _1762_ VGND VGND VPWR VPWR _1763_ sky130_fd_sc_hd__and3_1
XFILLER_0_19_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3797__68 clknet_3_3__leaf_clk VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__inv_2
XFILLER_0_53_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2140_ net159 net155 _1292_ _1326_ VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__and4_1
X_2071_ net99 _1267_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__nand2_2
X_2973_ _0578_ _0579_ _0581_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__nand3_1
X_1924_ net106 _1257_ _1262_ VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__and3_2
XFILLER_0_16_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3525_ delta\[10\] counter\[10\] VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__nand2_1
X_3456_ delta\[12\] _1008_ _0932_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__a21o_1
X_2269_ _1564_ _1607_ VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__xnor2_2
X_2338_ _1665_ _1671_ _1666_ VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__nand3_1
X_2407_ _1741_ _1744_ _1745_ VGND VGND VPWR VPWR _1746_ sky130_fd_sc_hd__a21bo_1
X_3387_ net171 _0962_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_62_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3310_ _0906_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__clkbuf_1
X_3172_ _0777_ _0778_ _0780_ _0763_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__o22ai_2
X_3241_ _0782_ _0828_ _0845_ _0849_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__a31o_1
X_2123_ _1403_ _1402_ VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__and2b_1
Xrebuffer16 _1766_ VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__clkbuf_1
X_2054_ _1346_ _1348_ _1392_ net114 VGND VGND VPWR VPWR _1393_ sky130_fd_sc_hd__a22o_1
X_2956_ _0499_ _0559_ _1903_ _1905_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__a211oi_1
X_2887_ _1731_ _1766_ _1765_ _0490_ _0492_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__o32a_1
XFILLER_0_32_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3767__38 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__inv_2
X_3508_ delta\[1\] counter\[1\] VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3439_ counter\[2\] VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__inv_2
XFILLER_0_35_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3781__52 clknet_3_4__leaf_clk VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__inv_2
XFILLER_0_58_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2672_ _0279_ _0280_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__nor2_1
X_2810_ _0399_ _0417_ _0418_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__a21o_1
X_2741_ _0316_ _0310_ _0315_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__nand3_1
X_3224_ _0831_ _0756_ _0832_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__o21a_1
XFILLER_0_1_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
.ends
