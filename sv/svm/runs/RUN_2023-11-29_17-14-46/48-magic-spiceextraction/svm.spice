* NGSPICE file created from svm.ext - technology: sky130A

.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.97
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.97
.ends

.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
X0 X a_35_297# a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.26 ps=2.52 w=1 l=0.15
X1 X B a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.25 pd=1.42 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_117_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 VPWR B a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.25 ps=1.42 w=0.65 l=0.15
X7 a_285_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A a_117_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=0.59
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=0.59
.ends

.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_109_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
X0 VPWR B a_207_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.228 pd=1.74 as=0.0609 ps=0.71 w=0.42 l=0.15
X1 X a_207_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.228 ps=1.74 w=1 l=0.15
X2 a_297_47# a_27_413# a_207_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0504 pd=0.66 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_207_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.99 w=0.65 l=0.15
X4 a_207_413# a_27_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0609 pd=0.71 as=0.0714 ps=0.76 w=0.42 l=0.15
X5 VPWR A_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0714 pd=0.76 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VGND B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.99 as=0.0504 ps=0.66 w=0.42 l=0.15
X7 a_27_413# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 a_81_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.257 ps=1.44 w=0.65 l=0.15
X1 a_299_297# B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_299_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 a_384_47# A1 a_81_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
X0 a_377_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.365 ps=1.73 w=1 l=0.15
X1 a_47_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.3 ps=2.6 w=1 l=0.15
X2 a_129_47# B a_47_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_285_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 Y a_47_47# a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_129_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0683 ps=0.86 w=0.65 l=0.15
X6 VPWR A a_47_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.365 pd=1.73 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_47_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.165 ps=1.33 w=1 l=0.15
X8 Y B a_377_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=2.89
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=2.89
.ends

.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.05
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.05
.ends

.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X3 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X4 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X5 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.301 ps=2.66 w=1 l=0.15
X7 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X8 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X10 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X12 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X13 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X14 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X15 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X16 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X17 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X18 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X20 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X21 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X22 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.209 ps=2.02 w=0.65 l=0.15
X23 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X24 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X25 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X26 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X27 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X1 a_80_21# C1 a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X2 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_300_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.26 ps=1.45 w=0.65 l=0.15
X6 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_80_21# A1 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 a_472_297# B1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X9 a_80_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
X0 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.157 ps=1.17 w=0.42 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.157 pd=1.17 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X6 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_382_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X1 a_297_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X2 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.327 pd=1.65 as=0.28 ps=2.56 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.327 ps=1.65 w=1 l=0.15
X6 a_382_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.195 ps=1.39 w=1 l=0.15
X7 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VPWR C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 a_181_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VGND C a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.132 pd=1.14 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 a_27_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X6 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.132 ps=1.14 w=0.65 l=0.15
X7 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 a_78_199# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 VPWR A1 a_493_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X2 a_493_297# A2 a_78_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.235 ps=1.47 w=1 l=0.15
X3 VPWR a_78_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.373 pd=1.75 as=0.28 ps=2.56 w=1 l=0.15
X4 VGND A2 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X5 a_78_199# B2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.235 pd=1.47 as=0.117 ps=1.24 w=1 l=0.15
X6 a_215_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_215_47# B2 a_78_199# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_292_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.117 pd=1.24 as=0.373 ps=1.75 w=1 l=0.15
X9 VGND a_78_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
X0 VPWR a_75_212# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 a_75_212# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 a_75_212# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND a_75_212# X VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A a_113_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_113_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
X0 a_27_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_560_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X2 VGND B a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0991 ps=0.955 w=0.65 l=0.15
X3 Y B a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_297# a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_474_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X7 VGND A a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# B a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X12 a_474_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_560_47# a_27_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X14 VPWR A a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X15 Y a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X16 VPWR a_27_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X17 a_560_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_199_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_113_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.147 ps=1.29 w=1 l=0.15
X2 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X3 VPWR A1 a_113_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.29 as=0.14 ps=1.28 w=1 l=0.15
X4 a_113_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A2 a_199_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0959 ps=0.945 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
X0 VGND A a_68_297# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_68_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_68_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR A a_150_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 X a_68_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.34 pd=2.68 as=0.146 ps=1.34 w=1 l=0.15
X5 a_150_297# B a_68_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.091 ps=0.93 w=0.65 l=0.15
X1 Y B1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.175 ps=1.35 w=1 l=0.15
X4 a_29_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y A2 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND A1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 a_112_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X8 a_112_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.14 ps=1.28 w=1 l=0.15
X9 a_29_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X11 a_29_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.149 ps=1.33 w=1 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.149 pd=1.33 as=0.166 ps=1.8 w=0.64 l=0.15
X3 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X4 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.42 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0703 pd=0.755 as=0.111 ps=1.37 w=0.42 l=0.15
X6 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.14 ps=1.28 w=1 l=0.15
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0703 ps=0.755 w=0.42 l=0.15
X8 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.165 ps=1.33 w=1 l=0.15
X9 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.745 as=0.111 ps=1.37 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.162 ps=1.33 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_467_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_467_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_109_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A2 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_109_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
X0 VPWR a_505_21# a_535_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_505_21# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.0693 ps=0.75 w=0.42 l=0.15
X2 a_218_374# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0767 pd=0.785 as=0.158 ps=1.39 w=0.42 l=0.15
X3 VGND a_505_21# a_439_47# VNB sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.11 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 a_76_199# A0 a_218_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.193 pd=1.34 as=0.0767 ps=0.785 w=0.42 l=0.15
X5 a_505_21# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.145 ps=1.11 w=0.42 l=0.15
X6 a_439_47# A0 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0997 ps=0.895 w=0.42 l=0.15
X7 a_535_374# A1 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.193 ps=1.34 w=0.42 l=0.15
X8 a_76_199# A1 a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0997 pd=0.895 as=0.0693 ps=0.75 w=0.42 l=0.15
X9 a_218_47# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.113 ps=1.04 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.158 pd=1.39 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.04 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
X0 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_161_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X2 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_161_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A a_161_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_161_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_226_47# A2_N a_226_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_489_413# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_226_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.167 ps=1.43 w=0.42 l=0.15
X3 VPWR B2 a_489_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_489_413# a_226_47# a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_76_199# a_226_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.139 ps=1.08 w=0.42 l=0.15
X6 VGND B1 a_556_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_556_47# B2 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VGND A2_N a_226_47# VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.08 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_226_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.12 ps=1.09 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.43 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.09 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_475_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A1 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X9 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.27 pd=1.48 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X12 a_475_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 Y A2 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X14 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.27 ps=1.48 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
X0 VPWR B a_59_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 X a_59_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.475 pd=2.95 as=0.167 ps=1.39 w=1 l=0.15
X2 VGND B a_145_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_59_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X4 X a_59_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.112 ps=1.04 w=0.65 l=0.15
X5 a_145_75# A a_59_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 Y A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.174 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.182 pd=1.92 as=0.174 ps=1.39 w=0.7 l=0.15
X2 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X3 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0683 ps=0.86 w=0.65 l=0.15
X1 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=2.1 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A1 a_114_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
X3 a_114_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.185 ps=1.87 w=0.65 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.28 ps=2.56 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X10 a_285_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.091 ps=0.93 w=0.65 l=0.15
X11 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_298_297# a_27_413# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.265 ps=2.53 w=1 l=0.15
X1 a_215_297# a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.136 ps=1.1 w=0.65 l=0.15
X2 a_298_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.258 ps=1.45 w=0.65 l=0.15
X4 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X6 a_382_47# A1 a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.136 pd=1.1 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VPWR A1 a_298_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND A2 a_382_47# VNB sky130_fd_pr__nfet_01v8 ad=0.258 pd=1.45 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_470_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_470_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_470_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.106 ps=0.975 w=0.65 l=0.15
X6 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X8 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X10 a_470_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.162 ps=1.33 w=1 l=0.15
X11 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 VPWR B a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X13 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X16 X a_112_47# a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 a_470_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X18 X B a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.35 as=0.265 ps=2.53 w=1 l=0.15
X1 a_209_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.172 ps=1.35 w=1 l=0.15
X2 a_303_47# A2 a_209_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.104 ps=0.97 w=0.65 l=0.15
X3 a_209_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.112 ps=0.995 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.172 ps=1.83 w=0.65 l=0.15
X5 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.107 ps=0.98 w=0.65 l=0.15
X6 a_80_21# A1 a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X7 VPWR A2 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.16 ps=1.32 w=1 l=0.15
X8 a_80_21# B1 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X9 a_209_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X1 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0926 ps=0.935 w=0.65 l=0.15
X2 VPWR A1 a_307_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.105 ps=1.21 w=1 l=0.15
X3 a_307_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.233 ps=1.47 w=1 l=0.15
X4 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.233 pd=1.47 as=0.112 ps=1.23 w=1 l=0.15
X6 a_109_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.112 pd=1.23 as=0.26 ps=2.52 w=1 l=0.15
X7 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y A1 a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.119 ps=1.01 w=0.65 l=0.15
X1 a_181_47# A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.0683 ps=0.86 w=0.65 l=0.15
X2 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.106 ps=0.975 w=0.65 l=0.15
X3 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.162 ps=1.33 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.153 ps=1.3 w=1 l=0.15
X6 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
X0 X a_29_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.148 ps=1.34 w=1 l=0.15
X1 a_111_297# C a_29_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_29_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.102 ps=0.99 w=0.65 l=0.15
X3 a_183_297# B a_111_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 VPWR A a_183_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X5 a_29_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VGND C a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
X0 VPWR A a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_218_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.156 ps=1.16 w=0.42 l=0.15
X2 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.156 pd=1.16 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_300_297# a_27_53# a_218_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_218_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 VPWR a_218_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_218_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X7 VGND a_218_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 VGND A a_218_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
X0 VPWR A a_49_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VGND a_285_47# a_391_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.5
X2 X a_391_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VGND A a_49_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR a_285_47# a_391_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.5
X5 a_285_47# a_49_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X6 a_285_47# a_49_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X7 X a_391_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
D0 VNB DIODE sky130_fd_pr__diode_pw2nd_05v5 pj=2.64e+06 area=4.347e+11
.ends

.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
X0 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X5 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X17 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X21 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X23 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X36 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X39 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
X0 VPWR D a_343_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.46 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_223_47# B_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.5 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 a_515_93# a_223_47# a_429_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 a_223_47# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.134 pd=1.48 as=0.0588 ps=0.7 w=0.42 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.168 ps=1.64 w=0.42 l=0.15
X5 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.168 ps=1.64 w=0.42 l=0.15
X6 X a_343_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.172 ps=1.46 w=1 l=0.15
X7 a_429_93# a_27_47# a_343_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.118 ps=1.4 w=0.42 l=0.15
X8 VGND D a_615_93# VNB sky130_fd_pr__nfet_01v8 ad=0.126 pd=1.11 as=0.0777 ps=0.79 w=0.42 l=0.15
X9 a_343_93# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X10 a_343_93# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.122 ps=1.42 w=0.42 l=0.15
X11 a_615_93# C a_515_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X12 X a_343_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.82 as=0.126 ps=1.11 w=0.65 l=0.15
X13 VPWR a_223_47# a_343_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__inv_4 A VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X2 a_193_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y A a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X4 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 a_109_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.16 ps=1.32 w=1 l=0.15
X1 a_27_297# B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X2 VGND A2 a_373_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.114 ps=1 w=0.65 l=0.15
X3 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X4 a_27_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.253 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.253 ps=2.52 w=1 l=0.15
X6 a_373_47# A1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.96 w=0.65 l=0.15
X8 a_109_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
X0 VGND A_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X1 Y a_27_93# a_206_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_206_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR a_27_93# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X5 VPWR A_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
X0 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=1.67 w=1 l=0.15
X1 VGND A_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0.194 pd=1.95 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VGND B a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y a_27_93# a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 a_229_47# a_27_93# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.147 ps=1.34 w=1 l=0.15
X6 VPWR a_27_93# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.335 pd=1.67 as=0.165 ps=1.33 w=1 l=0.15
X7 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.135 ps=1.27 w=1 l=0.15
X8 a_229_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR A_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 VGND A2 a_660_47# VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.0829 ps=0.905 w=0.65 l=0.15
X1 VGND C1 a_85_193# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.101 ps=0.96 w=0.65 l=0.15
X2 a_414_297# C1 a_334_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.125 ps=1.25 w=1 l=0.15
X3 VGND a_85_193# X VNB sky130_fd_pr__nfet_01v8 ad=0.275 pd=1.5 as=0.214 ps=1.96 w=0.65 l=0.15
X4 a_334_297# D1 a_85_193# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.125 pd=1.25 as=0.385 ps=2.77 w=1 l=0.15
X5 a_516_297# B1 a_414_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=1.56 as=0.18 ps=1.36 w=1 l=0.15
X6 a_516_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.135 ps=1.27 w=1 l=0.15
X7 a_660_47# A1 a_85_193# VNB sky130_fd_pr__nfet_01v8 ad=0.0829 pd=0.905 as=0.185 ps=1.22 w=0.65 l=0.15
X8 a_85_193# D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.275 ps=1.5 w=0.65 l=0.15
X9 VPWR A1 a_516_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=1.56 w=1 l=0.15
X10 a_85_193# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.22 as=0.117 ps=1.01 w=0.65 l=0.15
X11 VPWR a_85_193# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.29 ps=2.58 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_4 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_1021_47# A1 a_205_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 X a_205_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 VPWR a_205_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_205_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VGND A2 a_1021_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND a_42_47# a_205_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_861_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.101 ps=0.96 w=0.65 l=0.15
X7 a_205_21# A1 a_861_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0747 ps=0.88 w=0.65 l=0.15
X8 X a_205_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 a_603_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND B1_N a_42_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.25 ps=2.07 w=0.65 l=0.15
X11 VPWR A2 a_603_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_603_297# a_42_47# a_205_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 VPWR a_205_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.14 ps=1.28 w=1 l=0.15
X14 a_205_21# a_42_47# a_603_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND a_205_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.263 pd=1.46 as=0.091 ps=0.93 w=0.65 l=0.15
X16 VPWR B1_N a_42_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X17 VGND a_205_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VPWR A1 a_603_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 a_603_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 a_205_21# a_42_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.263 ps=1.46 w=0.65 l=0.15
X21 X a_205_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_77_199# B2 a_227_47# VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.127 ps=1.04 w=0.65 l=0.15
X1 a_323_297# A2 a_227_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.165 ps=1.33 w=1 l=0.15
X2 a_227_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_227_47# B1 a_77_199# VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.133 ps=1.06 w=0.65 l=0.15
X4 VGND a_77_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR B1 a_539_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.205 ps=1.41 w=1 l=0.15
X6 a_227_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X7 VPWR a_77_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=2.67 w=1 l=0.15
X8 a_77_199# A3 a_323_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X9 VGND A2 a_227_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 a_227_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_539_297# B2 a_77_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=1.41 as=0.195 ps=1.39 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_222_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X1 VPWR A1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.105 ps=1.21 w=1 l=0.15
X2 VGND a_79_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_222_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.186 ps=1.41 w=0.42 l=0.15
X4 VGND A2 a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_448_47# a_222_93# a_79_199# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_79_199# a_222_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.3 ps=2.6 w=1 l=0.15
X7 a_544_297# A2 a_79_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X8 a_448_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.186 pd=1.41 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_93_21# A1 a_346_47# VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.146 ps=1.1 w=0.65 l=0.15
X1 a_93_21# B1 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.185 ps=1.37 w=1 l=0.15
X2 a_584_47# B1 a_93_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.143 ps=1.09 w=0.65 l=0.15
X3 VPWR a_93_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.243 pd=1.49 as=0.33 ps=2.66 w=1 l=0.15
X4 VGND B2 a_584_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 a_256_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.167 ps=1.16 w=0.65 l=0.15
X6 a_250_297# B2 a_93_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 VGND a_93_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.167 pd=1.16 as=0.214 ps=1.96 w=0.65 l=0.15
X8 a_250_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.243 ps=1.49 w=1 l=0.15
X9 VPWR A2 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.225 pd=1.45 as=0.165 ps=1.33 w=1 l=0.15
X10 a_250_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.225 ps=1.45 w=1 l=0.15
X11 a_346_47# A2 a_256_47# VNB sky130_fd_pr__nfet_01v8 ad=0.146 pd=1.1 as=0.0975 ps=0.95 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_585_47# B1 a_266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.119 ps=1.01 w=0.65 l=0.15
X1 VGND A2 a_266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.137 pd=1.07 as=0.117 ps=1.01 w=0.65 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.62 as=0.26 ps=2.52 w=1 l=0.15
X3 a_81_21# C1 a_585_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.203 pd=1.27 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_266_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.312 ps=1.62 w=1 l=0.15
X6 a_368_297# A2 a_266_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.21 pd=1.42 as=0.18 ps=1.36 w=1 l=0.15
X7 a_266_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.137 ps=1.07 w=0.65 l=0.15
X8 a_266_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.203 ps=1.27 w=0.65 l=0.15
X9 a_81_21# A3 a_368_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.21 ps=1.42 w=1 l=0.15
X10 a_81_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.15 ps=1.3 w=1 l=0.15
X11 VPWR B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.138 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X7 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X11 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X12 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X14 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X15 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X16 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.155 ps=1.31 w=1 l=0.15
X20 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
X0 a_109_93# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_215_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 VGND a_109_93# a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND A a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 VPWR A a_369_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_369_297# B a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_215_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X7 a_297_297# a_109_93# a_215_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_109_93# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 X a_215_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.1 ps=0.985 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_197_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0798 pd=0.8 as=0.0609 ps=0.71 w=0.42 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.312 ps=1.68 w=1 l=0.15
X3 a_303_47# C a_197_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0798 ps=0.8 w=0.42 l=0.15
X4 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.68 as=0.0588 ps=0.7 w=0.42 l=0.15
X6 VGND D a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.196 pd=1.33 as=0.0693 ps=0.75 w=0.42 l=0.15
X7 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X8 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.196 ps=1.33 w=0.65 l=0.15
X9 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4bb_1 A B C_N D_N VGND VNB VPB VPWR X
X0 VGND A a_311_413# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 VPWR A a_561_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0598 ps=0.705 w=0.42 l=0.15
X2 a_393_413# a_205_93# a_311_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.122 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND C_N a_27_410# VNB sky130_fd_pr__nfet_01v8 ad=0.0619 pd=0.715 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR C_N a_27_410# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.123 pd=1.32 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_311_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X6 VGND a_27_410# a_311_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0598 ps=0.705 w=0.42 l=0.15
X7 a_561_297# B a_489_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0598 pd=0.705 as=0.0441 ps=0.63 w=0.42 l=0.15
X8 a_205_93# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0619 ps=0.715 w=0.42 l=0.15
X9 a_205_93# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.123 ps=1.32 w=0.42 l=0.15
X10 a_489_297# a_27_410# a_393_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.122 ps=1.33 w=0.42 l=0.15
X11 a_311_413# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X12 a_311_413# a_205_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0598 pd=0.705 as=0.109 ps=1.36 w=0.42 l=0.15
X13 X a_311_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.102 ps=0.99 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32oi_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.338 pd=1.67 as=0.135 ps=1.27 w=1 l=0.15
X5 a_1249_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_1249_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.252 pd=1.5 as=0.338 ps=1.67 w=1 l=0.15
X12 a_803_47# A2 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X16 a_803_47# A2 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X20 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X21 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_1249_47# A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.133 ps=1.06 w=0.65 l=0.15
X23 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 a_1249_47# A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.252 ps=1.5 w=1 l=0.15
X28 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X30 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X32 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X35 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 VGND A3 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X37 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VGND A3 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkinv_4 A VGND VNB VPB VPWR Y
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.166 pd=1.63 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.345 pd=2.69 as=0.14 ps=1.28 w=1 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X6 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.305 ps=2.61 w=1 l=0.15
X7 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.139 ps=1.5 w=0.42 l=0.15
X8 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32ai_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 a_1224_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 VPWR A1 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.183 ps=1.37 w=1 l=0.15
X2 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_806_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.205 ps=1.28 w=0.65 l=0.15
X8 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.205 pd=1.28 as=0.14 ps=1.08 w=0.65 l=0.15
X10 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_806_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A3 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y A3 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X19 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.119 ps=1.01 w=0.65 l=0.15
X22 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0926 ps=0.935 w=0.65 l=0.15
X24 a_806_297# A2 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X25 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.142 ps=1.28 w=1 l=0.15
X28 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_1224_297# A2 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 a_1224_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.183 pd=1.37 as=0.135 ps=1.27 w=1 l=0.15
X32 a_806_297# A2 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 VPWR A1 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X35 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X36 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X37 a_1224_297# A2 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X38 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X39 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.26 ps=1.45 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.4 ps=1.8 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.205 pd=1.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.135 ps=1.27 w=1 l=0.15
X5 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_109_297# C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_300_297# a_27_413# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X3 Y a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.102 ps=0.99 w=0.65 l=0.15
X4 VPWR A1 a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 a_384_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.143 ps=1.09 w=0.65 l=0.15
X6 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.111 ps=1.37 w=0.42 l=0.15
X7 a_300_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
X0 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X5 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X7 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_33_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND A1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_33_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_797_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_797_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y B2 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR B1 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_33_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 a_33_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_33_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_33_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_797_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.16 ps=1.32 w=1 l=0.15
X17 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR B1 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND A2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_33_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 a_797_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.135 ps=1.27 w=1 l=0.15
X24 Y B2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 Y B2 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 Y B1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.104 ps=0.97 w=0.65 l=0.15
X27 Y B2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 Y B1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_33_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.29 ps=2.58 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 Y a_61_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.183 ps=1.24 w=0.65 l=0.15
X1 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_217_297# a_61_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_479_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X4 a_217_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X5 Y a_61_47# a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 VPWR A1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_61_47# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VGND A2 a_637_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_61_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A1 a_479_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0683 ps=0.86 w=0.65 l=0.15
X11 VGND B1_N a_61_47# VNB sky130_fd_pr__nfet_01v8 ad=0.183 pd=1.24 as=0.126 ps=1.44 w=0.42 l=0.15
X12 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X13 a_637_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VGND A1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
X1 a_510_47# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.143 ps=1.09 w=0.65 l=0.15
X2 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.175 ps=1.35 w=1 l=0.15
X3 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.22 ps=1.44 w=1 l=0.15
X4 a_79_21# A2 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.22 pd=1.44 as=0.162 ps=1.33 w=1 l=0.15
X5 a_297_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X6 a_79_21# C1 a_510_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.114 ps=1 w=0.65 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X8 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
X9 a_215_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.106 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X3 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X4 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X5 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=2.61 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X8 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X9 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X12 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X14 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X15 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X16 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X17 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X18 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X19 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X20 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X21 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X23 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X24 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X25 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X28 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X29 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X30 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X31 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X32 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
X33 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4bb_4 A B C_N D_N VGND VNB VPB VPWR X
X0 VPWR a_315_380# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_315_380# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X2 a_315_380# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND C_N a_27_410# VNB sky130_fd_pr__nfet_01v8 ad=0.0619 pd=0.715 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR C_N a_27_410# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.123 pd=1.32 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VPWR A a_583_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_27_410# a_315_380# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X7 a_583_297# B a_499_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_315_380# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_397_297# a_205_93# a_315_380# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.258 ps=2.52 w=1 l=0.15
X10 X a_315_380# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X11 X a_315_380# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_499_297# a_27_410# a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.18 ps=1.36 w=1 l=0.15
X13 VPWR a_315_380# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 a_205_93# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0619 ps=0.715 w=0.42 l=0.15
X15 a_205_93# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.4 as=0.123 ps=1.32 w=0.42 l=0.15
X16 VGND a_315_380# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND a_315_380# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_315_380# a_205_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.169 ps=1.82 w=0.65 l=0.15
X19 X a_315_380# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X7 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.38 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X11 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X18 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_240_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_51_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A1 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_51_297# B2 a_245_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.412 pd=1.83 as=0.105 ps=1.21 w=1 l=0.15
X4 a_149_47# C1 a_51_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.201 ps=1.92 w=0.65 l=0.15
X5 a_240_47# B1 a_149_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0991 ps=0.955 w=0.65 l=0.15
X6 VPWR A1 a_512_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X7 X a_51_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.165 ps=1.33 w=1 l=0.15
X8 a_149_47# B2 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_245_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X10 VPWR C1 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.34 ps=2.68 w=1 l=0.15
X11 a_512_297# A2 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.412 ps=1.83 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y A3 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_449_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 Y A3 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y B1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_449_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.263 ps=2.57 w=1 l=0.15
X8 Y B1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_31_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_297# A2 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.261 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 a_31_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 a_31_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_31_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_449_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X20 VGND A2 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 VGND A2 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VGND A3 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.223 pd=1.34 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_31_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.223 ps=1.34 w=0.65 l=0.15
X25 a_27_297# A2 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND A3 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 a_31_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X28 a_449_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 a_31_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 a_31_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.272 ps=2.56 w=1 l=0.15
X15 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X17 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X19 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X24 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.257 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X30 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X38 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
X0 Y a_53_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.192 ps=1.38 w=1 l=0.15
X1 a_232_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.192 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A_N a_53_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A_N a_53_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_316_47# B a_232_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y a_53_93# a_316_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.125 ps=1.03 w=0.65 l=0.15
X7 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.385 pd=1.77 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X9 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.385 ps=1.77 w=1 l=0.15
X14 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X21 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X31 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_39_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=1 w=0.65 l=0.15
X2 VPWR a_39_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_39_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.156 ps=1.36 w=1 l=0.15
X4 VGND a_39_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.156 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VGND A a_39_297# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=1 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_39_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_206_369# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.146 ps=1.34 w=0.42 l=0.15
X1 a_206_369# A2_N a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 VGND B2 a_489_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_585_369# B2 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0672 ps=0.74 w=0.42 l=0.15
X4 a_489_47# a_206_369# a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_489_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VPWR A2_N a_206_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.209 pd=1.35 as=0.129 ps=1.18 w=0.42 l=0.15
X7 a_76_199# a_206_369# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.74 as=0.209 ps=1.35 w=0.42 l=0.15
X8 a_205_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0662 pd=0.735 as=0.0986 ps=0.98 w=0.42 l=0.15
X9 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.26 ps=2.52 w=1 l=0.15
X10 VPWR B1 a_585_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0986 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
X0 a_176_21# a_27_47# a_626_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X1 a_626_297# B a_542_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_542_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X8 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X12 a_176_21# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X13 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_2 A1 A2 B1_N VGND VNB VPB VPWR X
X0 VGND B1_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VGND A2 a_478_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.106 ps=0.975 w=0.65 l=0.15
X2 a_478_47# a_27_93# a_174_21# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_478_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 X a_174_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X5 VPWR a_174_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_174_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X7 VPWR A1 a_574_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.105 ps=1.21 w=1 l=0.15
X8 VGND a_174_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR B1_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X10 a_574_297# A2 a_174_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X11 a_174_21# a_27_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.395 ps=1.79 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o221ai_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
X0 Y A2 a_734_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_300_47# B2 a_28_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 a_300_47# B1 a_28_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_300_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_300_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_734_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.175 ps=1.35 w=1 l=0.15
X7 a_28_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C1 a_28_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR B1 a_382_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.135 ps=1.27 w=1 l=0.15
X11 a_382_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_28_47# B1 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_28_47# B2 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A1 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X15 Y B2 a_382_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 VPWR A1 a_734_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND A2 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_382_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X19 a_734_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_223_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 Y A1 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X3 a_223_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X4 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 VGND A2 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_223_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X7 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.123 ps=1.03 w=0.65 l=0.15
X8 VPWR A2 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 a_658_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.201 ps=1.27 w=0.65 l=0.15
X10 VPWR A1 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_223_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 a_658_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 Y a_27_47# a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_223_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X15 VPWR A2 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.155 ps=1.31 w=1 l=0.15
X16 VPWR A1 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 a_658_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VGND B1_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.27 ps=2.13 w=0.65 l=0.15
X19 a_223_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X20 a_658_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 VGND A2 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.27 as=0.091 ps=0.93 w=0.65 l=0.15
X23 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X24 Y A1 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X25 Y a_27_47# a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X21 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_27_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_277_297# B a_205_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VPWR A a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X5 a_205_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X6 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X7 VGND C a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0693 ps=0.75 w=0.42 l=0.15
X8 a_109_297# D a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X9 VGND A a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR A2 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 a_277_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X2 a_79_21# B1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X3 a_277_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_361_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_277_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.127 ps=1.04 w=0.65 l=0.15
X9 a_79_21# A1 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X8 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X11 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=1.37 as=0.0588 ps=0.7 w=0.42 l=0.15
X18 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X20 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X21 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X22 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X23 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X25 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X26 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X27 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X28 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X29 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X30 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X31 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X32 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X33 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X34 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X35 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X36 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X37 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X38 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X39 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0578 ps=0.695 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
X0 VGND C a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y a_27_47# a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y a_27_47# a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_633_47# B a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_633_47# B a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_215_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 a_215_47# B a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_215_47# B a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 a_633_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X17 a_633_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X20 a_215_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X23 VGND C a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X25 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_806_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_47# B1 a_1314_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=2.09 as=0.104 ps=0.97 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X17 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.0943 ps=0.94 w=0.65 l=0.15
X19 Y C1 a_978_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_27_47# B1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 a_806_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.675 pd=3.35 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.091 ps=0.93 w=0.65 l=0.15
X27 a_978_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.091 ps=0.93 w=0.65 l=0.15
X28 a_1314_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X31 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
X0 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X1 a_109_53# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_215_297# a_109_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_392_297# C a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0452 pd=0.635 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_465_297# B a_392_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.064 pd=0.725 as=0.0452 ps=0.635 w=0.42 l=0.15
X6 a_215_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 VPWR A a_465_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.064 ps=0.725 w=0.42 l=0.15
X8 a_297_297# a_109_53# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_109_53# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X10 VGND C a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.064 ps=0.725 w=0.42 l=0.15
X11 VGND A a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
X0 VPWR a_219_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.295 pd=2.59 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.202 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.17 pd=1.34 as=0.105 ps=1.21 w=1 l=0.15
X3 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.111 ps=0.99 w=0.65 l=0.15
X5 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X6 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=0.99 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_219_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND a_219_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.17 ps=1.34 w=1 l=0.15
X11 VGND a_219_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.214 pd=1.96 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.202 ps=1.4 w=0.65 l=0.15
X13 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a41o_2 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 a_381_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A2 a_381_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X2 a_465_47# A4 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_549_47# A3 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_665_47# A2 a_549_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.14 ps=1.08 w=0.65 l=0.15
X7 a_381_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A4 a_381_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_381_297# B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 a_79_21# A1 a_665_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 X a_79_204# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A1 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_473_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.195 ps=1.39 w=1 l=0.15
X3 X a_79_204# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X4 VGND C1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.104 ps=0.97 w=0.65 l=0.15
X5 a_79_204# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0926 ps=0.935 w=0.65 l=0.15
X6 VPWR a_79_204# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X7 a_473_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X8 a_473_297# B1 a_727_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.16 ps=1.32 w=1 l=0.15
X9 X a_79_204# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X10 VGND B1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.127 ps=1.04 w=0.65 l=0.15
X11 a_79_204# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.109 ps=0.985 w=0.65 l=0.15
X12 VGND a_79_204# X VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.0959 ps=0.945 w=0.65 l=0.15
X13 a_1123_47# A1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_555_297# B1 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X15 VPWR A2 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X16 VGND A2 a_1123_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.091 ps=0.93 w=0.65 l=0.15
X17 a_951_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.14 ps=1.08 w=0.65 l=0.15
X18 VPWR a_79_204# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_79_204# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X20 a_79_204# A1 a_951_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 a_79_204# C1 a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 a_727_297# C1 a_79_204# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X23 X a_79_204# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32ai_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X1 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X2 a_475_297# A2 a_729_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X3 a_729_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 VPWR A1 a_729_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X7 a_729_297# A2 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_475_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y A3 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X15 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.228 pd=2 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X19 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 VGND A4 a_321_47# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_321_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.123 ps=1.03 w=0.65 l=0.15
X2 a_103_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=1.52 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR a_103_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.425 ps=2.85 w=1 l=0.15
X4 VGND a_103_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.247 ps=2.06 w=0.65 l=0.15
X5 VGND A2 a_321_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X6 a_321_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.127 ps=1.04 w=0.65 l=0.15
X7 a_511_297# A3 a_393_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.22 ps=1.44 w=1 l=0.15
X8 a_619_297# A2 a_511_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X9 a_321_47# B1 a_103_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X10 a_393_297# A4 a_103_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.22 pd=1.44 as=0.26 ps=1.52 w=1 l=0.15
X11 VPWR A1 a_619_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.195 ps=1.39 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.135 ps=1.27 w=1 l=0.15
X3 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X17 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_803_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_803_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 VGND A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X30 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X31 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.28 ps=2.56 w=1 l=0.15
X1 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X4 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.177 ps=1.36 w=1 l=0.15
X7 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.105 ps=1.21 w=1 l=0.15
X9 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.117 ps=1.01 w=0.65 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.41 pd=1.82 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.175 ps=1.35 w=1 l=0.15
X4 a_277_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.41 ps=1.82 w=1 l=0.15
X10 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.18 ps=1.36 w=1 l=0.15
X11 a_277_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.114 ps=1 w=0.65 l=0.15
X13 Y A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.0975 ps=0.95 w=0.65 l=0.15
X14 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
X0 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X1 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND B a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111ai_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
X0 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_298_47# C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VGND A1 a_497_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X3 a_664_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.33 pd=2.66 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND A2 a_497_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_298_47# B1 a_497_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.176 ps=1.84 w=0.65 l=0.15
X7 a_497_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 Y D1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.224 ps=1.99 w=0.65 l=0.15
X9 a_497_47# B1 a_298_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 Y A2 a_664_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.295 ps=2.59 w=1 l=0.15
X12 a_27_47# C1 a_298_47# VNB sky130_fd_pr__nfet_01v8 ad=0.192 pd=1.89 as=0.091 ps=0.93 w=0.65 l=0.15
X13 VPWR D1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X14 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X15 a_27_47# D1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X16 a_497_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.214 pd=1.96 as=0.091 ps=0.93 w=0.65 l=0.15
X17 Y D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X18 VPWR A1 a_664_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X19 a_664_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_56_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A2 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_139_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.266 ps=2.12 w=0.65 l=0.15
X4 a_311_297# B1 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X5 Y C1 a_311_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X7 Y A1 a_139_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X16 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X17 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X20 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
X0 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR A a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_109_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 VPWR A a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VGND A a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 a_109_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.135 ps=1.27 w=1 l=0.15
X24 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_109_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X29 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 a_109_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X31 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
X0 a_27_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_27_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_277_297# B a_205_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VPWR A a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 a_205_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X6 VPWR a_27_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=2.61 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND a_27_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.91 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X9 VGND C a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0693 ps=0.75 w=0.42 l=0.15
X10 a_109_297# D a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND A a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 a_103_199# B1 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.107 ps=0.98 w=0.65 l=0.15
X1 VPWR a_103_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.36 ps=2.72 w=1 l=0.15
X2 a_337_297# A2 a_253_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_103_199# A3 a_337_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.165 ps=1.33 w=1 l=0.15
X4 a_253_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.195 ps=1.39 w=1 l=0.15
X5 VPWR B1 a_103_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.345 pd=2.69 as=0.213 ps=1.42 w=1 l=0.15
X6 VGND a_103_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.234 ps=2.02 w=0.65 l=0.15
X7 a_253_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X8 a_253_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X9 VGND A2 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
X0 VPWR a_30_53# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.315 pd=2.63 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND a_30_53# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_30_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X3 a_112_297# C a_30_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_30_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 VGND A a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 a_30_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 VGND C a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_184_297# B a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X9 VPWR A a_184_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31a_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 a_108_21# B1 a_346_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.107 ps=0.98 w=0.65 l=0.15
X1 a_346_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X2 X a_108_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.263 ps=2.11 w=0.65 l=0.15
X3 a_108_21# A3 a_430_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.165 ps=1.33 w=1 l=0.15
X4 a_430_297# A2 a_346_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR a_108_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.175 ps=1.35 w=1 l=0.15
X6 a_346_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.195 ps=1.39 w=1 l=0.15
X7 VGND A2 a_346_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_108_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.405 ps=2.81 w=1 l=0.15
X9 VPWR B1 a_108_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.34 pd=2.68 as=0.213 ps=1.42 w=1 l=0.15
X10 VGND a_108_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.114 ps=1 w=0.65 l=0.15
X11 a_346_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
X0 a_109_93# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_209_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X2 a_109_93# A_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_296_53# a_109_93# a_209_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.108 ps=1.36 w=0.42 l=0.15
X4 VPWR C a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0744 ps=0.815 w=0.42 l=0.15
X5 a_368_53# B a_296_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_209_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.122 ps=1.08 w=0.65 l=0.15
X7 a_209_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VPWR a_109_93# a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.108 ps=1.36 w=0.42 l=0.15
X9 VGND C a_368_53# VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.08 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VGND A2 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR A1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_37_297# B1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_485_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_292_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VPWR A2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X8 a_485_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X11 a_37_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 Y A1 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X13 Y C1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_292_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X15 a_292_297# B1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_286_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X2 a_286_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X3 Y A2 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 VGND A1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X6 VGND A2 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X7 a_487_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# B1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR A1 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_27_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X13 a_487_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X14 a_286_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
X0 VPWR A1 a_485_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_485_297# a_297_93# a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X2 a_297_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.108 ps=1.01 w=0.42 l=0.15
X3 a_581_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X4 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.01 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_79_21# a_297_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X6 VGND A2 a_581_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.182 pd=1.51 as=0.14 ps=1.28 w=1 l=0.15
X8 a_297_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.182 ps=1.51 w=0.42 l=0.15
X9 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X10 a_485_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X11 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_4 A B C D VGND VNB VPB VPWR Y
X0 a_27_47# C a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# C a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_445_47# B a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_445_47# B a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y A a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X14 Y A a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_803_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X17 a_803_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_445_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 a_803_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X23 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X24 a_445_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_803_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X30 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X31 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_397_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR B1_N a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X2 Y A2 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VGND A2 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND A1 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_28_297# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X6 Y a_28_297# a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VPWR a_28_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_397_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X9 a_229_47# a_28_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y a_28_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X11 a_229_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_229_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A1 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_388_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.127 pd=1.25 as=0.153 ps=1.3 w=1 l=0.15
X1 a_105_352# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_297_47# a_105_352# Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A1 a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.127 ps=1.25 w=1 l=0.15
X5 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X6 VPWR B1_N a_105_352# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.178 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 Y a_105_352# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.178 ps=1.4 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor4_1 A B C D VGND VNB VPB VPWR Y
X0 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0894 ps=0.925 w=0.65 l=0.15
X1 a_191_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.13 ps=1.26 w=1 l=0.15
X2 VPWR A a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.119 ps=1.01 w=0.65 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_297_297# B a_191_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X6 a_109_297# D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.13 pd=1.26 as=0.26 ps=2.52 w=1 l=0.15
X7 Y D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
X0 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND a_215_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR a_215_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_109_93# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X4 a_215_297# a_109_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.165 ps=1.82 w=0.65 l=0.15
X5 VGND C a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X6 VGND A a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X8 a_215_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_109_93# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X10 VPWR A a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND a_215_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_487_297# B a_403_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_403_297# C a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X14 VPWR a_215_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X15 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X16 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_297_297# a_109_93# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a41o_4 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 a_639_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_639_47# A2 a_889_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A3 a_467_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.385 pd=1.77 as=0.145 ps=1.29 w=1 l=0.15
X4 a_889_47# A2 a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_889_47# A3 a_1079_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_467_297# A4 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_467_297# B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X13 a_467_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR A4 a_467_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_1079_47# A3 a_889_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_79_21# B1 a_467_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 a_79_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0943 ps=0.94 w=0.65 l=0.15
X18 a_1079_47# A4 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 VPWR A2 a_467_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_467_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_79_21# A1 a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X23 VPWR A1 a_467_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X24 a_467_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.385 ps=1.77 w=1 l=0.15
X25 VGND A4 a_1079_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X27 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2111o_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 VPWR a_86_235# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X1 VGND C1 a_86_235# VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.02 as=0.091 ps=0.93 w=0.65 l=0.15
X2 X a_86_235# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 a_86_235# D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.291 ps=1.54 w=0.65 l=0.15
X4 X a_86_235# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X5 a_715_47# A1 a_86_235# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.109 ps=0.985 w=0.65 l=0.15
X6 VGND A2 a_715_47# VNB sky130_fd_pr__nfet_01v8 ad=0.221 pd=1.98 as=0.127 ps=1.04 w=0.65 l=0.15
X7 a_499_297# C1 a_427_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X8 VGND a_86_235# X VNB sky130_fd_pr__nfet_01v8 ad=0.291 pd=1.54 as=0.091 ps=0.93 w=0.65 l=0.15
X9 a_86_235# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.122 ps=1.02 w=0.65 l=0.15
X10 a_607_297# B1 a_499_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X11 a_427_297# D1 a_86_235# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.41 ps=2.82 w=1 l=0.15
X12 VPWR A1 a_607_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X13 a_607_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.195 ps=1.39 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_465_47# A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.157 ps=1.32 w=1 l=0.15
X2 a_109_297# B1 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 a_193_297# B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.102 ps=0.965 w=0.65 l=0.15
X5 a_205_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X6 VPWR A2 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.165 ps=1.33 w=1 l=0.15
X7 a_193_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X8 a_27_47# B1 a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X9 a_109_297# C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 VGND C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND A2 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4b_4 A_N B C D VGND VNB VPB VPWR Y
X0 a_991_47# C a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_991_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y a_27_47# a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 a_991_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_47# a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_633_47# B a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_633_47# B a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND D a_991_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND D a_991_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_215_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X15 a_215_47# B a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_215_47# B a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X18 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 a_633_47# C a_991_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X24 a_633_47# C a_991_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_215_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X30 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X31 a_991_47# C a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X32 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X33 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
X0 a_388_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.148 ps=1.34 w=0.42 l=0.15
X1 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X4 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X7 a_176_21# a_27_47# a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 a_472_297# B a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.102 ps=0.99 w=0.42 l=0.15
X10 a_176_21# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a221oi_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
X0 Y B1 a_383_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_301_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_301_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND B2 a_383_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A1 a_735_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_27_297# B2 a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 VPWR A1 a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A2 a_735_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_301_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 Y C1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.27 ps=2.54 w=1 l=0.15
X10 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.176 ps=1.84 w=0.65 l=0.15
X12 VPWR A2 a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.175 ps=1.35 w=1 l=0.15
X13 a_383_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X14 a_383_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_735_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X16 a_27_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X17 a_301_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.135 ps=1.27 w=1 l=0.15
X18 a_735_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_27_297# B1 a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_75_199# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.135 ps=1.07 w=0.65 l=0.15
X1 a_208_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.112 ps=0.995 w=0.65 l=0.15
X2 a_315_47# A2 a_208_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.17 as=0.125 ps=1.03 w=0.65 l=0.15
X3 VGND B1 a_75_199# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.07 as=0.106 ps=0.975 w=0.65 l=0.15
X4 a_75_199# A1 a_315_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.17 w=0.65 l=0.15
X5 a_75_199# C1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.207 ps=1.41 w=1 l=0.15
X6 a_544_297# B1 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.207 pd=1.41 as=0.162 ps=1.33 w=1 l=0.15
X7 VPWR a_75_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.285 ps=2.57 w=1 l=0.15
X8 a_201_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.142 ps=1.28 w=1 l=0.15
X9 VPWR A2 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.165 ps=1.33 w=1 l=0.15
X10 a_201_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.305 ps=1.61 w=1 l=0.15
X11 VGND a_75_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
X0 a_558_47# a_381_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X1 VGND X a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_841_47# a_664_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VPWR A a_62_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A a_62_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_558_47# a_381_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X6 X a_62_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR X a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_841_47# a_664_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X9 X a_62_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X10 VPWR a_558_47# a_664_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND a_558_47# a_664_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X6 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X11 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 a_676_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.213 ps=1.42 w=1 l=0.15
X1 a_512_47# B1 a_409_47# VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.119 ps=1.01 w=0.65 l=0.15
X2 a_306_47# D1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.198 ps=1.91 w=0.65 l=0.15
X3 VGND A2 a_512_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.198 ps=1.26 w=0.65 l=0.15
X4 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.218 ps=1.43 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.305 ps=1.61 w=1 l=0.15
X6 VPWR A1 a_676_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.105 ps=1.21 w=1 l=0.15
X7 a_512_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_409_47# C1 a_306_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.119 ps=1.01 w=0.65 l=0.15
X9 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.382 pd=1.76 as=0.26 ps=2.52 w=1 l=0.15
X10 a_79_21# D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.218 pd=1.43 as=0.382 ps=1.76 w=1 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 Y B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X1 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.135 ps=1.27 w=1 l=0.15
X3 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_381_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_109_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VGND A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0683 ps=0.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
X0 X a_299_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X1 VPWR a_193_47# a_299_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 VGND a_193_47# a_299_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X6 X a_299_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_2 A B C D VGND VNB VPB VPWR Y
X0 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X1 a_471_47# B a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.42 pd=2.84 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_47# C a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=1.67 w=1 l=0.15
X8 a_277_47# B a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X9 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.335 pd=1.67 as=0.135 ps=1.27 w=1 l=0.15
X10 Y A a_471_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_277_47# C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X13 a_471_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND D a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
X0 a_297_47# a_27_47# a_193_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_369_47# B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0441 ps=0.63 w=0.42 l=0.15
X2 VPWR D a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.0662 ps=0.735 w=0.42 l=0.15
X3 X a_193_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.103 ps=1 w=0.65 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND D a_469_47# VNB sky130_fd_pr__nfet_01v8 ad=0.103 pd=1 as=0.0609 ps=0.71 w=0.42 l=0.15
X6 X a_193_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR B a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.128 pd=1.03 as=0.0987 ps=0.89 w=0.42 l=0.15
X8 a_193_413# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.128 ps=1.03 w=0.42 l=0.15
X9 a_193_413# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0987 pd=0.89 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 a_469_47# C a_369_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.0735 ps=0.77 w=0.42 l=0.15
X11 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlymetal6s4s_1 A VGND VNB VPB VPWR X
X0 X a_345_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X1 VPWR a_239_47# a_345_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_841_47# a_664_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VGND a_239_47# a_345_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR A a_62_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND A a_62_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X6 X a_345_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 a_239_47# a_62_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X8 a_841_47# a_664_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X9 a_239_47# a_62_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X10 VPWR X a_664_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND X a_664_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
X0 VPWR A a_304_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X1 a_304_297# B a_220_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND C a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X3 a_220_297# C a_114_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X4 a_32_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_32_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X11 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X13 a_114_297# D a_32_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.26 ps=2.52 w=1 l=0.15
X14 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 a_465_47# A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND A4 a_561_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X2 VPWR A3 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X3 a_297_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X4 a_297_297# A4 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X5 VPWR A1 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_381_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.184 ps=1.22 w=0.65 l=0.15
X7 a_297_297# B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X8 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X9 a_79_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.184 pd=1.22 as=0.161 ps=1.14 w=0.65 l=0.15
X10 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.161 pd=1.14 as=0.169 ps=1.82 w=0.65 l=0.15
X11 a_561_47# A3 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
X0 X a_61_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.167 ps=1.39 w=1 l=0.15
X1 VPWR a_61_75# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.195 ps=1.39 w=1 l=0.15
X2 VPWR B a_61_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 VGND B a_147_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 X a_61_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.112 ps=1.04 w=0.65 l=0.15
X5 VGND a_61_75# X VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.127 ps=1.04 w=0.65 l=0.15
X6 a_61_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X7 a_147_75# A a_61_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
X0 VGND a_652_21# a_586_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0882 pd=0.84 as=0.0671 ps=0.75 w=0.42 l=0.15
X1 a_956_413# a_476_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0483 pd=0.65 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 VPWR a_476_47# a_652_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_586_47# a_193_47# a_476_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0671 pd=0.75 as=0.072 ps=0.76 w=0.36 l=0.15
X4 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X5 a_476_47# a_27_47# a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.072 pd=0.76 as=0.0935 ps=0.965 w=0.36 l=0.15
X6 a_1056_47# a_476_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X7 a_381_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.125 pd=1.17 as=0.218 ps=2.2 w=0.84 l=0.15
X8 a_652_21# SET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0798 ps=0.8 w=0.42 l=0.15
X9 a_1224_47# a_27_47# a_1032_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X10 a_562_413# a_27_47# a_476_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0945 pd=0.87 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 VGND a_1032_413# a_1602_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X12 VPWR a_1182_261# a_1140_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X13 Q a_1602_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.149 ps=1.33 w=1 l=0.15
X14 a_1032_413# a_193_47# a_1056_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X15 a_476_47# a_193_47# a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.125 ps=1.17 w=0.42 l=0.15
X16 a_1296_47# a_1182_261# a_1224_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0483 pd=0.65 as=0.0441 ps=0.63 w=0.42 l=0.15
X17 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X18 VPWR a_652_21# a_562_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0798 pd=0.8 as=0.0945 ps=0.87 w=0.42 l=0.15
X19 VPWR SET_B a_1032_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.123 pd=1.17 as=0.109 ps=1.36 w=0.42 l=0.15
X20 a_1032_413# a_27_47# a_956_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0483 ps=0.65 w=0.42 l=0.15
X21 a_1182_261# a_1032_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.218 pd=2.2 as=0.123 ps=1.17 w=0.84 l=0.15
X22 Q a_1602_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X23 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X24 a_1140_413# a_193_47# a_1032_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0819 ps=0.81 w=0.42 l=0.15
X25 VPWR a_1032_413# a_1602_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.149 pd=1.33 as=0.166 ps=1.8 w=0.64 l=0.15
X26 a_796_47# SET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0882 ps=0.84 w=0.42 l=0.15
X27 a_381_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0935 pd=0.965 as=0.166 ps=1.8 w=0.64 l=0.15
X28 a_1182_261# a_1032_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.6 as=0.114 ps=1.01 w=0.54 l=0.15
X29 a_652_21# a_476_47# a_796_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X30 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X31 VGND SET_B a_1296_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1.01 as=0.0483 ps=0.65 w=0.42 l=0.15
.ends

.subckt svm VGND VPWR clk halt periodTop[0] periodTop[10] periodTop[11] periodTop[12]
+ periodTop[13] periodTop[14] periodTop[15] periodTop[1] periodTop[2] periodTop[3]
+ periodTop[4] periodTop[5] periodTop[6] periodTop[7] periodTop[8] periodTop[9] pwmA
+ pwmB pwmC rstb vA[0] vA[10] vA[11] vA[12] vA[13] vA[14] vA[15] vA[1] vA[2] vA[3]
+ vA[4] vA[5] vA[6] vA[7] vA[8] vA[9] vB[0] vB[10] vB[11] vB[12] vB[13] vB[14] vB[15]
+ vB[1] vB[2] vB[3] vB[4] vB[5] vB[6] vB[7] vB[8] vB[9] vC[0] vC[10] vC[11] vC[12]
+ vC[13] vC[14] vC[15] vC[1] vC[2] vC[3] vC[4] vC[5] vC[6] vC[7] vC[8] vC[9]
XFILLER_0_94_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7963_ _3179_ _3195_ VGND VGND VPWR VPWR _3196_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_6_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6914_ _0725_ _2042_ VGND VGND VPWR VPWR _2043_ sky130_fd_sc_hd__nor2_1
X_7894_ _3103_ _3101_ VGND VGND VPWR VPWR _3120_ sky130_fd_sc_hd__and2b_1
X_6845_ _1879_ _1888_ _1878_ VGND VGND VPWR VPWR _1967_ sky130_fd_sc_hd__a21o_1
X_6776_ _1833_ _1890_ VGND VGND VPWR VPWR _1891_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_17_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5727_ _0706_ _0752_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8446_ net352 _0007_ net253 VGND VGND VPWR VPWR counter\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_72_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5658_ _0671_ _0681_ _0598_ _0670_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__a211o_1
X_8377_ _3633_ _3634_ VGND VGND VPWR VPWR _3635_ sky130_fd_sc_hd__or2b_1
X_5589_ _0532_ _0612_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_32_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4609_ _3676_ _3700_ _3702_ VGND VGND VPWR VPWR _3775_ sky130_fd_sc_hd__o21a_1
X_7328_ _2493_ _2494_ _2495_ VGND VGND VPWR VPWR _2497_ sky130_fd_sc_hd__and3_1
X_7259_ _2422_ net231 net233 _1983_ VGND VGND VPWR VPWR _2421_ sky130_fd_sc_hd__o22a_1
XFILLER_0_99_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_99_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer7 net361 VGND VGND VPWR VPWR net360 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_51_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_79_Left_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4960_ _4124_ _4125_ VGND VGND VPWR VPWR _4126_ sky130_fd_sc_hd__xor2_1
X_4891_ _3997_ net292 VGND VGND VPWR VPWR _4057_ sky130_fd_sc_hd__nand2_1
XFILLER_0_104_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_88_Left_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6630_ _1720_ _1737_ VGND VGND VPWR VPWR _1738_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6561_ _2191_ net61 VGND VGND VPWR VPWR _1669_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5512_ _0534_ _0535_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8300_ _3565_ _3559_ _3550_ VGND VGND VPWR VPWR _3567_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_54_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6492_ net210 _0925_ _1592_ VGND VGND VPWR VPWR _1594_ sky130_fd_sc_hd__a21oi_1
X_8231_ _2210_ _2209_ VGND VGND VPWR VPWR _3491_ sky130_fd_sc_hd__xor2_1
X_5443_ net188 net182 VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__or2b_1
XFILLER_0_89_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5374_ _0378_ _0397_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__or2_1
X_8162_ _3382_ _3383_ _3414_ VGND VGND VPWR VPWR _3415_ sky130_fd_sc_hd__o21ai_2
X_7113_ _2239_ _2260_ VGND VGND VPWR VPWR _2261_ sky130_fd_sc_hd__or2_1
X_4325_ net195 net420 VGND VGND VPWR VPWR _2016_ sky130_fd_sc_hd__or2b_1
Xfanout105 net106 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__buf_2
Xfanout138 net54 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__clkbuf_4
X_8093_ _3288_ _3293_ _3292_ VGND VGND VPWR VPWR _3339_ sky130_fd_sc_hd__a21o_1
Xfanout116 net60 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__buf_2
Xfanout127 net58 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__clkbuf_2
X_7044_ _2177_ _2181_ _2182_ _2184_ VGND VGND VPWR VPWR _2185_ sky130_fd_sc_hd__a22oi_2
X_4256_ _1240_ _0001_ _1261_ VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__mux2_1
Xfanout149 net150 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__buf_6
XFILLER_0_38_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7946_ _3175_ _2781_ _3176_ VGND VGND VPWR VPWR _3177_ sky130_fd_sc_hd__a21o_1
X_7877_ _2422_ net249 net88 _2374_ VGND VGND VPWR VPWR _3101_ sky130_fd_sc_hd__a2bb2o_1
X_6828_ _1945_ _1946_ VGND VGND VPWR VPWR _1948_ sky130_fd_sc_hd__xor2_1
XFILLER_0_65_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6759_ _1852_ _1870_ VGND VGND VPWR VPWR _1872_ sky130_fd_sc_hd__nor2_1
XFILLER_0_18_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8429_ net335 _0062_ net253 VGND VGND VPWR VPWR delta\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_60_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5090_ net42 _1884_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__nor2_1
X_7800_ _3014_ _3015_ VGND VGND VPWR VPWR _3017_ sky130_fd_sc_hd__and2b_1
X_5992_ _3885_ net125 net115 _2268_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__o22ai_2
XPHY_EDGE_ROW_96_Left_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7731_ _2930_ _2937_ _2940_ VGND VGND VPWR VPWR _2941_ sky130_fd_sc_hd__o21a_1
X_4943_ _4089_ _4084_ VGND VGND VPWR VPWR _4109_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_86_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7662_ net226 net276 VGND VGND VPWR VPWR _2865_ sky130_fd_sc_hd__or2b_1
X_6613_ _1658_ _1666_ _1665_ VGND VGND VPWR VPWR _1721_ sky130_fd_sc_hd__a21o_1
X_4874_ _4034_ _4039_ VGND VGND VPWR VPWR _4040_ sky130_fd_sc_hd__and2_1
X_7593_ _2702_ _2717_ VGND VGND VPWR VPWR _2789_ sky130_fd_sc_hd__or2_1
X_6544_ _1645_ _1650_ VGND VGND VPWR VPWR _1651_ sky130_fd_sc_hd__xnor2_2
X_6475_ _1556_ _1574_ VGND VGND VPWR VPWR _1575_ sky130_fd_sc_hd__xnor2_2
X_8214_ _3470_ _3391_ _3471_ VGND VGND VPWR VPWR _3472_ sky130_fd_sc_hd__o21ai_1
X_5426_ net81 _0209_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__and2_1
XFILLER_0_15_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8145_ _2182_ _2184_ VGND VGND VPWR VPWR _3396_ sky130_fd_sc_hd__xnor2_1
X_5357_ _3379_ _3423_ _0379_ _0380_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__o22a_1
X_5288_ _0270_ _0274_ _0273_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__a21oi_2
X_8076_ _3286_ _3319_ VGND VGND VPWR VPWR _3320_ sky130_fd_sc_hd__xnor2_1
X_4308_ net187 net310 VGND VGND VPWR VPWR _1829_ sky130_fd_sc_hd__or2b_1
X_7027_ _2160_ _2165_ VGND VGND VPWR VPWR _2166_ sky130_fd_sc_hd__xor2_1
X_4239_ _0756_ _1075_ net79 VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_4_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7929_ _2743_ _2786_ _3157_ VGND VGND VPWR VPWR _3158_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_37_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_104_Right_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4590_ _3748_ _3754_ _3755_ VGND VGND VPWR VPWR _3756_ sky130_fd_sc_hd__a21o_1
XFILLER_0_101_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6260_ _1166_ _1171_ VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__xnor2_2
X_5211_ _0230_ _0234_ _0233_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__a21oi_2
X_6191_ _1259_ _1260_ _1262_ VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__a21oi_1
X_5142_ _0161_ _0156_ _0159_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_20_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5073_ _0093_ _0095_ _0096_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__a21bo_1
X_5975_ _0971_ _1004_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__nor2_1
X_7714_ _2887_ _2886_ VGND VGND VPWR VPWR _2922_ sky130_fd_sc_hd__nand2_1
X_4926_ _4069_ _4091_ VGND VGND VPWR VPWR _4092_ sky130_fd_sc_hd__nand2_1
X_7645_ _2822_ _2845_ VGND VGND VPWR VPWR _2846_ sky130_fd_sc_hd__nor2_1
X_4857_ _3988_ net366 VGND VGND VPWR VPWR _4023_ sky130_fd_sc_hd__xor2_2
X_7576_ net246 net261 VGND VGND VPWR VPWR _2770_ sky130_fd_sc_hd__or2b_1
XFILLER_0_7_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6527_ net90 net134 _1631_ _1629_ VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__a31o_1
XFILLER_0_15_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4788_ _3878_ _3882_ VGND VGND VPWR VPWR _3954_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6458_ _1519_ _1526_ _1555_ VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__a21o_1
X_5409_ counter\[7\] _0430_ _0432_ net79 VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__o22ai_1
X_6389_ _1478_ _1479_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__xor2_2
X_8128_ _3371_ _3373_ VGND VGND VPWR VPWR _3377_ sky130_fd_sc_hd__nor2_1
X_8059_ _3297_ _3300_ VGND VGND VPWR VPWR _3301_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_15_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5760_ net214 _0685_ _0741_ _0740_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__a31oi_1
XFILLER_0_8_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5691_ _0692_ _0713_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_84_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4711_ _3840_ net368 VGND VGND VPWR VPWR _3877_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_8_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7430_ _2603_ _2608_ VGND VGND VPWR VPWR _2610_ sky130_fd_sc_hd__nand2_1
X_4642_ net172 _0921_ _3806_ VGND VGND VPWR VPWR _3808_ sky130_fd_sc_hd__or3_1
XFILLER_0_21_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4573_ _3737_ _3738_ VGND VGND VPWR VPWR _3739_ sky130_fd_sc_hd__and2_1
XFILLER_0_21_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7361_ _2527_ _2531_ _2533_ VGND VGND VPWR VPWR _2534_ sky130_fd_sc_hd__a21o_1
X_7292_ net203 net243 VGND VGND VPWR VPWR _2458_ sky130_fd_sc_hd__and2b_1
X_6312_ _1370_ _1394_ _1395_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_4_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6243_ _1309_ _1315_ VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__nand2_1
X_6174_ net113 net264 VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__or2b_2
X_5125_ _3827_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5056_ _3997_ net91 _0079_ _0078_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__a31o_1
XFILLER_0_79_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5958_ _0968_ _0958_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__or2b_1
X_4909_ _4048_ _4074_ VGND VGND VPWR VPWR _4075_ sky130_fd_sc_hd__xnor2_1
X_5889_ _0929_ _0930_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__or2_1
X_7628_ _2806_ _2809_ _2825_ _2826_ VGND VGND VPWR VPWR _2827_ sky130_fd_sc_hd__a31o_1
X_7559_ _2746_ _2750_ VGND VGND VPWR VPWR _2751_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_30_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_42_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold52 delta\[15\] VGND VGND VPWR VPWR net405 sky130_fd_sc_hd__dlygate4sd3_1
Xhold63 delta\[6\] VGND VGND VPWR VPWR net416 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_98_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8400__17 clknet_2_0__leaf_clk VGND VGND VPWR VPWR net338 sky130_fd_sc_hd__inv_2
XFILLER_0_42_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_51_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_5 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_60_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer17 _3798_ VGND VGND VPWR VPWR net370 sky130_fd_sc_hd__buf_1
X_6930_ _2033_ _2059_ VGND VGND VPWR VPWR _2061_ sky130_fd_sc_hd__xor2_1
XFILLER_0_83_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer28 _4013_ VGND VGND VPWR VPWR net381 sky130_fd_sc_hd__buf_1
Xrebuffer39 _3863_ VGND VGND VPWR VPWR net392 sky130_fd_sc_hd__clkbuf_1
X_6861_ _1977_ _1984_ VGND VGND VPWR VPWR _1985_ sky130_fd_sc_hd__xnor2_1
X_5812_ _0818_ _0823_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_88_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6792_ _1907_ _1908_ VGND VGND VPWR VPWR _1909_ sky130_fd_sc_hd__xnor2_1
X_5743_ _0730_ _0732_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__xnor2_1
X_5674_ _0688_ _0695_ _0696_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__o21a_1
X_4625_ net372 _3790_ VGND VGND VPWR VPWR _3791_ sky130_fd_sc_hd__xnor2_4
X_7413_ _2548_ _2584_ VGND VGND VPWR VPWR _2591_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_44_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4556_ _3718_ _3720_ _3721_ VGND VGND VPWR VPWR _3722_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_4_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7344_ _2217_ _2514_ VGND VGND VPWR VPWR _2515_ sky130_fd_sc_hd__xnor2_1
X_4487_ _3619_ _3628_ VGND VGND VPWR VPWR _3653_ sky130_fd_sc_hd__nand2_1
X_7275_ _2390_ _2405_ _2438_ VGND VGND VPWR VPWR _2439_ sky130_fd_sc_hd__a21oi_2
X_6226_ _1297_ _1300_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__and2_1
X_6157_ net129 net132 net149 net181 VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__and4bb_1
X_5108_ _0130_ _0131_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__xnor2_2
X_6088_ _1128_ _1149_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_79_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5039_ _4203_ _4204_ VGND VGND VPWR VPWR _4205_ sky130_fd_sc_hd__xor2_2
XFILLER_0_79_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4410_ net39 VGND VGND VPWR VPWR _2950_ sky130_fd_sc_hd__inv_2
XFILLER_0_78_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5390_ _3693_ _3722_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4341_ net182 VGND VGND VPWR VPWR _2191_ sky130_fd_sc_hd__inv_4
XFILLER_0_10_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4272_ _1382_ _1393_ _1415_ _1437_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__a211o_1
X_7060_ _2142_ _2143_ _2148_ VGND VGND VPWR VPWR _2203_ sky130_fd_sc_hd__and3_1
Xfanout309 net310 VGND VGND VPWR VPWR net309 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_94_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6011_ _0992_ _0999_ _1001_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__a21oi_1
X_7962_ _3188_ _3194_ VGND VGND VPWR VPWR _3195_ sky130_fd_sc_hd__xnor2_2
X_6913_ _0764_ _2040_ _2041_ VGND VGND VPWR VPWR _2042_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_77_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7893_ net94 _2449_ VGND VGND VPWR VPWR _3119_ sky130_fd_sc_hd__nand2_1
XFILLER_0_92_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6844_ _1957_ _1960_ VGND VGND VPWR VPWR _1966_ sky130_fd_sc_hd__xnor2_1
X_6775_ _1835_ _1889_ VGND VGND VPWR VPWR _1890_ sky130_fd_sc_hd__xnor2_1
X_5726_ _0702_ _0703_ _0705_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__and3_1
X_8445_ net351 _0006_ net253 VGND VGND VPWR VPWR counter\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_60_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5657_ _0606_ _0605_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__or2_1
X_8376_ delta\[14\] counter\[14\] VGND VGND VPWR VPWR _3634_ sky130_fd_sc_hd__or2_1
XFILLER_0_102_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5588_ _1426_ net39 VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4608_ _3769_ net209 _3773_ _3772_ VGND VGND VPWR VPWR _3774_ sky130_fd_sc_hd__a31o_1
X_4539_ _3704_ _3675_ VGND VGND VPWR VPWR _3705_ sky130_fd_sc_hd__xnor2_1
X_7327_ _2493_ _2494_ _2495_ VGND VGND VPWR VPWR _2496_ sky130_fd_sc_hd__a21oi_2
X_7258_ net90 _2162_ VGND VGND VPWR VPWR _2420_ sky130_fd_sc_hd__nand2_1
X_6209_ _1143_ _1279_ _1280_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__and3_1
X_7189_ _2340_ _2341_ _2343_ VGND VGND VPWR VPWR _2344_ sky130_fd_sc_hd__nand3_1
XFILLER_0_95_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer8 net362 VGND VGND VPWR VPWR net361 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4890_ _4053_ _4055_ VGND VGND VPWR VPWR _4056_ sky130_fd_sc_hd__xor2_1
XFILLER_0_74_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6560_ _1658_ _1667_ VGND VGND VPWR VPWR _1668_ sky130_fd_sc_hd__xnor2_2
X_5511_ _0458_ net39 VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__nor2_1
XFILLER_0_54_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6491_ net210 _0925_ _1592_ VGND VGND VPWR VPWR _1593_ sky130_fd_sc_hd__and3_1
X_5442_ net152 _3751_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__nand2_1
X_8230_ _3424_ _3482_ _3488_ VGND VGND VPWR VPWR _3490_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_2_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5373_ _0384_ _0395_ _0396_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__a21oi_1
X_8161_ _3411_ _3413_ VGND VGND VPWR VPWR _3414_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8092_ _3307_ _3315_ VGND VGND VPWR VPWR _3338_ sky130_fd_sc_hd__nand2_1
X_4324_ net158 net283 VGND VGND VPWR VPWR _2005_ sky130_fd_sc_hd__or2b_1
XFILLER_0_10_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7112_ _2253_ _2259_ VGND VGND VPWR VPWR _2260_ sky130_fd_sc_hd__xnor2_2
Xfanout106 net65 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__buf_2
X_7043_ _2140_ _2183_ VGND VGND VPWR VPWR _2184_ sky130_fd_sc_hd__xnor2_2
Xfanout117 net118 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__buf_2
Xfanout128 net58 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__clkbuf_2
Xfanout139 net54 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__clkbuf_4
X_4255_ net95 net82 VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__xor2_1
XFILLER_0_89_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7945_ _2773_ _2775_ VGND VGND VPWR VPWR _3176_ sky130_fd_sc_hd__nor2_1
XFILLER_0_54_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7876_ _3066_ _3070_ VGND VGND VPWR VPWR _3100_ sky130_fd_sc_hd__xnor2_1
X_6827_ _1916_ _1920_ VGND VGND VPWR VPWR _1947_ sky130_fd_sc_hd__xor2_1
XFILLER_0_49_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6758_ _1852_ _1870_ VGND VGND VPWR VPWR _1871_ sky130_fd_sc_hd__and2_1
XFILLER_0_33_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5709_ _0730_ _0732_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__nand2_1
X_6689_ net112 net110 net152 net182 VGND VGND VPWR VPWR _1797_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_103_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8428_ net334 _0061_ net253 VGND VGND VPWR VPWR delta\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_5_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8359_ _3617_ _3618_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__xor2_1
XFILLER_0_20_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_590 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5991_ _0985_ _1043_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__or2_1
X_4942_ _4106_ _4107_ VGND VGND VPWR VPWR _4108_ sky130_fd_sc_hd__xor2_1
X_7730_ _2806_ _2938_ VGND VGND VPWR VPWR _2940_ sky130_fd_sc_hd__nor2_1
XFILLER_0_86_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7661_ net250 net268 VGND VGND VPWR VPWR _2864_ sky130_fd_sc_hd__or2b_1
XFILLER_0_19_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6612_ _1644_ _1653_ _1719_ VGND VGND VPWR VPWR _1720_ sky130_fd_sc_hd__a21o_1
X_4873_ _4037_ net298 net308 _4038_ VGND VGND VPWR VPWR _4039_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7592_ net306 net227 VGND VGND VPWR VPWR _2788_ sky130_fd_sc_hd__nand2_1
X_6543_ _1647_ _1648_ _1649_ VGND VGND VPWR VPWR _1650_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_15_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6474_ _1557_ _1573_ VGND VGND VPWR VPWR _1574_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_42_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8213_ _3468_ _3469_ VGND VGND VPWR VPWR _3471_ sky130_fd_sc_hd__xor2_1
X_5425_ _0447_ _0448_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8144_ _3345_ _3351_ _3394_ VGND VGND VPWR VPWR _3395_ sky130_fd_sc_hd__a21o_1
X_5356_ _3159_ _3544_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__and2_1
XFILLER_0_49_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5287_ _0309_ _0310_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__xnor2_2
X_8075_ _3316_ _3318_ VGND VGND VPWR VPWR _3319_ sky130_fd_sc_hd__xnor2_1
X_4307_ net189 net419 VGND VGND VPWR VPWR _1818_ sky130_fd_sc_hd__nand2b_1
X_7026_ _2161_ _2164_ VGND VGND VPWR VPWR _2165_ sky130_fd_sc_hd__xor2_1
X_4238_ net297 _0745_ net288 VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_4_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7928_ _2787_ _2795_ VGND VGND VPWR VPWR _3157_ sky130_fd_sc_hd__and2_1
XFILLER_0_38_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7859_ _3079_ _3080_ VGND VGND VPWR VPWR _3081_ sky130_fd_sc_hd__xor2_1
XFILLER_0_18_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5210_ _0231_ _0232_ _0233_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_12_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6190_ net103 net144 net296 net305 VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_86_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5141_ _0142_ _0162_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__xor2_1
X_5072_ _0090_ _0092_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8406__23 clknet_2_2__leaf_clk VGND VGND VPWR VPWR net344 sky130_fd_sc_hd__inv_2
XFILLER_0_79_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5974_ _1023_ _1024_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__nor2_1
X_7713_ _2914_ _2920_ VGND VGND VPWR VPWR _2921_ sky130_fd_sc_hd__nor2_1
XFILLER_0_87_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4925_ _4024_ _4026_ VGND VGND VPWR VPWR _4091_ sky130_fd_sc_hd__or2_1
X_4856_ net369 _3952_ _3953_ net430 VGND VGND VPWR VPWR _4022_ sky130_fd_sc_hd__o22a_1
X_7644_ _2815_ _2820_ _2821_ VGND VGND VPWR VPWR _2845_ sky130_fd_sc_hd__and3_1
XFILLER_0_47_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7575_ net199 net244 VGND VGND VPWR VPWR _2769_ sky130_fd_sc_hd__or2b_1
XFILLER_0_105_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4787_ _3918_ _3950_ VGND VGND VPWR VPWR _3953_ sky130_fd_sc_hd__xnor2_2
X_6526_ _1629_ _1630_ VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__and2b_1
XFILLER_0_42_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6457_ _1517_ _1518_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__nor2_1
X_5408_ _0400_ _0428_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__xnor2_2
X_6388_ net133 net118 VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__nand2b_2
X_5339_ _0362_ _0361_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__xnor2_1
X_8127_ _3150_ _3156_ _3273_ _3279_ _3375_ VGND VGND VPWR VPWR _3376_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_11_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8058_ _3298_ _3299_ VGND VGND VPWR VPWR _3300_ sky130_fd_sc_hd__nor2_1
X_7009_ _0458_ net23 VGND VGND VPWR VPWR _2146_ sky130_fd_sc_hd__nor2_1
XFILLER_0_85_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5690_ _1426_ net55 VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__nor2_1
X_4710_ _3875_ _3874_ VGND VGND VPWR VPWR _3876_ sky130_fd_sc_hd__and2_1
XFILLER_0_29_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4641_ net172 _0921_ _3806_ VGND VGND VPWR VPWR _3807_ sky130_fd_sc_hd__o21ai_1
X_4572_ _1906_ _2060_ VGND VGND VPWR VPWR _3738_ sky130_fd_sc_hd__xor2_2
XFILLER_0_4_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7360_ _2530_ _2264_ VGND VGND VPWR VPWR _2533_ sky130_fd_sc_hd__nor2_1
X_7291_ net206 net216 VGND VGND VPWR VPWR _2457_ sky130_fd_sc_hd__and2b_1
X_6311_ _1392_ _1391_ VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__and2b_1
XFILLER_0_97_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6242_ _1318_ _1296_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__xnor2_1
X_6173_ net109 net264 VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__and2b_1
X_5124_ _0114_ _0118_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__xnor2_1
X_5055_ _4182_ _0076_ _0078_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5957_ _0967_ _0959_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__or2b_1
X_4908_ _4072_ _4073_ VGND VGND VPWR VPWR _4074_ sky130_fd_sc_hd__xor2_1
X_5888_ net124 net291 VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__or2b_1
X_7627_ _2823_ _2824_ VGND VGND VPWR VPWR _2826_ sky130_fd_sc_hd__nor2_1
XFILLER_0_105_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4839_ _4001_ _4002_ VGND VGND VPWR VPWR _4005_ sky130_fd_sc_hd__nor2_1
XFILLER_0_35_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7558_ _2747_ _2748_ _2749_ VGND VGND VPWR VPWR _2750_ sky130_fd_sc_hd__o21a_1
XFILLER_0_31_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6509_ _1473_ _1506_ VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__nor2_1
X_7489_ net27 net101 VGND VGND VPWR VPWR _2674_ sky130_fd_sc_hd__or2b_1
XFILLER_0_101_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold64 delta\[8\] VGND VGND VPWR VPWR net417 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 delta\[3\] VGND VGND VPWR VPWR net406 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8397__14 clknet_2_2__leaf_clk VGND VGND VPWR VPWR net335 sky130_fd_sc_hd__inv_2
XFILLER_0_85_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_6 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer18 _3944_ VGND VGND VPWR VPWR net371 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_88_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer29 _0201_ VGND VGND VPWR VPWR net382 sky130_fd_sc_hd__clkbuf_1
X_6860_ _1981_ _1982_ VGND VGND VPWR VPWR _1984_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5811_ _0845_ _0842_ _0841_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__a21bo_1
X_6791_ _1855_ _1859_ _1858_ VGND VGND VPWR VPWR _1908_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_57_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5742_ _0743_ _0769_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__nand2_1
XFILLER_0_17_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5673_ net120 _0691_ _0687_ net153 VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__a22o_1
XFILLER_0_72_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7412_ _2588_ _2589_ VGND VGND VPWR VPWR _2590_ sky130_fd_sc_hd__or2_1
X_4624_ _3767_ _3788_ _3789_ VGND VGND VPWR VPWR _3790_ sky130_fd_sc_hd__a21bo_4
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4555_ _3716_ _3717_ VGND VGND VPWR VPWR _3721_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7343_ _2218_ _2219_ _2221_ VGND VGND VPWR VPWR _2514_ sky130_fd_sc_hd__o21a_1
X_4486_ _2708_ VGND VGND VPWR VPWR _3652_ sky130_fd_sc_hd__clkbuf_4
X_7274_ _2373_ _2388_ VGND VGND VPWR VPWR _2438_ sky130_fd_sc_hd__nor2_1
X_6225_ net83 _1299_ VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__nor2_1
X_6156_ net132 net148 VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__or2b_1
X_5107_ _0085_ _0100_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__xnor2_2
X_6087_ _1129_ _1148_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__xnor2_1
X_5038_ _4139_ _4145_ VGND VGND VPWR VPWR _4204_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_95_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6989_ net73 _2045_ _2046_ net74 VGND VGND VPWR VPWR _2125_ sky130_fd_sc_hd__o22a_1
XFILLER_0_63_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4340_ net45 _0921_ VGND VGND VPWR VPWR _2180_ sky130_fd_sc_hd__nor2_1
X_4271_ _1426_ _0811_ net74 VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__o21a_1
X_6010_ _1029_ _1063_ VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7961_ _3189_ _3193_ VGND VGND VPWR VPWR _3194_ sky130_fd_sc_hd__xnor2_2
X_6912_ _0758_ _0762_ _0727_ VGND VGND VPWR VPWR _2041_ sky130_fd_sc_hd__a21oi_1
X_7892_ _3111_ _3117_ VGND VGND VPWR VPWR _3118_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6843_ _1882_ _1883_ _1886_ VGND VGND VPWR VPWR _1965_ sky130_fd_sc_hd__a21o_1
XFILLER_0_91_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6774_ _1880_ _1888_ VGND VGND VPWR VPWR _1889_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_9_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5725_ _0748_ _0749_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8444_ net350 _0005_ net254 VGND VGND VPWR VPWR counter\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_94_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5656_ _0440_ _0441_ _0677_ _0679_ _0431_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__o32a_1
X_4607_ _3770_ _3771_ _3772_ VGND VGND VPWR VPWR _3773_ sky130_fd_sc_hd__a21oi_2
X_8375_ delta\[14\] net74 VGND VGND VPWR VPWR _3633_ sky130_fd_sc_hd__and2_1
X_5587_ _0608_ _0610_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4538_ _3667_ net393 VGND VGND VPWR VPWR _3704_ sky130_fd_sc_hd__nand2_1
X_7326_ _2420_ _2421_ _2423_ VGND VGND VPWR VPWR _2495_ sky130_fd_sc_hd__o21ba_1
X_4469_ _3280_ _2752_ VGND VGND VPWR VPWR _3593_ sky130_fd_sc_hd__nor2_1
X_7257_ _2417_ _2418_ VGND VGND VPWR VPWR _2419_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_86_Right_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6208_ _1279_ _1280_ _1143_ VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__a21oi_2
X_7188_ _2342_ _2316_ VGND VGND VPWR VPWR _2343_ sky130_fd_sc_hd__or2_1
X_6139_ _1205_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_95_Right_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer9 net363 VGND VGND VPWR VPWR net362 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_51_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5510_ _0531_ _0492_ _0533_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6490_ _1485_ _1589_ _1590_ VGND VGND VPWR VPWR _1592_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5441_ net213 _3082_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__nand2_1
X_5372_ _0385_ _0394_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__and2b_1
X_8160_ _3307_ _3315_ _3360_ _3337_ _3361_ VGND VGND VPWR VPWR _3413_ sky130_fd_sc_hd__a32o_1
XFILLER_0_1_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8091_ _3334_ _3336_ VGND VGND VPWR VPWR _3337_ sky130_fd_sc_hd__xor2_1
XFILLER_0_22_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7111_ _2254_ _2258_ VGND VGND VPWR VPWR _2259_ sky130_fd_sc_hd__xnor2_2
X_4323_ net191 _1983_ VGND VGND VPWR VPWR _1994_ sky130_fd_sc_hd__nor2_1
X_7042_ net199 net102 VGND VGND VPWR VPWR _2183_ sky130_fd_sc_hd__and2b_1
Xfanout118 net123 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__buf_4
XFILLER_0_10_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout107 net64 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__buf_4
Xfanout129 net58 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__buf_2
X_4254_ counter\[0\] VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__inv_4
XFILLER_0_96_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7944_ _2773_ _2775_ VGND VGND VPWR VPWR _3175_ sky130_fd_sc_hd__nand2_1
X_7875_ _3061_ _3098_ VGND VGND VPWR VPWR _3099_ sky130_fd_sc_hd__nor2_1
X_6826_ _1837_ _1848_ VGND VGND VPWR VPWR _1946_ sky130_fd_sc_hd__or2b_1
XFILLER_0_65_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6757_ _1854_ _1869_ VGND VGND VPWR VPWR _1870_ sky130_fd_sc_hd__xor2_1
X_5708_ _0700_ _0731_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__xnor2_1
X_6688_ net112 net151 VGND VGND VPWR VPWR _1796_ sky130_fd_sc_hd__or2b_1
XFILLER_0_72_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5639_ _0636_ _0644_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__nand2_1
X_8427_ net333 _0060_ net253 VGND VGND VPWR VPWR delta\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_60_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8358_ _3609_ _3614_ _3611_ VGND VGND VPWR VPWR _3618_ sky130_fd_sc_hd__o21a_1
X_7309_ _2473_ _2474_ _2475_ VGND VGND VPWR VPWR _2476_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_13_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8289_ _2590_ _3553_ VGND VGND VPWR VPWR _3554_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_34_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5990_ net116 net257 VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__or2b_1
XFILLER_0_59_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4941_ _4056_ _4058_ VGND VGND VPWR VPWR _4107_ sky130_fd_sc_hd__xnor2_1
X_4872_ net164 VGND VGND VPWR VPWR _4038_ sky130_fd_sc_hd__inv_2
X_7660_ _2804_ _2861_ VGND VGND VPWR VPWR _2863_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6611_ _1651_ _1652_ VGND VGND VPWR VPWR _1719_ sky130_fd_sc_hd__nor2_1
X_7591_ _2743_ _2786_ VGND VGND VPWR VPWR _2787_ sky130_fd_sc_hd__xor2_1
X_6542_ net104 net145 net266 net274 VGND VGND VPWR VPWR _1649_ sky130_fd_sc_hd__and4bb_1
X_6473_ _1563_ _1572_ VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__xor2_2
X_8212_ _3349_ _3386_ _3385_ VGND VGND VPWR VPWR _3470_ sky130_fd_sc_hd__o21a_1
X_5424_ net82 _0446_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__and2_1
X_8143_ _3344_ _3339_ VGND VGND VPWR VPWR _3394_ sky130_fd_sc_hd__and2b_1
XFILLER_0_2_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5355_ _3357_ _3533_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__and2b_1
XFILLER_0_57_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5286_ _2191_ net192 VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__nor2_1
X_4306_ net404 _1646_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__xnor2_1
X_8074_ _3243_ _3254_ _3317_ VGND VGND VPWR VPWR _3318_ sky130_fd_sc_hd__a21o_1
X_7025_ net102 _2163_ _2133_ VGND VGND VPWR VPWR _2164_ sky130_fd_sc_hd__and3_1
X_4237_ counter\[7\] _1053_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_65_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7927_ _2588_ _3151_ _3153_ _3154_ _3155_ VGND VGND VPWR VPWR _3156_ sky130_fd_sc_hd__o311a_1
X_7858_ _3045_ _3047_ VGND VGND VPWR VPWR _3080_ sky130_fd_sc_hd__xnor2_1
X_6809_ _1042_ _1925_ _1926_ VGND VGND VPWR VPWR _1927_ sky130_fd_sc_hd__o21a_1
XFILLER_0_92_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7789_ _2995_ _3002_ _3003_ VGND VGND VPWR VPWR _3004_ sky130_fd_sc_hd__a21o_1
XFILLER_0_73_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5140_ _0135_ _0139_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5071_ _0094_ _0079_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__xnor2_2
X_5973_ _1006_ _1007_ _1022_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__and3_1
XFILLER_0_35_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7712_ _2910_ _2912_ _2913_ VGND VGND VPWR VPWR _2920_ sky130_fd_sc_hd__and3_1
X_4924_ _4084_ _4089_ VGND VGND VPWR VPWR _4090_ sky130_fd_sc_hd__or2b_1
XFILLER_0_74_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7643_ _2841_ _2843_ VGND VGND VPWR VPWR _2844_ sky130_fd_sc_hd__xor2_1
X_4855_ _3988_ _4019_ _4020_ VGND VGND VPWR VPWR _4021_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_74_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7574_ _0238_ net236 VGND VGND VPWR VPWR _2768_ sky130_fd_sc_hd__nor2_1
X_4786_ _3918_ _3950_ _3951_ VGND VGND VPWR VPWR _3952_ sky130_fd_sc_hd__a21oi_2
X_6525_ _1625_ _1626_ _1628_ VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__or3b_1
XFILLER_0_7_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6456_ _1552_ _1553_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_100_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5407_ counter\[7\] _0430_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__and2_1
XFILLER_0_11_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6387_ net129 net149 VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__or2b_1
XFILLER_0_100_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8126_ _3370_ _3374_ VGND VGND VPWR VPWR _3375_ sky130_fd_sc_hd__or2_1
X_5338_ _3584_ _3650_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__nand2_1
X_8057_ net245 net261 _2128_ _2130_ VGND VGND VPWR VPWR _3299_ sky130_fd_sc_hd__and4_1
X_7008_ _2144_ _2131_ VGND VGND VPWR VPWR _2145_ sky130_fd_sc_hd__nor2_1
X_5269_ _0291_ _0292_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout290 net292 VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__buf_2
XFILLER_0_88_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4640_ net169 net257 VGND VGND VPWR VPWR _3806_ sky130_fd_sc_hd__or2b_1
XFILLER_0_44_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4571_ _3728_ _3735_ _3736_ VGND VGND VPWR VPWR _3737_ sky130_fd_sc_hd__a21bo_1
X_6310_ _1391_ _1392_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7290_ net262 _2215_ VGND VGND VPWR VPWR _2456_ sky130_fd_sc_hd__nand2_1
XFILLER_0_97_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6241_ net93 _0926_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__nand2_1
X_6172_ _0927_ net107 VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__nor2_1
X_5123_ _0144_ _0146_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__nor2_1
X_5054_ _4184_ _0077_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__nor2_1
X_5956_ _0971_ _1004_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__xor2_1
XFILLER_0_75_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5887_ net114 net281 VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__or2b_1
X_4907_ _4008_ _4009_ VGND VGND VPWR VPWR _4073_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7626_ _2823_ _2824_ VGND VGND VPWR VPWR _2825_ sky130_fd_sc_hd__xor2_1
X_4838_ _3967_ _3960_ VGND VGND VPWR VPWR _4004_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_35_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7557_ net203 net206 net155 net186 VGND VGND VPWR VPWR _2749_ sky130_fd_sc_hd__or4bb_1
X_4769_ _3894_ _3891_ _3883_ VGND VGND VPWR VPWR _3935_ sky130_fd_sc_hd__a21oi_1
X_7488_ net220 net121 VGND VGND VPWR VPWR _2673_ sky130_fd_sc_hd__or2b_1
X_6508_ _1575_ _1610_ VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_43_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6439_ _1533_ _1274_ _1534_ VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_101_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8109_ _3354_ _3301_ _3355_ VGND VGND VPWR VPWR _3356_ sky130_fd_sc_hd__a21oi_2
Xhold54 delta\[12\] VGND VGND VPWR VPWR net407 sky130_fd_sc_hd__dlygate4sd3_1
Xhold65 rising VGND VGND VPWR VPWR net418 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_7 net218 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_6_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer19 _3766_ VGND VGND VPWR VPWR net372 sky130_fd_sc_hd__buf_6
XFILLER_0_88_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5810_ net70 VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__inv_2
X_6790_ _0848_ _0852_ VGND VGND VPWR VPWR _1907_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_9_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5741_ _0737_ _0742_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__or2_1
XFILLER_0_91_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5672_ net153 _0691_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7411_ _2503_ _2586_ VGND VGND VPWR VPWR _2589_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4623_ _3768_ _3787_ VGND VGND VPWR VPWR _3789_ sky130_fd_sc_hd__or2b_1
XFILLER_0_13_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4554_ _3719_ _2642_ VGND VGND VPWR VPWR _3720_ sky130_fd_sc_hd__xnor2_1
X_7342_ _0303_ net222 _2512_ VGND VGND VPWR VPWR _2513_ sky130_fd_sc_hd__o21ai_2
X_7273_ _2407_ _2428_ _2436_ VGND VGND VPWR VPWR _2437_ sky130_fd_sc_hd__a21oi_2
X_4485_ _3584_ _3650_ VGND VGND VPWR VPWR _3651_ sky130_fd_sc_hd__xnor2_1
X_6224_ _1229_ net108 _1178_ VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__o21a_1
XFILLER_0_0_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6155_ net129 net180 VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__or2b_1
X_5106_ _0113_ _0128_ _0129_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__a21bo_1
X_6086_ _1132_ _1147_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__xor2_1
X_5037_ _4186_ _4201_ _4202_ _4198_ _4200_ VGND VGND VPWR VPWR _4203_ sky130_fd_sc_hd__a32oi_4
X_6988_ _2055_ _2112_ _2121_ _2123_ VGND VGND VPWR VPWR _2124_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_75_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5939_ net126 net116 net264 net271 VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_106_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7609_ _2619_ _2805_ VGND VGND VPWR VPWR _2806_ sky130_fd_sc_hd__nor2_1
XFILLER_0_90_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput66 net66 VGND VGND VPWR VPWR halt sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4270_ net119 VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__clkinv_4
XFILLER_0_1_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7960_ _3190_ _3191_ VGND VGND VPWR VPWR _3193_ sky130_fd_sc_hd__nor2_1
X_6911_ _0805_ _0907_ _2039_ _0804_ _0765_ VGND VGND VPWR VPWR _2040_ sky130_fd_sc_hd__o32ai_4
X_7891_ _3108_ _3110_ VGND VGND VPWR VPWR _3117_ sky130_fd_sc_hd__or2_1
XFILLER_0_89_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6842_ _1902_ _1963_ VGND VGND VPWR VPWR _1964_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_92_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6773_ _1886_ _1887_ VGND VGND VPWR VPWR _1888_ sky130_fd_sc_hd__nor2_1
X_5724_ _0748_ _0749_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__or2_1
XFILLER_0_72_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8443_ net349 _0004_ net254 VGND VGND VPWR VPWR counter\[12\] sky130_fd_sc_hd__dfrtp_1
X_5655_ _0437_ _0678_ _0433_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_17_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8374_ _3631_ _3632_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__xor2_1
XFILLER_0_87_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4606_ net176 net197 net393 net180 VGND VGND VPWR VPWR _3772_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_103_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5586_ _0534_ _0535_ _0609_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__a21oi_1
X_7325_ _2427_ _2409_ VGND VGND VPWR VPWR _2494_ sky130_fd_sc_hd__or2b_1
XFILLER_0_102_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4537_ _3699_ _3701_ _3702_ VGND VGND VPWR VPWR _3703_ sky130_fd_sc_hd__o21ai_1
X_4468_ net45 _3566_ _3577_ VGND VGND VPWR VPWR _3584_ sky130_fd_sc_hd__o21ba_1
X_7256_ _2240_ _2244_ _2243_ VGND VGND VPWR VPWR _2418_ sky130_fd_sc_hd__a21oi_2
X_6207_ _1148_ _1129_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__or2b_1
X_7187_ net220 net185 VGND VGND VPWR VPWR _2342_ sky130_fd_sc_hd__or2b_1
X_4399_ _2697_ _2741_ _2818_ VGND VGND VPWR VPWR _2829_ sky130_fd_sc_hd__or3_4
X_6138_ _1157_ _1204_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__and2b_1
XFILLER_0_99_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6069_ _1067_ _1078_ _1076_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__a21o_1
XFILLER_0_67_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_39_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_48_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5440_ _0457_ _0463_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_57_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5371_ _0385_ _0394_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__xnor2_1
X_8090_ net270 net228 VGND VGND VPWR VPWR _3336_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4322_ net302 VGND VGND VPWR VPWR _1983_ sky130_fd_sc_hd__inv_4
X_7110_ _2255_ _2256_ VGND VGND VPWR VPWR _2258_ sky130_fd_sc_hd__nor2_1
Xfanout119 net120 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__clkbuf_4
X_7041_ _0458_ net235 VGND VGND VPWR VPWR _2182_ sky130_fd_sc_hd__nor2_1
Xfanout108 net63 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__buf_2
X_4253_ _1229_ VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__buf_4
X_8385__2 clknet_2_0__leaf_clk VGND VGND VPWR VPWR net323 sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_66_Left_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7943_ _3160_ _3173_ VGND VGND VPWR VPWR _3174_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7874_ _1229_ net222 VGND VGND VPWR VPWR _3098_ sky130_fd_sc_hd__or2_1
X_6825_ _1929_ _1931_ VGND VGND VPWR VPWR _1945_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_64_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6756_ _1863_ _1868_ VGND VGND VPWR VPWR _1869_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_9_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5707_ net105 net100 VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_75_Left_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6687_ _1694_ _1698_ _1697_ VGND VGND VPWR VPWR _1795_ sky130_fd_sc_hd__a21o_1
XFILLER_0_60_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8426_ net332 _0059_ net254 VGND VGND VPWR VPWR delta\[11\] sky130_fd_sc_hd__dfrtp_1
X_5638_ _0659_ _0660_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__nor2_1
X_8357_ _3615_ _3616_ VGND VGND VPWR VPWR _3617_ sky130_fd_sc_hd__or2b_1
X_5569_ _0577_ _0591_ _0590_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__a21o_1
X_7308_ net247 net200 net269 net278 VGND VGND VPWR VPWR _2475_ sky130_fd_sc_hd__and4bb_1
X_8288_ _3149_ _2665_ _3152_ VGND VGND VPWR VPWR _3553_ sky130_fd_sc_hd__a21oi_1
X_7239_ _2343_ _2344_ _2398_ VGND VGND VPWR VPWR _2399_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_84_Left_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4940_ _4102_ _4104_ _4105_ VGND VGND VPWR VPWR _4106_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_86_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4871_ net167 VGND VGND VPWR VPWR _4037_ sky130_fd_sc_hd__inv_2
XFILLER_0_47_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6610_ _1693_ _1717_ VGND VGND VPWR VPWR _1718_ sky130_fd_sc_hd__xor2_2
X_7590_ _2761_ _2784_ VGND VGND VPWR VPWR _2786_ sky130_fd_sc_hd__xor2_1
X_6541_ net104 net266 VGND VGND VPWR VPWR _1648_ sky130_fd_sc_hd__or2b_1
XFILLER_0_82_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6472_ _1570_ _1571_ VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__xor2_2
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8211_ _3392_ _3409_ _3408_ VGND VGND VPWR VPWR _3469_ sky130_fd_sc_hd__a21boi_1
X_5423_ net82 _0446_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5354_ _0358_ _0372_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__xnor2_1
X_8142_ _3358_ _3359_ VGND VGND VPWR VPWR _3393_ sky130_fd_sc_hd__and2b_1
X_4305_ net408 _1646_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5285_ _0306_ _0307_ _0308_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__a21oi_2
X_8073_ _3252_ _3253_ VGND VGND VPWR VPWR _3317_ sky130_fd_sc_hd__nor2_1
X_7024_ _2162_ VGND VGND VPWR VPWR _2163_ sky130_fd_sc_hd__clkbuf_4
X_4236_ _1042_ _0756_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7926_ _2799_ _2801_ VGND VGND VPWR VPWR _3155_ sky130_fd_sc_hd__or2_1
X_7857_ _3075_ _3077_ _3078_ VGND VGND VPWR VPWR _3079_ sky130_fd_sc_hd__a21boi_1
X_6808_ net278 net135 _1924_ VGND VGND VPWR VPWR _1926_ sky130_fd_sc_hd__a21o_1
XFILLER_0_37_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7788_ _2992_ _2993_ VGND VGND VPWR VPWR _3003_ sky130_fd_sc_hd__nor2_1
XFILLER_0_92_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6739_ _1836_ _1849_ VGND VGND VPWR VPWR _1850_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_33_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_96_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout90 net9 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__buf_6
XFILLER_0_9_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5070_ _3997_ net91 VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5972_ _1006_ _1007_ _1022_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__a21oi_2
X_4923_ net85 _4085_ _4086_ _4088_ VGND VGND VPWR VPWR _4089_ sky130_fd_sc_hd__a22o_1
X_7711_ _2916_ _2918_ VGND VGND VPWR VPWR _2919_ sky130_fd_sc_hd__and2_1
XFILLER_0_59_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7642_ _2638_ _2842_ VGND VGND VPWR VPWR _2843_ sky130_fd_sc_hd__xnor2_1
X_4854_ net428 _4018_ VGND VGND VPWR VPWR _4020_ sky130_fd_sc_hd__nor2_2
X_4785_ _3919_ _3949_ VGND VGND VPWR VPWR _3951_ sky130_fd_sc_hd__nor2_1
X_7573_ _2687_ _2765_ _2766_ VGND VGND VPWR VPWR _2767_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_7_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6524_ _1625_ _1626_ _1628_ VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_27_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6455_ net95 net134 VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__nand2_1
X_5406_ _0377_ _0429_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_30_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6386_ _1470_ net50 VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__nor2_1
X_8125_ _3371_ _3373_ VGND VGND VPWR VPWR _3374_ sky130_fd_sc_hd__xnor2_1
X_5337_ _0333_ _0334_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__xnor2_1
X_5268_ _1481_ net165 net162 _1426_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__o22a_1
X_8056_ _0303_ net232 net234 _0932_ VGND VGND VPWR VPWR _3298_ sky130_fd_sc_hd__o22a_1
X_7007_ _1503_ net233 _2133_ VGND VGND VPWR VPWR _2144_ sky130_fd_sc_hd__o21a_1
X_4219_ _0789_ _0855_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__nand2_1
X_5199_ _0218_ _0221_ _0222_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__o21a_1
XFILLER_0_78_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7909_ _3099_ _3116_ _3135_ _3113_ VGND VGND VPWR VPWR _3136_ sky130_fd_sc_hd__a211o_1
XFILLER_0_38_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout280 net282 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__buf_2
Xfanout291 net292 VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__clkbuf_4
X_4570_ _3732_ _3734_ VGND VGND VPWR VPWR _3736_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6240_ _1309_ _1315_ VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__xor2_1
X_6171_ _1104_ _1106_ _1105_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__a21bo_1
X_5122_ _0106_ _0145_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__nor2_1
X_5053_ net171 net84 VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__or2b_1
XFILLER_0_79_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5955_ _0991_ _1003_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__xnor2_1
X_4906_ _4068_ _4070_ _4071_ VGND VGND VPWR VPWR _4072_ sky130_fd_sc_hd__a21oi_1
X_5886_ _0927_ net125 net115 _1119_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__o22ai_4
XFILLER_0_75_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7625_ _2615_ _2626_ VGND VGND VPWR VPWR _2824_ sky130_fd_sc_hd__xnor2_1
X_4837_ _4001_ _4002_ VGND VGND VPWR VPWR _4003_ sky130_fd_sc_hd__xor2_1
XFILLER_0_16_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7556_ net203 net185 VGND VGND VPWR VPWR _2748_ sky130_fd_sc_hd__and2b_1
X_4768_ _3883_ _3894_ _3891_ VGND VGND VPWR VPWR _3934_ sky130_fd_sc_hd__and3_1
X_6507_ _1607_ _1609_ VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__xnor2_2
X_4699_ _3833_ _3817_ VGND VGND VPWR VPWR _3865_ sky130_fd_sc_hd__xnor2_2
X_7487_ _2452_ _2465_ _2671_ VGND VGND VPWR VPWR _2672_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_30_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6438_ _1266_ _1267_ _1268_ VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_101_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8108_ _3294_ _3295_ VGND VGND VPWR VPWR _3355_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6369_ _1200_ _1208_ VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__xor2_1
Xhold55 delta\[2\] VGND VGND VPWR VPWR net408 sky130_fd_sc_hd__dlygate4sd3_1
X_8039_ _3277_ _3278_ VGND VGND VPWR VPWR _3279_ sky130_fd_sc_hd__nand2_1
XFILLER_0_98_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_11_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_8 net279 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_61_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_20_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5740_ _0766_ _0753_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__xor2_1
XFILLER_0_32_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5671_ _0490_ net55 VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7410_ _2503_ _2586_ VGND VGND VPWR VPWR _2588_ sky130_fd_sc_hd__and2_1
X_4622_ _3768_ _3787_ VGND VGND VPWR VPWR _3788_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_102_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4553_ net310 net179 VGND VGND VPWR VPWR _3719_ sky130_fd_sc_hd__nand2_1
XFILLER_0_52_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7341_ net219 net270 VGND VGND VPWR VPWR _2512_ sky130_fd_sc_hd__or2b_1
XFILLER_0_40_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4484_ _3601_ _3649_ VGND VGND VPWR VPWR _3650_ sky130_fd_sc_hd__xor2_2
X_7272_ _2371_ _2406_ VGND VGND VPWR VPWR _2436_ sky130_fd_sc_hd__nor2_1
X_6223_ _1218_ net108 _1178_ VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__nor3_1
X_6154_ net118 _0916_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5105_ _0127_ _0126_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__or2b_1
X_6085_ _1145_ _1146_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__nand2_1
X_5036_ _3652_ net84 _4183_ _4185_ VGND VGND VPWR VPWR _4202_ sky130_fd_sc_hd__a22o_1
XFILLER_0_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6987_ _2053_ _2122_ VGND VGND VPWR VPWR _2123_ sky130_fd_sc_hd__nand2_1
X_5938_ net126 net264 VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__or2b_1
XFILLER_0_63_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5869_ _0908_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_90_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7608_ _1229_ net201 VGND VGND VPWR VPWR _2805_ sky130_fd_sc_hd__or2_1
X_7539_ _2727_ _2728_ VGND VGND VPWR VPWR _2729_ sky130_fd_sc_hd__nor2_2
XFILLER_0_105_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput67 net67 VGND VGND VPWR VPWR pwmA sky130_fd_sc_hd__buf_4
XFILLER_0_98_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6910_ _2028_ _2033_ _2035_ _2037_ VGND VGND VPWR VPWR _2039_ sky130_fd_sc_hd__o211a_1
X_7890_ _3113_ _3114_ VGND VGND VPWR VPWR _3116_ sky130_fd_sc_hd__nor2_1
X_6841_ _1953_ _1962_ VGND VGND VPWR VPWR _1963_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_43_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6772_ net297 net137 _1885_ VGND VGND VPWR VPWR _1887_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_57_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5723_ net184 net136 VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__and2_1
X_8442_ net348 _0003_ net254 VGND VGND VPWR VPWR counter\[11\] sky130_fd_sc_hd__dfrtp_4
X_5654_ _0438_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__inv_2
XFILLER_0_72_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8373_ _3624_ _3627_ _3625_ VGND VGND VPWR VPWR _3632_ sky130_fd_sc_hd__o21a_1
XFILLER_0_32_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4605_ net175 net180 VGND VGND VPWR VPWR _3771_ sky130_fd_sc_hd__or2b_1
XFILLER_0_102_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5585_ _0533_ _0537_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__xor2_1
XFILLER_0_13_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7324_ _2410_ _2426_ VGND VGND VPWR VPWR _2493_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4536_ net175 net197 net148 net118 VGND VGND VPWR VPWR _3702_ sky130_fd_sc_hd__or4bb_4
X_4467_ _1481_ net170 net45 _1426_ VGND VGND VPWR VPWR _3577_ sky130_fd_sc_hd__o22a_1
X_7255_ _2412_ _2416_ VGND VGND VPWR VPWR _2417_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_68_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4398_ _2785_ _2807_ VGND VGND VPWR VPWR _2818_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6206_ _1147_ _1132_ VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__or2b_1
X_7186_ _2191_ net223 _2318_ VGND VGND VPWR VPWR _2341_ sky130_fd_sc_hd__o21ai_1
X_6137_ _1195_ _1202_ _1203_ VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__a21o_1
XFILLER_0_84_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6068_ _1092_ _1127_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__xor2_1
X_5019_ net171 _1983_ _4184_ VGND VGND VPWR VPWR _4185_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_36_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_103_Left_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5370_ _0391_ _0393_ _0389_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4321_ _1917_ _1961_ VGND VGND VPWR VPWR _1972_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_10_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7040_ net199 net123 VGND VGND VPWR VPWR _2181_ sky130_fd_sc_hd__and2b_1
X_4252_ _1218_ VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__clkbuf_4
Xfanout109 net63 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__buf_1
XFILLER_0_89_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7942_ _3161_ _3172_ VGND VGND VPWR VPWR _3173_ sky130_fd_sc_hd__xnor2_1
X_7873_ _3087_ _3088_ VGND VGND VPWR VPWR _3097_ sky130_fd_sc_hd__nand2_1
X_6824_ _1941_ _1943_ VGND VGND VPWR VPWR _1944_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6755_ _1864_ _1867_ VGND VGND VPWR VPWR _1868_ sky130_fd_sc_hd__xnor2_1
X_5706_ _0458_ net143 VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8425_ net331 _0058_ net254 VGND VGND VPWR VPWR delta\[10\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_72_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6686_ net240 _0868_ _1709_ _1793_ VGND VGND VPWR VPWR _1794_ sky130_fd_sc_hd__a31o_1
XFILLER_0_5_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5637_ _0659_ _0660_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8356_ delta\[10\] counter\[10\] VGND VGND VPWR VPWR _3616_ sky130_fd_sc_hd__nand2_1
X_5568_ _0590_ _0591_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__or2b_1
XFILLER_0_5_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8287_ _3542_ _3551_ VGND VGND VPWR VPWR _3552_ sky130_fd_sc_hd__nand2_1
X_7307_ net247 net278 VGND VGND VPWR VPWR _2474_ sky130_fd_sc_hd__or2b_1
X_4519_ _3670_ _3683_ VGND VGND VPWR VPWR _3685_ sky130_fd_sc_hd__nor2_1
X_5499_ _0522_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__inv_2
X_7238_ _2393_ _2397_ VGND VGND VPWR VPWR _2398_ sky130_fd_sc_hd__xnor2_1
X_7169_ _2314_ _2321_ VGND VGND VPWR VPWR _2322_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_83_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4870_ net162 _4035_ VGND VGND VPWR VPWR _4036_ sky130_fd_sc_hd__nor2_1
X_6540_ net145 net274 VGND VGND VPWR VPWR _1647_ sky130_fd_sc_hd__or2b_1
XFILLER_0_70_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6471_ _1511_ _1516_ _1515_ VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__a21oi_2
X_8210_ _3446_ _3447_ VGND VGND VPWR VPWR _3468_ sky130_fd_sc_hd__xnor2_1
X_5422_ net389 _0445_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_2_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5353_ _0375_ _0376_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__or2_1
X_8141_ _3389_ _3391_ VGND VGND VPWR VPWR _3392_ sky130_fd_sc_hd__nor2_1
X_4304_ net406 _1646_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5284_ net160 net194 net119 net151 VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__and4bb_1
X_8072_ _3307_ _3315_ VGND VGND VPWR VPWR _3316_ sky130_fd_sc_hd__xnor2_1
X_7023_ net23 VGND VGND VPWR VPWR _2162_ sky130_fd_sc_hd__inv_2
X_4235_ _1031_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_4_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7925_ _2799_ _2801_ net390 _2736_ VGND VGND VPWR VPWR _3154_ sky130_fd_sc_hd__a211o_1
X_7856_ _3072_ _3074_ VGND VGND VPWR VPWR _3078_ sky130_fd_sc_hd__nand2_1
XFILLER_0_92_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6807_ net135 _1924_ VGND VGND VPWR VPWR _1925_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7787_ _2999_ _3001_ VGND VGND VPWR VPWR _3002_ sky130_fd_sc_hd__xnor2_1
X_4999_ _4163_ _4164_ VGND VGND VPWR VPWR _4165_ sky130_fd_sc_hd__xor2_1
XFILLER_0_46_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6738_ _1837_ _1848_ VGND VGND VPWR VPWR _1849_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_61_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6669_ net105 net241 VGND VGND VPWR VPWR _1777_ sky130_fd_sc_hd__or2b_1
XFILLER_0_103_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8339_ _3599_ _3600_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout80 counter\[4\] VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__buf_4
Xfanout91 net97 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_64_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5971_ _1019_ _1021_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__nand2_1
X_4922_ _4033_ _4087_ VGND VGND VPWR VPWR _4088_ sky130_fd_sc_hd__xnor2_1
X_7710_ _2914_ _2915_ VGND VGND VPWR VPWR _2918_ sky130_fd_sc_hd__or2_1
XFILLER_0_87_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7641_ _2599_ _2640_ VGND VGND VPWR VPWR _2842_ sky130_fd_sc_hd__and2_1
XFILLER_0_47_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4853_ _4017_ _4018_ VGND VGND VPWR VPWR _4019_ sky130_fd_sc_hd__xor2_2
XFILLER_0_74_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4784_ _3919_ _3949_ VGND VGND VPWR VPWR _3950_ sky130_fd_sc_hd__xor2_2
X_7572_ _2688_ _2694_ VGND VGND VPWR VPWR _2766_ sky130_fd_sc_hd__nand2_1
X_6523_ _1627_ _1562_ _1560_ VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__a21oi_1
X_6454_ _1549_ _1551_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__xnor2_2
X_5405_ _0400_ _0428_ _0398_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__o21a_1
X_6385_ net118 _0916_ _1227_ _1226_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__a31o_1
X_5336_ _0331_ _0336_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__xnor2_1
X_8124_ _3219_ _3268_ _3372_ VGND VGND VPWR VPWR _3373_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_11_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5267_ _1470_ net162 _0264_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__nor3_1
X_8055_ net269 _2162_ VGND VGND VPWR VPWR _3297_ sky130_fd_sc_hd__nand2_2
X_4218_ net244 _0778_ net217 VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__o21ai_1
X_7006_ _1492_ net235 _2140_ VGND VGND VPWR VPWR _2143_ sky130_fd_sc_hd__or3_1
X_5198_ _0216_ _0217_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__or2_1
X_8412__29 clknet_2_3__leaf_clk VGND VGND VPWR VPWR net350 sky130_fd_sc_hd__inv_2
XFILLER_0_78_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7908_ _3099_ _3116_ _3129_ _3133_ _3134_ VGND VGND VPWR VPWR _3135_ sky130_fd_sc_hd__o221a_1
XFILLER_0_65_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7839_ _3025_ _3058_ VGND VGND VPWR VPWR _3059_ sky130_fd_sc_hd__and2b_1
XFILLER_0_93_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout281 net282 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__buf_2
Xfanout292 net293 VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__clkbuf_4
Xfanout270 net15 VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_56_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6170_ _1114_ _1239_ _1117_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__o21ai_2
X_5121_ net173 _1229_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__or2_1
X_5052_ net168 net84 VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__or2b_1
XFILLER_0_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5954_ _1001_ _1002_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__nor2_1
X_5885_ _2455_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__clkbuf_8
X_4905_ _4066_ _4067_ VGND VGND VPWR VPWR _4071_ sky130_fd_sc_hd__nor2_1
X_7624_ _2813_ _2814_ _2822_ VGND VGND VPWR VPWR _2823_ sky130_fd_sc_hd__a21oi_1
X_4836_ _3927_ _3929_ VGND VGND VPWR VPWR _4002_ sky130_fd_sc_hd__xnor2_1
X_7555_ net206 net155 VGND VGND VPWR VPWR _2747_ sky130_fd_sc_hd__and2b_1
XFILLER_0_7_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4767_ _3931_ _3932_ VGND VGND VPWR VPWR _3933_ sky130_fd_sc_hd__xor2_1
XFILLER_0_43_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6506_ _1491_ _1505_ _1608_ VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__a21o_1
XFILLER_0_15_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4698_ _3862_ _3863_ VGND VGND VPWR VPWR _3864_ sky130_fd_sc_hd__xor2_2
X_7486_ _2441_ _2451_ VGND VGND VPWR VPWR _2671_ sky130_fd_sc_hd__or2b_1
XFILLER_0_101_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6437_ _1256_ _1271_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__or2_1
XFILLER_0_3_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6368_ _1356_ _1451_ _1456_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__a21o_1
X_5319_ _0260_ _0342_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__or2b_1
XFILLER_0_87_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8107_ _3294_ _3295_ VGND VGND VPWR VPWR _3354_ sky130_fd_sc_hd__nand2_1
X_6299_ _1380_ _1308_ VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__xnor2_1
Xhold56 delta\[5\] VGND VGND VPWR VPWR net409 sky130_fd_sc_hd__dlygate4sd3_1
X_8038_ _3274_ _3276_ VGND VGND VPWR VPWR _3278_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_9 net299 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_22_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5670_ net120 _0691_ _0692_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__and3_1
XFILLER_0_29_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4621_ _3783_ _3785_ _3786_ VGND VGND VPWR VPWR _3787_ sky130_fd_sc_hd__a21o_1
XFILLER_0_72_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4552_ _3716_ _3717_ VGND VGND VPWR VPWR _3718_ sky130_fd_sc_hd__xor2_2
XFILLER_0_13_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7340_ _1042_ net29 VGND VGND VPWR VPWR _2511_ sky130_fd_sc_hd__nor2_1
X_4483_ _3643_ _3648_ VGND VGND VPWR VPWR _3649_ sky130_fd_sc_hd__xor2_2
XFILLER_0_12_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7271_ _2430_ _2432_ _2434_ VGND VGND VPWR VPWR _2435_ sky130_fd_sc_hd__a21oi_2
X_6222_ net93 _0926_ _1296_ _1295_ VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__a31o_1
XFILLER_0_12_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6153_ _0458_ net50 _1101_ _1100_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__o31ai_4
X_5104_ _0126_ _0127_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__xnor2_2
X_6084_ _1140_ _1144_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__or2_1
X_5035_ _4198_ _4200_ VGND VGND VPWR VPWR _4201_ sky130_fd_sc_hd__xor2_4
XFILLER_0_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6986_ net74 _2046_ _2054_ VGND VGND VPWR VPWR _2122_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_95_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5937_ net114 net271 VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__or2b_1
XFILLER_0_106_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5868_ net50 VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__inv_2
X_7607_ _2629_ _2661_ VGND VGND VPWR VPWR _2804_ sky130_fd_sc_hd__xnor2_1
X_5799_ _0830_ _0831_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__nor2_1
XFILLER_0_16_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4819_ _3983_ _3984_ VGND VGND VPWR VPWR _3985_ sky130_fd_sc_hd__and2_1
XFILLER_0_105_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7538_ _2724_ _2725_ _2726_ VGND VGND VPWR VPWR _2728_ sky130_fd_sc_hd__and3_1
X_7469_ _2649_ _2650_ _2651_ VGND VGND VPWR VPWR _2652_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_31_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput68 net68 VGND VGND VPWR VPWR pwmB sky130_fd_sc_hd__buf_6
XFILLER_0_98_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6840_ _1949_ _1954_ _1955_ _1957_ _1960_ VGND VGND VPWR VPWR _1962_ sky130_fd_sc_hd__a32o_1
X_6771_ net296 net137 _1885_ VGND VGND VPWR VPWR _1886_ sky130_fd_sc_hd__and3_1
X_5722_ _0746_ _0747_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__xor2_1
XFILLER_0_45_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8441_ net347 _0002_ net254 VGND VGND VPWR VPWR counter\[10\] sky130_fd_sc_hd__dfrtp_4
X_5653_ _0676_ _0450_ _0210_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__o21a_1
XFILLER_0_17_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8372_ _3629_ _3630_ VGND VGND VPWR VPWR _3631_ sky130_fd_sc_hd__nand2_1
X_5584_ net152 net178 VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4604_ net197 net148 VGND VGND VPWR VPWR _3770_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4535_ _3676_ _3700_ VGND VGND VPWR VPWR _3701_ sky130_fd_sc_hd__nor2_1
X_7323_ net90 net227 VGND VGND VPWR VPWR _2492_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4466_ net169 net117 net98 VGND VGND VPWR VPWR _3566_ sky130_fd_sc_hd__nand3b_1
X_7254_ _2413_ _2414_ _2415_ VGND VGND VPWR VPWR _2416_ sky130_fd_sc_hd__a21oi_2
X_4397_ _2796_ net162 VGND VGND VPWR VPWR _2807_ sky130_fd_sc_hd__nor2_1
X_6205_ _1216_ _1277_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__xor2_1
X_7185_ _0932_ net29 VGND VGND VPWR VPWR _2340_ sky130_fd_sc_hd__nor2_1
X_6136_ _1193_ _1194_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6067_ _1111_ _1126_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_84_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5018_ net168 net308 VGND VGND VPWR VPWR _4184_ sky130_fd_sc_hd__or2b_1
XFILLER_0_67_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6969_ _1824_ _1831_ _1897_ VGND VGND VPWR VPWR _2103_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_36_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4320_ _1928_ _1939_ _1950_ VGND VGND VPWR VPWR _1961_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_10_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4251_ net319 VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__clkinv_4
XPHY_EDGE_ROW_91_Right_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7941_ _3168_ _3171_ VGND VGND VPWR VPWR _3172_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_54_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7872_ _3090_ _3086_ _3089_ VGND VGND VPWR VPWR _3096_ sky130_fd_sc_hd__and3_1
XFILLER_0_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6823_ _0874_ _1942_ VGND VGND VPWR VPWR _1943_ sky130_fd_sc_hd__nor2_1
X_6754_ _1865_ _1866_ VGND VGND VPWR VPWR _1867_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5705_ _0703_ _0728_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6685_ _1708_ _1660_ VGND VGND VPWR VPWR _1793_ sky130_fd_sc_hd__nor2_1
X_5636_ _0643_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__inv_2
X_8424_ net330 _0057_ net254 VGND VGND VPWR VPWR delta\[9\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_92_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8355_ delta\[10\] counter\[10\] VGND VGND VPWR VPWR _3615_ sky130_fd_sc_hd__nor2_1
X_5567_ _0587_ _0588_ _0589_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__a21o_1
X_5498_ _0482_ _0483_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__nor2_1
X_8286_ _3149_ _2665_ VGND VGND VPWR VPWR _3551_ sky130_fd_sc_hd__or2_1
X_7306_ net200 net269 VGND VGND VPWR VPWR _2473_ sky130_fd_sc_hd__or2b_1
X_4518_ _3670_ _3683_ VGND VGND VPWR VPWR _3684_ sky130_fd_sc_hd__xor2_2
X_4449_ net189 net187 net273 net283 VGND VGND VPWR VPWR _3379_ sky130_fd_sc_hd__and4bb_1
X_7237_ _2394_ _2395_ _2396_ VGND VGND VPWR VPWR _2397_ sky130_fd_sc_hd__o21a_1
XFILLER_0_95_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7168_ _2315_ _2320_ VGND VGND VPWR VPWR _2321_ sky130_fd_sc_hd__xnor2_2
X_6119_ _1180_ _1183_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__nand2_1
X_7099_ _2240_ _2244_ VGND VGND VPWR VPWR _2245_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_95_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6470_ _1564_ _1568_ VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__xnor2_2
X_5421_ net431 net429 _0202_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__o21a_1
X_5352_ _0345_ _0374_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__and2_1
X_8140_ net262 net229 _3388_ VGND VGND VPWR VPWR _3391_ sky130_fd_sc_hd__and3_1
XFILLER_0_2_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4303_ net415 _1646_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__xnor2_1
X_8071_ _3312_ _3314_ VGND VGND VPWR VPWR _3315_ sky130_fd_sc_hd__and2_1
XFILLER_0_49_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7022_ net122 net228 VGND VGND VPWR VPWR _2161_ sky130_fd_sc_hd__nand2_1
X_5283_ net194 net151 VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__or2b_1
X_4234_ net274 VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7924_ _3152_ _2589_ VGND VGND VPWR VPWR _3153_ sky130_fd_sc_hd__nor2_1
X_7855_ _3076_ _3063_ VGND VGND VPWR VPWR _3077_ sky130_fd_sc_hd__xnor2_1
X_6806_ _1922_ _1923_ VGND VGND VPWR VPWR _1924_ sky130_fd_sc_hd__xor2_1
X_7786_ net94 _2883_ _3000_ VGND VGND VPWR VPWR _3001_ sky130_fd_sc_hd__and3_1
X_4998_ _4108_ _4109_ VGND VGND VPWR VPWR _4164_ sky130_fd_sc_hd__xnor2_1
X_6737_ _1845_ _1847_ VGND VGND VPWR VPWR _1848_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_73_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6668_ _1774_ _1775_ VGND VGND VPWR VPWR _1776_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_45_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5619_ _0636_ _0642_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__nand2_1
X_6599_ net110 net212 VGND VGND VPWR VPWR _1707_ sky130_fd_sc_hd__and2b_1
X_8338_ _3594_ _3598_ _3595_ VGND VGND VPWR VPWR _3600_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_14_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8269_ _3422_ _3376_ _3381_ VGND VGND VPWR VPWR _3532_ sky130_fd_sc_hd__and3_1
XFILLER_0_96_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout81 counter\[2\] VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__clkbuf_4
Xfanout92 net97 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__buf_1
XFILLER_0_52_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5970_ _1011_ _1018_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__or2_1
XFILLER_0_35_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4921_ net163 net85 VGND VGND VPWR VPWR _4087_ sky130_fd_sc_hd__and2b_1
X_7640_ _2836_ _2838_ _2839_ VGND VGND VPWR VPWR _2841_ sky130_fd_sc_hd__a21boi_1
X_4852_ _3945_ _3947_ VGND VGND VPWR VPWR _4018_ sky130_fd_sc_hd__xnor2_4
X_7571_ _2688_ _2694_ VGND VGND VPWR VPWR _2765_ sky130_fd_sc_hd__or2_1
X_4783_ _3945_ _3947_ _3948_ VGND VGND VPWR VPWR _3949_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_55_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6522_ _1522_ _1559_ VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6453_ _1523_ _1550_ VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__nor2_1
XFILLER_0_15_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5404_ _0412_ _0418_ net357 _0427_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__a31oi_4
X_8123_ _3266_ _3267_ VGND VGND VPWR VPWR _3372_ sky130_fd_sc_hd__or2b_1
X_6384_ _1230_ _1236_ _1474_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__a21oi_2
X_5335_ _0329_ _0339_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5266_ net151 _2115_ _0266_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__and3_1
X_8054_ _3294_ _3295_ VGND VGND VPWR VPWR _3296_ sky130_fd_sc_hd__xnor2_1
X_7005_ _2138_ _2141_ VGND VGND VPWR VPWR _2142_ sky130_fd_sc_hd__or2b_1
X_4217_ net75 _0811_ _0822_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__or3_1
X_5197_ _0220_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__inv_2
XFILLER_0_78_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7907_ _3118_ _3128_ VGND VGND VPWR VPWR _3134_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7838_ _3034_ _3056_ _3057_ VGND VGND VPWR VPWR _3058_ sky130_fd_sc_hd__a21o_1
XFILLER_0_65_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7769_ _2981_ _2945_ VGND VGND VPWR VPWR _2982_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout271 net272 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__buf_2
Xfanout282 net289 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__clkbuf_4
Xfanout260 net262 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__buf_2
XFILLER_0_88_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout293 net12 VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__buf_6
XFILLER_0_69_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5120_ net168 _1229_ _0107_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__o21a_1
X_5051_ _4193_ _0074_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_79_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5953_ _0962_ _0964_ _1000_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__and3_1
XFILLER_0_75_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4904_ _4069_ _4046_ VGND VGND VPWR VPWR _4070_ sky130_fd_sc_hd__xnor2_1
X_5884_ _0925_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_90_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7623_ _2815_ _2820_ _2821_ VGND VGND VPWR VPWR _2822_ sky130_fd_sc_hd__a21oi_1
X_4835_ _3996_ _3999_ _4000_ VGND VGND VPWR VPWR _4001_ sky130_fd_sc_hd__a21boi_1
X_7554_ net216 _2216_ VGND VGND VPWR VPWR _2746_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4766_ _3852_ _3854_ VGND VGND VPWR VPWR _3932_ sky130_fd_sc_hd__xnor2_1
X_6505_ net402 _1490_ VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7485_ _2468_ _2489_ _2669_ VGND VGND VPWR VPWR _2670_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_43_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4697_ net354 _3785_ VGND VGND VPWR VPWR _3863_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_3_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6436_ net321 net134 VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__nand2_1
X_6367_ _1449_ _1450_ VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__and2b_1
XFILLER_0_101_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5318_ _0327_ _0341_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__xor2_1
X_8106_ _3312_ _3352_ VGND VGND VPWR VPWR _3353_ sky130_fd_sc_hd__xor2_2
X_6298_ net291 _0909_ VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__nand2_1
X_5249_ net159 net193 net151 net182 VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__and4bb_1
X_8037_ _3274_ _3276_ VGND VGND VPWR VPWR _3277_ sky130_fd_sc_hd__or2_2
Xhold57 delta\[7\] VGND VGND VPWR VPWR net410 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_38_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4620_ _3781_ _3782_ VGND VGND VPWR VPWR _3786_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4551_ _3688_ _3689_ VGND VGND VPWR VPWR _3717_ sky130_fd_sc_hd__xnor2_2
X_4482_ _3646_ _3647_ VGND VGND VPWR VPWR _3648_ sky130_fd_sc_hd__xnor2_2
X_7270_ _2369_ _2429_ VGND VGND VPWR VPWR _2434_ sky130_fd_sc_hd__nor2_1
X_6221_ _1290_ _1291_ _1295_ VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_12_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6152_ _1103_ _1109_ _1220_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_57_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5103_ _0093_ _0095_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6083_ _1140_ _1144_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__nand2_1
X_5034_ _4199_ _4135_ VGND VGND VPWR VPWR _4200_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6985_ _2119_ _2120_ _2074_ _2055_ VGND VGND VPWR VPWR _2121_ sky130_fd_sc_hd__a211o_1
XFILLER_0_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5936_ net281 _0925_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__nand2_1
X_5867_ _0902_ _0905_ _0906_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_63_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7606_ _2665_ _2737_ _2802_ VGND VGND VPWR VPWR _2803_ sky130_fd_sc_hd__and3_1
XFILLER_0_48_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5798_ _0809_ _0828_ _0829_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__and3_1
X_4818_ _3975_ _3981_ _3982_ VGND VGND VPWR VPWR _3984_ sky130_fd_sc_hd__nand3_1
X_7537_ _2724_ _2725_ _2726_ VGND VGND VPWR VPWR _2727_ sky130_fd_sc_hd__a21oi_2
X_4749_ _3897_ _3913_ _3914_ VGND VGND VPWR VPWR _3915_ sky130_fd_sc_hd__a21oi_1
X_7468_ _2647_ _2648_ VGND VGND VPWR VPWR _2651_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6419_ net103 net287 VGND VGND VPWR VPWR _1513_ sky130_fd_sc_hd__or2b_1
X_7399_ _2571_ _2573_ _2574_ VGND VGND VPWR VPWR _2575_ sky130_fd_sc_hd__a21oi_2
Xoutput69 net69 VGND VGND VPWR VPWR pwmC sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8393__10 clknet_2_3__leaf_clk VGND VGND VPWR VPWR net331 sky130_fd_sc_hd__inv_2
XFILLER_0_85_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6770_ _1882_ _1883_ VGND VGND VPWR VPWR _1885_ sky130_fd_sc_hd__xor2_1
X_5721_ _0694_ _0696_ _0695_ _0688_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_57_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8440_ net346 _0016_ net254 VGND VGND VPWR VPWR counter\[9\] sky130_fd_sc_hd__dfrtp_1
X_5652_ _0444_ _0449_ _0447_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_5_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8371_ delta\[13\] counter\[13\] VGND VGND VPWR VPWR _3630_ sky130_fd_sc_hd__nand2_1
X_5583_ _0601_ _0605_ _0606_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__or3b_4
XFILLER_0_25_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4603_ _3667_ VGND VGND VPWR VPWR _3769_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_103_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4534_ net175 net393 VGND VGND VPWR VPWR _3700_ sky130_fd_sc_hd__and2b_1
X_7322_ _2437_ _2490_ VGND VGND VPWR VPWR _2491_ sky130_fd_sc_hd__xor2_2
XFILLER_0_7_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4465_ _3159_ _3544_ VGND VGND VPWR VPWR _3555_ sky130_fd_sc_hd__xor2_1
X_7253_ net247 net200 net278 net287 VGND VGND VPWR VPWR _2415_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_7_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4396_ net258 VGND VGND VPWR VPWR _2796_ sky130_fd_sc_hd__inv_2
XFILLER_0_0_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6204_ _1254_ _1276_ VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__xnor2_1
X_7184_ _2332_ _2338_ VGND VGND VPWR VPWR _2339_ sky130_fd_sc_hd__xor2_2
X_6135_ _1200_ _1201_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__nor2_1
X_6066_ _1124_ _1125_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__nor2_1
X_5017_ _4141_ _4182_ VGND VGND VPWR VPWR _4183_ sky130_fd_sc_hd__or2_1
X_6968_ _2003_ _2101_ VGND VGND VPWR VPWR _2102_ sky130_fd_sc_hd__xor2_1
XFILLER_0_48_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6899_ _2024_ _2025_ VGND VGND VPWR VPWR _2026_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5919_ _4035_ net107 _0963_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__or3b_1
XFILLER_0_90_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_17_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4250_ counter\[3\] _1196_ VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__xor2_1
XFILLER_0_10_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_26_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7940_ _2746_ _3169_ _2749_ VGND VGND VPWR VPWR _3171_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_89_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7871_ _3024_ _3094_ VGND VGND VPWR VPWR _3095_ sky130_fd_sc_hd__and2_1
XFILLER_0_89_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6822_ _0865_ _0871_ _0873_ VGND VGND VPWR VPWR _1942_ sky130_fd_sc_hd__nor3_1
XPHY_EDGE_ROW_35_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6753_ _0238_ net139 _1772_ VGND VGND VPWR VPWR _1866_ sky130_fd_sc_hd__nor3_1
XFILLER_0_64_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5704_ _1503_ net146 _0699_ net123 VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_70_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6684_ net61 _1790_ _1791_ VGND VGND VPWR VPWR _1792_ sky130_fd_sc_hd__o21ba_2
XFILLER_0_9_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5635_ _0639_ _0641_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__nand2_1
X_8423_ net329 _0056_ net253 VGND VGND VPWR VPWR delta\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_33_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8354_ _3612_ _3614_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__xor2_1
X_5566_ _0587_ _0588_ _0589_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__and3_1
X_5497_ _0518_ _0520_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__nor2_1
X_8285_ counter\[3\] _3547_ _3549_ net81 VGND VGND VPWR VPWR _3550_ sky130_fd_sc_hd__o22ai_1
X_7305_ _0927_ net235 VGND VGND VPWR VPWR _2472_ sky130_fd_sc_hd__nor2_1
X_4517_ _3671_ _3673_ _3678_ _3680_ _3682_ VGND VGND VPWR VPWR _3683_ sky130_fd_sc_hd__a32oi_4
XPHY_EDGE_ROW_44_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4448_ net189 net273 VGND VGND VPWR VPWR _3368_ sky130_fd_sc_hd__or2b_1
X_7236_ net203 net206 net243 net262 VGND VGND VPWR VPWR _2396_ sky130_fd_sc_hd__or4bb_4
X_4379_ _2082_ _2587_ _2598_ VGND VGND VPWR VPWR _2609_ sky130_fd_sc_hd__a21o_1
X_7167_ _2317_ _2319_ VGND VGND VPWR VPWR _2320_ sky130_fd_sc_hd__nand2_1
X_6118_ _1179_ _1182_ VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__and2_1
X_7098_ _2241_ _2242_ _2243_ VGND VGND VPWR VPWR _2244_ sky130_fd_sc_hd__a21oi_2
X_6049_ _1105_ _1106_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_53_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5420_ counter\[0\] _0443_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__and2_1
X_5351_ _0345_ _0374_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__nor2_1
X_4302_ net409 _1646_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__xnor2_1
X_5282_ net159 net119 VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__or2b_1
X_8070_ _3246_ _3308_ _3311_ VGND VGND VPWR VPWR _3314_ sky130_fd_sc_hd__or3_1
XFILLER_0_10_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7021_ _2155_ _2159_ VGND VGND VPWR VPWR _2160_ sky130_fd_sc_hd__or2b_1
X_4233_ _0767_ _0998_ net78 VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_4_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7923_ _2591_ _2663_ VGND VGND VPWR VPWR _3152_ sky130_fd_sc_hd__nor2_2
X_7854_ net320 _2678_ VGND VGND VPWR VPWR _3076_ sky130_fd_sc_hd__nand2_1
X_6805_ _1910_ _1911_ _1912_ VGND VGND VPWR VPWR _1923_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_77_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7785_ _1218_ net205 VGND VGND VPWR VPWR _3000_ sky130_fd_sc_hd__nor2_1
X_6736_ _1846_ _1799_ _1797_ VGND VGND VPWR VPWR _1847_ sky130_fd_sc_hd__a21o_1
X_4997_ _4149_ _4161_ _4162_ VGND VGND VPWR VPWR _4163_ sky130_fd_sc_hd__a21oi_1
X_6667_ _1119_ net55 VGND VGND VPWR VPWR _1775_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5618_ _0634_ _0635_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__nand2_1
X_6598_ net112 net182 VGND VGND VPWR VPWR _1706_ sky130_fd_sc_hd__and2b_1
XFILLER_0_5_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8337_ delta\[6\] counter\[6\] VGND VGND VPWR VPWR _3599_ sky130_fd_sc_hd__xnor2_1
X_5549_ _0289_ _0296_ _0318_ _0319_ _0326_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__a32o_1
X_8268_ _3520_ _3530_ VGND VGND VPWR VPWR _3531_ sky130_fd_sc_hd__or2b_1
X_8199_ _3428_ _3429_ VGND VGND VPWR VPWR _3455_ sky130_fd_sc_hd__nor2_1
X_7219_ net121 _2286_ _2374_ net101 VGND VGND VPWR VPWR _2377_ sky130_fd_sc_hd__a22o_1
XFILLER_0_96_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout82 counter\[1\] VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_91_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout93 net97 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_101_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4920_ net162 _3901_ VGND VGND VPWR VPWR _4086_ sky130_fd_sc_hd__nor2_1
XFILLER_0_51_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4851_ _4013_ _4015_ _4016_ VGND VGND VPWR VPWR _4017_ sky130_fd_sc_hd__a21oi_2
X_7570_ _2711_ _2716_ _2762_ VGND VGND VPWR VPWR _2764_ sky130_fd_sc_hd__a21o_1
XFILLER_0_7_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4782_ _3943_ net371 VGND VGND VPWR VPWR _3948_ sky130_fd_sc_hd__nor2_1
X_6521_ _1574_ _1556_ VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__and2b_1
XFILLER_0_51_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6452_ net95 _0685_ _1524_ VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__and3_1
XFILLER_0_42_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5403_ _0426_ _0416_ _0411_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_70_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8122_ _3326_ _3327_ VGND VGND VPWR VPWR _3371_ sky130_fd_sc_hd__xnor2_1
X_6383_ _1222_ _1228_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__and2_1
X_5334_ net284 net177 _0356_ _0357_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__a31o_1
XFILLER_0_2_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5265_ _0285_ _0288_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__xor2_2
X_8053_ _3223_ _3228_ _3227_ VGND VGND VPWR VPWR _3295_ sky130_fd_sc_hd__a21oi_2
X_4216_ _0811_ _0822_ net75 VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__o21ai_1
X_7004_ net102 _2139_ _2140_ VGND VGND VPWR VPWR _2141_ sky130_fd_sc_hd__and3_1
X_5196_ _0219_ _3647_ _3645_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__a21o_1
X_7906_ _3066_ _3130_ _3131_ _3132_ VGND VGND VPWR VPWR _3133_ sky130_fd_sc_hd__o211a_1
X_7837_ _3054_ _3055_ VGND VGND VPWR VPWR _3057_ sky130_fd_sc_hd__nor2_1
X_7768_ net294 _2287_ VGND VGND VPWR VPWR _2981_ sky130_fd_sc_hd__nand2_1
XFILLER_0_80_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6719_ _1814_ _1816_ _1751_ net394 VGND VGND VPWR VPWR _1828_ sky130_fd_sc_hd__a211o_1
X_7699_ _2903_ _2904_ VGND VGND VPWR VPWR _2905_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout250 net18 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__buf_1
Xfanout261 net262 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__clkbuf_4
Xfanout272 net275 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__buf_2
Xfanout283 net284 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__buf_4
Xfanout294 net295 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_69_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5050_ _0072_ _0073_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_9_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5952_ _0962_ _0964_ _1000_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_1_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4903_ _4024_ _4026_ VGND VGND VPWR VPWR _4069_ sky130_fd_sc_hd__nand2_1
X_5883_ net61 VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__inv_2
XFILLER_0_7_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7622_ _2813_ _2814_ VGND VGND VPWR VPWR _2821_ sky130_fd_sc_hd__xnor2_1
X_4834_ _3993_ _3995_ VGND VGND VPWR VPWR _4000_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7553_ _2679_ _2677_ VGND VGND VPWR VPWR _2745_ sky130_fd_sc_hd__nand2_1
XFILLER_0_16_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4765_ _3927_ _3929_ _3930_ VGND VGND VPWR VPWR _3931_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_55_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6504_ _1588_ _1606_ VGND VGND VPWR VPWR _1607_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_43_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4696_ _3858_ _3860_ _3861_ VGND VGND VPWR VPWR _3862_ sky130_fd_sc_hd__a21oi_4
X_7484_ _2439_ _2467_ VGND VGND VPWR VPWR _2669_ sky130_fd_sc_hd__nor2_1
X_6435_ _1471_ _1530_ VGND VGND VPWR VPWR _1531_ sky130_fd_sc_hd__xor2_2
XFILLER_0_101_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6366_ _1422_ _1446_ _1452_ _1453_ _1454_ VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__o221ai_2
X_5317_ _0329_ _0339_ _0340_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__a21boi_1
X_8105_ _3345_ _3351_ VGND VGND VPWR VPWR _3352_ sky130_fd_sc_hd__xor2_2
X_8036_ _2738_ net375 _3275_ VGND VGND VPWR VPWR _3276_ sky130_fd_sc_hd__a21oi_1
X_6297_ _1374_ _1378_ _1377_ VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__a21o_1
X_5248_ net193 net182 VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__or2b_1
XFILLER_0_98_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold58 delta\[9\] VGND VGND VPWR VPWR net411 sky130_fd_sc_hd__dlygate4sd3_1
X_5179_ net369 _3952_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__and2_1
XFILLER_0_66_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4550_ _3694_ _3714_ _3715_ VGND VGND VPWR VPWR _3716_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_4_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8388__5 clknet_2_1__leaf_clk VGND VGND VPWR VPWR net326 sky130_fd_sc_hd__inv_2
X_4481_ _2202_ net162 VGND VGND VPWR VPWR _3647_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6220_ _1292_ _1293_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6151_ _1095_ _1102_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__nand2_1
X_5102_ _0122_ _0124_ _0125_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__a21bo_1
X_6082_ _1142_ _1143_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__and2_1
X_5033_ _3769_ net290 VGND VGND VPWR VPWR _4199_ sky130_fd_sc_hd__nand2_2
X_6984_ _2067_ _2062_ _2073_ VGND VGND VPWR VPWR _2120_ sky130_fd_sc_hd__a21oi_1
X_5935_ _0974_ _0981_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__xor2_1
X_5866_ _0839_ _0904_ _0803_ _0903_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__o211a_1
XFILLER_0_87_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7605_ _2799_ _2801_ VGND VGND VPWR VPWR _2802_ sky130_fd_sc_hd__xor2_1
X_4817_ _3975_ _3981_ _3982_ VGND VGND VPWR VPWR _3983_ sky130_fd_sc_hd__a21o_1
X_5797_ _0809_ _0828_ _0829_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_7_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7536_ _2481_ _2482_ _2483_ VGND VGND VPWR VPWR _2726_ sky130_fd_sc_hd__o21ba_1
X_4748_ _3826_ _3828_ _3829_ VGND VGND VPWR VPWR _3914_ sky130_fd_sc_hd__o21ba_1
X_7467_ _2627_ _2614_ VGND VGND VPWR VPWR _2650_ sky130_fd_sc_hd__xnor2_2
X_4679_ net197 net180 VGND VGND VPWR VPWR _3845_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6418_ net144 net296 VGND VGND VPWR VPWR _1512_ sky130_fd_sc_hd__or2b_1
XFILLER_0_101_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7398_ _2569_ _2570_ VGND VGND VPWR VPWR _2574_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6349_ _1240_ net124 _1432_ VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__o21ai_1
X_8019_ _3255_ _3256_ VGND VGND VPWR VPWR _3257_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_86_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5720_ _0736_ _0743_ _0744_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_99_Left_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5651_ _0667_ _0674_ _0658_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__o21a_1
XFILLER_0_72_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8370_ delta\[13\] counter\[13\] VGND VGND VPWR VPWR _3629_ sky130_fd_sc_hd__or2_1
X_5582_ net77 _0604_ _0600_ net78 VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__o22a_1
X_4602_ _3697_ _3711_ VGND VGND VPWR VPWR _3768_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_25_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4533_ _3667_ net180 VGND VGND VPWR VPWR _3699_ sky130_fd_sc_hd__nand2_1
X_7321_ _2468_ _2489_ VGND VGND VPWR VPWR _2490_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_102_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7252_ net247 net287 VGND VGND VPWR VPWR _2414_ sky130_fd_sc_hd__or2b_1
X_4464_ _3357_ _3533_ VGND VGND VPWR VPWR _3544_ sky130_fd_sc_hd__xnor2_1
X_6203_ _1274_ _1275_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__and2_1
XFILLER_0_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4395_ _2752_ _2763_ _2774_ VGND VGND VPWR VPWR _2785_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7183_ _2333_ _2337_ VGND VGND VPWR VPWR _2338_ sky130_fd_sc_hd__xnor2_2
X_6134_ _1197_ _1189_ _1199_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__nor3_1
X_6065_ _1121_ _1123_ _1113_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_84_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5016_ net171 net309 VGND VGND VPWR VPWR _4182_ sky130_fd_sc_hd__or2b_1
XFILLER_0_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6967_ _1894_ _2075_ VGND VGND VPWR VPWR _2101_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5918_ _0960_ _0961_ _0962_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__o21a_1
X_6898_ _2022_ _2023_ VGND VGND VPWR VPWR _2025_ sky130_fd_sc_hd__nand2_1
X_5849_ _0883_ _0884_ _0885_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__or3b_1
XFILLER_0_8_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7519_ _2704_ _2705_ _2706_ VGND VGND VPWR VPWR _2707_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_102_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7870_ _3091_ _3092_ _3059_ VGND VGND VPWR VPWR _3094_ sky130_fd_sc_hd__a21o_1
X_6821_ _1938_ _1940_ VGND VGND VPWR VPWR _1941_ sky130_fd_sc_hd__nor2_1
X_6752_ _0238_ net140 net139 _1042_ VGND VGND VPWR VPWR _1865_ sky130_fd_sc_hd__o22a_1
XFILLER_0_73_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5703_ _0720_ _0726_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__nand2_1
X_6683_ _1481_ net116 net61 _1426_ VGND VGND VPWR VPWR _1791_ sky130_fd_sc_hd__o22a_1
X_5634_ net73 _0654_ _0657_ net74 VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__o22a_1
X_8422_ net328 _0055_ net253 VGND VGND VPWR VPWR delta\[7\] sky130_fd_sc_hd__dfrtp_1
X_8353_ delta\[8\] counter\[8\] _3613_ VGND VGND VPWR VPWR _3614_ sky130_fd_sc_hd__o21ai_2
X_5565_ _0567_ _0566_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__xnor2_1
X_7304_ _2392_ _2402_ _2399_ VGND VGND VPWR VPWR _2471_ sky130_fd_sc_hd__a21boi_4
X_5496_ _0517_ _0519_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__or2_1
X_8284_ net374 _3543_ VGND VGND VPWR VPWR _3549_ sky130_fd_sc_hd__xnor2_1
X_4516_ _3681_ _3678_ VGND VGND VPWR VPWR _3682_ sky130_fd_sc_hd__xnor2_2
X_4447_ _3192_ _3335_ _3346_ VGND VGND VPWR VPWR _3357_ sky130_fd_sc_hd__o21a_1
X_7235_ net203 net260 VGND VGND VPWR VPWR _2395_ sky130_fd_sc_hd__and2b_1
XFILLER_0_0_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7166_ _2318_ _2226_ VGND VGND VPWR VPWR _2319_ sky130_fd_sc_hd__or2_1
X_4378_ _2356_ _2576_ VGND VGND VPWR VPWR _2598_ sky130_fd_sc_hd__nor2_1
X_6117_ net87 _1181_ _0863_ net93 VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__a22o_1
X_7097_ net248 net201 net287 net296 VGND VGND VPWR VPWR _2243_ sky130_fd_sc_hd__and4bb_1
X_6048_ _0921_ net125 _1043_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__o21ai_1
X_7999_ _3233_ _3234_ VGND VGND VPWR VPWR _3235_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5350_ _0358_ _0372_ _0373_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_23_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4301_ net416 _1657_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__xnor2_1
X_5281_ _0302_ _0304_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_10_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8409__26 clknet_2_3__leaf_clk VGND VGND VPWR VPWR net347 sky130_fd_sc_hd__inv_2
X_7020_ _2156_ _2157_ VGND VGND VPWR VPWR _2159_ sky130_fd_sc_hd__xnor2_1
X_4232_ net78 _0767_ _0998_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__and3_1
XFILLER_0_10_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7922_ _2737_ _2802_ VGND VGND VPWR VPWR _3151_ sky130_fd_sc_hd__nand2_1
XFILLER_0_81_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7853_ _3072_ _3074_ VGND VGND VPWR VPWR _3075_ sky130_fd_sc_hd__xor2_1
XFILLER_0_92_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6804_ _1916_ _1920_ _1921_ VGND VGND VPWR VPWR _1922_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_65_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7784_ _2996_ _2998_ VGND VGND VPWR VPWR _2999_ sky130_fd_sc_hd__xor2_1
X_4996_ _4147_ _4148_ VGND VGND VPWR VPWR _4162_ sky130_fd_sc_hd__nor2_1
XFILLER_0_105_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6735_ _1796_ _1708_ VGND VGND VPWR VPWR _1846_ sky130_fd_sc_hd__nand2_1
XFILLER_0_61_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6666_ _1772_ _1732_ _1773_ VGND VGND VPWR VPWR _1774_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_33_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5617_ _0637_ _0593_ _0640_ _0546_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__o211a_1
X_6597_ net400 _0868_ VGND VGND VPWR VPWR _1705_ sky130_fd_sc_hd__nand2_1
X_8336_ _3596_ _3598_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__xnor2_1
X_5548_ _0558_ _0563_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8267_ _2080_ _3517_ _3525_ _3529_ VGND VGND VPWR VPWR _3530_ sky130_fd_sc_hd__o211a_1
XFILLER_0_41_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5479_ net72 _0502_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__nand2_1
X_7218_ net154 _2287_ _2337_ _2375_ VGND VGND VPWR VPWR _2376_ sky130_fd_sc_hd__a31o_1
X_8198_ _3451_ _3453_ VGND VGND VPWR VPWR _3454_ sky130_fd_sc_hd__nor2_1
X_7149_ _2293_ _2299_ VGND VGND VPWR VPWR _2300_ sky130_fd_sc_hd__xor2_2
XFILLER_0_96_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout94 net97 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_91_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_86_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4850_ _4011_ _4012_ VGND VGND VPWR VPWR _4016_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_72_Left_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6520_ _1557_ _1573_ VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__and2_1
XFILLER_0_51_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4781_ _3946_ _3917_ VGND VGND VPWR VPWR _3947_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_55_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6451_ _1510_ _1527_ _1548_ VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__a21o_1
X_5402_ _0401_ _0409_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__or2_1
X_6382_ _1238_ _1252_ _1472_ VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__a21oi_2
X_5333_ _0250_ _0346_ _0351_ _0355_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__o22a_1
X_8121_ _3367_ _3369_ VGND VGND VPWR VPWR _3370_ sky130_fd_sc_hd__or2b_1
XFILLER_0_23_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_81_Left_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5264_ _0286_ _0242_ _0287_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__a21oi_2
X_8052_ _3288_ _3293_ VGND VGND VPWR VPWR _3294_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_11_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4215_ net156 _0800_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__and2_1
X_7003_ net246 net122 VGND VGND VPWR VPWR _2140_ sky130_fd_sc_hd__or2b_1
X_5195_ _3644_ _3280_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__nand2_1
X_7905_ _3098_ _3125_ VGND VGND VPWR VPWR _3132_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_90_Left_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7836_ _3054_ _3055_ VGND VGND VPWR VPWR _3056_ sky130_fd_sc_hd__xor2_1
XFILLER_0_19_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4979_ _4140_ _4144_ VGND VGND VPWR VPWR _4145_ sky130_fd_sc_hd__xnor2_2
X_7767_ net302 _2449_ _2979_ _2978_ VGND VGND VPWR VPWR _2980_ sky130_fd_sc_hd__a31o_1
X_6718_ _1620_ _1622_ _1819_ _1821_ VGND VGND VPWR VPWR _1827_ sky130_fd_sc_hd__o22a_1
XFILLER_0_18_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7698_ _2899_ _2900_ _2902_ VGND VGND VPWR VPWR _2904_ sky130_fd_sc_hd__and3_1
X_6649_ _1754_ _1756_ VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__xor2_1
XFILLER_0_104_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8319_ delta\[2\] net81 VGND VGND VPWR VPWR _3583_ sky130_fd_sc_hd__nor2_1
Xfanout240 net241 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__buf_8
Xfanout251 net18 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__buf_2
Xfanout262 net16 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__buf_2
Xfanout273 net274 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__buf_6
Xfanout295 net12 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__clkbuf_4
Xfanout284 net289 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__buf_6
XFILLER_0_56_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5951_ _0992_ _0999_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4902_ _4066_ _4067_ VGND VGND VPWR VPWR _4068_ sky130_fd_sc_hd__xor2_1
XFILLER_0_87_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5882_ _0915_ _0923_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__xor2_2
XFILLER_0_75_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7621_ _4035_ net32 _2819_ VGND VGND VPWR VPWR _2820_ sky130_fd_sc_hd__or3b_1
X_4833_ _3998_ _3957_ VGND VGND VPWR VPWR _3999_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_90_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7552_ net244 _2216_ _2693_ _2692_ VGND VGND VPWR VPWR _2744_ sky130_fd_sc_hd__a31o_1
XFILLER_0_55_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4764_ _3924_ _3926_ VGND VGND VPWR VPWR _3930_ sky130_fd_sc_hd__nand2_1
X_6503_ _1603_ _1605_ VGND VGND VPWR VPWR _1606_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_7_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_422 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7483_ _2491_ _2500_ _2667_ VGND VGND VPWR VPWR _2668_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_31_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4695_ _3856_ _3857_ VGND VGND VPWR VPWR _3861_ sky130_fd_sc_hd__nor2_1
X_6434_ _1507_ _1529_ VGND VGND VPWR VPWR _1530_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_102_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6365_ _1363_ _1441_ _1419_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__or3b_1
XFILLER_0_3_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5316_ _0330_ _0338_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__or2b_1
X_8104_ _3347_ _3350_ VGND VGND VPWR VPWR _3351_ sky130_fd_sc_hd__xnor2_2
X_6296_ _1375_ _1376_ _1377_ VGND VGND VPWR VPWR _1378_ sky130_fd_sc_hd__a21oi_1
X_5247_ net159 net151 VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__or2b_1
X_8035_ _2740_ _2797_ VGND VGND VPWR VPWR _3275_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold59 delta\[13\] VGND VGND VPWR VPWR net412 sky130_fd_sc_hd__dlygate4sd3_1
X_5178_ _0200_ net382 VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__or2_1
XFILLER_0_97_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7819_ net249 net295 VGND VGND VPWR VPWR _3037_ sky130_fd_sc_hd__or2b_1
XFILLER_0_53_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4480_ _3644_ _3280_ _3645_ VGND VGND VPWR VPWR _3646_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6150_ _1111_ _1126_ _1217_ VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__a21oi_2
X_5101_ _0119_ _0121_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6081_ _3901_ _1218_ net141 net138 VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__or4_1
X_5032_ _3769_ net298 _4197_ _4196_ VGND VGND VPWR VPWR _4198_ sky130_fd_sc_hd__a31o_2
XFILLER_0_79_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6983_ _2114_ _2118_ _2068_ VGND VGND VPWR VPWR _2119_ sky130_fd_sc_hd__a21o_1
X_5934_ _0975_ _0980_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__xnor2_1
X_5865_ _0803_ _0903_ _0839_ _0904_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__a211o_1
XFILLER_0_75_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7604_ _2666_ _2733_ _2800_ VGND VGND VPWR VPWR _2801_ sky130_fd_sc_hd__a21oi_2
X_4816_ _3902_ _3904_ VGND VGND VPWR VPWR _3982_ sky130_fd_sc_hd__xnor2_1
X_5796_ _0780_ _0781_ _0783_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_105_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4747_ _3898_ _3912_ VGND VGND VPWR VPWR _3913_ sky130_fd_sc_hd__or2b_1
X_7535_ _2487_ _2470_ VGND VGND VPWR VPWR _2725_ sky130_fd_sc_hd__or2b_1
XFILLER_0_98_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4678_ _3767_ _3788_ VGND VGND VPWR VPWR _3844_ sky130_fd_sc_hd__xnor2_2
X_7466_ _2647_ _2648_ VGND VGND VPWR VPWR _2649_ sky130_fd_sc_hd__xor2_2
X_7397_ _2542_ _2572_ VGND VGND VPWR VPWR _2573_ sky130_fd_sc_hd__and2_1
X_6417_ _1983_ net142 VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__nor2_1
X_6348_ _1423_ _1434_ VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__nand2_1
X_6279_ _1353_ _1358_ VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__xor2_1
X_8018_ _2754_ _2757_ _3173_ _3174_ _3197_ VGND VGND VPWR VPWR _3256_ sky130_fd_sc_hd__a32o_1
XFILLER_0_98_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8390__7 clknet_2_2__leaf_clk VGND VGND VPWR VPWR net328 sky130_fd_sc_hd__inv_2
X_5650_ net74 _0657_ _0666_ net75 VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__a22o_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_84_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4601_ _3756_ net376 VGND VGND VPWR VPWR _3767_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_38_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5581_ counter\[10\] _0602_ _0604_ net77 VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__a22o_1
XFILLER_0_5_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4532_ _3680_ _3682_ VGND VGND VPWR VPWR _3698_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_4_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7320_ _2470_ _2487_ VGND VGND VPWR VPWR _2489_ sky130_fd_sc_hd__xnor2_2
X_4463_ _3434_ _3522_ VGND VGND VPWR VPWR _3533_ sky130_fd_sc_hd__xor2_1
X_7251_ net200 net278 VGND VGND VPWR VPWR _2413_ sky130_fd_sc_hd__or2b_1
XFILLER_0_68_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6202_ _1255_ _1145_ _1273_ VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__nand3_1
X_4394_ net166 net164 net210 net239 VGND VGND VPWR VPWR _2774_ sky130_fd_sc_hd__and4bb_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7182_ _2335_ _2336_ VGND VGND VPWR VPWR _2337_ sky130_fd_sc_hd__xnor2_2
X_6133_ _1197_ _1189_ _1199_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__o21a_1
X_6064_ _1113_ _1121_ _1123_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__and3_1
X_5015_ _4023_ _4127_ _4129_ _4180_ VGND VGND VPWR VPWR _4181_ sky130_fd_sc_hd__o211a_1
XFILLER_0_84_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6966_ _2090_ _2097_ _2098_ _2099_ VGND VGND VPWR VPWR _2100_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_67_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5917_ net111 net108 net301 net311 VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__or4bb_1
X_6897_ _2022_ _2023_ VGND VGND VPWR VPWR _2024_ sky130_fd_sc_hd__or2_1
XFILLER_0_36_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5848_ _0883_ _0884_ _0885_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_75_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5779_ net71 _0808_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_90_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7518_ net247 net200 net261 net269 VGND VGND VPWR VPWR _2706_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_44_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7449_ net225 net260 VGND VGND VPWR VPWR _2630_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_89_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6820_ _1934_ _1937_ VGND VGND VPWR VPWR _1940_ sky130_fd_sc_hd__and2_1
X_6751_ net289 _0684_ VGND VGND VPWR VPWR _1864_ sky130_fd_sc_hd__nand2_1
X_5702_ _0707_ _0710_ _0719_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__nand3_1
XFILLER_0_72_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6682_ _1470_ _1695_ VGND VGND VPWR VPWR _1790_ sky130_fd_sc_hd__or2_1
XFILLER_0_18_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5633_ _0651_ _0656_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__xnor2_2
X_8421_ net327 _0054_ net253 VGND VGND VPWR VPWR delta\[6\] sky130_fd_sc_hd__dfrtp_1
X_8352_ delta\[8\] counter\[8\] _3608_ VGND VGND VPWR VPWR _3613_ sky130_fd_sc_hd__a21o_1
X_5564_ _0571_ _0574_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4515_ _3671_ _3673_ VGND VGND VPWR VPWR _3681_ sky130_fd_sc_hd__nand2_1
X_7303_ _2419_ _2425_ _2469_ VGND VGND VPWR VPWR _2470_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_103_Right_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5495_ _0501_ _0516_ _0515_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__o21a_1
X_8283_ counter\[3\] _3547_ VGND VGND VPWR VPWR _3548_ sky130_fd_sc_hd__and2_1
X_4446_ _3258_ _3324_ VGND VGND VPWR VPWR _3346_ sky130_fd_sc_hd__nand2_1
X_7234_ net206 net243 VGND VGND VPWR VPWR _2394_ sky130_fd_sc_hd__and2b_1
X_4377_ _2356_ _2576_ VGND VGND VPWR VPWR _2587_ sky130_fd_sc_hd__xor2_1
X_7165_ net220 net215 VGND VGND VPWR VPWR _2318_ sky130_fd_sc_hd__or2b_1
XFILLER_0_95_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6116_ net111 VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__inv_2
X_7096_ net248 net296 VGND VGND VPWR VPWR _2242_ sky130_fd_sc_hd__or2b_1
X_6047_ _0921_ net125 _1043_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__or3_1
XFILLER_0_68_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7998_ net261 net269 _2128_ _2130_ VGND VGND VPWR VPWR _3234_ sky130_fd_sc_hd__and4_1
XFILLER_0_83_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6949_ net79 _2077_ _2079_ _2080_ VGND VGND VPWR VPWR _2081_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_48_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4300_ net410 _1657_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__xnor2_1
X_5280_ _0303_ net39 VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__nor2_1
XFILLER_0_49_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4231_ net278 _0756_ net269 VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_65_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7921_ _2590_ _2803_ _3149_ VGND VGND VPWR VPWR _3150_ sky130_fd_sc_hd__nand3b_4
XFILLER_0_81_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7852_ _3073_ _3041_ VGND VGND VPWR VPWR _3074_ sky130_fd_sc_hd__xnor2_1
X_6803_ _1905_ _1915_ VGND VGND VPWR VPWR _1921_ sky130_fd_sc_hd__and2b_1
XFILLER_0_58_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7783_ _2932_ _2997_ VGND VGND VPWR VPWR _2998_ sky130_fd_sc_hd__xor2_1
X_4995_ _4159_ _4160_ VGND VGND VPWR VPWR _4161_ sky130_fd_sc_hd__nor2_1
XFILLER_0_81_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6734_ _1843_ _1844_ VGND VGND VPWR VPWR _1845_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_73_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6665_ _0927_ net138 _1772_ VGND VGND VPWR VPWR _1773_ sky130_fd_sc_hd__nor3_1
XFILLER_0_45_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5616_ _0547_ _0595_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__nand2_1
X_6596_ _1669_ _1673_ _1672_ VGND VGND VPWR VPWR _1704_ sky130_fd_sc_hd__a21o_1
X_8335_ delta\[4\] net80 _3597_ VGND VGND VPWR VPWR _3598_ sky130_fd_sc_hd__o21ai_2
X_5547_ net267 net178 _0324_ _0570_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__a31o_1
XFILLER_0_14_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5478_ _0474_ _0479_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__xor2_1
X_8266_ net80 _3527_ _3528_ VGND VGND VPWR VPWR _3529_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4429_ _2939_ _3016_ _3148_ VGND VGND VPWR VPWR _3159_ sky130_fd_sc_hd__a21o_1
X_7217_ net101 _2374_ _2308_ VGND VGND VPWR VPWR _2375_ sky130_fd_sc_hd__and3_1
X_8197_ _3450_ _3452_ VGND VGND VPWR VPWR _3453_ sky130_fd_sc_hd__or2_1
X_7148_ _2294_ _2298_ VGND VGND VPWR VPWR _2299_ sky130_fd_sc_hd__xnor2_2
X_7079_ _0238_ net29 VGND VGND VPWR VPWR _2223_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_100_Left_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout73 counter\[15\] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_64_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout95 net96 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__clkbuf_4
Xfanout84 net85 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4780_ net318 net179 VGND VGND VPWR VPWR _3946_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6450_ _1528_ _1509_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__and2b_1
X_5401_ _0200_ _0421_ _0422_ _0424_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_23_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6381_ _1221_ _1237_ VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__nor2_1
XFILLER_0_42_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5332_ _0250_ _0346_ _0351_ _0355_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__or4_1
X_8120_ _3366_ _3323_ _3328_ VGND VGND VPWR VPWR _3369_ sky130_fd_sc_hd__nand3_1
XFILLER_0_23_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8051_ _3289_ _3290_ _3292_ VGND VGND VPWR VPWR _3293_ sky130_fd_sc_hd__a21oi_2
X_5263_ _0229_ _0235_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__nor2_1
X_4214_ net156 _0800_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__nor2_1
XFILLER_0_76_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7002_ net235 VGND VGND VPWR VPWR _2139_ sky130_fd_sc_hd__inv_2
X_5194_ _0216_ _0217_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_92_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7904_ net249 _3127_ _3122_ net320 VGND VGND VPWR VPWR _3131_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_78_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7835_ _2995_ _3002_ VGND VGND VPWR VPWR _3055_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4978_ _4141_ _4142_ _4143_ VGND VGND VPWR VPWR _4144_ sky130_fd_sc_hd__a21oi_2
X_7766_ _2976_ _2977_ _2978_ VGND VGND VPWR VPWR _2979_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_18_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6717_ _1819_ _1821_ VGND VGND VPWR VPWR _1826_ sky130_fd_sc_hd__and2_1
X_7697_ _2899_ _2900_ _2902_ VGND VGND VPWR VPWR _2903_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_46_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6648_ _1554_ _1615_ _1755_ VGND VGND VPWR VPWR _1756_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_104_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8318_ _0001_ _3581_ _3579_ VGND VGND VPWR VPWR _3582_ sky130_fd_sc_hd__o21a_1
X_6579_ _1684_ _1686_ VGND VGND VPWR VPWR _1687_ sky130_fd_sc_hd__xnor2_1
X_8249_ _3465_ _3509_ VGND VGND VPWR VPWR _3510_ sky130_fd_sc_hd__xnor2_1
Xfanout241 net242 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__buf_8
Xfanout230 net24 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__clkbuf_2
Xfanout252 net255 VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__clkbuf_4
Xfanout263 net15 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__buf_2
Xfanout274 net275 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__buf_6
Xfanout285 net286 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__buf_2
Xfanout296 net297 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__buf_2
XFILLER_0_88_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5950_ _0993_ _0997_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__xnor2_1
X_4901_ _4003_ _4004_ VGND VGND VPWR VPWR _4067_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7620_ _2816_ _2817_ _2815_ VGND VGND VPWR VPWR _2819_ sky130_fd_sc_hd__a21boi_1
X_5881_ _0917_ _0922_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_47_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4832_ _3997_ net282 VGND VGND VPWR VPWR _3998_ sky130_fd_sc_hd__nand2_1
XFILLER_0_90_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7551_ _2699_ _2720_ _2742_ VGND VGND VPWR VPWR _2743_ sky130_fd_sc_hd__a21o_1
X_4763_ _3893_ _3928_ VGND VGND VPWR VPWR _3929_ sky130_fd_sc_hd__and2_1
X_4694_ _3804_ _3859_ VGND VGND VPWR VPWR _3860_ sky130_fd_sc_hd__xnor2_2
X_6502_ _1483_ _1489_ _1604_ VGND VGND VPWR VPWR _1605_ sky130_fd_sc_hd__a21bo_1
X_7482_ _2437_ _2490_ VGND VGND VPWR VPWR _2667_ sky130_fd_sc_hd__nor2_1
XFILLER_0_102_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6433_ _1509_ _1528_ VGND VGND VPWR VPWR _1529_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_11_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6364_ _1362_ _1420_ _1361_ VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_11_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5315_ _0330_ _0338_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__xnor2_1
X_8103_ _3348_ _3349_ VGND VGND VPWR VPWR _3350_ sky130_fd_sc_hd__nor2_1
X_6295_ net127 net130 net308 net84 VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__and4bb_1
X_5246_ _0269_ net192 VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__nor2_1
X_8034_ _3216_ net426 VGND VGND VPWR VPWR _3274_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_89_Right_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5177_ _3953_ _4021_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_98_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_98_Right_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7818_ _3034_ _3035_ VGND VGND VPWR VPWR _3036_ sky130_fd_sc_hd__nor2_1
X_7749_ _2957_ _2958_ _2959_ VGND VGND VPWR VPWR _2960_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_46_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5100_ _0123_ _0109_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6080_ net96 _0691_ _0687_ net320 VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__a22o_1
X_5031_ _4194_ _4195_ _4196_ VGND VGND VPWR VPWR _4197_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_79_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6982_ _2081_ _2088_ _2117_ _2110_ VGND VGND VPWR VPWR _2118_ sky130_fd_sc_hd__or4b_1
X_5933_ _0977_ _0978_ _0979_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__a21oi_1
X_5864_ _0830_ _0840_ _0845_ _0842_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__o211a_1
XFILLER_0_63_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4815_ _3977_ _3980_ _3975_ VGND VGND VPWR VPWR _3981_ sky130_fd_sc_hd__nand3b_1
X_7603_ net401 _2732_ VGND VGND VPWR VPWR _2800_ sky130_fd_sc_hd__nor2_1
X_5795_ _0810_ _0827_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__or2b_1
XFILLER_0_56_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7534_ _2471_ _2486_ VGND VGND VPWR VPWR _2724_ sky130_fd_sc_hd__or2_1
XFILLER_0_28_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4746_ _3907_ _3910_ _3911_ VGND VGND VPWR VPWR _3912_ sky130_fd_sc_hd__a21o_1
XFILLER_0_31_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7465_ _2563_ _2567_ VGND VGND VPWR VPWR _2648_ sky130_fd_sc_hd__xnor2_2
X_4677_ _3838_ _3842_ VGND VGND VPWR VPWR _3843_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_101_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7396_ _2535_ _2540_ _2541_ VGND VGND VPWR VPWR _2572_ sky130_fd_sc_hd__nand3_1
X_6416_ _1241_ _1250_ _1249_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__a21o_1
X_6347_ _1425_ _1431_ _1433_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_101_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6278_ _1356_ _1357_ VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__nor2_1
X_5229_ _0245_ _0246_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__nor2_1
X_8017_ _3243_ _3254_ VGND VGND VPWR VPWR _3255_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap70 _0839_ VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__buf_1
XFILLER_0_76_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4600_ _3694_ _3714_ VGND VGND VPWR VPWR _3766_ sky130_fd_sc_hd__xnor2_2
X_5580_ _0592_ _0603_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__xor2_2
X_4531_ _2169_ _3696_ VGND VGND VPWR VPWR _3697_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_25_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4462_ _3500_ _3511_ VGND VGND VPWR VPWR _3522_ sky130_fd_sc_hd__xor2_1
X_7250_ _1119_ net235 VGND VGND VPWR VPWR _2412_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6201_ _1255_ _1145_ _1273_ VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__a21o_1
X_4393_ net164 net239 VGND VGND VPWR VPWR _2763_ sky130_fd_sc_hd__or2b_4
XFILLER_0_0_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7181_ net18 net101 VGND VGND VPWR VPWR _2336_ sky130_fd_sc_hd__and2b_1
X_6132_ _1011_ _1198_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__nor2_1
X_6063_ _1041_ _1045_ _1120_ _1122_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__a211o_1
X_5014_ _4122_ _4126_ _4130_ _4179_ VGND VGND VPWR VPWR _4180_ sky130_fd_sc_hd__o22a_1
XFILLER_0_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6965_ counter\[0\] _2091_ VGND VGND VPWR VPWR _2099_ sky130_fd_sc_hd__or2_1
X_5916_ net111 net301 VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__and2b_1
XFILLER_0_91_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6896_ _1985_ _1987_ _1989_ VGND VGND VPWR VPWR _2023_ sky130_fd_sc_hd__o21a_1
XFILLER_0_75_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5847_ _0814_ _0815_ _0813_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_63_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5778_ net71 _0808_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__nand2_1
X_7517_ net247 net269 VGND VGND VPWR VPWR _2705_ sky130_fd_sc_hd__or2b_1
XFILLER_0_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4729_ _3883_ _3891_ _3894_ VGND VGND VPWR VPWR _3895_ sky130_fd_sc_hd__a21boi_2
X_7448_ _2613_ _2628_ _2537_ VGND VGND VPWR VPWR _2629_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_31_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7379_ net260 _2287_ _2552_ _2551_ VGND VGND VPWR VPWR _2553_ sky130_fd_sc_hd__a31o_1
XFILLER_0_98_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6750_ _1860_ _1861_ VGND VGND VPWR VPWR _1863_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5701_ _0721_ _0724_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6681_ _1770_ _1788_ VGND VGND VPWR VPWR _1789_ sky130_fd_sc_hd__xor2_2
XFILLER_0_57_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5632_ _0632_ _0636_ _0644_ _0645_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__a31o_1
X_8420_ net326 _0053_ net252 VGND VGND VPWR VPWR delta\[5\] sky130_fd_sc_hd__dfrtp_1
X_8351_ _3609_ _3611_ VGND VGND VPWR VPWR _3612_ sky130_fd_sc_hd__or2b_1
X_5563_ _0572_ _0573_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__or2b_1
XFILLER_0_72_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4514_ _2741_ _3679_ VGND VGND VPWR VPWR _3680_ sky130_fd_sc_hd__nor2_2
XFILLER_0_5_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7302_ _2417_ _2418_ VGND VGND VPWR VPWR _2469_ sky130_fd_sc_hd__nor2_1
X_5494_ _0510_ _0512_ _0509_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__o21ba_1
X_8282_ net373 _3546_ VGND VGND VPWR VPWR _3547_ sky130_fd_sc_hd__xnor2_1
X_4445_ _3258_ _3324_ VGND VGND VPWR VPWR _3335_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_13_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7233_ net269 _2215_ VGND VGND VPWR VPWR _2393_ sky130_fd_sc_hd__nand2_1
X_4376_ _2444_ _2565_ VGND VGND VPWR VPWR _2576_ sky130_fd_sc_hd__xnor2_1
X_7164_ _0932_ net220 _2316_ VGND VGND VPWR VPWR _2317_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_13_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6115_ _1218_ net107 VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__nor2_1
X_7095_ net201 net287 VGND VGND VPWR VPWR _2241_ sky130_fd_sc_hd__or2b_1
X_6046_ _2268_ net61 VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__nor2_1
X_7997_ _0238_ net232 net234 _0303_ VGND VGND VPWR VPWR _3233_ sky130_fd_sc_hd__o22a_1
X_6948_ counter\[7\] VGND VGND VPWR VPWR _2080_ sky130_fd_sc_hd__inv_2
XFILLER_0_64_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6879_ _1824_ _1831_ _1897_ _1997_ _2003_ VGND VGND VPWR VPWR _2004_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_63_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_2_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_24_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4230_ net77 _0778_ _0965_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__and3_1
XFILLER_0_4_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7920_ _2863_ _2919_ _2975_ _3146_ _3147_ VGND VGND VPWR VPWR _3149_ sky130_fd_sc_hd__a41o_2
X_7851_ net312 _2449_ VGND VGND VPWR VPWR _3073_ sky130_fd_sc_hd__nand2_1
X_6802_ _1918_ _1868_ _1919_ VGND VGND VPWR VPWR _1920_ sky130_fd_sc_hd__a21o_1
X_7782_ _2935_ _2933_ VGND VGND VPWR VPWR _2997_ sky130_fd_sc_hd__nand2_1
X_4994_ _4151_ _4155_ _4158_ VGND VGND VPWR VPWR _4160_ sky130_fd_sc_hd__and3_1
XFILLER_0_73_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6733_ net61 _1790_ VGND VGND VPWR VPWR _1844_ sky130_fd_sc_hd__or2_1
XFILLER_0_58_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6664_ net140 net274 VGND VGND VPWR VPWR _1772_ sky130_fd_sc_hd__or2b_1
X_5615_ _0582_ _0584_ _0637_ _0638_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__a211o_4
XFILLER_0_83_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6595_ _1701_ _1702_ VGND VGND VPWR VPWR _1703_ sky130_fd_sc_hd__and2b_1
XFILLER_0_5_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8334_ delta\[4\] net80 _3592_ VGND VGND VPWR VPWR _3597_ sky130_fd_sc_hd__a21o_1
X_5546_ _0281_ _0322_ _0321_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__o21a_1
XFILLER_0_30_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5477_ _0487_ _0500_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__nor2_1
X_8265_ counter\[5\] _3521_ _3523_ _3527_ net80 VGND VGND VPWR VPWR _3528_ sky130_fd_sc_hd__o32ai_2
X_4428_ _2917_ _2928_ VGND VGND VPWR VPWR _3148_ sky130_fd_sc_hd__nor2_1
X_7216_ net224 VGND VGND VPWR VPWR _2374_ sky130_fd_sc_hd__inv_2
X_8196_ _3437_ _3449_ _3448_ VGND VGND VPWR VPWR _3452_ sky130_fd_sc_hd__o21a_1
XFILLER_0_1_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4359_ net419 _2378_ VGND VGND VPWR VPWR _2389_ sky130_fd_sc_hd__nand2_1
X_7147_ _2295_ _2296_ _2297_ VGND VGND VPWR VPWR _2298_ sky130_fd_sc_hd__a21oi_2
X_7078_ _2217_ _2220_ _2221_ VGND VGND VPWR VPWR _2222_ sky130_fd_sc_hd__o21ai_2
X_6029_ _1023_ _1084_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout74 counter\[14\] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_91_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout96 net97 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_64_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout85 net86 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__buf_2
XFILLER_0_101_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8414__31 clknet_2_2__leaf_clk VGND VGND VPWR VPWR net352 sky130_fd_sc_hd__inv_2
XFILLER_0_74_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5400_ _0419_ _3798_ _0203_ _4022_ _0423_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__o41a_1
XFILLER_0_2_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6380_ _1254_ _1276_ _1469_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__a21oi_2
X_5331_ _0353_ _0354_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__and2_1
XFILLER_0_11_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8050_ net246 net199 net156 net4 VGND VGND VPWR VPWR _3292_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_2_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7001_ _2132_ _2137_ VGND VGND VPWR VPWR _2138_ sky130_fd_sc_hd__xnor2_1
X_5262_ _0229_ _0235_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4213_ net186 _0789_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__or2_2
X_5193_ net45 _3566_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__or2_1
XFILLER_0_92_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7903_ net88 _2449_ VGND VGND VPWR VPWR _3130_ sky130_fd_sc_hd__nor2_1
X_7834_ _3036_ _3052_ _3053_ VGND VGND VPWR VPWR _3054_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_93_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7765_ net224 net249 net285 net294 VGND VGND VPWR VPWR _2978_ sky130_fd_sc_hd__and4bb_1
X_6716_ _1760_ _1817_ VGND VGND VPWR VPWR _1825_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4977_ net171 net168 net290 net298 VGND VGND VPWR VPWR _4143_ sky130_fd_sc_hd__and4bb_1
X_7696_ _2852_ _2901_ VGND VGND VPWR VPWR _2902_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6647_ _1611_ _1614_ VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__or2b_1
XFILLER_0_61_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6578_ _1575_ _1610_ _1685_ VGND VGND VPWR VPWR _1686_ sky130_fd_sc_hd__a21bo_1
X_5529_ _0302_ _0304_ _0301_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__a21oi_1
X_8317_ counter\[0\] _3581_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8248_ _3474_ _3508_ _3486_ VGND VGND VPWR VPWR _3509_ sky130_fd_sc_hd__o21ba_1
X_8179_ _3431_ _3432_ VGND VGND VPWR VPWR _3433_ sky130_fd_sc_hd__nand2_1
Xfanout231 net22 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__buf_4
Xfanout220 net221 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__buf_2
Xfanout253 net255 VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__clkbuf_4
Xfanout264 net15 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__buf_2
Xfanout242 net245 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__buf_8
Xfanout275 net14 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__buf_2
Xfanout286 net289 VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__buf_2
Xfanout297 net12 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_69_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5880_ _0918_ _0919_ _0920_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__a21oi_2
X_4900_ _4062_ _4064_ _4065_ VGND VGND VPWR VPWR _4066_ sky130_fd_sc_hd__a21oi_1
X_4831_ _3652_ VGND VGND VPWR VPWR _3997_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_28_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7550_ _2672_ _2698_ VGND VGND VPWR VPWR _2742_ sky130_fd_sc_hd__nor2_1
XFILLER_0_16_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4762_ _3886_ _3892_ _3884_ VGND VGND VPWR VPWR _3928_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4693_ _3814_ _3813_ VGND VGND VPWR VPWR _3859_ sky130_fd_sc_hd__or2b_1
X_6501_ _1476_ _1482_ VGND VGND VPWR VPWR _1604_ sky130_fd_sc_hd__nand2_1
X_7481_ net9 net227 _2498_ _2496_ VGND VGND VPWR VPWR _2666_ sky130_fd_sc_hd__a31o_1
XFILLER_0_3_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6432_ _1510_ _1527_ VGND VGND VPWR VPWR _1528_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_101_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8102_ net217 net245 _2128_ _2130_ VGND VGND VPWR VPWR _3349_ sky130_fd_sc_hd__and4_1
X_6363_ _1356_ _1451_ VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__xnor2_1
X_5314_ _0331_ _0336_ _0337_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__a21o_1
X_6294_ net127 net84 VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__or2b_1
X_5245_ _2202_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__buf_4
X_8033_ _3271_ _3272_ VGND VGND VPWR VPWR _3273_ sky130_fd_sc_hd__or2_1
X_5176_ _4023_ _4128_ _4181_ _0199_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_78_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7817_ _3031_ _3033_ VGND VGND VPWR VPWR _3035_ sky130_fd_sc_hd__nor2_1
XFILLER_0_93_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7748_ _2954_ _2956_ VGND VGND VPWR VPWR _2959_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7679_ net202 VGND VGND VPWR VPWR _2883_ sky130_fd_sc_hd__inv_2
XFILLER_0_19_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_5_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5030_ net174 net196 net280 net290 VGND VGND VPWR VPWR _4196_ sky130_fd_sc_hd__and4bb_1
XPHY_EDGE_ROW_69_Left_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6981_ _2116_ _2098_ _2090_ VGND VGND VPWR VPWR _2117_ sky130_fd_sc_hd__a21oi_1
X_5932_ net129 net132 net242 net257 VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_87_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5863_ _0799_ _0794_ _0802_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__nand3_1
XFILLER_0_8_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5794_ _0816_ _0825_ _0826_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__a21o_1
X_7602_ _2738_ _2798_ VGND VGND VPWR VPWR _2799_ sky130_fd_sc_hd__xnor2_2
X_4814_ _3978_ net85 net91 _3979_ VGND VGND VPWR VPWR _3980_ sky130_fd_sc_hd__a22o_1
X_7533_ net315 net227 VGND VGND VPWR VPWR _2723_ sky130_fd_sc_hd__nand2_1
XFILLER_0_16_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4745_ _3906_ _3905_ VGND VGND VPWR VPWR _3911_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_78_Left_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4676_ net92 net179 VGND VGND VPWR VPWR _3842_ sky130_fd_sc_hd__nand2_1
X_7464_ _2644_ _2645_ _2646_ VGND VGND VPWR VPWR _2647_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_43_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7395_ _2569_ _2570_ VGND VGND VPWR VPWR _2571_ sky130_fd_sc_hd__xor2_2
X_6415_ _1265_ _1270_ _1508_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__a21o_1
XFILLER_0_11_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6346_ _1240_ net124 _1432_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__or3_1
XFILLER_0_11_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8016_ _3252_ _3253_ VGND VGND VPWR VPWR _3254_ sky130_fd_sc_hd__xor2_1
X_6277_ _1010_ _1354_ _1355_ VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__and3_1
X_5228_ _0248_ _0251_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_87_Left_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5159_ _4097_ net316 _0174_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__and3_1
XFILLER_0_94_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap71 _0807_ VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__buf_1
XFILLER_0_69_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4530_ _2345_ _2334_ VGND VGND VPWR VPWR _3696_ sky130_fd_sc_hd__nand2_1
X_4461_ _2862_ _2906_ _2895_ VGND VGND VPWR VPWR _3511_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_53_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6200_ _1256_ _1271_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__xnor2_1
X_7180_ net226 net121 VGND VGND VPWR VPWR _2335_ sky130_fd_sc_hd__nand2b_2
XFILLER_0_68_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4392_ net166 net210 VGND VGND VPWR VPWR _2752_ sky130_fd_sc_hd__or2b_1
X_6131_ _1240_ net144 _1014_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__o21a_1
XFILLER_0_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6062_ _0985_ _1043_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5013_ _4175_ _4177_ _4178_ VGND VGND VPWR VPWR _4179_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_88_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6964_ net81 _2089_ VGND VGND VPWR VPWR _2098_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6895_ _2013_ _2021_ VGND VGND VPWR VPWR _2022_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5915_ net108 net311 VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__and2b_1
X_5846_ _0876_ _0862_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__and2b_1
XFILLER_0_91_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5777_ _0779_ _0785_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__xor2_1
XFILLER_0_90_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7516_ net200 net261 VGND VGND VPWR VPWR _2704_ sky130_fd_sc_hd__or2b_1
X_4728_ _3892_ _3893_ _3890_ VGND VGND VPWR VPWR _3894_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_71_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7447_ _2614_ _2627_ VGND VGND VPWR VPWR _2628_ sky130_fd_sc_hd__or2b_1
X_4659_ _3823_ _3824_ VGND VGND VPWR VPWR _3825_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_44_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7378_ _2549_ _2550_ _2551_ VGND VGND VPWR VPWR _2552_ sky130_fd_sc_hd__a21oi_2
X_6329_ _1412_ _1413_ VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_95_Left_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_104_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5700_ net55 _0716_ _0722_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__o21a_1
XFILLER_0_70_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6680_ _1771_ _1787_ VGND VGND VPWR VPWR _1788_ sky130_fd_sc_hd__xnor2_2
X_5631_ net73 _0654_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5562_ _0580_ _0585_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__or2_4
X_8350_ delta\[9\] net77 VGND VGND VPWR VPWR _3611_ sky130_fd_sc_hd__nand2_1
X_8281_ net427 _3543_ _3545_ VGND VGND VPWR VPWR _3546_ sky130_fd_sc_hd__a21o_1
X_4513_ _3652_ net210 _2730_ VGND VGND VPWR VPWR _3679_ sky130_fd_sc_hd__a21oi_1
X_7301_ _2439_ _2467_ VGND VGND VPWR VPWR _2468_ sky130_fd_sc_hd__xor2_2
X_5493_ _0501_ _0515_ _0516_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__nor3_1
XFILLER_0_78_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7232_ _2353_ _2391_ _2357_ VGND VGND VPWR VPWR _2392_ sky130_fd_sc_hd__o21ai_2
X_4444_ _3269_ _3313_ VGND VGND VPWR VPWR _3324_ sky130_fd_sc_hd__xnor2_2
X_4375_ _2543_ _2554_ VGND VGND VPWR VPWR _2565_ sky130_fd_sc_hd__nor2_1
X_7163_ net223 net215 VGND VGND VPWR VPWR _2316_ sky130_fd_sc_hd__or2b_1
XFILLER_0_0_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6114_ _0955_ _1178_ VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__or2_1
X_7094_ _1983_ net235 VGND VGND VPWR VPWR _2240_ sky130_fd_sc_hd__nor2_1
X_6045_ _1095_ _1102_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__xor2_2
XFILLER_0_95_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7996_ net279 _2163_ VGND VGND VPWR VPWR _3232_ sky130_fd_sc_hd__nand2_1
X_6947_ _1996_ _2078_ VGND VGND VPWR VPWR _2079_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_91_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6878_ _2001_ _2002_ VGND VGND VPWR VPWR _2003_ sky130_fd_sc_hd__or2_1
XFILLER_0_63_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5829_ net100 _0863_ _0864_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__and3_1
XFILLER_0_91_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_544 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7850_ _3066_ _3070_ _3069_ VGND VGND VPWR VPWR _3072_ sky130_fd_sc_hd__a21o_1
XFILLER_0_81_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6801_ _1860_ _1861_ VGND VGND VPWR VPWR _1919_ sky130_fd_sc_hd__nor2_1
XFILLER_0_105_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7781_ net88 _2678_ _2989_ _2988_ VGND VGND VPWR VPWR _2996_ sky130_fd_sc_hd__a31o_1
X_4993_ _4151_ _4155_ _4158_ VGND VGND VPWR VPWR _4159_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_105_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6732_ _1838_ _1842_ VGND VGND VPWR VPWR _1843_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6663_ _1704_ _1710_ _1714_ VGND VGND VPWR VPWR _1771_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_58_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5614_ _0580_ _0592_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__or2_1
XFILLER_0_33_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6594_ _1699_ _1700_ VGND VGND VPWR VPWR _1702_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5545_ _0549_ _0568_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__xnor2_1
X_8333_ _3594_ _3595_ VGND VGND VPWR VPWR _3596_ sky130_fd_sc_hd__and2b_1
X_5476_ _0498_ _0499_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8264_ _3514_ _3526_ VGND VGND VPWR VPWR _3527_ sky130_fd_sc_hd__nand2_1
X_8195_ _3442_ _3444_ _3441_ VGND VGND VPWR VPWR _3451_ sky130_fd_sc_hd__o21ba_1
X_4427_ _3115_ _3126_ VGND VGND VPWR VPWR _3137_ sky130_fd_sc_hd__xnor2_1
X_7215_ _2339_ _2347_ _2372_ VGND VGND VPWR VPWR _2373_ sky130_fd_sc_hd__a21boi_2
X_7146_ net225 net251 net154 net185 VGND VGND VPWR VPWR _2297_ sky130_fd_sc_hd__and4bb_1
X_4358_ net187 VGND VGND VPWR VPWR _2378_ sky130_fd_sc_hd__inv_2
X_4289_ rising _1547_ _1624_ VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__a21bo_1
X_7077_ net202 net205 net276 net285 VGND VGND VPWR VPWR _2221_ sky130_fd_sc_hd__or4bb_1
X_6028_ _1027_ _1082_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__xor2_1
X_7979_ _3204_ _3212_ VGND VGND VPWR VPWR _3213_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout75 counter\[13\] VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_64_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout86 net9 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__clkbuf_2
Xfanout97 net8 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_32_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_41_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5330_ _0348_ _0350_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__xor2_1
X_5261_ _0268_ _0284_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_2_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7000_ _2133_ _2134_ _2135_ VGND VGND VPWR VPWR _2137_ sky130_fd_sc_hd__o21a_1
X_4212_ net217 net244 _0778_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__or3_1
XFILLER_0_11_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5192_ _0211_ _0215_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_50_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7902_ _3118_ _3128_ VGND VGND VPWR VPWR _3129_ sky130_fd_sc_hd__nor2_1
X_7833_ _3051_ _3050_ VGND VGND VPWR VPWR _3053_ sky130_fd_sc_hd__or2b_1
XFILLER_0_25_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7764_ net224 net294 VGND VGND VPWR VPWR _2977_ sky130_fd_sc_hd__or2b_1
X_6715_ _1545_ _1823_ VGND VGND VPWR VPWR _1824_ sky130_fd_sc_hd__nand2_1
X_4976_ net171 net290 VGND VGND VPWR VPWR _4142_ sky130_fd_sc_hd__or2b_1
XFILLER_0_73_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7695_ _2806_ _2809_ VGND VGND VPWR VPWR _2901_ sky130_fd_sc_hd__or2_1
XFILLER_0_46_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6646_ _1634_ _1687_ VGND VGND VPWR VPWR _1754_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6577_ _1607_ _1609_ VGND VGND VPWR VPWR _1685_ sky130_fd_sc_hd__or2b_1
XFILLER_0_104_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5528_ _0315_ _0299_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__and2b_1
X_8316_ _3579_ _3580_ VGND VGND VPWR VPWR _3581_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5459_ net213 _3082_ _0469_ _0468_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__a31oi_2
X_8247_ _3424_ _3483_ _3484_ VGND VGND VPWR VPWR _3508_ sky130_fd_sc_hd__a21oi_1
X_8178_ net218 net229 _3430_ VGND VGND VPWR VPWR _3432_ sky130_fd_sc_hd__a21o_1
Xfanout232 net22 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__clkbuf_2
Xfanout210 net211 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__buf_6
Xfanout221 net28 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__clkbuf_2
Xfanout254 net255 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__clkbuf_4
Xfanout265 net267 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__clkbuf_4
Xfanout243 net244 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__buf_2
X_7129_ _2271_ _2276_ _2277_ VGND VGND VPWR VPWR _2278_ sky130_fd_sc_hd__a21o_1
Xfanout298 net419 VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__buf_4
XFILLER_0_5_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout276 net279 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__buf_2
Xfanout287 net289 VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__buf_2
XFILLER_0_69_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4830_ _3993_ _3995_ VGND VGND VPWR VPWR _3996_ sky130_fd_sc_hd__xor2_1
X_4761_ _3924_ _3926_ VGND VGND VPWR VPWR _3927_ sky130_fd_sc_hd__xor2_1
XFILLER_0_55_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6500_ _1595_ _1601_ VGND VGND VPWR VPWR _1603_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_28_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7480_ _2591_ _2663_ VGND VGND VPWR VPWR _2665_ sky130_fd_sc_hd__xor2_2
X_4692_ _3856_ _3857_ VGND VGND VPWR VPWR _3858_ sky130_fd_sc_hd__xor2_2
XFILLER_0_43_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6431_ _1519_ _1526_ VGND VGND VPWR VPWR _1527_ sky130_fd_sc_hd__xor2_2
XFILLER_0_102_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6362_ _1449_ _1450_ VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__xnor2_1
X_5313_ _0332_ _0335_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__nor2_1
X_8101_ _0932_ net232 net234 _0269_ VGND VGND VPWR VPWR _3348_ sky130_fd_sc_hd__o22a_1
XFILLER_0_11_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6293_ net130 net308 VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__or2b_1
X_5244_ _0261_ _0267_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__nand2_1
X_8032_ _3270_ _3215_ _3218_ VGND VGND VPWR VPWR _3272_ sky130_fd_sc_hd__and3_1
X_5175_ _0189_ _0194_ _0197_ _0198_ _4130_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__a32o_1
XFILLER_0_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7816_ _3031_ _3033_ VGND VGND VPWR VPWR _3034_ sky130_fd_sc_hd__and2_1
X_7747_ _2936_ _2931_ VGND VGND VPWR VPWR _2958_ sky130_fd_sc_hd__xnor2_1
X_4959_ net381 _4015_ VGND VGND VPWR VPWR _4125_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_61_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7678_ _0149_ net32 VGND VGND VPWR VPWR _2882_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6629_ _1721_ _1736_ VGND VGND VPWR VPWR _1737_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_14_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_106_Left_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6980_ net82 _2094_ _2097_ VGND VGND VPWR VPWR _2116_ sky130_fd_sc_hd__o21ai_1
X_5931_ net132 net237 VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__or2b_1
X_5862_ _0843_ _0846_ _0896_ _0901_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__a211o_1
X_5793_ _0817_ _0824_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__nor2_1
XFILLER_0_75_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4813_ net193 VGND VGND VPWR VPWR _3979_ sky130_fd_sc_hd__inv_2
X_7601_ _2740_ _2797_ VGND VGND VPWR VPWR _2798_ sky130_fd_sc_hd__xor2_2
X_7532_ _2670_ _2721_ VGND VGND VPWR VPWR _2722_ sky130_fd_sc_hd__xor2_2
X_4744_ _3908_ _3909_ VGND VGND VPWR VPWR _3910_ sky130_fd_sc_hd__and2_1
XFILLER_0_22_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4675_ _3765_ _3791_ VGND VGND VPWR VPWR _3841_ sky130_fd_sc_hd__xnor2_2
X_7463_ _2641_ _2643_ VGND VGND VPWR VPWR _2646_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7394_ _2324_ _2326_ VGND VGND VPWR VPWR _2570_ sky130_fd_sc_hd__xnor2_2
X_6414_ _1264_ _1257_ VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__and2b_1
X_6345_ _1425_ _1431_ VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__xnor2_1
X_6276_ _1354_ _1355_ _1010_ VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__a21oi_2
X_5227_ _0249_ _0250_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__nor2_1
X_8015_ _3161_ _3172_ VGND VGND VPWR VPWR _3253_ sky130_fd_sc_hd__or2b_4
X_5158_ _3668_ net84 VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__nor2_1
X_5089_ _0111_ _0112_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__nor2_1
XFILLER_0_93_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmax_cap72 _0291_ VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__buf_1
XFILLER_0_38_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4460_ _3478_ _3489_ VGND VGND VPWR VPWR _3500_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4391_ _2708_ net210 _2730_ VGND VGND VPWR VPWR _2741_ sky130_fd_sc_hd__and3_1
XFILLER_0_68_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6130_ _1187_ _1186_ VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__and2b_1
XFILLER_0_0_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6061_ _1044_ _1046_ _1120_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__a21bo_1
X_5012_ _4093_ _4119_ VGND VGND VPWR VPWR _4178_ sky130_fd_sc_hd__xnor2_1
X_6963_ counter\[0\] _2091_ _2095_ _2096_ VGND VGND VPWR VPWR _2097_ sky130_fd_sc_hd__a211o_1
X_6894_ _2019_ _2020_ VGND VGND VPWR VPWR _2021_ sky130_fd_sc_hd__and2_1
X_5914_ _0931_ _0933_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__nand2_1
X_5845_ _0874_ _0875_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__and2_1
XFILLER_0_48_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5776_ _1481_ net107 _0806_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__nor3_1
XFILLER_0_56_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7515_ _1042_ net235 VGND VGND VPWR VPWR _2703_ sky130_fd_sc_hd__nor2_1
X_4727_ _3884_ _3886_ _3892_ VGND VGND VPWR VPWR _3893_ sky130_fd_sc_hd__nand3_1
XFILLER_0_16_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7446_ _2615_ _2626_ _2624_ VGND VGND VPWR VPWR _2627_ sky130_fd_sc_hd__a21o_1
X_4658_ _3742_ _3746_ VGND VGND VPWR VPWR _3824_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_101_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7377_ net225 net251 net215 net243 VGND VGND VPWR VPWR _2551_ sky130_fd_sc_hd__and4bb_1
X_4589_ _3741_ _3747_ VGND VGND VPWR VPWR _3755_ sky130_fd_sc_hd__nor2_1
X_6328_ _1399_ _1411_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__nand2_1
X_6259_ _1325_ _1331_ _1336_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_86_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5630_ _0652_ _0653_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__and2_1
X_5561_ _0582_ _0584_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__and2_4
XFILLER_0_5_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5492_ _0487_ _0500_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8280_ net391 _2736_ VGND VGND VPWR VPWR _3545_ sky130_fd_sc_hd__nor2_1
XFILLER_0_53_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4512_ _3667_ net393 _3675_ _3677_ VGND VGND VPWR VPWR _3678_ sky130_fd_sc_hd__a31o_2
X_7300_ _2452_ _2465_ VGND VGND VPWR VPWR _2467_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_13_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7231_ _2354_ _2355_ VGND VGND VPWR VPWR _2391_ sky130_fd_sc_hd__nor2_1
X_4443_ _3280_ _2752_ _3291_ _3302_ VGND VGND VPWR VPWR _3313_ sky130_fd_sc_hd__o22a_1
X_4374_ _2521_ _2532_ VGND VGND VPWR VPWR _2554_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7162_ _0303_ net29 VGND VGND VPWR VPWR _2315_ sky130_fd_sc_hd__nor2_1
XFILLER_0_95_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6113_ net111 net93 VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__or2b_1
X_7093_ _2222_ _2237_ _2238_ VGND VGND VPWR VPWR _2239_ sky130_fd_sc_hd__a21boi_2
X_6044_ _1096_ _1101_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_28_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7995_ _3229_ _3230_ VGND VGND VPWR VPWR _3231_ sky130_fd_sc_hd__xor2_1
X_6946_ _1971_ _2076_ _2008_ VGND VGND VPWR VPWR _2078_ sky130_fd_sc_hd__o21ai_1
X_6877_ _1998_ _1999_ _2000_ VGND VGND VPWR VPWR _2002_ sky130_fd_sc_hd__and3_1
XFILLER_0_64_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5828_ net112 net119 VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__and2b_1
X_5759_ _0770_ _0787_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__or2b_1
XFILLER_0_17_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7429_ _2604_ _2607_ VGND VGND VPWR VPWR _2608_ sky130_fd_sc_hd__or2b_1
XFILLER_0_67_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6800_ _1860_ _1861_ VGND VGND VPWR VPWR _1918_ sky130_fd_sc_hd__nand2_1
X_7780_ _2992_ _2993_ VGND VGND VPWR VPWR _2995_ sky130_fd_sc_hd__xor2_1
X_4992_ _4156_ _4157_ VGND VGND VPWR VPWR _4158_ sky130_fd_sc_hd__xor2_1
XFILLER_0_81_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6731_ _0864_ _1839_ _1841_ VGND VGND VPWR VPWR _1842_ sky130_fd_sc_hd__o21a_1
XFILLER_0_14_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6662_ _1729_ _1735_ _1769_ VGND VGND VPWR VPWR _1770_ sky130_fd_sc_hd__a21o_1
X_5613_ _0548_ _0569_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8332_ delta\[5\] counter\[5\] VGND VGND VPWR VPWR _3595_ sky130_fd_sc_hd__nand2_1
X_6593_ _1699_ _1700_ VGND VGND VPWR VPWR _1701_ sky130_fd_sc_hd__nor2_1
XFILLER_0_61_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5544_ _0515_ _0550_ _0564_ _0566_ _0567_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__a32oi_4
X_5475_ _0488_ _0489_ _0497_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__nand3_1
X_8263_ _3279_ _3150_ _3156_ VGND VGND VPWR VPWR _3526_ sky130_fd_sc_hd__nand3_1
XFILLER_0_14_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8194_ _3437_ _3448_ _3449_ VGND VGND VPWR VPWR _3450_ sky130_fd_sc_hd__nor3_1
X_4426_ net419 net179 VGND VGND VPWR VPWR _3126_ sky130_fd_sc_hd__nand2_1
X_7214_ _2332_ _2338_ VGND VGND VPWR VPWR _2372_ sky130_fd_sc_hd__nand2_1
X_7145_ net225 net185 VGND VGND VPWR VPWR _2296_ sky130_fd_sc_hd__or2b_1
X_4357_ net189 net420 VGND VGND VPWR VPWR _2367_ sky130_fd_sc_hd__or2b_1
X_4288_ _0001_ _1602_ _1613_ VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__o21ai_1
X_7076_ _2218_ _2219_ VGND VGND VPWR VPWR _2220_ sky130_fd_sc_hd__nor2_1
X_6027_ _1027_ _1082_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__or2_1
X_7978_ _3205_ _3211_ VGND VGND VPWR VPWR _3212_ sky130_fd_sc_hd__xnor2_1
X_6929_ _2024_ _2028_ VGND VGND VPWR VPWR _2059_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout76 counter\[12\] VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__clkbuf_4
Xfanout98 net99 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__clkbuf_4
Xfanout87 net89 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__buf_4
XFILLER_0_51_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_559 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5260_ _0277_ _0283_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_50_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4211_ net261 _0767_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__or2_2
XFILLER_0_76_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5191_ _0212_ _0213_ _0214_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__o21a_1
XFILLER_0_48_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8405__22 clknet_2_2__leaf_clk VGND VGND VPWR VPWR net343 sky130_fd_sc_hd__inv_2
X_7901_ _3121_ _3124_ _3127_ VGND VGND VPWR VPWR _3128_ sky130_fd_sc_hd__a21oi_1
X_7832_ _3050_ _3051_ VGND VGND VPWR VPWR _3052_ sky130_fd_sc_hd__xnor2_1
X_4975_ net168 net298 VGND VGND VPWR VPWR _4141_ sky130_fd_sc_hd__or2b_1
X_7763_ net249 net285 VGND VGND VPWR VPWR _2976_ sky130_fd_sc_hd__or2b_1
XFILLER_0_86_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6714_ _1623_ _1760_ _1817_ _1822_ VGND VGND VPWR VPWR _1823_ sky130_fd_sc_hd__and4_1
XFILLER_0_18_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7694_ _2892_ _2888_ VGND VGND VPWR VPWR _2900_ sky130_fd_sc_hd__or2b_1
XFILLER_0_61_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6645_ net95 net134 _1552_ _1752_ VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__a31o_1
XFILLER_0_41_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6576_ _1656_ _1683_ VGND VGND VPWR VPWR _1684_ sky130_fd_sc_hd__xnor2_1
X_5527_ _0294_ _0314_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__and2_1
X_8315_ delta\[1\] counter\[1\] VGND VGND VPWR VPWR _3580_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8246_ _1404_ _3499_ _3502_ _3505_ _3506_ VGND VGND VPWR VPWR _3507_ sky130_fd_sc_hd__o2111ai_2
X_5458_ _0471_ _0481_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__or2b_1
X_8177_ net217 net229 _3430_ VGND VGND VPWR VPWR _3431_ sky130_fd_sc_hd__nand3_1
X_5389_ _0403_ _0407_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__xnor2_1
X_4409_ _2917_ _2928_ VGND VGND VPWR VPWR _2939_ sky130_fd_sc_hd__xor2_1
Xfanout200 net33 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__buf_2
Xfanout211 net218 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__buf_4
XFILLER_0_10_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout222 net223 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__clkbuf_4
Xfanout255 net17 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_5_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout233 net21 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__clkbuf_4
Xfanout244 net245 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__buf_6
X_7128_ _2270_ _2269_ VGND VGND VPWR VPWR _2277_ sky130_fd_sc_hd__and2b_1
X_7059_ _2198_ _2199_ VGND VGND VPWR VPWR _2201_ sky130_fd_sc_hd__nand2_1
Xfanout288 net289 VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__buf_2
Xfanout266 net267 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__clkbuf_4
Xfanout299 net307 VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__clkbuf_2
Xfanout277 net279 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_69_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4760_ _3925_ _3848_ VGND VGND VPWR VPWR _3926_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_70_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4691_ net367 _3779_ VGND VGND VPWR VPWR _3857_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_102_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6430_ _1520_ _1524_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_11_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6361_ _1195_ _1202_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__xor2_1
XFILLER_0_87_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5312_ _0332_ _0335_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__xor2_1
X_8100_ net261 _2163_ VGND VGND VPWR VPWR _3347_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6292_ _1983_ net50 VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__nor2_1
X_5243_ _0262_ _0266_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__xnor2_1
X_8031_ _3215_ _3218_ _3270_ VGND VGND VPWR VPWR _3271_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_11_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5174_ _0193_ _0196_ _4179_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7815_ _3001_ _3032_ VGND VGND VPWR VPWR _3033_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7746_ _2954_ _2956_ VGND VGND VPWR VPWR _2957_ sky130_fd_sc_hd__xor2_1
X_4958_ _4048_ _4074_ _4123_ VGND VGND VPWR VPWR _4124_ sky130_fd_sc_hd__a21oi_1
X_7677_ _2879_ _2880_ VGND VGND VPWR VPWR _2881_ sky130_fd_sc_hd__xor2_1
X_4889_ _4054_ _3992_ VGND VGND VPWR VPWR _4055_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6628_ _1729_ _1735_ VGND VGND VPWR VPWR _1736_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6559_ _1665_ _1666_ VGND VGND VPWR VPWR _1667_ sky130_fd_sc_hd__or2b_1
XFILLER_0_42_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8229_ _3463_ _3485_ _3487_ VGND VGND VPWR VPWR _3488_ sky130_fd_sc_hd__nand3_1
XFILLER_0_100_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8396__13 clknet_2_2__leaf_clk VGND VGND VPWR VPWR net334 sky130_fd_sc_hd__inv_2
XFILLER_0_25_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_94_Right_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5930_ net129 net256 VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__or2b_1
X_5861_ _0897_ _0900_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__and2_1
X_7600_ _2787_ _2795_ VGND VGND VPWR VPWR _2797_ sky130_fd_sc_hd__xnor2_2
X_5792_ _0817_ _0824_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__xor2_1
X_4812_ net161 VGND VGND VPWR VPWR _3978_ sky130_fd_sc_hd__inv_2
XFILLER_0_56_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7531_ _2699_ _2720_ VGND VGND VPWR VPWR _2721_ sky130_fd_sc_hd__xnor2_2
X_4743_ _3751_ net92 net318 _2378_ VGND VGND VPWR VPWR _3909_ sky130_fd_sc_hd__a22o_1
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7462_ _2610_ _2602_ VGND VGND VPWR VPWR _2645_ sky130_fd_sc_hd__xnor2_1
X_4674_ net92 net179 _3838_ _3839_ VGND VGND VPWR VPWR _3840_ sky130_fd_sc_hd__a31o_1
X_6413_ _1473_ _1506_ VGND VGND VPWR VPWR _1507_ sky130_fd_sc_hd__xor2_2
XFILLER_0_3_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7393_ _2563_ _2567_ _2568_ VGND VGND VPWR VPWR _2569_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_101_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6344_ net87 _0909_ _1429_ _1430_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__a31o_1
X_6275_ net83 _1343_ VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__nand2_1
X_5226_ _0238_ net188 _3368_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__nor3_1
X_8014_ _3244_ _3251_ VGND VGND VPWR VPWR _3252_ sky130_fd_sc_hd__xor2_1
X_5157_ _0145_ _0177_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__nand2_1
X_5088_ _4037_ net316 _0110_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_2_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7729_ _1240_ net248 _2616_ VGND VGND VPWR VPWR _2938_ sky130_fd_sc_hd__o21a_1
XFILLER_0_105_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4390_ _2719_ _2224_ _2697_ VGND VGND VPWR VPWR _2730_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_21_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6060_ _1114_ _1118_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__xnor2_1
X_5011_ _4169_ _4176_ VGND VGND VPWR VPWR _4177_ sky130_fd_sc_hd__nand2_1
XFILLER_0_88_451 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6962_ net82 _2094_ VGND VGND VPWR VPWR _2096_ sky130_fd_sc_hd__nor2_1
XFILLER_0_88_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6893_ _2018_ _2014_ _2015_ VGND VGND VPWR VPWR _2020_ sky130_fd_sc_hd__nand3_1
X_5913_ _0952_ _0957_ _0956_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__a21bo_1
X_5844_ _0880_ _0881_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__or2b_1
XFILLER_0_8_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5775_ net110 net123 VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__or2b_1
X_7514_ _2454_ _2463_ _2462_ VGND VGND VPWR VPWR _2702_ sky130_fd_sc_hd__a21boi_4
X_4726_ _3806_ _3887_ VGND VGND VPWR VPWR _3892_ sky130_fd_sc_hd__or2_1
XFILLER_0_16_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7445_ _2624_ _2625_ VGND VGND VPWR VPWR _2626_ sky130_fd_sc_hd__nor2_1
X_4657_ _3818_ _3822_ _3821_ VGND VGND VPWR VPWR _3823_ sky130_fd_sc_hd__a21o_1
X_7376_ net251 net215 VGND VGND VPWR VPWR _2550_ sky130_fd_sc_hd__or2b_1
XFILLER_0_31_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6327_ _1399_ _1411_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__or2_1
XFILLER_0_3_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4588_ _3749_ _3753_ VGND VGND VPWR VPWR _3754_ sky130_fd_sc_hd__xnor2_2
X_6258_ _1322_ _1324_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__nand2_1
X_5209_ net159 net193 net212 net239 VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__and4bb_1
X_6189_ net103 net296 VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__or2b_1
XFILLER_0_98_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5560_ _0581_ _0427_ _0375_ _0583_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__a211oi_1
X_5491_ _0513_ _0514_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__nand2_2
XFILLER_0_53_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4511_ _3672_ net98 _3676_ VGND VGND VPWR VPWR _3677_ sky130_fd_sc_hd__and3_1
XFILLER_0_79_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4442_ net166 net181 VGND VGND VPWR VPWR _3302_ sky130_fd_sc_hd__and2b_1
X_7230_ _2373_ _2388_ VGND VGND VPWR VPWR _2390_ sky130_fd_sc_hd__xor2_2
XFILLER_0_95_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4373_ _2521_ _2532_ VGND VGND VPWR VPWR _2543_ sky130_fd_sc_hd__nor2_1
X_7161_ _2306_ _2313_ VGND VGND VPWR VPWR _2314_ sky130_fd_sc_hd__xor2_2
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6112_ _1173_ _1176_ VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__xor2_2
X_7092_ _2229_ _2236_ VGND VGND VPWR VPWR _2238_ sky130_fd_sc_hd__nand2_1
X_6043_ _1098_ _1099_ _1100_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__o21ai_4
X_7994_ _3180_ _3185_ _3184_ VGND VGND VPWR VPWR _3230_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6945_ _1971_ _2076_ VGND VGND VPWR VPWR _2077_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6876_ _1998_ _1999_ _2000_ VGND VGND VPWR VPWR _2001_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_91_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5827_ net108 VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__inv_2
X_5758_ _0779_ _0785_ _0786_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__a21o_1
XFILLER_0_63_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4709_ net424 net356 VGND VGND VPWR VPWR _3875_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5689_ _0710_ _0711_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__nand2_1
X_7428_ _2605_ _2606_ _2603_ VGND VGND VPWR VPWR _2607_ sky130_fd_sc_hd__o21a_1
XFILLER_0_12_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7359_ _2528_ _2529_ _2530_ _2264_ VGND VGND VPWR VPWR _2531_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6730_ net113 net63 net119 net151 VGND VGND VPWR VPWR _1841_ sky130_fd_sc_hd__or4bb_1
X_4991_ _4086_ _4088_ VGND VGND VPWR VPWR _4157_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_73_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6661_ _1727_ _1728_ VGND VGND VPWR VPWR _1769_ sky130_fd_sc_hd__nor2_1
X_5612_ _0634_ _0635_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__or2_1
X_6592_ _1479_ _1674_ _1481_ net58 VGND VGND VPWR VPWR _1700_ sky130_fd_sc_hd__a211o_1
X_8331_ delta\[5\] counter\[5\] VGND VGND VPWR VPWR _3594_ sky130_fd_sc_hd__nor2_1
XFILLER_0_90_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5543_ net259 net178 _0556_ _0554_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__a31o_1
XFILLER_0_5_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5474_ _0488_ _0489_ _0497_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__a21o_1
X_8262_ net79 _3518_ _3524_ counter\[5\] VGND VGND VPWR VPWR _3525_ sky130_fd_sc_hd__a22oi_2
X_8193_ _3433_ _3436_ VGND VGND VPWR VPWR _3449_ sky130_fd_sc_hd__and2_1
X_4425_ _3071_ _3104_ VGND VGND VPWR VPWR _3115_ sky130_fd_sc_hd__xnor2_1
X_7213_ _2349_ _2363_ _2370_ VGND VGND VPWR VPWR _2371_ sky130_fd_sc_hd__a21oi_4
X_4356_ _2169_ _2334_ _2345_ VGND VGND VPWR VPWR _2356_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_1_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7144_ net251 net154 VGND VGND VPWR VPWR _2295_ sky130_fd_sc_hd__or2b_1
X_4287_ net418 VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__inv_2
X_7075_ net205 net276 VGND VGND VPWR VPWR _2219_ sky130_fd_sc_hd__and2b_1
X_6026_ _1065_ _1081_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_96_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7977_ _3209_ _3210_ VGND VGND VPWR VPWR _3211_ sky130_fd_sc_hd__and2b_1
X_6928_ net78 _2057_ VGND VGND VPWR VPWR _2058_ sky130_fd_sc_hd__and2_1
XFILLER_0_76_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6859_ net266 net135 VGND VGND VPWR VPWR _1982_ sky130_fd_sc_hd__nand2_1
Xfanout77 counter\[9\] VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__buf_4
Xfanout99 net100 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_64_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout88 net89 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__buf_2
XFILLER_0_91_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4210_ net269 net278 _0756_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__or3_4
X_5190_ net166 net164 net119 net151 VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__or4bb_1
XFILLER_0_92_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7900_ _3098_ _3125_ VGND VGND VPWR VPWR _3127_ sky130_fd_sc_hd__nor2_1
X_7831_ _2984_ _2990_ VGND VGND VPWR VPWR _3051_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4974_ _3652_ net309 VGND VGND VPWR VPWR _4140_ sky130_fd_sc_hd__nand2_1
X_7762_ _2921_ _2974_ VGND VGND VPWR VPWR _2975_ sky130_fd_sc_hd__or2b_1
XFILLER_0_58_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6713_ _1819_ _1821_ VGND VGND VPWR VPWR _1822_ sky130_fd_sc_hd__xor2_1
X_7693_ _2891_ _2889_ VGND VGND VPWR VPWR _2899_ sky130_fd_sc_hd__or2b_1
X_6644_ _1523_ _1550_ _1549_ VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__o21a_1
XFILLER_0_34_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6575_ _1680_ _1682_ VGND VGND VPWR VPWR _1683_ sky130_fd_sc_hd__xor2_2
XFILLER_0_6_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5526_ _0513_ _0514_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__or2_1
X_8314_ delta\[1\] counter\[1\] VGND VGND VPWR VPWR _3579_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8245_ net75 _3504_ VGND VGND VPWR VPWR _3506_ sky130_fd_sc_hd__nand2_1
X_5457_ _0474_ _0479_ _0480_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__a21o_1
X_4408_ _2466_ _2510_ _2499_ VGND VGND VPWR VPWR _2928_ sky130_fd_sc_hd__a21oi_1
X_8176_ _3428_ _3429_ VGND VGND VPWR VPWR _3430_ sky130_fd_sc_hd__xor2_1
X_5388_ _0410_ _0411_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__nor2_2
Xfanout212 net214 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__buf_2
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout223 net27 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__buf_2
Xfanout201 net33 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__buf_2
Xfanout234 net21 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__clkbuf_2
X_4339_ _2093_ _2104_ _2126_ _2158_ VGND VGND VPWR VPWR _2169_ sky130_fd_sc_hd__o22ai_4
Xfanout256 net257 VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__clkbuf_4
Xfanout245 net2 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__buf_12
X_7127_ _2272_ _2275_ VGND VGND VPWR VPWR _2276_ sky130_fd_sc_hd__xnor2_1
X_7058_ _2198_ _2199_ VGND VGND VPWR VPWR _2200_ sky130_fd_sc_hd__or2_1
Xfanout278 net279 VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__clkbuf_4
Xfanout267 net15 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__clkbuf_4
Xfanout289 net13 VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__buf_6
X_6009_ _1050_ _1062_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4690_ _3852_ _3854_ _3855_ VGND VGND VPWR VPWR _3856_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_70_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6360_ net378 _1358_ _1447_ VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__a21boi_1
X_5311_ _0333_ _0334_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__or2b_1
X_8030_ _3219_ _3268_ VGND VGND VPWR VPWR _3270_ sky130_fd_sc_hd__xnor2_1
X_6291_ _1370_ _1372_ VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__nor2_1
X_5242_ _0263_ _0265_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__nor2_1
X_5173_ _0190_ _0191_ _0192_ _0195_ _0196_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__o311a_1
Xinput1 periodTop[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_1
XFILLER_0_78_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7814_ _1229_ net202 _2934_ VGND VGND VPWR VPWR _3032_ sky130_fd_sc_hd__o21a_1
XFILLER_0_52_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7745_ _2871_ _2955_ VGND VGND VPWR VPWR _2956_ sky130_fd_sc_hd__xnor2_1
X_4957_ _4072_ _4073_ VGND VGND VPWR VPWR _4123_ sky130_fd_sc_hd__nor2_1
X_4888_ _3769_ net263 VGND VGND VPWR VPWR _4054_ sky130_fd_sc_hd__nand2_1
X_7676_ _2836_ _2838_ VGND VGND VPWR VPWR _2880_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_74_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6627_ _1730_ _1734_ VGND VGND VPWR VPWR _1735_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_6_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6558_ _1590_ _1593_ _1664_ VGND VGND VPWR VPWR _1666_ sky130_fd_sc_hd__or3_1
XFILLER_0_6_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5509_ net120 _3751_ _0532_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__and3_1
X_6489_ net125 net115 net149 net181 VGND VGND VPWR VPWR _1590_ sky130_fd_sc_hd__and4bb_1
X_8228_ _3464_ _3486_ VGND VGND VPWR VPWR _3487_ sky130_fd_sc_hd__nand2_1
XFILLER_0_100_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8159_ _3392_ _3410_ VGND VGND VPWR VPWR _3411_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_16_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_29_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5860_ _0896_ _0898_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__nor2_1
XFILLER_0_75_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4811_ _3976_ net318 VGND VGND VPWR VPWR _3977_ sky130_fd_sc_hd__nand2_1
X_5791_ _0818_ _0823_ _0821_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_8_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_38_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7530_ _2701_ _2718_ VGND VGND VPWR VPWR _2720_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_28_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4742_ net190 net187 _3901_ _1218_ VGND VGND VPWR VPWR _3908_ sky130_fd_sc_hd__or4_2
XFILLER_0_83_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4673_ _3752_ _3836_ _3835_ VGND VGND VPWR VPWR _3839_ sky130_fd_sc_hd__o21a_1
X_7461_ _2641_ _2643_ VGND VGND VPWR VPWR _2644_ sky130_fd_sc_hd__xor2_2
XFILLER_0_98_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6412_ _1491_ _1505_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_98_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7392_ _2561_ _2562_ VGND VGND VPWR VPWR _2568_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6343_ net317 _1427_ _1428_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__and3_1
XFILLER_0_11_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6274_ _1342_ _1341_ VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_47_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5225_ _0238_ net189 net188 _1042_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__o22a_1
X_8013_ _3245_ _3250_ VGND VGND VPWR VPWR _3251_ sky130_fd_sc_hd__xnor2_1
X_5156_ _0170_ _0179_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5087_ _4037_ net316 _0110_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__and3_1
XFILLER_0_2_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_56_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5989_ _1031_ net61 VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__nor2_1
X_7728_ _2931_ _2936_ VGND VGND VPWR VPWR _2937_ sky130_fd_sc_hd__and2b_1
XFILLER_0_34_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7659_ _2859_ _2860_ VGND VGND VPWR VPWR _2861_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_65_Left_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_74_Left_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_83_Left_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5010_ _4173_ _4131_ VGND VGND VPWR VPWR _4176_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_88_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6961_ net82 _2094_ VGND VGND VPWR VPWR _2095_ sky130_fd_sc_hd__and2_1
XFILLER_0_88_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6892_ _2014_ _2015_ _2018_ VGND VGND VPWR VPWR _2019_ sky130_fd_sc_hd__a21o_1
X_5912_ _0953_ _0955_ _0956_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__a21boi_1
X_5843_ _0827_ _0810_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_91_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5774_ _0765_ _0804_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__xnor2_2
X_7513_ _2480_ _2485_ _2700_ VGND VGND VPWR VPWR _2701_ sky130_fd_sc_hd__a21o_1
XFILLER_0_90_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4725_ _3884_ _3886_ _3888_ _3890_ VGND VGND VPWR VPWR _3891_ sky130_fd_sc_hd__a211o_1
X_7444_ _2617_ _2622_ _2623_ VGND VGND VPWR VPWR _2625_ sky130_fd_sc_hd__and3_1
XFILLER_0_31_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4656_ _3819_ _3820_ _3821_ VGND VGND VPWR VPWR _3822_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_102_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7375_ net225 net243 VGND VGND VPWR VPWR _2549_ sky130_fd_sc_hd__or2b_1
XFILLER_0_31_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4587_ _3750_ _3752_ VGND VGND VPWR VPWR _3753_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6326_ _1402_ _1410_ _1403_ _1409_ VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__o2bb2a_1
X_6257_ _1303_ _1333_ _1334_ VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__a21bo_1
X_5208_ net193 net400 VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__or2b_1
X_6188_ net144 net305 VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__or2b_1
X_5139_ _0142_ _0162_ _0135_ _0139_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__a211o_1
XFILLER_0_98_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5490_ _0481_ _0471_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4510_ net197 net118 VGND VGND VPWR VPWR _3676_ sky130_fd_sc_hd__and2b_1
XFILLER_0_102_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4441_ net164 net212 VGND VGND VPWR VPWR _3291_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7160_ _2307_ _2311_ VGND VGND VPWR VPWR _2313_ sky130_fd_sc_hd__xnor2_2
X_4372_ _1917_ _1961_ _1950_ VGND VGND VPWR VPWR _2532_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_21_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6111_ _0924_ _1175_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7091_ _2229_ _2236_ VGND VGND VPWR VPWR _2237_ sky130_fd_sc_hd__or2_1
X_6042_ net129 net132 net180 net211 VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__or4bb_4
X_7993_ _3223_ _3228_ VGND VGND VPWR VPWR _3229_ sky130_fd_sc_hd__xnor2_1
X_6944_ _2075_ _2007_ _2002_ VGND VGND VPWR VPWR _2076_ sky130_fd_sc_hd__a21o_1
XFILLER_0_76_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6875_ _1965_ _1968_ VGND VGND VPWR VPWR _2000_ sky130_fd_sc_hd__xnor2_1
X_5826_ _0854_ _0860_ _0861_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__a21o_1
X_5757_ _0771_ _0777_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4708_ net424 net355 VGND VGND VPWR VPWR _3874_ sky130_fd_sc_hd__or2_1
XFILLER_0_32_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5688_ net153 net135 _0690_ _0709_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__a211o_1
X_7427_ net202 net303 VGND VGND VPWR VPWR _2606_ sky130_fd_sc_hd__and2b_1
XFILLER_0_32_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4639_ net45 _2268_ VGND VGND VPWR VPWR _3805_ sky130_fd_sc_hd__nor2_1
X_7358_ net201 net89 VGND VGND VPWR VPWR _2530_ sky130_fd_sc_hd__or2b_1
X_6309_ _1303_ _1333_ VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__xnor2_1
X_7289_ _2393_ _2453_ _2396_ VGND VGND VPWR VPWR _2454_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_99_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclone40 net149 VGND VGND VPWR VPWR net393 sky130_fd_sc_hd__buf_4
XFILLER_0_23_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4990_ _3997_ net309 _4144_ _4143_ VGND VGND VPWR VPWR _4156_ sky130_fd_sc_hd__a31o_1
XFILLER_0_105_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6660_ _1766_ _1767_ VGND VGND VPWR VPWR _1768_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5611_ _0542_ _0487_ _0500_ _0544_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__o31a_1
X_6591_ _1694_ _1698_ VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5542_ _0565_ _0564_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__xnor2_2
X_8330_ _3591_ _3592_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5473_ _0495_ _0496_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__xor2_1
X_8261_ _3521_ _3523_ VGND VGND VPWR VPWR _3524_ sky130_fd_sc_hd__or2_1
X_8192_ _3446_ _3447_ VGND VGND VPWR VPWR _3448_ sky130_fd_sc_hd__nand2_1
X_4424_ _2994_ _3093_ VGND VGND VPWR VPWR _3104_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7212_ net379 _2348_ VGND VGND VPWR VPWR _2370_ sky130_fd_sc_hd__nor2_1
X_4355_ _2257_ _2323_ VGND VGND VPWR VPWR _2345_ sky130_fd_sc_hd__nand2_1
X_7143_ net215 _2286_ VGND VGND VPWR VPWR _2294_ sky130_fd_sc_hd__nand2_1
X_7074_ net202 net285 VGND VGND VPWR VPWR _2218_ sky130_fd_sc_hd__and2b_1
X_4286_ _1558_ _1569_ _1591_ VGND VGND VPWR VPWR _1602_ sky130_fd_sc_hd__or3_2
X_6025_ _1019_ _1080_ VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7976_ _2779_ _3206_ _3207_ _3208_ VGND VGND VPWR VPWR _3210_ sky130_fd_sc_hd__or4_1
X_6927_ _2028_ _2056_ VGND VGND VPWR VPWR _2057_ sky130_fd_sc_hd__nand2_1
XFILLER_0_76_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6858_ _1978_ _1980_ VGND VGND VPWR VPWR _1981_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_64_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout78 counter\[8\] VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__clkbuf_4
X_5809_ net70 _0841_ _0842_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__or3b_1
XFILLER_0_64_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout89 net90 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__clkbuf_2
X_6789_ _1845_ _1903_ _1904_ VGND VGND VPWR VPWR _1905_ sky130_fd_sc_hd__o21a_1
XFILLER_0_102_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_10_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7830_ _3045_ _3047_ _3048_ VGND VGND VPWR VPWR _3050_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_25_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4973_ _4136_ _4138_ VGND VGND VPWR VPWR _4139_ sky130_fd_sc_hd__xor2_2
X_7761_ _2971_ _2973_ VGND VGND VPWR VPWR _2974_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7692_ _2896_ _2897_ VGND VGND VPWR VPWR _2898_ sky130_fd_sc_hd__xor2_1
X_6712_ _1546_ _1619_ _1820_ VGND VGND VPWR VPWR _1821_ sky130_fd_sc_hd__a21oi_1
X_6643_ _1632_ _1750_ VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_46_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6574_ _1588_ _1606_ _1681_ VGND VGND VPWR VPWR _1682_ sky130_fd_sc_hd__a21boi_2
X_5525_ _0518_ _0520_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__xnor2_1
X_8313_ _1613_ _1547_ _1624_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__o21a_1
XFILLER_0_14_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8244_ net75 _3504_ _3501_ net76 VGND VGND VPWR VPWR _3505_ sky130_fd_sc_hd__o22a_1
X_5456_ _0472_ _0473_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__nor2_1
X_4407_ _2862_ _2906_ VGND VGND VPWR VPWR _2917_ sky130_fd_sc_hd__xnor2_1
Xfanout213 net214 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__clkbuf_2
X_8175_ net217 _2163_ _2192_ _2190_ VGND VGND VPWR VPWR _3429_ sky130_fd_sc_hd__a31oi_2
X_5387_ _0401_ _0409_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__and2_1
Xfanout202 net31 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__buf_2
Xfanout246 net247 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__buf_2
X_4338_ _2136_ _2147_ VGND VGND VPWR VPWR _2158_ sky130_fd_sc_hd__nor2_1
Xfanout224 net226 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__clkbuf_4
Xfanout235 net20 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__clkbuf_4
X_7126_ _2273_ _2274_ VGND VGND VPWR VPWR _2275_ sky130_fd_sc_hd__nor2_1
X_7057_ net186 net228 VGND VGND VPWR VPWR _2199_ sky130_fd_sc_hd__and2_1
X_4269_ net156 _0800_ _1404_ net122 VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__o211a_1
Xfanout279 net14 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__buf_2
Xfanout268 net270 VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__clkbuf_4
Xfanout257 net16 VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__buf_2
X_6008_ _1052_ _1061_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7959_ net269 net278 _2128_ _2130_ VGND VGND VPWR VPWR _3191_ sky130_fd_sc_hd__and4_1
XFILLER_0_77_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_620 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5310_ _0218_ _0220_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6290_ net319 _1181_ _1369_ VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_3_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5241_ _1470_ net46 _0264_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__o21a_1
X_5172_ _4175_ _4177_ _4178_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__nand3_1
Xinput2 periodTop[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_6
XFILLER_0_36_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7813_ net94 _2678_ _3030_ _3029_ VGND VGND VPWR VPWR _3031_ sky130_fd_sc_hd__a31o_1
XFILLER_0_93_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7744_ _2877_ _2878_ VGND VGND VPWR VPWR _2955_ sky130_fd_sc_hd__and2_1
XFILLER_0_19_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4956_ _4075_ _4121_ VGND VGND VPWR VPWR _4122_ sky130_fd_sc_hd__and2b_1
X_4887_ _3668_ net272 _4052_ _4051_ VGND VGND VPWR VPWR _4053_ sky130_fd_sc_hd__a31o_1
X_7675_ _2871_ _2877_ _2878_ _2870_ _2868_ VGND VGND VPWR VPWR _2879_ sky130_fd_sc_hd__a32oi_4
X_6626_ _1731_ _1733_ VGND VGND VPWR VPWR _1734_ sky130_fd_sc_hd__nor2_1
XFILLER_0_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6557_ _1590_ _1593_ _1664_ VGND VGND VPWR VPWR _1665_ sky130_fd_sc_hd__o21a_1
X_5508_ _1492_ net188 VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__nor2_1
X_6488_ net125 net149 VGND VGND VPWR VPWR _1589_ sky130_fd_sc_hd__or2b_1
XFILLER_0_100_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5439_ _1492_ net160 _0454_ _0462_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__o31a_1
X_8227_ _3466_ _3473_ VGND VGND VPWR VPWR _3486_ sky130_fd_sc_hd__nor2_1
X_8158_ _3408_ _3409_ VGND VGND VPWR VPWR _3410_ sky130_fd_sc_hd__and2_1
X_7109_ net314 net90 _2127_ _2129_ VGND VGND VPWR VPWR _2256_ sky130_fd_sc_hd__and4_1
X_8089_ _3332_ _3333_ VGND VGND VPWR VPWR _3334_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_97_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_103_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4810_ net191 VGND VGND VPWR VPWR _3976_ sky130_fd_sc_hd__inv_2
X_5790_ _0819_ _0820_ _0821_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_7_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4741_ _3905_ _3906_ VGND VGND VPWR VPWR _3907_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_56_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4672_ _3835_ _3837_ VGND VGND VPWR VPWR _3838_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_22_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7460_ _2557_ _2559_ VGND VGND VPWR VPWR _2643_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6411_ _1494_ _1504_ VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_98_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7391_ _2564_ _2566_ VGND VGND VPWR VPWR _2567_ sky130_fd_sc_hd__nor2_2
XFILLER_0_3_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6342_ net316 _1427_ _1428_ VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__a21o_1
X_6273_ _1351_ _1352_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__xor2_1
X_5224_ net284 _3082_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__nand2_1
X_8012_ _3246_ _3249_ VGND VGND VPWR VPWR _3250_ sky130_fd_sc_hd__nor2_1
X_5155_ _0145_ _0177_ _0178_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__o21a_1
XFILLER_0_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5086_ _3997_ net316 _0109_ _0108_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__a31o_1
XFILLER_0_93_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5988_ _1033_ _1039_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__xor2_1
XFILLER_0_47_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4939_ _4099_ _4101_ VGND VGND VPWR VPWR _4105_ sky130_fd_sc_hd__and2_1
X_7727_ _2932_ _2933_ _2935_ VGND VGND VPWR VPWR _2936_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_74_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7658_ _2655_ _2657_ VGND VGND VPWR VPWR _2860_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6609_ _1703_ _1716_ VGND VGND VPWR VPWR _1717_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_62_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7589_ _2764_ _2783_ VGND VGND VPWR VPWR _2784_ sky130_fd_sc_hd__xor2_1
XFILLER_0_27_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6960_ _1822_ _2092_ VGND VGND VPWR VPWR _2094_ sky130_fd_sc_hd__xor2_1
XFILLER_0_17_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5911_ net111 net108 net311 net87 VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__or4bb_1
X_6891_ _0893_ _2017_ VGND VGND VPWR VPWR _2018_ sky130_fd_sc_hd__nand2_1
X_5842_ net107 _0878_ _0879_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__or3_1
XFILLER_0_48_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5773_ _0768_ _0796_ _0798_ _0803_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__o31a_2
XFILLER_0_75_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7512_ _2478_ _2479_ VGND VGND VPWR VPWR _2700_ sky130_fd_sc_hd__nor2_1
X_4724_ _3800_ _3889_ VGND VGND VPWR VPWR _3890_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_71_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_2_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7443_ _2617_ _2622_ _2623_ VGND VGND VPWR VPWR _2624_ sky130_fd_sc_hd__a21oi_1
X_4655_ net158 net195 net300 net310 VGND VGND VPWR VPWR _3821_ sky130_fd_sc_hd__and4bb_1
X_4586_ _1829_ _3751_ net86 VGND VGND VPWR VPWR _3752_ sky130_fd_sc_hd__and3b_1
Xinput60 vC[4] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_1
X_7374_ net319 net227 _2547_ _2545_ VGND VGND VPWR VPWR _2548_ sky130_fd_sc_hd__a31o_1
XFILLER_0_101_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6325_ _1403_ _1409_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__xor2_1
X_6256_ _1332_ _1321_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__or2b_1
X_5207_ net159 net212 VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__or2b_1
X_6187_ _2422_ net142 VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__nor2_1
X_5138_ _0156_ _0159_ _0160_ _0161_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__a211oi_2
X_5069_ _0090_ _0092_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__xor2_2
XFILLER_0_79_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_100_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4440_ net164 net181 VGND VGND VPWR VPWR _3280_ sky130_fd_sc_hd__or2b_1
XFILLER_0_1_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4371_ _2466_ _2510_ VGND VGND VPWR VPWR _2521_ sky130_fd_sc_hd__xnor2_1
X_6110_ _0933_ _0934_ VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__and2_1
XFILLER_0_95_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7090_ _2230_ _2234_ VGND VGND VPWR VPWR _2236_ sky130_fd_sc_hd__xnor2_1
X_6041_ net132 net180 VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__and2b_1
XFILLER_0_28_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7992_ _3224_ _3226_ _3227_ VGND VGND VPWR VPWR _3228_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_88_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6943_ _1824_ _1831_ _1897_ VGND VGND VPWR VPWR _2075_ sky130_fd_sc_hd__a21o_1
X_6874_ _1833_ _1890_ VGND VGND VPWR VPWR _1999_ sky130_fd_sc_hd__nand2_1
X_5825_ _0847_ _0853_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__nor2_1
XFILLER_0_64_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5756_ _0780_ _0784_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_56_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5687_ _0690_ _0709_ net153 net135 VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_71_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4707_ _3840_ _3871_ _3872_ VGND VGND VPWR VPWR _3873_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_17_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7426_ net208 net295 VGND VGND VPWR VPWR _2605_ sky130_fd_sc_hd__and2b_1
X_4638_ _3800_ _3802_ _3803_ VGND VGND VPWR VPWR _3804_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_8_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4569_ _3732_ _3734_ VGND VGND VPWR VPWR _3735_ sky130_fd_sc_hd__or2_1
X_7357_ net201 net313 VGND VGND VPWR VPWR _2529_ sky130_fd_sc_hd__or2b_1
XFILLER_0_12_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6308_ _1373_ _1389_ _1390_ VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__a21bo_1
X_7288_ _2394_ _2395_ VGND VGND VPWR VPWR _2453_ sky130_fd_sc_hd__nor2_1
X_6239_ _1310_ _1314_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5610_ _0621_ _0633_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6590_ _1695_ _1696_ _1697_ VGND VGND VPWR VPWR _1698_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5541_ _0515_ _0550_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__nand2_1
X_8260_ _3277_ _3514_ _3273_ VGND VGND VPWR VPWR _3523_ sky130_fd_sc_hd__and3_1
X_5472_ net100 _3976_ _0454_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__and3_1
X_7211_ _2365_ _2366_ _2368_ VGND VGND VPWR VPWR _2369_ sky130_fd_sc_hd__a21oi_4
X_8191_ _3427_ _3425_ VGND VGND VPWR VPWR _3447_ sky130_fd_sc_hd__xnor2_1
X_4423_ net419 _3082_ _3005_ VGND VGND VPWR VPWR _3093_ sky130_fd_sc_hd__and3_1
X_4354_ _2257_ _2323_ VGND VGND VPWR VPWR _2334_ sky130_fd_sc_hd__or2_1
X_7142_ net243 _2287_ _2292_ _2291_ VGND VGND VPWR VPWR _2293_ sky130_fd_sc_hd__a31o_1
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7073_ net294 _2216_ VGND VGND VPWR VPWR _2217_ sky130_fd_sc_hd__nand2_1
X_4285_ counter\[10\] net77 net78 _1580_ VGND VGND VPWR VPWR _1591_ sky130_fd_sc_hd__or4_1
X_6024_ _1066_ _1079_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__xor2_1
X_7975_ _2779_ _3206_ _3207_ _3208_ VGND VGND VPWR VPWR _3209_ sky130_fd_sc_hd__o22a_1
XFILLER_0_55_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6926_ _2026_ _2004_ _2011_ VGND VGND VPWR VPWR _2056_ sky130_fd_sc_hd__nand3_1
X_6857_ _0858_ _1979_ VGND VGND VPWR VPWR _1980_ sky130_fd_sc_hd__nor2_1
X_5808_ _0801_ _0838_ _0837_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__o21ai_1
Xfanout79 counter\[6\] VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__clkbuf_4
X_6788_ _1843_ _1844_ VGND VGND VPWR VPWR _1904_ sky130_fd_sc_hd__or2_1
X_5739_ _0750_ _0751_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7409_ _2548_ _2584_ _2585_ VGND VGND VPWR VPWR _2586_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_102_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4972_ _4137_ _4096_ VGND VGND VPWR VPWR _4138_ sky130_fd_sc_hd__xnor2_2
X_7760_ _2903_ _2911_ VGND VGND VPWR VPWR _2973_ sky130_fd_sc_hd__xor2_1
XFILLER_0_86_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7691_ _2844_ _2846_ VGND VGND VPWR VPWR _2897_ sky130_fd_sc_hd__xnor2_1
X_6711_ _1616_ _1618_ VGND VGND VPWR VPWR _1820_ sky130_fd_sc_hd__nor2_1
X_6642_ _1689_ _1749_ VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_41_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8312_ counter\[0\] _1602_ VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__nor2_1
X_6573_ _1603_ _1605_ VGND VGND VPWR VPWR _1681_ sky130_fd_sc_hd__or2b_1
X_5524_ _0546_ _0547_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8243_ _3496_ _3503_ VGND VGND VPWR VPWR _3504_ sky130_fd_sc_hd__xnor2_1
X_5455_ _0475_ _0478_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__xnor2_1
X_8174_ _3425_ _3427_ VGND VGND VPWR VPWR _3428_ sky130_fd_sc_hd__or2b_1
X_4406_ _2873_ _2884_ _2895_ VGND VGND VPWR VPWR _2906_ sky130_fd_sc_hd__a21oi_1
Xfanout214 net218 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__buf_2
X_5386_ _0401_ _0409_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__nor2_1
X_7125_ net90 net95 _2127_ _2129_ VGND VGND VPWR VPWR _2274_ sky130_fd_sc_hd__and4_1
Xfanout203 net204 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__clkbuf_2
Xfanout247 net248 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__clkbuf_4
Xfanout236 net20 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__clkbuf_2
X_4337_ net163 net265 VGND VGND VPWR VPWR _2147_ sky130_fd_sc_hd__and2b_1
XFILLER_0_10_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout225 net226 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__buf_2
X_4268_ net74 VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__inv_2
X_7056_ _2196_ _2197_ VGND VGND VPWR VPWR _2198_ sky130_fd_sc_hd__xor2_1
Xfanout258 net259 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__buf_6
Xfanout269 net270 VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6007_ _1054_ _1060_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__xnor2_1
X_8411__28 clknet_2_3__leaf_clk VGND VGND VPWR VPWR net349 sky130_fd_sc_hd__inv_2
XFILLER_0_69_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7958_ _1042_ net232 net234 _0238_ VGND VGND VPWR VPWR _3190_ sky130_fd_sc_hd__o22a_1
X_6909_ _0906_ _2036_ _0905_ VGND VGND VPWR VPWR _2037_ sky130_fd_sc_hd__o21ai_1
X_7889_ _3112_ _3106_ _3111_ VGND VGND VPWR VPWR _3114_ sky130_fd_sc_hd__and3_1
XFILLER_0_37_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5240_ net165 net119 VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5171_ _0075_ _0141_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__nand2_1
Xinput3 periodTop[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_1
XFILLER_0_36_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7812_ _2987_ _3026_ _3029_ VGND VGND VPWR VPWR _3030_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_59_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7743_ _2949_ _2952_ _2953_ VGND VGND VPWR VPWR _2954_ sky130_fd_sc_hd__a21boi_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4955_ _4093_ _4119_ _4120_ VGND VGND VPWR VPWR _4121_ sky130_fd_sc_hd__a21o_1
XFILLER_0_86_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4886_ _4049_ _4050_ _4051_ VGND VGND VPWR VPWR _4052_ sky130_fd_sc_hd__a21oi_2
X_7674_ net303 _2381_ _2874_ _2876_ VGND VGND VPWR VPWR _2878_ sky130_fd_sc_hd__a22o_1
X_6625_ _1640_ _1732_ VGND VGND VPWR VPWR _1733_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6556_ _1662_ _1663_ VGND VGND VPWR VPWR _1664_ sky130_fd_sc_hd__xnor2_1
X_5507_ net100 _3751_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8226_ _3465_ _3474_ _3484_ VGND VGND VPWR VPWR _3485_ sky130_fd_sc_hd__or3b_1
X_6487_ _1577_ _1587_ VGND VGND VPWR VPWR _1588_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5438_ _0459_ _0461_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8157_ _3393_ _3407_ VGND VGND VPWR VPWR _3409_ sky130_fd_sc_hd__or2_1
X_5369_ _0392_ _0383_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8088_ _3297_ _3298_ _3299_ VGND VGND VPWR VPWR _3333_ sky130_fd_sc_hd__o21ba_1
X_7108_ _4035_ net231 net233 _2422_ VGND VGND VPWR VPWR _2255_ sky130_fd_sc_hd__o22a_1
X_7039_ _2143_ _2178_ VGND VGND VPWR VPWR _2179_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4740_ _3818_ _3822_ VGND VGND VPWR VPWR _3906_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_83_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4671_ _3752_ _3836_ VGND VGND VPWR VPWR _3837_ sky130_fd_sc_hd__nor2_1
X_7390_ _2522_ _2518_ _2509_ VGND VGND VPWR VPWR _2566_ sky130_fd_sc_hd__a21oi_1
X_6410_ _1501_ _1502_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6341_ _0149_ net131 VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__nor2_1
XFILLER_0_51_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6272_ _1177_ _1191_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__xor2_2
X_5223_ _0245_ _0246_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__nand2_1
X_8011_ _1481_ net207 _3248_ VGND VGND VPWR VPWR _3249_ sky130_fd_sc_hd__o21a_1
X_5154_ _0172_ _0176_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5085_ _0077_ _0106_ _0108_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_79_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5987_ _1034_ _1038_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4938_ _4103_ _4081_ VGND VGND VPWR VPWR _4104_ sky130_fd_sc_hd__xnor2_2
X_7726_ _1884_ net202 _2934_ VGND VGND VPWR VPWR _2935_ sky130_fd_sc_hd__or3_1
XFILLER_0_19_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4869_ _1873_ VGND VGND VPWR VPWR _4035_ sky130_fd_sc_hd__buf_4
X_7657_ _2827_ _2857_ _2858_ VGND VGND VPWR VPWR _2859_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_90_Right_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6608_ _1714_ _1715_ VGND VGND VPWR VPWR _1716_ sky130_fd_sc_hd__nor2_1
XFILLER_0_104_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7588_ _2767_ _2782_ VGND VGND VPWR VPWR _2783_ sky130_fd_sc_hd__xor2_1
XFILLER_0_15_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6539_ _0927_ net142 VGND VGND VPWR VPWR _1645_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8209_ _3451_ _3453_ VGND VGND VPWR VPWR _3466_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_100_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5910_ net108 net87 VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__or2b_1
X_6890_ _0891_ _0892_ VGND VGND VPWR VPWR _2017_ sky130_fd_sc_hd__or2_1
X_5841_ net7 _0806_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5772_ _0799_ _0794_ _0802_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__a21o_1
X_7511_ _2672_ _2698_ VGND VGND VPWR VPWR _2699_ sky130_fd_sc_hd__xor2_2
X_4723_ _3727_ _3801_ _3803_ VGND VGND VPWR VPWR _3889_ sky130_fd_sc_hd__o21a_1
X_7442_ _2527_ _2531_ VGND VGND VPWR VPWR _2623_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4654_ net195 net310 VGND VGND VPWR VPWR _3820_ sky130_fd_sc_hd__or2b_1
X_4585_ net189 VGND VGND VPWR VPWR _3751_ sky130_fd_sc_hd__inv_2
Xinput61 vC[5] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_12_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput50 vC[0] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_24_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7373_ _2545_ _2546_ VGND VGND VPWR VPWR _2547_ sky130_fd_sc_hd__nor2_1
XFILLER_0_102_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6324_ _2422_ net50 _1408_ _1407_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__o31a_1
XFILLER_0_12_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6255_ _1321_ _1332_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__xnor2_1
X_5206_ _3885_ net192 VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__nor2_1
XFILLER_0_58_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6186_ _1135_ _1138_ _1137_ VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__a21o_1
X_5137_ _0113_ _0128_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__xnor2_2
X_5068_ _0091_ _4197_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_79_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7709_ _2914_ _2915_ VGND VGND VPWR VPWR _2916_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4370_ _2477_ _2488_ _2499_ VGND VGND VPWR VPWR _2510_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6040_ net129 net211 VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__and2b_1
X_7991_ net246 net199 net186 net217 VGND VGND VPWR VPWR _3227_ sky130_fd_sc_hd__and4bb_1
X_6942_ counter\[11\] _2072_ VGND VGND VPWR VPWR _2074_ sky130_fd_sc_hd__and2_1
X_6873_ _1889_ _1835_ VGND VGND VPWR VPWR _1998_ sky130_fd_sc_hd__or2b_1
X_5824_ _0856_ _0859_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_91_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5755_ _0781_ _0783_ VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5686_ _0707_ _0708_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__and2_1
XFILLER_0_97_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4706_ _3841_ _3870_ VGND VGND VPWR VPWR _3872_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7425_ net313 _2216_ VGND VGND VPWR VPWR _2604_ sky130_fd_sc_hd__nand2_1
X_4637_ net167 net165 net273 net283 VGND VGND VPWR VPWR _3803_ sky130_fd_sc_hd__or4bb_1
XFILLER_0_44_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4568_ _2126_ _3733_ VGND VGND VPWR VPWR _3734_ sky130_fd_sc_hd__xnor2_1
X_7356_ net248 net88 VGND VGND VPWR VPWR _2528_ sky130_fd_sc_hd__or2b_1
XFILLER_0_40_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4499_ _2829_ _2840_ VGND VGND VPWR VPWR _3665_ sky130_fd_sc_hd__or2b_4
X_6307_ _1388_ _1387_ VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__or2b_1
X_7287_ _2441_ _2451_ VGND VGND VPWR VPWR _2452_ sky130_fd_sc_hd__xnor2_2
X_6238_ _1311_ _1312_ _1313_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__a21oi_1
X_6169_ _1115_ _1116_ VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__nor2_1
XFILLER_0_82_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5540_ _0558_ _0563_ _0561_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__a21bo_2
XFILLER_0_26_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5471_ _0491_ _0494_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_53_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7210_ _2328_ _2364_ VGND VGND VPWR VPWR _2368_ sky130_fd_sc_hd__nor2_1
X_4422_ _2950_ VGND VGND VPWR VPWR _3082_ sky130_fd_sc_hd__clkbuf_4
X_8190_ _3443_ _3444_ VGND VGND VPWR VPWR _3446_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4353_ _2279_ _2312_ VGND VGND VPWR VPWR _2323_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7141_ _2288_ _2289_ _2291_ VGND VGND VPWR VPWR _2292_ sky130_fd_sc_hd__a21oi_2
X_4284_ net74 net75 net76 counter\[11\] VGND VGND VPWR VPWR _1580_ sky130_fd_sc_hd__or4_1
XFILLER_0_39_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7072_ _2215_ VGND VGND VPWR VPWR _2216_ sky130_fd_sc_hd__clkbuf_4
X_6023_ _1067_ _1078_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_55_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7974_ _2764_ _2783_ VGND VGND VPWR VPWR _3208_ sky130_fd_sc_hd__and2_1
X_6925_ net74 _2046_ _2050_ _2053_ _2054_ VGND VGND VPWR VPWR _2055_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6856_ net266 _0685_ _0859_ VGND VGND VPWR VPWR _1979_ sky130_fd_sc_hd__and3_1
XFILLER_0_9_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5807_ _0830_ _0840_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__nor2_1
XFILLER_0_91_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6787_ _1847_ VGND VGND VPWR VPWR _1903_ sky130_fd_sc_hd__inv_2
XFILLER_0_36_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5738_ _0761_ _0760_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__xor2_4
XFILLER_0_91_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5669_ _1503_ net139 VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__nor2_1
X_7408_ _2582_ net380 VGND VGND VPWR VPWR _2585_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7339_ _2504_ _2508_ _2507_ VGND VGND VPWR VPWR _2509_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_67_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4971_ _3769_ net280 VGND VGND VPWR VPWR _4137_ sky130_fd_sc_hd__nand2_1
X_6710_ _1753_ _1757_ VGND VGND VPWR VPWR _1819_ sky130_fd_sc_hd__xnor2_1
X_7690_ _2881_ _2893_ _2894_ VGND VGND VPWR VPWR _2896_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_19_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6641_ _1740_ _1748_ VGND VGND VPWR VPWR _1749_ sky130_fd_sc_hd__xnor2_2
X_8311_ _3574_ _3578_ counter\[15\] _3576_ VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__a2bb2o_1
X_6572_ _1668_ _1679_ VGND VGND VPWR VPWR _1680_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_6_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5523_ _0544_ _0545_ _0517_ _0521_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__a211o_1
XFILLER_0_81_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8242_ _3497_ _2212_ VGND VGND VPWR VPWR _3503_ sky130_fd_sc_hd__nor2_1
X_5454_ _0476_ _0477_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__nor2_1
X_8173_ _3398_ _3404_ _3426_ VGND VGND VPWR VPWR _3427_ sky130_fd_sc_hd__a21bo_1
X_5385_ _0403_ _0407_ _0408_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__a21boi_1
X_4405_ net159 net193 net258 net265 VGND VGND VPWR VPWR _2895_ sky130_fd_sc_hd__and4bb_1
X_4336_ net166 net258 VGND VGND VPWR VPWR _2136_ sky130_fd_sc_hd__and2b_1
XFILLER_0_10_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7124_ _3901_ net231 net233 _4035_ VGND VGND VPWR VPWR _2273_ sky130_fd_sc_hd__o22a_1
Xfanout204 net31 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__clkbuf_2
Xfanout226 net25 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__buf_2
Xfanout237 net238 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__buf_4
Xfanout215 net218 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__buf_2
X_4267_ net102 net73 VGND VGND VPWR VPWR _1393_ sky130_fd_sc_hd__nand2_1
X_7055_ _2132_ _2135_ _2134_ _2133_ VGND VGND VPWR VPWR _2197_ sky130_fd_sc_hd__o2bb2a_1
Xfanout248 net19 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__clkbuf_4
Xfanout259 net16 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__buf_6
X_6006_ _1055_ _1059_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__xnor2_1
X_7957_ net288 _2163_ VGND VGND VPWR VPWR _3189_ sky130_fd_sc_hd__nand2_1
X_6908_ _0896_ _0901_ _0843_ _0846_ VGND VGND VPWR VPWR _2036_ sky130_fd_sc_hd__o211a_1
X_7888_ _3106_ _3111_ _3112_ VGND VGND VPWR VPWR _3113_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_37_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6839_ _1958_ _1959_ VGND VGND VPWR VPWR _1960_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_64_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_611 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5170_ _4179_ _0193_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__nor2_1
Xinput4 periodTop[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_2_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_78_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7811_ _2986_ _3028_ VGND VGND VPWR VPWR _3029_ sky130_fd_sc_hd__nor2_1
X_7742_ _2946_ _2948_ VGND VGND VPWR VPWR _2953_ sky130_fd_sc_hd__nand2_1
X_4954_ _4117_ _4118_ VGND VGND VPWR VPWR _4120_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4885_ net174 net196 net256 net263 VGND VGND VPWR VPWR _4051_ sky130_fd_sc_hd__and4bb_1
X_7673_ net303 _2381_ _2874_ _2876_ VGND VGND VPWR VPWR _2877_ sky130_fd_sc_hd__nand4_4
X_6624_ net138 net287 VGND VGND VPWR VPWR _1732_ sky130_fd_sc_hd__or2b_1
X_6555_ _3885_ net107 VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5506_ _0495_ _0496_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__or2b_1
X_8225_ _3420_ _3483_ _3480_ VGND VGND VPWR VPWR _3484_ sky130_fd_sc_hd__a21o_1
X_6486_ _1585_ _1586_ VGND VGND VPWR VPWR _1587_ sky130_fd_sc_hd__nand2_1
X_5437_ _0454_ _0460_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8156_ _3393_ _3407_ VGND VGND VPWR VPWR _3408_ sky130_fd_sc_hd__nand2_1
X_5368_ net420 net177 VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__nand2_1
X_5299_ _0281_ _0322_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__nor2_1
X_8087_ _3304_ _3306_ _3331_ VGND VGND VPWR VPWR _3332_ sky130_fd_sc_hd__o21a_1
X_4319_ net158 net195 net273 net283 VGND VGND VPWR VPWR _1950_ sky130_fd_sc_hd__and4bb_1
X_7107_ net95 _2162_ VGND VGND VPWR VPWR _2254_ sky130_fd_sc_hd__nand2_1
X_7038_ net123 _2139_ _2177_ VGND VGND VPWR VPWR _2178_ sky130_fd_sc_hd__a21o_1
XFILLER_0_97_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4670_ _3082_ net92 _3753_ VGND VGND VPWR VPWR _3836_ sky130_fd_sc_hd__and3_1
XFILLER_0_36_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6340_ net128 VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__inv_2
XFILLER_0_98_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6271_ _1340_ _1344_ _1350_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__a21o_1
X_5222_ _3478_ _3489_ _3467_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__a21oi_2
X_8010_ net204 net122 VGND VGND VPWR VPWR _3248_ sky130_fd_sc_hd__or2b_1
X_5153_ _0172_ _0176_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_16_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5084_ _0076_ _0107_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5986_ _1035_ _1036_ _1037_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_59_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4937_ _3652_ net298 VGND VGND VPWR VPWR _4103_ sky130_fd_sc_hd__nand2_1
X_7725_ net205 net94 VGND VGND VPWR VPWR _2934_ sky130_fd_sc_hd__or2b_1
X_4868_ _3964_ _4033_ VGND VGND VPWR VPWR _4034_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_25_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7656_ _2855_ _2856_ VGND VGND VPWR VPWR _2858_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_20 net420 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6607_ _1713_ _1711_ VGND VGND VPWR VPWR _1715_ sky130_fd_sc_hd__and2b_1
XFILLER_0_6_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7587_ _2776_ _2781_ VGND VGND VPWR VPWR _2782_ sky130_fd_sc_hd__xnor2_1
X_4799_ _3963_ _3964_ _3961_ VGND VGND VPWR VPWR _3965_ sky130_fd_sc_hd__a21boi_2
X_6538_ _1642_ _1643_ VGND VGND VPWR VPWR _1644_ sky130_fd_sc_hd__xnor2_2
X_6469_ _1565_ _1566_ _1567_ VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__a21oi_2
X_8208_ _3463_ _3464_ VGND VGND VPWR VPWR _3465_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8139_ net262 net229 _3388_ VGND VGND VPWR VPWR _3389_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_34_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_102_Right_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_43_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5840_ _0862_ _0876_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__xor2_1
XFILLER_0_29_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5771_ _0768_ _0801_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7510_ _2684_ _2696_ VGND VGND VPWR VPWR _2698_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_16_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4722_ _3806_ _3887_ VGND VGND VPWR VPWR _3888_ sky130_fd_sc_hd__nor2_1
XFILLER_0_83_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7441_ _2618_ _2621_ _2617_ VGND VGND VPWR VPWR _2622_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_44_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput40 vB[15] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_2
X_4653_ net158 net300 VGND VGND VPWR VPWR _3819_ sky130_fd_sc_hd__or2b_1
Xinput51 vC[10] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_580 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput62 vC[6] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__buf_1
XFILLER_0_3_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7372_ _2525_ _2542_ _2544_ VGND VGND VPWR VPWR _2546_ sky130_fd_sc_hd__and3_1
X_4584_ net190 _1840_ net187 _1873_ VGND VGND VPWR VPWR _3750_ sky130_fd_sc_hd__o22a_1
XFILLER_0_12_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6323_ _1405_ _1406_ _1407_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__o21ai_2
X_6254_ _1325_ _1331_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__xnor2_1
X_5205_ _0224_ _0228_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__xnor2_2
X_6185_ _1113_ _1123_ _1121_ VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__a21boi_2
X_5136_ _0111_ _0132_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__xnor2_1
X_5067_ _3769_ net419 VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5969_ _1011_ _1018_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__nand2_1
X_7708_ _2859_ _2860_ VGND VGND VPWR VPWR _2915_ sky130_fd_sc_hd__xor2_1
X_7639_ _2833_ _2835_ VGND VGND VPWR VPWR _2839_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7990_ net246 net217 VGND VGND VPWR VPWR _3226_ sky130_fd_sc_hd__or2b_1
X_6941_ counter\[10\] _2066_ _2072_ counter\[11\] VGND VGND VPWR VPWR _2073_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_88_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6872_ _1971_ _1996_ VGND VGND VPWR VPWR _1997_ sky130_fd_sc_hd__or2_1
X_5823_ _0857_ _0858_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5754_ _0739_ _0782_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5685_ _0693_ _0706_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__or2_1
X_4705_ _3841_ _3870_ VGND VGND VPWR VPWR _3871_ sky130_fd_sc_hd__xor2_2
XFILLER_0_44_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7424_ net202 net208 net295 net303 VGND VGND VPWR VPWR _2603_ sky130_fd_sc_hd__or4bb_1
X_4636_ _3727_ _3801_ VGND VGND VPWR VPWR _3802_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7355_ _3901_ net235 VGND VGND VPWR VPWR _2527_ sky130_fd_sc_hd__nor2_1
XFILLER_0_69_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4567_ _2093_ _2104_ _2147_ _2136_ VGND VGND VPWR VPWR _3733_ sky130_fd_sc_hd__o22a_1
XFILLER_0_12_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6306_ _1387_ _1388_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__xnor2_1
X_4498_ _3555_ _3663_ VGND VGND VPWR VPWR _3664_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7286_ _2448_ _2450_ VGND VGND VPWR VPWR _2451_ sky130_fd_sc_hd__xnor2_2
X_6237_ net127 net130 net291 net301 VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__and4bb_1
X_6168_ _1221_ _1237_ VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__xor2_2
XFILLER_0_99_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5119_ _0122_ _0124_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__xnor2_1
X_6099_ net271 _0909_ _1161_ _1160_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__a31o_1
XFILLER_0_67_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5470_ _0492_ _0466_ _0493_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__o21a_1
XFILLER_0_5_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4421_ _2851_ _3027_ _3060_ VGND VGND VPWR VPWR _3071_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8386__3 clknet_2_1__leaf_clk VGND VGND VPWR VPWR net324 sky130_fd_sc_hd__inv_2
X_4352_ _2290_ _2093_ _2301_ VGND VGND VPWR VPWR _2312_ sky130_fd_sc_hd__a21o_1
X_7140_ net225 net251 net185 net215 VGND VGND VPWR VPWR _2291_ sky130_fd_sc_hd__and4bb_1
X_4283_ net82 counter\[3\] net81 counter\[7\] VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__or4_1
X_7071_ net32 VGND VGND VPWR VPWR _2215_ sky130_fd_sc_hd__inv_2
X_6022_ _1076_ _1077_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__nor2_1
X_7973_ _2767_ _2782_ VGND VGND VPWR VPWR _3207_ sky130_fd_sc_hd__and2_1
X_6924_ net75 _2052_ VGND VGND VPWR VPWR _2054_ sky130_fd_sc_hd__and2_1
XFILLER_0_89_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6855_ _1932_ _1933_ _1938_ VGND VGND VPWR VPWR _1978_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_64_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5806_ net398 net136 _0832_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__and3_1
XFILLER_0_76_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6786_ net287 net137 _1900_ _1901_ VGND VGND VPWR VPWR _1902_ sky130_fd_sc_hd__a31o_1
XFILLER_0_64_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5737_ _0763_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__inv_2
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5668_ net140 VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__inv_2
X_7407_ _2582_ _2583_ VGND VGND VPWR VPWR _2584_ sky130_fd_sc_hd__xor2_2
XFILLER_0_102_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5599_ net120 net178 VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4619_ _3728_ _3784_ VGND VGND VPWR VPWR _3785_ sky130_fd_sc_hd__xnor2_1
X_7338_ _2505_ _2506_ _2507_ VGND VGND VPWR VPWR _2508_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_8_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7269_ _2431_ _2284_ VGND VGND VPWR VPWR _2432_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_95_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4970_ _3668_ net290 _4135_ _4134_ VGND VGND VPWR VPWR _4136_ sky130_fd_sc_hd__a31o_1
XFILLER_0_25_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6640_ _1746_ _1747_ VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6571_ _1676_ _1678_ VGND VGND VPWR VPWR _1679_ sky130_fd_sc_hd__xor2_2
XFILLER_0_6_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5522_ _0517_ _0521_ _0544_ _0545_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__o211ai_2
X_8310_ net73 _3576_ _3499_ _1404_ VGND VGND VPWR VPWR _3578_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_54_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8241_ net76 _3501_ VGND VGND VPWR VPWR _3502_ sky130_fd_sc_hd__nand2_1
X_5453_ _0467_ _0300_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__nor2_1
X_8172_ _3396_ _3397_ VGND VGND VPWR VPWR _3426_ sky130_fd_sc_hd__or2b_1
X_5384_ _0406_ _0405_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__or2b_1
X_4404_ net194 net265 VGND VGND VPWR VPWR _2884_ sky130_fd_sc_hd__or2b_1
X_4335_ _2115_ net273 VGND VGND VPWR VPWR _2126_ sky130_fd_sc_hd__nand2_2
Xfanout205 net208 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__buf_2
X_7123_ net319 _2162_ VGND VGND VPWR VPWR _2272_ sky130_fd_sc_hd__nand2_1
Xfanout216 net218 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__buf_1
XFILLER_0_10_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout238 net242 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__buf_2
Xfanout227 net230 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__clkbuf_4
X_4266_ net102 net73 VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__or2_1
X_7054_ _2186_ _2194_ _2195_ VGND VGND VPWR VPWR _2196_ sky130_fd_sc_hd__a21o_1
Xfanout249 net18 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__buf_2
X_6005_ _1056_ _1057_ _1058_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__o21a_1
XFILLER_0_96_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7956_ _3186_ _3187_ VGND VGND VPWR VPWR _3188_ sky130_fd_sc_hd__xnor2_1
X_6907_ _2034_ VGND VGND VPWR VPWR _2035_ sky130_fd_sc_hd__inv_2
X_7887_ _3075_ _3077_ VGND VGND VPWR VPWR _3112_ sky130_fd_sc_hd__xnor2_1
X_6838_ _1901_ _1900_ VGND VGND VPWR VPWR _1959_ sky130_fd_sc_hd__and2b_1
XFILLER_0_9_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6769_ _1774_ _1775_ _1773_ VGND VGND VPWR VPWR _1883_ sky130_fd_sc_hd__a21o_1
XFILLER_0_17_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8439_ net345 _0015_ net254 VGND VGND VPWR VPWR counter\[8\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_103_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8402__19 clknet_2_0__leaf_clk VGND VGND VPWR VPWR net340 sky130_fd_sc_hd__inv_2
XFILLER_0_83_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput5 periodTop[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_36_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7810_ net222 net88 VGND VGND VPWR VPWR _3028_ sky130_fd_sc_hd__or2b_1
XFILLER_0_59_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7741_ _2951_ _2927_ VGND VGND VPWR VPWR _2952_ sky130_fd_sc_hd__xnor2_1
X_4953_ _4117_ _4118_ VGND VGND VPWR VPWR _4119_ sky130_fd_sc_hd__xor2_1
XFILLER_0_52_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7672_ _2810_ _2875_ VGND VGND VPWR VPWR _2876_ sky130_fd_sc_hd__or2_2
XFILLER_0_19_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6623_ _0927_ net141 net138 _1119_ VGND VGND VPWR VPWR _1731_ sky130_fd_sc_hd__o22a_1
X_4884_ net174 net263 VGND VGND VPWR VPWR _4050_ sky130_fd_sc_hd__or2b_1
X_6554_ _1659_ _1660_ _1661_ VGND VGND VPWR VPWR _1662_ sky130_fd_sc_hd__a21o_1
X_5505_ _0527_ _0528_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__or2_1
X_6485_ _1578_ _1584_ VGND VGND VPWR VPWR _1586_ sky130_fd_sc_hd__or2_1
X_5436_ net160 net100 VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__and2b_1
X_8224_ _3475_ _3415_ _3477_ VGND VGND VPWR VPWR _3483_ sky130_fd_sc_hd__nand3_1
XFILLER_0_100_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8155_ _3395_ _3406_ VGND VGND VPWR VPWR _3407_ sky130_fd_sc_hd__xnor2_1
X_5367_ _0389_ _0390_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5298_ net265 _3082_ _0282_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__and3_1
X_8086_ _3287_ _3303_ VGND VGND VPWR VPWR _3331_ sky130_fd_sc_hd__or2b_1
X_4318_ net195 net283 VGND VGND VPWR VPWR _1939_ sky130_fd_sc_hd__or2b_1
X_7106_ _2245_ _2252_ VGND VGND VPWR VPWR _2253_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_98_Left_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7037_ _1492_ net246 VGND VGND VPWR VPWR _2177_ sky130_fd_sc_hd__nor2_1
X_4249_ _0734_ _1185_ VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7939_ _2747_ _2748_ VGND VGND VPWR VPWR _3169_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6270_ _1337_ _1339_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__nor2_1
X_5221_ _0230_ _0234_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5152_ _0173_ _0174_ _0175_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__a21o_1
X_5083_ net173 net91 VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__or2b_1
X_7724_ net93 _2883_ _2885_ net88 VGND VGND VPWR VPWR _2933_ sky130_fd_sc_hd__a22o_1
X_5985_ net129 net132 net209 net238 VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_93_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4936_ _4099_ _4101_ VGND VGND VPWR VPWR _4102_ sky130_fd_sc_hd__xor2_2
XFILLER_0_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XANTENNA_10 net4 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_21 net310 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_62_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4867_ net167 net309 VGND VGND VPWR VPWR _4033_ sky130_fd_sc_hd__nand2b_1
X_7655_ _2855_ _2856_ VGND VGND VPWR VPWR _2857_ sky130_fd_sc_hd__xor2_1
XFILLER_0_47_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6606_ _1711_ _1713_ VGND VGND VPWR VPWR _1714_ sky130_fd_sc_hd__and2b_1
X_7586_ _2777_ _2780_ VGND VGND VPWR VPWR _2781_ sky130_fd_sc_hd__xnor2_1
X_6537_ _2422_ net55 VGND VGND VPWR VPWR _1643_ sky130_fd_sc_hd__nor2_1
X_4798_ net163 net298 VGND VGND VPWR VPWR _3964_ sky130_fd_sc_hd__or2b_1
X_6468_ net104 net145 net274 net284 VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__and4bb_1
X_8207_ _3461_ _3462_ _3450_ _3454_ VGND VGND VPWR VPWR _3464_ sky130_fd_sc_hd__a211o_1
X_5419_ _0202_ _0442_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__nand2_1
X_6399_ _1475_ _1490_ VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__xor2_2
X_8138_ _3385_ _3387_ VGND VGND VPWR VPWR _3388_ sky130_fd_sc_hd__xnor2_1
X_8069_ _3246_ _3308_ _3311_ VGND VGND VPWR VPWR _3312_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_97_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5770_ _0796_ _0798_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4721_ net171 net263 VGND VGND VPWR VPWR _3887_ sky130_fd_sc_hd__or2b_1
XFILLER_0_71_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7440_ _2530_ _2619_ VGND VGND VPWR VPWR _2621_ sky130_fd_sc_hd__nand2_1
X_4652_ net191 _1873_ VGND VGND VPWR VPWR _3818_ sky130_fd_sc_hd__nor2_1
Xinput30 vA[6] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__buf_1
Xinput52 vC[11] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__buf_1
Xinput41 vB[1] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__clkbuf_1
Xinput63 vC[7] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__buf_2
X_7371_ _2525_ _2542_ _2544_ VGND VGND VPWR VPWR _2545_ sky130_fd_sc_hd__a21oi_1
X_4583_ _2950_ net91 VGND VGND VPWR VPWR _3749_ sky130_fd_sc_hd__nand2_1
X_6322_ net127 net130 net87 net93 VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__or4bb_4
X_6253_ _1326_ _1330_ VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__xnor2_1
X_5204_ _0225_ _0226_ _0227_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__a21oi_2
X_6184_ _1139_ _1134_ VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__or2b_1
X_5135_ _0146_ _0158_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5066_ _3668_ net308 _0089_ _0088_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__a31o_1
XFILLER_0_66_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5968_ _1012_ _1017_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__xor2_1
XFILLER_0_90_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7707_ _2910_ _2912_ _2913_ VGND VGND VPWR VPWR _2914_ sky130_fd_sc_hd__a21oi_1
X_4919_ net163 _4033_ VGND VGND VPWR VPWR _4085_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5899_ _0937_ _0941_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_62_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7638_ _2837_ _2812_ VGND VGND VPWR VPWR _2838_ sky130_fd_sc_hd__xnor2_1
X_7569_ _2709_ _2710_ VGND VGND VPWR VPWR _2762_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_95_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6940_ _2069_ _2070_ VGND VGND VPWR VPWR _2072_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_88_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6871_ _1991_ _1995_ VGND VGND VPWR VPWR _1996_ sky130_fd_sc_hd__xor2_1
XFILLER_0_48_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5822_ _0303_ net141 _0812_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__nor3_1
X_5753_ net140 net214 VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__or2b_1
XFILLER_0_8_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4704_ _3843_ _3868_ _3869_ VGND VGND VPWR VPWR _3870_ sky130_fd_sc_hd__a21boi_4
XFILLER_0_29_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5684_ _0693_ _0706_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_62_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7423_ _2600_ _2601_ VGND VGND VPWR VPWR _2602_ sky130_fd_sc_hd__xnor2_1
X_4635_ net165 net283 VGND VGND VPWR VPWR _3801_ sky130_fd_sc_hd__and2b_1
XFILLER_0_8_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7354_ _2263_ _2267_ VGND VGND VPWR VPWR _2526_ sky130_fd_sc_hd__xnor2_1
X_4566_ _3652_ net256 _3731_ _3730_ VGND VGND VPWR VPWR _3732_ sky130_fd_sc_hd__a31o_1
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6305_ _1317_ _1319_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_69_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4497_ _3651_ _3662_ VGND VGND VPWR VPWR _3663_ sky130_fd_sc_hd__xor2_1
X_7285_ net101 _2449_ _2335_ VGND VGND VPWR VPWR _2450_ sky130_fd_sc_hd__and3_1
X_6236_ net127 net301 VGND VGND VPWR VPWR _1312_ sky130_fd_sc_hd__or2b_1
X_6167_ _1230_ _1236_ VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_71_Left_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5118_ _0105_ _0134_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__xor2_2
X_6098_ _1158_ _1159_ _1160_ VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__a21oi_2
X_5049_ _4165_ _4171_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__xor2_1
XFILLER_0_79_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_80_Left_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_101_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4420_ _3038_ _3049_ VGND VGND VPWR VPWR _3060_ sky130_fd_sc_hd__and2b_1
XFILLER_0_1_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4351_ net166 net164 net258 net239 VGND VGND VPWR VPWR _2301_ sky130_fd_sc_hd__and4bb_1
X_7070_ _2212_ VGND VGND VPWR VPWR _2214_ sky130_fd_sc_hd__inv_2
X_4282_ net79 counter\[5\] net80 net73 VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__or4_1
XFILLER_0_1_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8408__25 clknet_2_3__leaf_clk VGND VGND VPWR VPWR net346 sky130_fd_sc_hd__inv_2
X_6021_ _1068_ _1069_ _1074_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__and3_1
XFILLER_0_89_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7972_ net297 _2163_ _2780_ VGND VGND VPWR VPWR _3206_ sky130_fd_sc_hd__and3_1
XFILLER_0_55_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6923_ net75 _2052_ _2048_ net76 VGND VGND VPWR VPWR _2053_ sky130_fd_sc_hd__o22ai_1
X_6854_ _1974_ _1976_ VGND VGND VPWR VPWR _1977_ sky130_fd_sc_hd__xnor2_1
X_5805_ _0801_ _0837_ _0838_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__nor3_1
XFILLER_0_76_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6785_ _1866_ _1898_ _1899_ _1871_ VGND VGND VPWR VPWR _1901_ sky130_fd_sc_hd__o22a_1
XFILLER_0_45_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5736_ _0727_ _0758_ _0762_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__and3_1
XFILLER_0_72_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5667_ net153 _0685_ _0686_ _0689_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__and4_1
XFILLER_0_44_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4618_ _3736_ _3735_ VGND VGND VPWR VPWR _3784_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7406_ _2430_ _2432_ VGND VGND VPWR VPWR _2583_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_44_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5598_ _0533_ _0537_ _0610_ _0608_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_13_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4549_ _3695_ _3713_ VGND VGND VPWR VPWR _3715_ sky130_fd_sc_hd__nor2_1
X_7337_ net202 net205 net286 net294 VGND VGND VPWR VPWR _2507_ sky130_fd_sc_hd__or4bb_1
X_7268_ net95 net227 VGND VGND VPWR VPWR _2431_ sky130_fd_sc_hd__nand2_1
X_6219_ net124 net87 VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__or2b_1
X_7199_ net203 net268 VGND VGND VPWR VPWR _2355_ sky130_fd_sc_hd__and2b_1
XFILLER_0_99_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6570_ _1595_ _1601_ _1677_ VGND VGND VPWR VPWR _1678_ sky130_fd_sc_hd__a21oi_2
X_5521_ _0523_ _0485_ _0543_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__nand3_1
X_8240_ _3490_ _3495_ VGND VGND VPWR VPWR _3501_ sky130_fd_sc_hd__xnor2_1
X_5452_ _2191_ net190 net188 _0269_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__o22a_1
XFILLER_0_14_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8171_ _2187_ _2193_ VGND VGND VPWR VPWR _3425_ sky130_fd_sc_hd__xnor2_1
X_5383_ _0405_ _0406_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__xnor2_1
X_4403_ net160 net258 VGND VGND VPWR VPWR _2873_ sky130_fd_sc_hd__or2b_1
X_4334_ net162 VGND VGND VPWR VPWR _2115_ sky130_fd_sc_hd__clkinv_4
X_7122_ _2269_ _2270_ VGND VGND VPWR VPWR _2271_ sky130_fd_sc_hd__xnor2_1
Xfanout217 net218 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__clkbuf_4
X_7053_ _2138_ _2141_ VGND VGND VPWR VPWR _2195_ sky130_fd_sc_hd__xor2_1
Xfanout228 net230 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout206 net207 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__clkbuf_2
X_4265_ _0877_ _0899_ _0910_ _1360_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__or4_1
Xfanout239 net240 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__buf_6
XFILLER_0_5_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6004_ net111 net109 net282 net295 VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__or4bb_1
X_7955_ _2768_ _2772_ _2771_ VGND VGND VPWR VPWR _3187_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_49_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6906_ _2024_ _2032_ _2031_ VGND VGND VPWR VPWR _2034_ sky130_fd_sc_hd__a21oi_1
X_7886_ _3108_ _3110_ VGND VGND VPWR VPWR _3111_ sky130_fd_sc_hd__nand2_1
X_6837_ net287 net137 VGND VGND VPWR VPWR _1958_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6768_ _1770_ _1788_ _1881_ VGND VGND VPWR VPWR _1882_ sky130_fd_sc_hd__a21o_1
XFILLER_0_45_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5719_ _0698_ _0701_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__xor2_1
X_6699_ _1693_ _1717_ VGND VGND VPWR VPWR _1807_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8438_ net344 _0014_ net253 VGND VGND VPWR VPWR counter\[7\] sky130_fd_sc_hd__dfrtp_4
XFILLER_0_103_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8369_ _3626_ _3627_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__xor2_1
XFILLER_0_13_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8399__16 clknet_2_0__leaf_clk VGND VGND VPWR VPWR net337 sky130_fd_sc_hd__inv_2
XFILLER_0_28_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput6 periodTop[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_1
X_7740_ net312 _2381_ VGND VGND VPWR VPWR _2951_ sky130_fd_sc_hd__nand2_1
X_4952_ _4068_ _4070_ VGND VGND VPWR VPWR _4118_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_86_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4883_ net196 net256 VGND VGND VPWR VPWR _4049_ sky130_fd_sc_hd__or2b_1
X_7671_ net222 net294 VGND VGND VPWR VPWR _2875_ sky130_fd_sc_hd__or2b_1
X_6622_ net305 _0684_ VGND VGND VPWR VPWR _1730_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6553_ net112 net110 net211 net241 VGND VGND VPWR VPWR _1661_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_6_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5504_ _0525_ _0526_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__and2_1
X_6484_ _1578_ _1584_ VGND VGND VPWR VPWR _1585_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5435_ _0458_ net192 VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__nor2_1
X_8223_ _3465_ _3474_ _3481_ VGND VGND VPWR VPWR _3482_ sky130_fd_sc_hd__nor3_1
XFILLER_0_2_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8154_ _3309_ _3405_ VGND VGND VPWR VPWR _3406_ sky130_fd_sc_hd__xnor2_1
X_5366_ _0386_ _0388_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__and2_1
X_5297_ _0285_ _0288_ _0320_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__o21ai_1
X_8085_ net279 net229 _3284_ _3329_ VGND VGND VPWR VPWR _3330_ sky130_fd_sc_hd__a31o_1
X_4317_ net158 net273 VGND VGND VPWR VPWR _1928_ sky130_fd_sc_hd__or2b_1
XFILLER_0_10_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7105_ _2247_ _2251_ _2250_ VGND VGND VPWR VPWR _2252_ sky130_fd_sc_hd__a21oi_2
X_7036_ _2167_ _2175_ VGND VGND VPWR VPWR _2176_ sky130_fd_sc_hd__nand2_1
X_4248_ net314 _0723_ VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__nand2_1
XFILLER_0_93_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7938_ _3167_ _2755_ VGND VGND VPWR VPWR _3168_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7869_ _3058_ _3025_ VGND VGND VPWR VPWR _3092_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_9_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5220_ _0223_ _0243_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5151_ _0173_ _0174_ _3668_ net316 VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__o211a_1
X_5082_ net168 _3827_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__or2_1
XFILLER_0_2_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_619 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7723_ _1218_ net32 VGND VGND VPWR VPWR _2932_ sky130_fd_sc_hd__nor2_1
X_5984_ net132 net209 VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__or2b_1
XFILLER_0_47_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4935_ _4100_ _4052_ VGND VGND VPWR VPWR _4101_ sky130_fd_sc_hd__xnor2_2
XANTENNA_11 net16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4866_ _3962_ _3965_ VGND VGND VPWR VPWR _4032_ sky130_fd_sc_hd__xnor2_2
X_7654_ _2649_ _2650_ VGND VGND VPWR VPWR _2856_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_62_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7585_ _2778_ _2779_ VGND VGND VPWR VPWR _2780_ sky130_fd_sc_hd__nor2_1
X_6605_ _1712_ _1663_ _1661_ VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__a21o_1
X_4797_ net167 net292 VGND VGND VPWR VPWR _3963_ sky130_fd_sc_hd__or2b_1
XFILLER_0_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6536_ _1639_ _1640_ _1641_ VGND VGND VPWR VPWR _1642_ sky130_fd_sc_hd__a21o_1
XFILLER_0_70_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6467_ net104 net274 VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__or2b_1
XFILLER_0_30_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8206_ _3450_ _3454_ _3461_ _3462_ VGND VGND VPWR VPWR _3463_ sky130_fd_sc_hd__o211ai_2
X_5418_ _0200_ net383 VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6398_ _1483_ _1489_ VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__xnor2_2
X_5349_ _0359_ _0371_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__and2b_1
X_8137_ _3349_ _3386_ VGND VGND VPWR VPWR _3387_ sky130_fd_sc_hd__nor2_1
XFILLER_0_100_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8068_ _3309_ _3310_ VGND VGND VPWR VPWR _3311_ sky130_fd_sc_hd__and2_1
X_7019_ _1426_ net23 VGND VGND VPWR VPWR _2157_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_630 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4720_ net172 _3885_ _2268_ net169 VGND VGND VPWR VPWR _3886_ sky130_fd_sc_hd__o22ai_2
X_4651_ _3815_ _3816_ VGND VGND VPWR VPWR _3817_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_4_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput31 vA[7] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_2
Xinput20 vA[11] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_2
Xinput53 vC[12] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_71_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput42 vB[2] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_12_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput64 vC[8] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__buf_2
X_7370_ _2272_ _2273_ _2274_ VGND VGND VPWR VPWR _2544_ sky130_fd_sc_hd__o21ba_1
X_4582_ _3741_ _3747_ VGND VGND VPWR VPWR _3748_ sky130_fd_sc_hd__xor2_2
X_6321_ net127 net91 VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__and2b_1
XFILLER_0_3_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6252_ _1328_ _1292_ _1329_ VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__a21oi_1
X_5203_ net159 net193 net182 net212 VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_58_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6183_ _1219_ _1253_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__xor2_2
XFILLER_0_58_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5134_ _0156_ _0157_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__and2_1
X_5065_ _0086_ _0087_ _0088_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5967_ _1008_ _1013_ _1016_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__a21o_1
X_4918_ _4082_ _4076_ VGND VGND VPWR VPWR _4084_ sky130_fd_sc_hd__xor2_1
X_7706_ _2827_ _2857_ VGND VGND VPWR VPWR _2913_ sky130_fd_sc_hd__xnor2_1
X_7637_ net295 _2381_ VGND VGND VPWR VPWR _2837_ sky130_fd_sc_hd__nand2_1
X_5898_ _0938_ _0939_ _0940_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__a21oi_1
X_4849_ _3988_ _4014_ VGND VGND VPWR VPWR _4015_ sky130_fd_sc_hd__nor2_2
XFILLER_0_99_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7568_ _2758_ _2760_ VGND VGND VPWR VPWR _2761_ sky130_fd_sc_hd__xor2_1
X_6519_ _1620_ _1622_ VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__xor2_2
X_7499_ _2457_ _2458_ VGND VGND VPWR VPWR _2685_ sky130_fd_sc_hd__nor2_1
XFILLER_0_85_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6870_ _1992_ _1993_ VGND VGND VPWR VPWR _1995_ sky130_fd_sc_hd__nand2_1
X_5821_ _0932_ net140 net139 _0303_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__o22a_1
X_5752_ _0490_ net140 net139 _0269_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__o22a_1
XFILLER_0_91_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4703_ _3867_ _3844_ VGND VGND VPWR VPWR _3869_ sky130_fd_sc_hd__or2b_1
X_5683_ _0702_ _0703_ _0705_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__a21oi_1
X_7422_ _2504_ _2508_ VGND VGND VPWR VPWR _2601_ sky130_fd_sc_hd__xor2_1
X_4634_ _2115_ net420 VGND VGND VPWR VPWR _3800_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4565_ _2235_ _3729_ _3730_ VGND VGND VPWR VPWR _3731_ sky130_fd_sc_hd__a21oi_2
X_7353_ _2523_ _2524_ VGND VGND VPWR VPWR _2525_ sky130_fd_sc_hd__or2_1
XFILLER_0_102_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6304_ _1383_ _1385_ _1386_ VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__a21bo_1
X_4496_ _3659_ _3660_ _3661_ VGND VGND VPWR VPWR _3662_ sky130_fd_sc_hd__a21boi_2
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7284_ _2286_ VGND VGND VPWR VPWR _2449_ sky130_fd_sc_hd__buf_4
X_6235_ net130 net291 VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__or2b_1
X_6166_ _1231_ _1235_ VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__xnor2_2
X_6097_ net127 net130 net281 net291 VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__and4bb_1
X_5117_ _0135_ _0139_ _0140_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__a21boi_1
X_5048_ _0068_ _0070_ _0071_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_79_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6999_ net156 _2128_ _2130_ net122 VGND VGND VPWR VPWR _2135_ sky130_fd_sc_hd__a22o_1
XFILLER_0_35_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclone45 net242 VGND VGND VPWR VPWR net398 sky130_fd_sc_hd__buf_4
XFILLER_0_35_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_98_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4350_ net166 net238 VGND VGND VPWR VPWR _2290_ sky130_fd_sc_hd__or2b_1
XFILLER_0_1_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4281_ _0833_ _0844_ _1371_ _1536_ VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__a211o_1
XFILLER_0_39_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6020_ _1068_ _1069_ _1074_ VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_55_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7971_ net297 net227 VGND VGND VPWR VPWR _3205_ sky130_fd_sc_hd__nand2_1
X_6922_ _2040_ _2051_ VGND VGND VPWR VPWR _2052_ sky130_fd_sc_hd__xnor2_1
X_6853_ _0880_ _1975_ VGND VGND VPWR VPWR _1976_ sky130_fd_sc_hd__and2_1
XFILLER_0_49_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5804_ _0796_ _0798_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6784_ _1866_ _1898_ _1899_ _1871_ VGND VGND VPWR VPWR _1900_ sky130_fd_sc_hd__or4_1
X_5735_ _0760_ _0761_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__or2b_1
XFILLER_0_84_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5666_ _1503_ net140 _0688_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_95_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7405_ _2578_ _2580_ _2581_ VGND VGND VPWR VPWR _2582_ sky130_fd_sc_hd__a21oi_2
X_4617_ _3781_ _3782_ VGND VGND VPWR VPWR _3783_ sky130_fd_sc_hd__xor2_2
X_5597_ _0618_ _0528_ _0620_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__o21bai_1
X_4548_ _3695_ _3713_ VGND VGND VPWR VPWR _3714_ sky130_fd_sc_hd__xor2_2
XFILLER_0_4_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7336_ net208 net285 VGND VGND VPWR VPWR _2506_ sky130_fd_sc_hd__and2b_1
X_4479_ net166 net164 net150 net182 VGND VGND VPWR VPWR _3645_ sky130_fd_sc_hd__and4bb_1
X_7267_ _2369_ _2429_ VGND VGND VPWR VPWR _2430_ sky130_fd_sc_hd__xor2_2
X_6218_ net114 net311 VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__or2b_1
X_7198_ net206 net260 VGND VGND VPWR VPWR _2354_ sky130_fd_sc_hd__and2b_1
X_6149_ _1094_ _1110_ VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_88_Right_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_97_Right_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5520_ _0523_ _0485_ _0543_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5451_ net240 _3082_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__nand2_1
XFILLER_0_41_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5382_ _0391_ _0393_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__xnor2_1
X_8170_ _3376_ _3381_ _3422_ VGND VGND VPWR VPWR _3424_ sky130_fd_sc_hd__a21oi_4
X_4402_ _1031_ net191 VGND VGND VPWR VPWR _2862_ sky130_fd_sc_hd__nor2_1
X_4333_ net167 net265 VGND VGND VPWR VPWR _2104_ sky130_fd_sc_hd__nand2b_2
XFILLER_0_10_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7121_ _2247_ _2251_ VGND VGND VPWR VPWR _2270_ sky130_fd_sc_hd__xnor2_1
Xfanout218 net3 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__buf_6
X_7052_ _2187_ _2193_ VGND VGND VPWR VPWR _2194_ sky130_fd_sc_hd__nand2_1
X_4264_ _0954_ _0976_ _0987_ _1349_ VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__or4_1
Xfanout229 net230 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__clkbuf_2
Xfanout207 net208 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__clkbuf_2
X_6003_ net111 net286 VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__and2b_1
XFILLER_0_77_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7954_ _3180_ _3185_ VGND VGND VPWR VPWR _3186_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_89_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6905_ _2031_ _2032_ VGND VGND VPWR VPWR _2033_ sky130_fd_sc_hd__or2b_1
XFILLER_0_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7885_ _3106_ _3109_ VGND VGND VPWR VPWR _3110_ sky130_fd_sc_hd__and2_1
XFILLER_0_92_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_92_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6836_ _1956_ _1955_ VGND VGND VPWR VPWR _1957_ sky130_fd_sc_hd__xnor2_1
X_6767_ _1771_ _1787_ VGND VGND VPWR VPWR _1881_ sky130_fd_sc_hd__and2b_1
XFILLER_0_64_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5718_ _0737_ _0742_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6698_ _1789_ _1805_ VGND VGND VPWR VPWR _1806_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_33_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8437_ net343 _0013_ net254 VGND VGND VPWR VPWR counter\[6\] sky130_fd_sc_hd__dfrtp_1
X_5649_ _0440_ _0441_ _0452_ _0672_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__nor4_1
X_8368_ _3620_ _3623_ _3621_ VGND VGND VPWR VPWR _3627_ sky130_fd_sc_hd__o21a_1
XFILLER_0_60_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7319_ _2471_ _2486_ VGND VGND VPWR VPWR _2487_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_13_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8299_ net82 _3554_ _3558_ VGND VGND VPWR VPWR _3565_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput7 periodTop[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4951_ _4113_ _4115_ _4116_ VGND VGND VPWR VPWR _4117_ sky130_fd_sc_hd__a21oi_1
X_7670_ _0927_ net222 _2872_ VGND VGND VPWR VPWR _2874_ sky130_fd_sc_hd__o21ai_2
X_4882_ _4024_ _4026_ _4046_ _4047_ VGND VGND VPWR VPWR _4048_ sky130_fd_sc_hd__a31o_1
X_6621_ _1727_ _1728_ VGND VGND VPWR VPWR _1729_ sky130_fd_sc_hd__xor2_2
XFILLER_0_39_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6552_ net112 net212 VGND VGND VPWR VPWR _1660_ sky130_fd_sc_hd__or2b_1
XFILLER_0_61_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5503_ _0525_ _0526_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__nor2_1
X_6483_ _1579_ _1583_ VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__xnor2_1
X_8222_ _3479_ _3480_ VGND VGND VPWR VPWR _3481_ sky130_fd_sc_hd__or2_1
XFILLER_0_2_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5434_ _3641_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__clkbuf_8
X_8153_ _3398_ _3404_ VGND VGND VPWR VPWR _3405_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5365_ _0386_ _0388_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7104_ _2248_ _2249_ _2250_ VGND VGND VPWR VPWR _2251_ sky130_fd_sc_hd__a21oi_1
X_5296_ _0268_ _0284_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__or2_1
XFILLER_0_77_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8084_ _3282_ _3283_ VGND VGND VPWR VPWR _3329_ sky130_fd_sc_hd__nor2_1
X_4316_ _1108_ net191 VGND VGND VPWR VPWR _1917_ sky130_fd_sc_hd__nor2_1
X_7035_ _2150_ _2154_ _2166_ VGND VGND VPWR VPWR _2175_ sky130_fd_sc_hd__or3_1
X_4247_ counter\[4\] _0745_ _1152_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__and3_1
XFILLER_0_97_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7937_ _3162_ _3166_ VGND VGND VPWR VPWR _3167_ sky130_fd_sc_hd__xnor2_2
X_7868_ _3086_ _3089_ _3090_ VGND VGND VPWR VPWR _3091_ sky130_fd_sc_hd__a21oi_1
X_6819_ _1934_ _1937_ VGND VGND VPWR VPWR _1938_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7799_ _2963_ _2965_ VGND VGND VPWR VPWR _3015_ sky130_fd_sc_hd__xor2_1
XFILLER_0_92_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5150_ net176 _0149_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__nor2_1
X_5081_ _0083_ _0104_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_47_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5983_ net129 net238 VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__or2b_1
X_4934_ _3769_ net272 VGND VGND VPWR VPWR _4100_ sky130_fd_sc_hd__nand2_1
X_7722_ _2929_ _2923_ VGND VGND VPWR VPWR _2931_ sky130_fd_sc_hd__xor2_1
XFILLER_0_19_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4865_ _3997_ net292 _4030_ _4029_ VGND VGND VPWR VPWR _4031_ sky130_fd_sc_hd__a31o_1
XANTENNA_12 net16 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_7653_ _2850_ _2853_ _2854_ VGND VGND VPWR VPWR _2855_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_74_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7584_ net278 net288 _2127_ _2130_ VGND VGND VPWR VPWR _2779_ sky130_fd_sc_hd__and4_1
X_6604_ _1659_ _1660_ VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__nand2_1
X_4796_ _2115_ net309 VGND VGND VPWR VPWR _3962_ sky130_fd_sc_hd__nand2_1
XFILLER_0_103_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6535_ _1119_ net138 _1559_ VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__nor3_1
XFILLER_0_6_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8205_ _3457_ _3431_ _3460_ VGND VGND VPWR VPWR _3462_ sky130_fd_sc_hd__nand3_1
X_6466_ net144 net284 VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__or2b_1
XFILLER_0_15_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5417_ counter\[3\] _0207_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__and2_1
X_6397_ _1484_ _1488_ VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__xnor2_2
X_5348_ _0359_ _0371_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__xnor2_1
X_8136_ net261 _2163_ _3350_ VGND VGND VPWR VPWR _3386_ sky130_fd_sc_hd__and3_1
X_8067_ net122 _2216_ _2883_ net101 VGND VGND VPWR VPWR _3310_ sky130_fd_sc_hd__a22o_1
X_7018_ net102 _2128_ VGND VGND VPWR VPWR _2156_ sky130_fd_sc_hd__nand2_1
X_5279_ _3885_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_65_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4650_ _3748_ _3754_ VGND VGND VPWR VPWR _3816_ sky130_fd_sc_hd__xor2_2
Xinput10 periodTop[3] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_71_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput21 vA[12] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_37_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput54 vC[13] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_1
Xinput43 vB[3] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__buf_1
X_6320_ net130 net84 VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__and2b_1
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput32 vA[8] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_4
X_4581_ _3742_ _3746_ _3745_ VGND VGND VPWR VPWR _3747_ sky130_fd_sc_hd__a21oi_2
Xinput65 vC[9] VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6251_ _1168_ _1290_ VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__nor2_1
X_5202_ net193 net212 VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__or2b_1
X_6182_ _1238_ _1252_ VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__xnor2_2
X_5133_ _0143_ _0155_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__nand2_1
X_5064_ net174 net196 net291 net298 VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_94_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5966_ _1014_ _1015_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__nor2_1
XFILLER_0_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7705_ _2903_ _2911_ VGND VGND VPWR VPWR _2912_ sky130_fd_sc_hd__nand2_1
X_4917_ _4076_ _4082_ VGND VGND VPWR VPWR _4083_ sky130_fd_sc_hd__or2b_1
X_5897_ net128 net132 net256 net264 VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_90_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7636_ _2833_ _2835_ VGND VGND VPWR VPWR _2836_ sky130_fd_sc_hd__xor2_1
X_4848_ _3908_ _3970_ _3987_ VGND VGND VPWR VPWR _4014_ sky130_fd_sc_hd__and3_1
XFILLER_0_47_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7567_ _2684_ _2696_ _2759_ VGND VGND VPWR VPWR _2760_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_7_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4779_ _3943_ _3944_ VGND VGND VPWR VPWR _3945_ sky130_fd_sc_hd__xor2_4
X_7498_ _2682_ _2683_ VGND VGND VPWR VPWR _2684_ sky130_fd_sc_hd__xor2_2
X_6518_ _1281_ _1541_ _1621_ VGND VGND VPWR VPWR _1622_ sky130_fd_sc_hd__a21oi_2
X_6449_ net321 net134 _1538_ _1535_ VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__a31o_1
X_8119_ _3323_ _3328_ _3366_ VGND VGND VPWR VPWR _3367_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5820_ net266 _0684_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5751_ net398 _0685_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4702_ _3844_ _3867_ VGND VGND VPWR VPWR _3868_ sky130_fd_sc_hd__xnor2_2
X_5682_ _0690_ _0704_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__or2_1
X_7421_ _2595_ _2599_ VGND VGND VPWR VPWR _2600_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4633_ _3763_ _3795_ VGND VGND VPWR VPWR _3799_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_8_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7352_ _2271_ _2276_ VGND VGND VPWR VPWR _2524_ sky130_fd_sc_hd__xnor2_1
X_4564_ net173 net169 net210 net238 VGND VGND VPWR VPWR _3730_ sky130_fd_sc_hd__and4bb_1
X_7283_ _2442_ _2447_ VGND VGND VPWR VPWR _2448_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6303_ _1379_ _1381_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__nand2_1
X_4495_ _3655_ _3658_ VGND VGND VPWR VPWR _3661_ sky130_fd_sc_hd__or2_1
X_6234_ net281 _0909_ VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__nand2_1
XFILLER_0_100_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6165_ _1233_ _1234_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__nand2_1
X_6096_ net127 net291 VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__or2b_1
X_5116_ _0137_ _0138_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__nand2_1
X_5047_ _0066_ _0067_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__nand2_1
XFILLER_0_67_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6998_ net156 _2130_ VGND VGND VPWR VPWR _2134_ sky130_fd_sc_hd__nand2_1
XFILLER_0_94_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5949_ _0994_ _0995_ _0996_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__o21a_1
XFILLER_0_75_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7619_ net202 net313 VGND VGND VPWR VPWR _2817_ sky130_fd_sc_hd__or2b_1
XFILLER_0_90_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4280_ _1448_ _1514_ _1525_ VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__mux2_1
X_7970_ _3201_ _3202_ VGND VGND VPWR VPWR _3204_ sky130_fd_sc_hd__nor2_1
X_6921_ _2041_ _0763_ VGND VGND VPWR VPWR _2051_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6852_ net64 _0879_ _0878_ VGND VGND VPWR VPWR _1975_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_76_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5803_ _0835_ _0836_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__nand2_1
X_6783_ _1854_ _1869_ VGND VGND VPWR VPWR _1899_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5734_ _0746_ _0747_ _0751_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_84_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5665_ net120 _0687_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__nand2_1
XFILLER_0_17_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7404_ _2575_ _2577_ VGND VGND VPWR VPWR _2581_ sky130_fd_sc_hd__nor2_1
X_4616_ _3706_ _3708_ VGND VGND VPWR VPWR _3782_ sky130_fd_sc_hd__xnor2_1
X_5596_ _0617_ _0619_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__nand2_1
X_7335_ net31 net294 VGND VGND VPWR VPWR _2505_ sky130_fd_sc_hd__and2b_1
XFILLER_0_102_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4547_ _3697_ _3711_ _3712_ VGND VGND VPWR VPWR _3713_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_96_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4478_ net166 net150 VGND VGND VPWR VPWR _3644_ sky130_fd_sc_hd__or2b_1
X_7266_ _2407_ _2428_ VGND VGND VPWR VPWR _2429_ sky130_fd_sc_hd__xnor2_2
X_6217_ net114 net87 VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__or2b_1
X_7197_ net277 _2216_ VGND VGND VPWR VPWR _2353_ sky130_fd_sc_hd__nand2_1
X_6148_ _1128_ _1149_ _1215_ VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__a21oi_1
X_6079_ _1134_ _1139_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_95_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8413__30 clknet_2_2__leaf_clk VGND VGND VPWR VPWR net351 sky130_fd_sc_hd__inv_2
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5450_ _0472_ _0473_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__xor2_1
X_4401_ _2686_ _2829_ _2840_ VGND VGND VPWR VPWR _2851_ sky130_fd_sc_hd__a21o_1
XFILLER_0_41_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5381_ _3137_ _3692_ _0404_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_1_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4332_ net164 net258 VGND VGND VPWR VPWR _2093_ sky130_fd_sc_hd__or2b_4
X_7120_ _2263_ _2267_ _2266_ VGND VGND VPWR VPWR _2269_ sky130_fd_sc_hd__a21o_1
X_7051_ _2188_ _2192_ VGND VGND VPWR VPWR _2193_ sky130_fd_sc_hd__xnor2_1
X_4263_ _1009_ _1020_ _1064_ _1338_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__or4_1
Xfanout219 net221 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__buf_2
Xfanout208 net30 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_10_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6002_ net108 net295 VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__and2b_1
X_7953_ _3182_ _3183_ _3184_ VGND VGND VPWR VPWR _3185_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_89_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6904_ _2019_ _2029_ _2030_ VGND VGND VPWR VPWR _2032_ sky130_fd_sc_hd__a21o_1
XFILLER_0_82_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7884_ _3100_ _3105_ VGND VGND VPWR VPWR _3109_ sky130_fd_sc_hd__nand2_1
X_6835_ _1949_ _1954_ VGND VGND VPWR VPWR _1956_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_59_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6766_ _1878_ _1879_ VGND VGND VPWR VPWR _1880_ sky130_fd_sc_hd__and2b_1
X_5717_ _0738_ _0741_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_57_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6697_ _1803_ _1804_ VGND VGND VPWR VPWR _1805_ sky130_fd_sc_hd__xor2_2
XFILLER_0_60_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5648_ _0598_ _0607_ _0670_ _0671_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__or4b_4
X_8436_ net342 _0012_ net255 VGND VGND VPWR VPWR counter\[5\] sky130_fd_sc_hd__dfrtp_4
XFILLER_0_5_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8367_ _3624_ _3625_ VGND VGND VPWR VPWR _3626_ sky130_fd_sc_hd__or2b_1
X_5579_ _0577_ _0586_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8298_ _2080_ _3517_ _3563_ VGND VGND VPWR VPWR _3564_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_68_Left_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7318_ _2480_ _2485_ VGND VGND VPWR VPWR _2486_ sky130_fd_sc_hd__xnor2_2
X_7249_ _2351_ _2361_ _2360_ VGND VGND VPWR VPWR _2410_ sky130_fd_sc_hd__a21boi_4
XFILLER_0_99_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_77_Left_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_86_Left_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput8 periodTop[1] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_1
XFILLER_0_78_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4950_ _4111_ _4112_ VGND VGND VPWR VPWR _4116_ sky130_fd_sc_hd__nor2_1
XFILLER_0_52_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4881_ _4044_ _4045_ VGND VGND VPWR VPWR _4047_ sky130_fd_sc_hd__nor2_1
XFILLER_0_86_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6620_ _1645_ _1650_ _1649_ VGND VGND VPWR VPWR _1728_ sky130_fd_sc_hd__a21oi_2
X_6551_ net110 net238 VGND VGND VPWR VPWR _1659_ sky130_fd_sc_hd__or2b_1
X_5502_ _0490_ _0453_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__nor2_1
XFILLER_0_82_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6482_ _1497_ _1581_ _1582_ VGND VGND VPWR VPWR _1583_ sky130_fd_sc_hd__a21oi_1
X_5433_ _0455_ _0456_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__nand2_1
X_8221_ _3475_ _3415_ _3477_ VGND VGND VPWR VPWR _3480_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_100_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8152_ _3399_ _3403_ VGND VGND VPWR VPWR _3404_ sky130_fd_sc_hd__xnor2_1
X_5364_ _3555_ _3663_ _0387_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_77_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4315_ _1862_ _1895_ VGND VGND VPWR VPWR _1906_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7103_ net248 net201 net296 net306 VGND VGND VPWR VPWR _2250_ sky130_fd_sc_hd__and4bb_1
X_5295_ _0297_ _0318_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8083_ _3326_ _3327_ VGND VGND VPWR VPWR _3328_ sky130_fd_sc_hd__nand2_1
X_7034_ _2172_ _2173_ VGND VGND VPWR VPWR _2174_ sky130_fd_sc_hd__nand2_1
X_4246_ _0745_ _1152_ counter\[4\] VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_93_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7936_ _3163_ _3164_ _3165_ VGND VGND VPWR VPWR _3166_ sky130_fd_sc_hd__o21a_1
X_7867_ _3034_ _3056_ VGND VGND VPWR VPWR _3090_ sky130_fd_sc_hd__xnor2_1
X_6818_ _1935_ _1914_ _1936_ VGND VGND VPWR VPWR _1937_ sky130_fd_sc_hd__a21oi_1
X_7798_ _3007_ _3012_ _3013_ VGND VGND VPWR VPWR _3014_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_9_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6749_ _1780_ _1781_ _1779_ VGND VGND VPWR VPWR _1861_ sky130_fd_sc_hd__a21oi_2
X_8419_ net325 _0052_ net252 VGND VGND VPWR VPWR delta\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_20_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_94_Left_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5080_ _0102_ _0103_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_78_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5982_ net180 _0916_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__nand2_1
XFILLER_0_93_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4933_ _3668_ net280 _4096_ _4098_ VGND VGND VPWR VPWR _4099_ sky130_fd_sc_hd__a31o_1
X_7721_ _2923_ _2929_ VGND VGND VPWR VPWR _2930_ sky130_fd_sc_hd__and2b_1
XANTENNA_13 net123 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_74_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4864_ _4027_ _4028_ _4029_ VGND VGND VPWR VPWR _4030_ sky130_fd_sc_hd__a21oi_1
X_7652_ _2848_ _2849_ VGND VGND VPWR VPWR _2854_ sky130_fd_sc_hd__nor2_1
XFILLER_0_105_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6603_ _1704_ _1710_ VGND VGND VPWR VPWR _1711_ sky130_fd_sc_hd__xnor2_1
X_7583_ _0927_ net231 net233 _1042_ VGND VGND VPWR VPWR _2778_ sky130_fd_sc_hd__o22a_1
X_4795_ net167 net163 net290 net298 VGND VGND VPWR VPWR _3961_ sky130_fd_sc_hd__or4bb_1
X_6534_ net141 net296 VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__or2b_1
XFILLER_0_15_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6465_ _1108_ net142 VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__nor2_2
XFILLER_0_12_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8204_ _3457_ _3431_ _3460_ VGND VGND VPWR VPWR _3461_ sky130_fd_sc_hd__a21o_1
X_5416_ _0431_ _0433_ _0437_ _0439_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__or4_1
XFILLER_0_70_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6396_ _1486_ _1487_ VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__or2b_1
X_5347_ _0366_ _0369_ _0370_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__a21bo_1
X_8135_ _3353_ _3356_ _3384_ VGND VGND VPWR VPWR _3385_ sky130_fd_sc_hd__o21ai_2
X_5278_ _0300_ _0280_ _0301_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__a21oi_2
X_8066_ _1492_ net32 _3248_ VGND VGND VPWR VPWR _3309_ sky130_fd_sc_hd__or3_4
X_7017_ _2153_ _2154_ VGND VGND VPWR VPWR _2155_ sky130_fd_sc_hd__or2_1
X_4229_ _0778_ _0965_ net77 VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_69_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7919_ _2861_ _2916_ _2804_ VGND VGND VPWR VPWR _3147_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_92_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8389__6 clknet_2_1__leaf_clk VGND VGND VPWR VPWR net327 sky130_fd_sc_hd__inv_2
Xinput11 periodTop[4] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_1
Xinput22 vA[13] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_2
X_4580_ _3743_ _3744_ _3745_ VGND VGND VPWR VPWR _3746_ sky130_fd_sc_hd__a21oi_2
Xinput55 vC[14] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_4
Xinput44 vB[4] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__buf_1
XFILLER_0_52_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput33 vA[9] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6250_ _1983_ net124 VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__or2_1
X_5201_ net159 net182 VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__or2b_1
XFILLER_0_20_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6181_ _1241_ _1251_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__xnor2_2
X_5132_ _0143_ _0155_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__or2_1
XFILLER_0_74_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5063_ net174 net298 VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__or2b_1
XFILLER_0_79_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5965_ net144 net89 VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__or2b_1
XFILLER_0_90_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4916_ _3997_ net298 _4081_ _4080_ VGND VGND VPWR VPWR _4082_ sky130_fd_sc_hd__a31o_1
X_7704_ _2908_ _2909_ VGND VGND VPWR VPWR _2911_ sky130_fd_sc_hd__xor2_1
X_5896_ net132 net256 VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__or2b_1
XFILLER_0_47_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7635_ _2834_ _2634_ VGND VGND VPWR VPWR _2835_ sky130_fd_sc_hd__xnor2_1
X_4847_ _4011_ _4012_ VGND VGND VPWR VPWR _4013_ sky130_fd_sc_hd__xor2_2
XFILLER_0_74_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7566_ _2682_ _2683_ VGND VGND VPWR VPWR _2759_ sky130_fd_sc_hd__or2_1
X_4778_ net365 _3865_ VGND VGND VPWR VPWR _3944_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_70_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7497_ _2335_ _2448_ _1492_ net26 VGND VGND VPWR VPWR _2683_ sky130_fd_sc_hd__a211o_1
XFILLER_0_15_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6517_ _1468_ _1540_ VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__nor2_1
XFILLER_0_101_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6448_ _1212_ _1289_ _1465_ _1543_ _1544_ VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__a41o_4
X_6379_ _1219_ _1253_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__nor2_1
X_8118_ _3330_ _3365_ VGND VGND VPWR VPWR _3366_ sky130_fd_sc_hd__xnor2_1
X_8049_ net246 net186 VGND VGND VPWR VPWR _3290_ sky130_fd_sc_hd__or2b_1
XFILLER_0_26_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_592 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5750_ _0771_ _0777_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_22_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5681_ _0686_ _0689_ _0458_ net55 VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_84_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4701_ _3864_ _3865_ _3866_ VGND VGND VPWR VPWR _3867_ sky130_fd_sc_hd__a21o_1
X_4632_ _3724_ _3797_ VGND VGND VPWR VPWR _3798_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_71_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7420_ _2596_ _2516_ _2597_ _0927_ net29 VGND VGND VPWR VPWR _2599_ sky130_fd_sc_hd__a2111o_2
XFILLER_0_4_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7351_ _2509_ _2518_ _2522_ VGND VGND VPWR VPWR _2523_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_40_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4563_ net169 net238 VGND VGND VPWR VPWR _3729_ sky130_fd_sc_hd__or2b_1
X_4494_ _3181_ _3335_ VGND VGND VPWR VPWR _3660_ sky130_fd_sc_hd__xnor2_2
X_7282_ _2443_ _2445_ _2446_ VGND VGND VPWR VPWR _2447_ sky130_fd_sc_hd__a21oi_2
X_6302_ _1384_ _1368_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6233_ net291 _0909_ _1308_ _1307_ VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_31_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6164_ _0921_ net115 _1232_ VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__o21ai_1
X_6095_ net130 net281 VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__or2b_1
X_5115_ _0137_ _0138_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__xor2_2
X_5046_ _0069_ _4192_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6997_ net122 _2128_ VGND VGND VPWR VPWR _2133_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_40_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5948_ net111 net108 net292 net301 VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__or4bb_1
XFILLER_0_35_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5879_ net128 net131 net264 net271 VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__and4bb_1
Xclone47 net240 VGND VGND VPWR VPWR net400 sky130_fd_sc_hd__buf_4
X_7618_ net205 net303 VGND VGND VPWR VPWR _2816_ sky130_fd_sc_hd__or2b_1
XFILLER_0_105_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7549_ _2722_ _2731_ _2739_ VGND VGND VPWR VPWR _2740_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_16_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6920_ net76 _2048_ VGND VGND VPWR VPWR _2050_ sky130_fd_sc_hd__and2_1
X_6851_ _1941_ _1943_ VGND VGND VPWR VPWR _1974_ sky130_fd_sc_hd__nand2_1
XFILLER_0_71_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5802_ _0787_ _0770_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_71_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6782_ net287 _0685_ _1867_ VGND VGND VPWR VPWR _1898_ sky130_fd_sc_hd__and3_1
XFILLER_0_71_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5733_ _0758_ _0759_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__nand2_2
XFILLER_0_72_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5664_ net139 VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__inv_2
X_5595_ _0540_ _0616_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__or2_1
X_8383_ _3639_ _3640_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7403_ _2579_ _2547_ VGND VGND VPWR VPWR _2580_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_44_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4615_ _3777_ _3779_ _3780_ VGND VGND VPWR VPWR _3781_ sky130_fd_sc_hd__a21oi_4
X_4546_ _3698_ _3710_ VGND VGND VPWR VPWR _3712_ sky130_fd_sc_hd__or2b_1
XFILLER_0_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7334_ _1983_ net32 VGND VGND VPWR VPWR _2504_ sky130_fd_sc_hd__nor2_1
X_4477_ _3610_ _3642_ VGND VGND VPWR VPWR _3643_ sky130_fd_sc_hd__nand2_1
X_7265_ _2409_ _2427_ VGND VGND VPWR VPWR _2428_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_96_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6216_ net124 net311 VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__or2b_1
X_7196_ _2315_ _2317_ _2319_ VGND VGND VPWR VPWR _2352_ sky130_fd_sc_hd__a21bo_1
X_6147_ _1092_ _1127_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__nor2_1
XFILLER_0_99_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6078_ _1135_ _1138_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__xnor2_1
X_5029_ net174 net290 VGND VGND VPWR VPWR _4195_ sky130_fd_sc_hd__or2b_1
XFILLER_0_95_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4400_ _2697_ _2741_ _2818_ VGND VGND VPWR VPWR _2840_ sky130_fd_sc_hd__o21a_1
X_5380_ _3664_ _3691_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__or2b_1
XFILLER_0_22_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4331_ _1906_ _2060_ _2071_ VGND VGND VPWR VPWR _2082_ sky130_fd_sc_hd__a21o_1
XFILLER_0_22_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7050_ _2134_ _2189_ _2190_ VGND VGND VPWR VPWR _2192_ sky130_fd_sc_hd__a21oi_2
X_4262_ _1086_ _1097_ _1327_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__or3_1
XFILLER_0_10_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout209 net211 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_105_Left_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6001_ net304 _0868_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__nand2_1
X_7952_ net246 net199 net217 net244 VGND VGND VPWR VPWR _3184_ sky130_fd_sc_hd__and4bb_1
X_6903_ _2019_ _2029_ _2030_ VGND VGND VPWR VPWR _2031_ sky130_fd_sc_hd__and3_1
XFILLER_0_82_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7883_ _3099_ _3107_ VGND VGND VPWR VPWR _3108_ sky130_fd_sc_hd__nor2_1
XFILLER_0_106_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6834_ _1792_ _1802_ _1849_ _1850_ _1874_ VGND VGND VPWR VPWR _1955_ sky130_fd_sc_hd__a32o_1
X_6765_ _1875_ _1877_ VGND VGND VPWR VPWR _1879_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5716_ _0695_ _0739_ _0740_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__a21oi_1
X_8435_ net341 _0011_ net252 VGND VGND VPWR VPWR counter\[4\] sky130_fd_sc_hd__dfrtp_1
X_6696_ _1703_ _1716_ _1701_ VGND VGND VPWR VPWR _1804_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_60_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5647_ counter\[11\] _0597_ _0602_ counter\[10\] VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__o22a_1
XFILLER_0_72_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_103_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8366_ delta\[12\] counter\[12\] VGND VGND VPWR VPWR _3625_ sky130_fd_sc_hd__nand2_1
X_5578_ _0569_ _0594_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_13_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8297_ _2080_ _3517_ _3528_ _3525_ _3519_ VGND VGND VPWR VPWR _3563_ sky130_fd_sc_hd__a221o_1
X_4529_ _3666_ _3684_ VGND VGND VPWR VPWR _3695_ sky130_fd_sc_hd__xnor2_4
X_7317_ _2481_ _2484_ VGND VGND VPWR VPWR _2485_ sky130_fd_sc_hd__xnor2_2
X_7248_ _2253_ _2259_ _2408_ VGND VGND VPWR VPWR _2409_ sky130_fd_sc_hd__a21o_1
X_7179_ net154 _2286_ VGND VGND VPWR VPWR _2333_ sky130_fd_sc_hd__nand2_1
XFILLER_0_99_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput9 periodTop[2] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4880_ _4044_ _4045_ VGND VGND VPWR VPWR _4046_ sky130_fd_sc_hd__xor2_1
X_6550_ net266 _0868_ _1583_ _1582_ VGND VGND VPWR VPWR _1658_ sky130_fd_sc_hd__a31o_1
XFILLER_0_27_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5501_ _0498_ _0524_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__xor2_1
XFILLER_0_6_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6481_ net112 net110 net242 net259 VGND VGND VPWR VPWR _1582_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_27_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8220_ _3475_ _3415_ _3477_ VGND VGND VPWR VPWR _3479_ sky130_fd_sc_hd__and3_1
X_5432_ net99 _3979_ _3976_ net117 VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8151_ _3400_ _3402_ VGND VGND VPWR VPWR _3403_ sky130_fd_sc_hd__nor2_1
X_5363_ _3651_ _3662_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4314_ _1884_ net39 VGND VGND VPWR VPWR _1895_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7102_ net248 net306 VGND VGND VPWR VPWR _2249_ sky130_fd_sc_hd__or2b_1
X_5294_ _0316_ _0317_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__xor2_1
X_8082_ _3320_ _3322_ VGND VGND VPWR VPWR _3327_ sky130_fd_sc_hd__xnor2_1
X_7033_ _2168_ _2171_ VGND VGND VPWR VPWR _2173_ sky130_fd_sc_hd__or2_1
X_4245_ net306 _0734_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__nand2_1
XFILLER_0_93_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7935_ net204 net207 net122 net155 VGND VGND VPWR VPWR _3165_ sky130_fd_sc_hd__or4bb_1
X_7866_ _3087_ _3088_ VGND VGND VPWR VPWR _3089_ sky130_fd_sc_hd__or2_1
X_6817_ _1907_ _1908_ VGND VGND VPWR VPWR _1936_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7797_ _3004_ _3006_ VGND VGND VPWR VPWR _3013_ sky130_fd_sc_hd__nand2_1
X_6748_ _1855_ _1859_ VGND VGND VPWR VPWR _1860_ sky130_fd_sc_hd__xnor2_2
X_6679_ _1776_ _1786_ VGND VGND VPWR VPWR _1787_ sky130_fd_sc_hd__xor2_2
XFILLER_0_60_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8418_ net324 _0051_ net252 VGND VGND VPWR VPWR delta\[3\] sky130_fd_sc_hd__dfrtp_1
X_8349_ delta\[9\] net77 VGND VGND VPWR VPWR _3609_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5981_ net209 _0909_ _0980_ _0979_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__a31o_1
X_4932_ _4097_ net263 _4095_ VGND VGND VPWR VPWR _4098_ sky130_fd_sc_hd__and3_1
X_7720_ net312 _2678_ _2927_ _2926_ VGND VGND VPWR VPWR _2929_ sky130_fd_sc_hd__a31o_1
XFILLER_0_59_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7651_ _2852_ _2825_ VGND VGND VPWR VPWR _2853_ sky130_fd_sc_hd__xnor2_1
XANTENNA_14 net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_6602_ _1705_ _1709_ VGND VGND VPWR VPWR _1710_ sky130_fd_sc_hd__xnor2_1
X_4863_ net171 net168 net272 net280 VGND VGND VPWR VPWR _4029_ sky130_fd_sc_hd__and4bb_1
X_7582_ net297 _2162_ VGND VGND VPWR VPWR _2777_ sky130_fd_sc_hd__nand2_1
X_4794_ _3958_ _3954_ VGND VGND VPWR VPWR _3960_ sky130_fd_sc_hd__xor2_1
XFILLER_0_104_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6533_ net305 _0687_ VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6464_ _1561_ _1562_ VGND VGND VPWR VPWR _1563_ sky130_fd_sc_hd__xnor2_2
X_8203_ _3459_ _3437_ VGND VGND VPWR VPWR _3460_ sky130_fd_sc_hd__xor2_1
X_5415_ net80 _0436_ _0438_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__a21o_1
XFILLER_0_88_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6395_ _2191_ net125 net115 _2202_ VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_2_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5346_ _0360_ _0365_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__or2b_1
X_8134_ _3312_ _3352_ VGND VGND VPWR VPWR _3384_ sky130_fd_sc_hd__or2b_1
X_5277_ _2202_ net190 _0280_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__nor3_1
X_8065_ _3245_ _3250_ VGND VGND VPWR VPWR _3308_ sky130_fd_sc_hd__and2_1
X_7016_ net156 net228 _2152_ VGND VGND VPWR VPWR _2154_ sky130_fd_sc_hd__and3_1
X_4228_ net261 _0767_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_106_Right_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7918_ _2921_ _3022_ _3023_ _3143_ _3145_ VGND VGND VPWR VPWR _3146_ sky130_fd_sc_hd__a32o_1
XFILLER_0_65_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7849_ _3067_ _3068_ _3069_ VGND VGND VPWR VPWR _3070_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_104_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput12 periodTop[5] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_4
Xinput23 vA[14] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_2
Xinput45 vB[5] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_4
Xinput34 vB[0] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput56 vC[15] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6180_ _1249_ _1250_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__or2b_1
X_5200_ _0921_ net191 VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__nor2_2
X_5131_ _0147_ _0154_ _0148_ _0153_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__o2bb2a_1
X_5062_ net196 net291 VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__or2b_1
X_7703_ _2908_ _2909_ VGND VGND VPWR VPWR _2910_ sky130_fd_sc_hd__or2_1
X_5964_ net103 net93 VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__or2b_1
XFILLER_0_74_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4915_ _4079_ _4080_ VGND VGND VPWR VPWR _4081_ sky130_fd_sc_hd__nor2_1
X_5895_ net128 net263 VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__or2b_1
X_7634_ net268 _2286_ VGND VGND VPWR VPWR _2834_ sky130_fd_sc_hd__nand2_1
X_4846_ _3940_ _3941_ VGND VGND VPWR VPWR _4012_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_62_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7565_ _2754_ _2757_ VGND VGND VPWR VPWR _2758_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_28_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6516_ _1546_ _1619_ VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__xnor2_2
X_4777_ _3940_ _3941_ _3942_ VGND VGND VPWR VPWR _3943_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_70_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7496_ _2677_ _2681_ VGND VGND VPWR VPWR _2682_ sky130_fd_sc_hd__nand2_1
X_6447_ _1466_ _1287_ _1542_ VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__a21oi_1
X_6378_ _1278_ _1284_ _1467_ VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__a21oi_2
X_8117_ _3362_ _3364_ VGND VGND VPWR VPWR _3365_ sky130_fd_sc_hd__xnor2_1
X_5329_ _3434_ _3522_ _0352_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__a21o_1
X_8048_ net199 net156 VGND VGND VPWR VPWR _3289_ sky130_fd_sc_hd__or2b_1
XFILLER_0_93_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8391__8 clknet_2_2__leaf_clk VGND VGND VPWR VPWR net329 sky130_fd_sc_hd__inv_2
XFILLER_0_69_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5680_ _1492_ net142 _0700_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__or3_1
X_4700_ _3862_ net392 VGND VGND VPWR VPWR _3866_ sky130_fd_sc_hd__nor2_1
X_4631_ _3763_ _3795_ _3796_ VGND VGND VPWR VPWR _3797_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_60_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7350_ _2519_ _2520_ _2515_ VGND VGND VPWR VPWR _2522_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_40_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4562_ _2115_ net283 _3726_ _3727_ _2147_ VGND VGND VPWR VPWR _3728_ sky130_fd_sc_hd__a32o_1
X_4493_ _3655_ _3658_ VGND VGND VPWR VPWR _3659_ sky130_fd_sc_hd__xor2_2
X_7281_ net220 net27 net121 net155 VGND VGND VPWR VPWR _2446_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_12_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6301_ net319 _0926_ VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__nand2_1
X_6232_ _1304_ _1306_ _1307_ VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__a21oi_1
X_6163_ _0921_ net115 _1232_ VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__or3_1
X_5114_ _0068_ _0070_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__xor2_2
X_6094_ _1005_ _1025_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5045_ _3978_ net316 VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6996_ _0490_ net23 VGND VGND VPWR VPWR _2132_ sky130_fd_sc_hd__nor2_1
X_5947_ net111 net295 VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__and2b_1
X_5878_ net131 net263 VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__or2b_1
X_7617_ net202 net205 net303 net313 VGND VGND VPWR VPWR _2815_ sky130_fd_sc_hd__or4bb_1
XFILLER_0_7_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4829_ _3994_ _3923_ VGND VGND VPWR VPWR _3995_ sky130_fd_sc_hd__xnor2_1
X_7548_ _2670_ _2721_ VGND VGND VPWR VPWR _2739_ sky130_fd_sc_hd__nor2_1
X_7479_ _2629_ _2661_ _2662_ VGND VGND VPWR VPWR _2663_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_101_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_603 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6850_ _1922_ _1923_ _1925_ _1042_ VGND VGND VPWR VPWR _1973_ sky130_fd_sc_hd__o22a_1
XFILLER_0_76_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5801_ _0832_ _0834_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6781_ _1894_ _1896_ VGND VGND VPWR VPWR _1897_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5732_ _0754_ _0757_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__or2_1
XFILLER_0_72_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5663_ _1503_ _1426_ net140 net138 VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__or4_1
XFILLER_0_72_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5594_ _0498_ _0524_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__nor2_1
X_8382_ delta\[15\] net73 VGND VGND VPWR VPWR _3640_ sky130_fd_sc_hd__xnor2_1
X_7402_ net319 net227 VGND VGND VPWR VPWR _2579_ sky130_fd_sc_hd__nand2_1
X_4614_ _3774_ _3776_ VGND VGND VPWR VPWR _3780_ sky130_fd_sc_hd__and2_1
X_4545_ _3698_ _3710_ VGND VGND VPWR VPWR _3711_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_20_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7333_ _2285_ _2502_ VGND VGND VPWR VPWR _2503_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4476_ _3619_ _3628_ _3638_ _3641_ net45 VGND VGND VPWR VPWR _3642_ sky130_fd_sc_hd__a2111o_1
X_7264_ _2410_ _2426_ VGND VGND VPWR VPWR _2427_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_96_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6215_ _1287_ _1288_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7195_ _2230_ _2350_ _2233_ VGND VGND VPWR VPWR _2351_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_0_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6146_ _1088_ _1151_ _1213_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__a21o_1
X_6077_ _1072_ _1136_ _1137_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__a21oi_1
X_5028_ net196 net280 VGND VGND VPWR VPWR _4194_ sky130_fd_sc_hd__or2b_1
XFILLER_0_95_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6979_ _2080_ _2079_ _2081_ _2113_ VGND VGND VPWR VPWR _2114_ sky130_fd_sc_hd__o22ai_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4330_ _1972_ _2049_ VGND VGND VPWR VPWR _2071_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4261_ _1141_ _1163_ _1174_ _1316_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__or4_1
X_6000_ net281 _0925_ _0988_ _0986_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__a31o_1
X_8404__21 clknet_2_1__leaf_clk VGND VGND VPWR VPWR net342 sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7951_ net246 net244 VGND VGND VPWR VPWR _3183_ sky130_fd_sc_hd__or2b_1
X_6902_ _0897_ _0900_ VGND VGND VPWR VPWR _2030_ sky130_fd_sc_hd__xnor2_1
X_7882_ _1240_ net219 net222 _0149_ VGND VGND VPWR VPWR _3107_ sky130_fd_sc_hd__o22a_1
X_6833_ _1947_ _1948_ VGND VGND VPWR VPWR _1954_ sky130_fd_sc_hd__or2_1
XFILLER_0_9_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6764_ _1875_ _1877_ VGND VGND VPWR VPWR _1878_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5715_ net153 net184 _0691_ _0687_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__and4_1
X_6695_ _1792_ _1802_ VGND VGND VPWR VPWR _1803_ sky130_fd_sc_hd__xnor2_2
X_5646_ _0655_ _0658_ _0667_ _0669_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__nand4b_4
XFILLER_0_93_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8434_ net340 _0010_ net252 VGND VGND VPWR VPWR counter\[3\] sky130_fd_sc_hd__dfrtp_4
XFILLER_0_33_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_93_Right_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8365_ delta\[12\] net76 VGND VGND VPWR VPWR _3624_ sky130_fd_sc_hd__nor2_1
X_5577_ net78 _0600_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8296_ _3531_ _3540_ _3541_ _3561_ VGND VGND VPWR VPWR _3562_ sky130_fd_sc_hd__or4_1
X_4528_ _2082_ _2587_ VGND VGND VPWR VPWR _3694_ sky130_fd_sc_hd__xor2_1
X_7316_ _2482_ _2483_ VGND VGND VPWR VPWR _2484_ sky130_fd_sc_hd__nor2_1
X_4459_ _2268_ net191 VGND VGND VPWR VPWR _3489_ sky130_fd_sc_hd__nor2_1
X_7247_ _2245_ _2252_ VGND VGND VPWR VPWR _2408_ sky130_fd_sc_hd__nor2_1
X_7178_ _2307_ _2331_ _2310_ VGND VGND VPWR VPWR _2332_ sky130_fd_sc_hd__o21ai_2
X_6129_ _1193_ _1194_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__xor2_1
XFILLER_0_102_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5500_ _0491_ _0493_ _0466_ _0492_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_15_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6480_ net112 net242 VGND VGND VPWR VPWR _1581_ sky130_fd_sc_hd__or2b_1
XFILLER_0_14_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5431_ _1481_ net192 _0454_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__or3_1
XFILLER_0_2_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8150_ _0269_ net234 _2189_ VGND VGND VPWR VPWR _3402_ sky130_fd_sc_hd__nor3_1
XFILLER_0_77_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5362_ _0363_ _0364_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__xnor2_1
X_8081_ net288 net228 _3264_ _3325_ VGND VGND VPWR VPWR _3326_ sky130_fd_sc_hd__a31o_1
X_7101_ net201 net296 VGND VGND VPWR VPWR _2248_ sky130_fd_sc_hd__or2b_1
X_4313_ _1873_ VGND VGND VPWR VPWR _1884_ sky130_fd_sc_hd__buf_4
X_7032_ _2168_ _2171_ VGND VGND VPWR VPWR _2172_ sky130_fd_sc_hd__nand2_1
X_5293_ _1503_ net48 _0264_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__or3b_2
XFILLER_0_77_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4244_ counter\[5\] _1130_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_97_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_96_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7934_ net207 net121 VGND VGND VPWR VPWR _3164_ sky130_fd_sc_hd__and2b_1
X_7865_ _3084_ _3085_ VGND VGND VPWR VPWR _3088_ sky130_fd_sc_hd__xnor2_1
X_6816_ _1907_ _1908_ VGND VGND VPWR VPWR _1935_ sky130_fd_sc_hd__nand2_1
X_7796_ _3010_ _3011_ VGND VGND VPWR VPWR _3012_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6747_ _1856_ _1857_ _1858_ VGND VGND VPWR VPWR _1859_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_73_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6678_ _1784_ _1785_ VGND VGND VPWR VPWR _1786_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5629_ net100 _0647_ _0649_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__a21oi_1
X_8417_ net323 _0050_ net252 VGND VGND VPWR VPWR delta\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_33_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8348_ _3607_ _3608_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8279_ _3542_ _3153_ _2588_ VGND VGND VPWR VPWR _3543_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_87_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8395__12 clknet_2_2__leaf_clk VGND VGND VPWR VPWR net333 sky130_fd_sc_hd__inv_2
XFILLER_0_95_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5980_ _0982_ _0989_ _1030_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__a21boi_1
X_4931_ net196 VGND VGND VPWR VPWR _4097_ sky130_fd_sc_hd__inv_2
X_4862_ net168 net282 VGND VGND VPWR VPWR _4028_ sky130_fd_sc_hd__or2b_1
X_7650_ _2806_ _2809_ VGND VGND VPWR VPWR _2852_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6601_ _1706_ _1707_ _1660_ _1708_ VGND VGND VPWR VPWR _1709_ sky130_fd_sc_hd__o22a_1
XFILLER_0_7_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7581_ _2773_ _2775_ VGND VGND VPWR VPWR _2776_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_55_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4793_ _3954_ _3958_ VGND VGND VPWR VPWR _3959_ sky130_fd_sc_hd__or2b_1
XANTENNA_15 net170 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_103_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6532_ _1577_ _1586_ _1585_ VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__a21boi_2
X_6463_ _4035_ net55 VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__nor2_1
X_8202_ _3458_ _2204_ VGND VGND VPWR VPWR _3459_ sky130_fd_sc_hd__xor2_1
X_5414_ net79 _0432_ _0435_ counter\[5\] VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__a22o_1
XFILLER_0_2_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8133_ _3334_ _3336_ VGND VGND VPWR VPWR _3383_ sky130_fd_sc_hd__nor2_1
X_6394_ _1232_ _1485_ VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__nor2_1
X_5345_ _0367_ _0368_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5276_ net190 net212 VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__or2b_1
X_8064_ _3304_ _3306_ VGND VGND VPWR VPWR _3307_ sky130_fd_sc_hd__xor2_2
XFILLER_0_10_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7015_ net156 net228 _2152_ VGND VGND VPWR VPWR _2153_ sky130_fd_sc_hd__a21oi_1
X_4227_ counter\[10\] _0943_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_97_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7917_ _2974_ _3021_ _3144_ VGND VGND VPWR VPWR _3145_ sky130_fd_sc_hd__and3_1
X_7848_ net224 net249 net302 net312 VGND VGND VPWR VPWR _3069_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_92_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7779_ _2949_ _2952_ VGND VGND VPWR VPWR _2993_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_103_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput13 periodTop[6] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_1
Xinput35 vB[10] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_1
Xinput46 vB[6] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput24 vA[15] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_1
Xinput57 vC[1] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_1
X_5130_ _0148_ _0153_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__xor2_1
X_5061_ _0083_ _0084_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__nor2_1
X_5963_ net103 net89 VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__or2b_1
X_4914_ _4077_ _4078_ VGND VGND VPWR VPWR _4080_ sky130_fd_sc_hd__and2_1
X_7702_ _2850_ _2853_ VGND VGND VPWR VPWR _2909_ sky130_fd_sc_hd__xnor2_1
X_5894_ net237 _0916_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__nand2_1
XFILLER_0_90_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7633_ net276 _2287_ _2832_ _2831_ VGND VGND VPWR VPWR _2833_ sky130_fd_sc_hd__a31o_1
X_4845_ _4008_ _4009_ _4010_ VGND VGND VPWR VPWR _4011_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_62_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7564_ _2755_ _2756_ VGND VGND VPWR VPWR _2757_ sky130_fd_sc_hd__and2_1
X_4776_ _3938_ _3939_ VGND VGND VPWR VPWR _3942_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6515_ _1616_ _1618_ VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__xor2_2
X_7495_ net154 _2678_ _2679_ _2680_ VGND VGND VPWR VPWR _2681_ sky130_fd_sc_hd__a22o_1
XFILLER_0_43_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6446_ _1466_ _1542_ VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__xor2_1
XFILLER_0_30_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6377_ _1216_ _1277_ VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__nor2_1
X_8116_ _3338_ _3363_ _3318_ _3286_ _3319_ VGND VGND VPWR VPWR _3364_ sky130_fd_sc_hd__a32o_1
X_5328_ _3500_ _3511_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8047_ _0269_ net236 VGND VGND VPWR VPWR _3288_ sky130_fd_sc_hd__nor2_1
X_5259_ _0278_ _0282_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__xnor2_1
Xclkbuf_2_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_97_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_104_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout190 net37 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_88_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4630_ _3793_ _3794_ VGND VGND VPWR VPWR _3796_ sky130_fd_sc_hd__or2b_1
XFILLER_0_44_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6300_ _1379_ _1381_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__xor2_1
X_4561_ net167 net273 VGND VGND VPWR VPWR _3727_ sky130_fd_sc_hd__and2b_1
X_4492_ _3656_ _3657_ _1481_ net42 VGND VGND VPWR VPWR _3658_ sky130_fd_sc_hd__a211o_1
X_7280_ net220 net154 VGND VGND VPWR VPWR _2445_ sky130_fd_sc_hd__or2b_1
XFILLER_0_8_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6231_ net127 net130 net301 net311 VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_100_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6162_ net125 net210 VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__or2b_1
XFILLER_0_85_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5113_ _0083_ _0104_ _0136_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__a21bo_1
X_6093_ _1154_ _1155_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__nor2_1
X_5044_ _0066_ _0067_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__xor2_2
XFILLER_0_79_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6995_ net102 net122 _2128_ _2130_ VGND VGND VPWR VPWR _2131_ sky130_fd_sc_hd__and4_1
XFILLER_0_94_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5946_ net108 net301 VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__and2b_1
XFILLER_0_63_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5877_ net128 net271 VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__or2b_1
XFILLER_0_90_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7616_ _2604_ _2607_ VGND VGND VPWR VPWR _2814_ sky130_fd_sc_hd__xnor2_1
X_4828_ _3769_ net256 VGND VGND VPWR VPWR _3994_ sky130_fd_sc_hd__nand2_1
X_7547_ net315 net227 _2729_ _2727_ VGND VGND VPWR VPWR _2738_ sky130_fd_sc_hd__a31o_1
XFILLER_0_7_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4759_ _3769_ net237 VGND VGND VPWR VPWR _3925_ sky130_fd_sc_hd__nand2_1
XFILLER_0_16_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7478_ _2659_ _2660_ VGND VGND VPWR VPWR _2662_ sky130_fd_sc_hd__nor2_1
X_6429_ _1521_ _1523_ VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__nor2_1
XFILLER_0_98_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5800_ net398 net136 VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__nand2_1
X_6780_ _1891_ _1893_ VGND VGND VPWR VPWR _1896_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5731_ _0754_ _0757_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5662_ _0684_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__clkbuf_4
X_8381_ _3629_ _3634_ _3636_ _3633_ VGND VGND VPWR VPWR _3639_ sky130_fd_sc_hd__a31o_1
X_5593_ _0540_ _0616_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7401_ _2575_ _2577_ VGND VGND VPWR VPWR _2578_ sky130_fd_sc_hd__xor2_2
X_4613_ _3778_ _3731_ VGND VGND VPWR VPWR _3779_ sky130_fd_sc_hd__xnor2_2
X_7332_ _2435_ _2501_ VGND VGND VPWR VPWR _2502_ sky130_fd_sc_hd__xor2_2
X_4544_ _3706_ _3708_ _3709_ VGND VGND VPWR VPWR _3710_ sky130_fd_sc_hd__a21bo_1
X_7263_ _2419_ _2425_ VGND VGND VPWR VPWR _2426_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_96_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4475_ net393 VGND VGND VPWR VPWR _3641_ sky130_fd_sc_hd__inv_2
X_6214_ _1154_ _1286_ VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__or2_1
X_7194_ _2231_ _2232_ VGND VGND VPWR VPWR _2350_ sky130_fd_sc_hd__nor2_1
X_6145_ _1090_ _1150_ VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6076_ net103 net144 net305 net314 VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__and4bb_1
X_5027_ _3978_ net316 _4192_ VGND VGND VPWR VPWR _4193_ sky130_fd_sc_hd__and3_1
XFILLER_0_45_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6978_ _2107_ _2108_ VGND VGND VPWR VPWR _2113_ sky130_fd_sc_hd__and2b_1
XFILLER_0_48_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5929_ net209 _0916_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_101_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4260_ _1207_ _1272_ _1294_ _1305_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__or4_1
XFILLER_0_82_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7950_ net199 net217 VGND VGND VPWR VPWR _3182_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_19_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6901_ _2013_ _2021_ VGND VGND VPWR VPWR _2029_ sky130_fd_sc_hd__nand2_1
X_7881_ _3100_ _3105_ VGND VGND VPWR VPWR _3106_ sky130_fd_sc_hd__or2_1
XFILLER_0_89_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6832_ _1927_ _1952_ VGND VGND VPWR VPWR _1953_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_106_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6763_ _1789_ _1805_ _1876_ VGND VGND VPWR VPWR _1877_ sky130_fd_sc_hd__a21oi_1
X_5714_ net139 net184 VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__or2b_1
X_6694_ _1794_ _1801_ VGND VGND VPWR VPWR _1802_ sky130_fd_sc_hd__xor2_2
X_5645_ net74 _0657_ _0666_ net75 _0668_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__a221oi_2
X_8433_ net339 _0009_ net252 VGND VGND VPWR VPWR counter\[2\] sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_28_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8364_ _3622_ _3623_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__xor2_1
X_5576_ _0586_ _0599_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__nand2_1
X_4527_ _3137_ _3692_ VGND VGND VPWR VPWR _3693_ sky130_fd_sc_hd__xnor2_1
X_8295_ _3548_ _3550_ _3558_ _3560_ VGND VGND VPWR VPWR _3561_ sky130_fd_sc_hd__or4_1
X_7315_ net297 net306 _2127_ _2129_ VGND VGND VPWR VPWR _2483_ sky130_fd_sc_hd__and4_1
X_4458_ _3445_ _3456_ _3467_ VGND VGND VPWR VPWR _3478_ sky130_fd_sc_hd__a21oi_1
X_7246_ _2371_ _2406_ VGND VGND VPWR VPWR _2407_ sky130_fd_sc_hd__xor2_2
X_7177_ _2308_ _2309_ VGND VGND VPWR VPWR _2331_ sky130_fd_sc_hd__nor2_1
X_4389_ net172 net148 VGND VGND VPWR VPWR _2719_ sky130_fd_sc_hd__or2b_1
X_6128_ _0951_ _0969_ VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_37_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6059_ _1115_ _1116_ _1117_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__o21a_1
XFILLER_0_83_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_46_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_55_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_64_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5430_ net194 net119 VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__or2b_1
X_5361_ _0366_ _0369_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_509 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5292_ _0299_ _0315_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_73_Left_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8080_ _3191_ _3262_ _3261_ VGND VGND VPWR VPWR _3325_ sky130_fd_sc_hd__o21a_1
XFILLER_0_65_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4312_ net85 VGND VGND VPWR VPWR _1873_ sky130_fd_sc_hd__inv_2
X_7100_ _2422_ net235 VGND VGND VPWR VPWR _2247_ sky130_fd_sc_hd__nor2_1
X_7031_ net228 _2157_ _2170_ net102 VGND VGND VPWR VPWR _2171_ sky130_fd_sc_hd__o211a_1
X_4243_ _1119_ _0745_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_93_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7933_ net204 net155 VGND VGND VPWR VPWR _3163_ sky130_fd_sc_hd__and2b_1
XFILLER_0_77_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7864_ _1240_ net205 _3064_ VGND VGND VPWR VPWR _3087_ sky130_fd_sc_hd__or3_1
XFILLER_0_92_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6815_ _1932_ _1933_ VGND VGND VPWR VPWR _1934_ sky130_fd_sc_hd__xnor2_1
X_7795_ _2805_ _3008_ _3009_ VGND VGND VPWR VPWR _3011_ sky130_fd_sc_hd__nand3_1
XFILLER_0_92_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6746_ net105 net146 net212 net398 VGND VGND VPWR VPWR _1858_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_9_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6677_ _1782_ _1783_ VGND VGND VPWR VPWR _1785_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5628_ _0632_ _0636_ _0644_ _0645_ _0651_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__a311o_1
X_8416_ net322 _0049_ net252 VGND VGND VPWR VPWR delta\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_5_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8347_ _3602_ _3606_ _3603_ VGND VGND VPWR VPWR _3608_ sky130_fd_sc_hd__o21ai_1
X_5559_ _0376_ _0398_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__nor2_1
XFILLER_0_103_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8278_ _3149_ _2665_ VGND VGND VPWR VPWR _3542_ sky130_fd_sc_hd__nand2_1
X_7229_ _2380_ _2387_ VGND VGND VPWR VPWR _2388_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_96_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4930_ _4094_ _4095_ VGND VGND VPWR VPWR _4096_ sky130_fd_sc_hd__xnor2_2
X_4861_ net171 net272 VGND VGND VPWR VPWR _4027_ sky130_fd_sc_hd__or2b_1
XFILLER_0_74_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6600_ net110 net182 VGND VGND VPWR VPWR _1708_ sky130_fd_sc_hd__or2b_1
X_7580_ _2703_ _2707_ _2706_ VGND VGND VPWR VPWR _2775_ sky130_fd_sc_hd__a21oi_2
XANTENNA_16 net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4792_ _3652_ net282 _3957_ _3956_ VGND VGND VPWR VPWR _3958_ sky130_fd_sc_hd__a31o_1
X_6531_ _1563_ _1572_ _1636_ VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6462_ _1522_ _1559_ _1560_ VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__a21o_1
X_8201_ _2200_ _2201_ VGND VGND VPWR VPWR _3458_ sky130_fd_sc_hd__nand2_1
X_5413_ counter\[5\] _0435_ _0436_ net80 VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__o22ai_1
X_6393_ net115 net181 VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__or2b_1
XFILLER_0_30_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5344_ _0357_ _0356_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__and2b_1
X_8132_ _3332_ _3333_ VGND VGND VPWR VPWR _3382_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5275_ _0277_ _0283_ _0298_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__a21o_1
X_8063_ _3231_ _3237_ _3305_ VGND VGND VPWR VPWR _3306_ sky130_fd_sc_hd__a21oi_2
X_7014_ _2150_ _2151_ _2145_ _2146_ VGND VGND VPWR VPWR _2152_ sky130_fd_sc_hd__a2bb2o_1
X_4226_ _0932_ _0778_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7916_ _3017_ _3019_ _3020_ VGND VGND VPWR VPWR _3144_ sky130_fd_sc_hd__or3_1
X_7847_ net224 net312 VGND VGND VPWR VPWR _3068_ sky130_fd_sc_hd__or2b_1
XFILLER_0_92_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7778_ _2984_ _2990_ _2991_ VGND VGND VPWR VPWR _2992_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6729_ net110 net152 VGND VGND VPWR VPWR _1839_ sky130_fd_sc_hd__and2b_1
XFILLER_0_46_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput36 vB[11] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__buf_1
Xinput14 periodTop[7] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_4_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput25 vA[1] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_1
Xinput47 vB[7] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__buf_1
Xinput58 vC[2] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_58_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5060_ _0080_ _0082_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__nor2_1
XFILLER_0_74_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5962_ net319 _0699_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__nand2_1
X_4913_ _4077_ _4078_ VGND VGND VPWR VPWR _4079_ sky130_fd_sc_hd__nor2_1
X_7701_ _2898_ _2905_ _2907_ VGND VGND VPWR VPWR _2908_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_59_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5893_ net257 _0916_ _0922_ _0920_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__a31o_1
XFILLER_0_7_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7632_ _2828_ _2830_ _2831_ VGND VGND VPWR VPWR _2832_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_23_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4844_ _4006_ _4007_ VGND VGND VPWR VPWR _4010_ sky130_fd_sc_hd__nor2_1
XFILLER_0_74_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7563_ _1492_ net221 net121 _2678_ VGND VGND VPWR VPWR _2756_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_28_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4775_ _3912_ _3898_ VGND VGND VPWR VPWR _3941_ sky130_fd_sc_hd__xnor2_2
X_6514_ _1531_ _1539_ _1617_ VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__a21oi_2
X_7494_ _2673_ _2674_ VGND VGND VPWR VPWR _2680_ sky130_fd_sc_hd__nand2_1
X_6445_ _1281_ _1541_ VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__xnor2_1
X_6376_ _1285_ _1214_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__or2b_1
X_5327_ _0348_ _0350_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__and2_1
X_8115_ _3307_ _3315_ VGND VGND VPWR VPWR _3363_ sky130_fd_sc_hd__or2_1
X_8046_ _3251_ _3244_ VGND VGND VPWR VPWR _3287_ sky130_fd_sc_hd__or2b_1
X_5258_ _0279_ _0281_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__nor2_1
X_4209_ net288 net297 _0745_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__or3_4
X_5189_ net166 net117 VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__and2b_1
XFILLER_0_3_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout191 net36 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__buf_4
Xfanout180 net181 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__buf_2
XFILLER_0_44_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4560_ _2104_ _3725_ VGND VGND VPWR VPWR _3726_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4491_ _3203_ _3247_ VGND VGND VPWR VPWR _3657_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_587 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_546 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6230_ net127 net308 VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__or2b_1
XFILLER_0_40_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6161_ _3885_ net61 VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__nor2_1
XFILLER_0_85_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5112_ _0103_ _0102_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__or2b_1
XFILLER_0_85_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6092_ _1083_ _1085_ _1153_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__and3_1
X_5043_ _4149_ _4161_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__xor2_2
XFILLER_0_94_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6994_ _2129_ VGND VGND VPWR VPWR _2130_ sky130_fd_sc_hd__buf_2
X_5945_ net311 _0868_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5876_ net257 _0916_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__nand2_1
X_7615_ net295 _2381_ _2812_ _2811_ VGND VGND VPWR VPWR _2813_ sky130_fd_sc_hd__a31o_1
X_4827_ _3668_ net263 _3992_ _3991_ VGND VGND VPWR VPWR _3993_ sky130_fd_sc_hd__a31o_1
XFILLER_0_7_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7546_ _2734_ _2736_ VGND VGND VPWR VPWR _2737_ sky130_fd_sc_hd__xor2_2
XFILLER_0_16_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4758_ _3668_ net256 _3923_ _3922_ VGND VGND VPWR VPWR _3924_ sky130_fd_sc_hd__a31o_1
X_7477_ _2659_ _2660_ VGND VGND VPWR VPWR _2661_ sky130_fd_sc_hd__xor2_2
X_4689_ _3849_ _3851_ VGND VGND VPWR VPWR _3855_ sky130_fd_sc_hd__nand2_1
X_6428_ _1884_ net141 _1522_ VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__nor3_1
XFILLER_0_101_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6359_ _1351_ _1352_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__nand2_1
X_8029_ _3266_ _3267_ VGND VGND VPWR VPWR _3268_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5730_ _0715_ _0755_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5661_ net55 VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__inv_2
X_7400_ _2365_ _2366_ VGND VGND VPWR VPWR _2577_ sky130_fd_sc_hd__xnor2_2
X_8380_ _3635_ _3637_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__xnor2_1
X_5592_ _0614_ _0615_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4612_ _3652_ net257 VGND VGND VPWR VPWR _3778_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4543_ _3703_ _3705_ VGND VGND VPWR VPWR _3709_ sky130_fd_sc_hd__nand2_1
X_7331_ _2491_ _2500_ VGND VGND VPWR VPWR _2501_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_40_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7262_ _2420_ _2424_ VGND VGND VPWR VPWR _2425_ sky130_fd_sc_hd__xnor2_2
X_4474_ net173 net170 net98 net117 VGND VGND VPWR VPWR _3638_ sky130_fd_sc_hd__and4bb_1
X_6213_ _1154_ _1286_ VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7193_ _2330_ _2348_ VGND VGND VPWR VPWR _2349_ sky130_fd_sc_hd__xor2_2
X_6144_ _1156_ _1211_ VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__or2_1
X_6075_ net103 net305 VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__or2b_1
X_5026_ _4187_ _4188_ _4191_ VGND VGND VPWR VPWR _4192_ sky130_fd_sc_hd__a21o_1
XFILLER_0_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6977_ _2068_ _2073_ _2074_ _2111_ VGND VGND VPWR VPWR _2112_ sky130_fd_sc_hd__or4_1
XFILLER_0_48_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5928_ net237 _0916_ _0941_ _0940_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__a31o_1
XFILLER_0_75_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5859_ _0895_ _0882_ _0893_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__and3_1
X_7529_ _2702_ _2717_ VGND VGND VPWR VPWR _2718_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_9_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6900_ _2004_ _2011_ _2026_ VGND VGND VPWR VPWR _2028_ sky130_fd_sc_hd__a21o_1
XFILLER_0_82_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7880_ net94 _2449_ _3101_ _3103_ VGND VGND VPWR VPWR _3105_ sky130_fd_sc_hd__a31oi_2
X_6831_ _1944_ _1951_ VGND VGND VPWR VPWR _1952_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_106_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6762_ _1803_ _1804_ VGND VGND VPWR VPWR _1876_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5713_ net214 _0685_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__nand2_1
X_6693_ _1795_ _1800_ VGND VGND VPWR VPWR _1801_ sky130_fd_sc_hd__xor2_2
X_5644_ _0661_ _0662_ net76 VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__o21a_1
X_8432_ net338 _0008_ net252 VGND VGND VPWR VPWR counter\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_5_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8363_ _3615_ _3618_ _3616_ VGND VGND VPWR VPWR _3623_ sky130_fd_sc_hd__o21a_1
XFILLER_0_72_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5575_ _0580_ _0585_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__nand2_1
X_7314_ _1983_ net231 net233 _1119_ VGND VGND VPWR VPWR _2482_ sky130_fd_sc_hd__o22a_1
XFILLER_0_25_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4526_ _3664_ _3691_ VGND VGND VPWR VPWR _3692_ sky130_fd_sc_hd__xnor2_1
X_8294_ counter\[0\] _3552_ _3559_ VGND VGND VPWR VPWR _3560_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_13_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4457_ net159 net193 net239 net258 VGND VGND VPWR VPWR _3467_ sky130_fd_sc_hd__and4bb_1
X_7245_ _2390_ _2405_ VGND VGND VPWR VPWR _2406_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7176_ _2314_ _2321_ _2329_ VGND VGND VPWR VPWR _2330_ sky130_fd_sc_hd__a21boi_2
X_4388_ net45 VGND VGND VPWR VPWR _2708_ sky130_fd_sc_hd__inv_2
X_6127_ net377 _1191_ _1192_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_99_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6058_ net113 net109 net275 net284 VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__or4bb_1
X_5009_ _4174_ VGND VGND VPWR VPWR _4175_ sky130_fd_sc_hd__inv_2
XFILLER_0_95_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_102_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_101_Right_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5360_ net420 net177 _0383_ _0381_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__a31o_1
XFILLER_0_2_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5291_ _0294_ _0314_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__xnor2_1
X_4311_ _1818_ _1829_ _1851_ VGND VGND VPWR VPWR _1862_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7030_ net228 net231 _2157_ VGND VGND VPWR VPWR _2170_ sky130_fd_sc_hd__o21ai_1
X_4242_ _1108_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_93_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7932_ _0490_ net32 VGND VGND VPWR VPWR _3162_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7863_ _3084_ _3085_ VGND VGND VPWR VPWR _3086_ sky130_fd_sc_hd__or2_1
X_6814_ _0854_ _0860_ VGND VGND VPWR VPWR _1933_ sky130_fd_sc_hd__xnor2_1
X_7794_ _3008_ _3009_ _2805_ VGND VGND VPWR VPWR _3010_ sky130_fd_sc_hd__a21o_1
X_6745_ net146 net241 VGND VGND VPWR VPWR _1857_ sky130_fd_sc_hd__or2b_1
XFILLER_0_18_446 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6676_ _1782_ _1783_ VGND VGND VPWR VPWR _1784_ sky130_fd_sc_hd__or2_1
XFILLER_0_103_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5627_ _0649_ _0650_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__or2_1
XFILLER_0_33_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8346_ delta\[8\] net78 VGND VGND VPWR VPWR _3607_ sky130_fd_sc_hd__xnor2_1
X_5558_ _0581_ _0412_ _0418_ _0425_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__nand4_4
XFILLER_0_60_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8277_ counter\[11\] _3510_ VGND VGND VPWR VPWR _3541_ sky130_fd_sc_hd__and2_1
X_4509_ _3656_ _3674_ VGND VGND VPWR VPWR _3675_ sky130_fd_sc_hd__xnor2_1
X_5489_ _0511_ _0512_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__xnor2_1
X_7228_ _2385_ _2386_ VGND VGND VPWR VPWR _2387_ sky130_fd_sc_hd__nor2_1
X_7159_ _2308_ _2309_ _2310_ VGND VGND VPWR VPWR _2311_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_1_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4860_ _3981_ _4025_ VGND VGND VPWR VPWR _4026_ sky130_fd_sc_hd__and2_1
X_6530_ _1570_ _1571_ VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__nor2_1
XANTENNA_17 net200 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4791_ _3887_ _3955_ _3956_ VGND VGND VPWR VPWR _3957_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_82_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6461_ _1840_ net138 _1559_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__nor3_1
XFILLER_0_42_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8200_ _3455_ VGND VGND VPWR VPWR _3457_ sky130_fd_sc_hd__inv_2
X_5412_ _0418_ _0425_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_88_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6392_ _0921_ net61 VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__nor2_1
X_5343_ net284 net177 VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__nand2_1
X_8131_ _3369_ _3377_ _3380_ _3367_ VGND VGND VPWR VPWR _3381_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_2_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5274_ _0275_ _0276_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__nor2_1
X_8062_ _3229_ _3230_ VGND VGND VPWR VPWR _3305_ sky130_fd_sc_hd__nor2_1
X_7013_ _2131_ _2149_ VGND VGND VPWR VPWR _2151_ sky130_fd_sc_hd__nor2_1
X_4225_ _0921_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__clkbuf_8
XFILLER_0_77_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7915_ _3024_ _3059_ _3095_ _3142_ _3023_ VGND VGND VPWR VPWR _3143_ sky130_fd_sc_hd__o221a_1
XFILLER_0_77_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7846_ net249 net302 VGND VGND VPWR VPWR _3067_ sky130_fd_sc_hd__or2b_1
XFILLER_0_93_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_92_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7777_ _2980_ _2982_ VGND VGND VPWR VPWR _2991_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4989_ _4152_ _4154_ VGND VGND VPWR VPWR _4155_ sky130_fd_sc_hd__or2b_1
X_6728_ _0490_ net64 VGND VGND VPWR VPWR _1838_ sky130_fd_sc_hd__nor2_1
XFILLER_0_61_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6659_ net305 net134 VGND VGND VPWR VPWR _1767_ sky130_fd_sc_hd__nand2_1
X_8329_ _3587_ _3590_ _3588_ VGND VGND VPWR VPWR _3592_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_92_Left_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_614 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput37 vB[12] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_1
XFILLER_0_52_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput26 vA[2] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_2
Xinput15 periodTop[8] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__buf_2
Xinput48 vB[8] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput59 vC[3] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5961_ _1008_ _1010_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__nor2_1
XFILLER_0_90_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4912_ net168 net290 VGND VGND VPWR VPWR _4078_ sky130_fd_sc_hd__and2b_1
X_7700_ _2896_ _2897_ VGND VGND VPWR VPWR _2907_ sky130_fd_sc_hd__nor2_1
XFILLER_0_90_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7631_ net224 net250 net260 net268 VGND VGND VPWR VPWR _2831_ sky130_fd_sc_hd__and4bb_1
X_5892_ _0924_ _0933_ _0934_ _0923_ _0915_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__a32oi_4
X_4843_ _3986_ _3972_ VGND VGND VPWR VPWR _4009_ sky130_fd_sc_hd__xnor2_1
X_7562_ _1492_ net29 _2673_ VGND VGND VPWR VPWR _2755_ sky130_fd_sc_hd__or3_4
XFILLER_0_7_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4774_ _3938_ _3939_ VGND VGND VPWR VPWR _3940_ sky130_fd_sc_hd__xor2_4
XFILLER_0_99_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7493_ _1470_ net220 _2443_ VGND VGND VPWR VPWR _2679_ sky130_fd_sc_hd__or3_1
X_6513_ _1471_ _1530_ VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6444_ _1468_ _1540_ VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__xor2_2
XFILLER_0_43_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6375_ _1455_ _1463_ _1464_ _1156_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__a22o_1
X_5326_ _0349_ _0252_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__xnor2_1
X_8114_ _3337_ _3361_ VGND VGND VPWR VPWR _3362_ sky130_fd_sc_hd__xnor2_1
X_5257_ _3885_ net189 _0280_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__nor3_1
X_8045_ _3284_ _3285_ VGND VGND VPWR VPWR _3286_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4208_ net306 _0734_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__or2_2
X_5188_ net164 net151 VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__and2b_1
Xwire83 _1298_ VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_38_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7829_ _3042_ _3044_ VGND VGND VPWR VPWR _3048_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_530 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout192 net36 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__clkbuf_2
Xfanout170 net44 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__buf_2
Xfanout181 net4 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__buf_2
XFILLER_0_88_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4490_ net175 net118 VGND VGND VPWR VPWR _3656_ sky130_fd_sc_hd__or2b_2
XFILLER_0_69_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6160_ _1222_ _1228_ VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__xor2_2
X_5111_ _0105_ _0134_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__nor2_1
X_6091_ _1083_ _1085_ _1153_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__a21oi_1
X_5042_ _4205_ _0064_ _0065_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6993_ net233 VGND VGND VPWR VPWR _2129_ sky130_fd_sc_hd__inv_2
X_5944_ net292 _0925_ _0948_ _0947_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__a31o_1
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5875_ _0908_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_34_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7614_ _2594_ _2810_ _2811_ VGND VGND VPWR VPWR _2812_ sky130_fd_sc_hd__a21oi_1
X_4826_ _3989_ _3990_ _3991_ VGND VGND VPWR VPWR _3992_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_7_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7545_ _2285_ _2502_ _2735_ VGND VGND VPWR VPWR _2736_ sky130_fd_sc_hd__a21oi_4
X_4757_ _3920_ _3921_ _3922_ VGND VGND VPWR VPWR _3923_ sky130_fd_sc_hd__a21oi_1
X_7476_ _2578_ _2580_ VGND VGND VPWR VPWR _2660_ sky130_fd_sc_hd__xnor2_2
X_4688_ _3805_ _3853_ VGND VGND VPWR VPWR _3854_ sky130_fd_sc_hd__xnor2_1
X_6427_ net138 net314 VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__or2b_1
X_6358_ _1435_ _1440_ _1442_ _1445_ VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__a211o_1
X_5309_ net98 _3997_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__nand2_1
X_6289_ net319 _1181_ _1369_ VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__and3_1
X_8028_ _3204_ _3212_ _3201_ VGND VGND VPWR VPWR _3267_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_93_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5660_ _0210_ _0673_ _0683_ VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__a21o_1
XFILLER_0_72_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4611_ _3774_ _3776_ VGND VGND VPWR VPWR _3777_ sky130_fd_sc_hd__xor2_2
X_5591_ _0611_ _0613_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7330_ _2492_ _2498_ VGND VGND VPWR VPWR _2500_ sky130_fd_sc_hd__xnor2_2
X_4542_ _2180_ _3707_ VGND VGND VPWR VPWR _3708_ sky130_fd_sc_hd__xnor2_1
X_4473_ net173 net98 VGND VGND VPWR VPWR _3628_ sky130_fd_sc_hd__or2b_1
XFILLER_0_13_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7261_ _2421_ _2423_ VGND VGND VPWR VPWR _2424_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6212_ _1214_ _1285_ VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7192_ _2339_ _2347_ VGND VGND VPWR VPWR _2348_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6143_ _1206_ _1209_ _1210_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__a21oi_1
X_6074_ _1884_ net142 VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__nor2_1
X_5025_ _4189_ _4190_ VGND VGND VPWR VPWR _4191_ sky130_fd_sc_hd__and2b_1
XFILLER_0_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6976_ _2081_ _2088_ _2100_ _2110_ VGND VGND VPWR VPWR _2111_ sky130_fd_sc_hd__or4bb_1
X_5927_ _0944_ _0949_ _0972_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_75_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5858_ net259 net135 _0889_ _0886_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__a31o_1
XFILLER_0_75_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5789_ net106 net147 net152 net183 VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_90_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_90_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4809_ _3899_ _3974_ VGND VGND VPWR VPWR _3975_ sky130_fd_sc_hd__or2_1
X_7528_ _2711_ _2716_ VGND VGND VPWR VPWR _2717_ sky130_fd_sc_hd__xnor2_2
X_7459_ _2599_ _2638_ _2640_ _2635_ _2637_ VGND VGND VPWR VPWR _2641_ sky130_fd_sc_hd__a32oi_4
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6830_ _1945_ _1946_ _1949_ VGND VGND VPWR VPWR _1951_ sky130_fd_sc_hd__o21ai_1
X_6761_ _1850_ _1874_ VGND VGND VPWR VPWR _1875_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5712_ _0729_ _0735_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__xor2_1
XFILLER_0_85_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6692_ _1798_ _1799_ VGND VGND VPWR VPWR _1800_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_45_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5643_ net76 _0661_ _0662_ _0666_ net75 VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__o32a_1
X_8431_ net337 _0001_ net252 VGND VGND VPWR VPWR counter\[0\] sky130_fd_sc_hd__dfrtp_4
XFILLER_0_72_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8362_ _3620_ _3621_ VGND VGND VPWR VPWR _3622_ sky130_fd_sc_hd__or2b_1
X_5574_ counter\[11\] _0597_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__and2_1
XFILLER_0_31_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4525_ _3688_ _3689_ _3690_ VGND VGND VPWR VPWR _3691_ sky130_fd_sc_hd__a21o_1
XFILLER_0_53_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7313_ net315 _2162_ VGND VGND VPWR VPWR _2481_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8293_ net81 _3549_ VGND VGND VPWR VPWR _3559_ sky130_fd_sc_hd__nand2_1
XFILLER_0_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4456_ net193 net258 VGND VGND VPWR VPWR _3456_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7244_ _2403_ _2404_ VGND VGND VPWR VPWR _2405_ sky130_fd_sc_hd__nor2_4
X_4387_ net172 net169 net181 net148 VGND VGND VPWR VPWR _2697_ sky130_fd_sc_hd__and4bb_1
X_7175_ _2306_ _2313_ VGND VGND VPWR VPWR _2329_ sky130_fd_sc_hd__nand2_1
X_6126_ _1173_ _1176_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__nor2_1
XFILLER_0_99_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6057_ net113 net275 VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__and2b_1
X_5008_ _4131_ _4173_ VGND VGND VPWR VPWR _4174_ sky130_fd_sc_hd__and2b_1
X_8410__27 clknet_2_3__leaf_clk VGND VGND VPWR VPWR net348 sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6959_ _1545_ _1623_ _1622_ _1620_ VGND VGND VPWR VPWR _2092_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_48_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5290_ _0305_ _0313_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__xor2_1
X_4310_ _1840_ net187 _1818_ VGND VGND VPWR VPWR _1851_ sky130_fd_sc_hd__nor3_1
XFILLER_0_77_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4241_ net420 VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7931_ net101 _2678_ VGND VGND VPWR VPWR _3161_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7862_ _3036_ _3052_ VGND VGND VPWR VPWR _3085_ sky130_fd_sc_hd__xnor2_1
X_6813_ _1929_ _1931_ VGND VGND VPWR VPWR _1932_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7793_ _2999_ _3001_ VGND VGND VPWR VPWR _3009_ sky130_fd_sc_hd__or2b_1
XFILLER_0_92_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6744_ net105 net212 VGND VGND VPWR VPWR _1856_ sky130_fd_sc_hd__or2b_1
X_6675_ _1722_ _1726_ _1725_ VGND VGND VPWR VPWR _1783_ sky130_fd_sc_hd__a21oi_1
X_5626_ _0626_ _0629_ _0648_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__and3_1
XFILLER_0_91_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8345_ _3604_ _3606_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__xnor2_1
X_5557_ _0377_ _0400_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__nor2_1
XFILLER_0_41_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5488_ net240 net177 VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__nand2_1
X_8276_ _3535_ _3538_ _3539_ VGND VGND VPWR VPWR _3540_ sky130_fd_sc_hd__or3b_4
X_4508_ net197 net98 VGND VGND VPWR VPWR _3674_ sky130_fd_sc_hd__and2b_1
X_4439_ net400 _2115_ VGND VGND VPWR VPWR _3269_ sky130_fd_sc_hd__nand2_1
X_7227_ net215 _2381_ _2384_ VGND VGND VPWR VPWR _2386_ sky130_fd_sc_hd__a21oi_1
X_7158_ net225 net251 net121 net154 VGND VGND VPWR VPWR _2310_ sky130_fd_sc_hd__or4bb_1
X_6109_ _1166_ _1171_ _1172_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__a21boi_1
X_7089_ _2231_ _2232_ _2233_ VGND VGND VPWR VPWR _2234_ sky130_fd_sc_hd__o21a_1
XFILLER_0_49_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_95_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_102_Left_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4790_ net171 net170 net263 net272 VGND VGND VPWR VPWR _3956_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_103_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_18 net242 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_103_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_586 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6460_ net141 net305 VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__nand2b_1
XFILLER_0_15_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5411_ _0412_ _0434_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__xnor2_2
X_6391_ _1476_ _1482_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__xor2_2
X_5342_ _0360_ _0365_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__xnor2_1
X_8130_ _3378_ _3277_ _3272_ _3375_ VGND VGND VPWR VPWR _3380_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_11_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8061_ _3287_ _3303_ VGND VGND VPWR VPWR _3304_ sky130_fd_sc_hd__xor2_2
X_5273_ _0289_ _0296_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__nand2_1
X_7012_ _2131_ _2149_ VGND VGND VPWR VPWR _2150_ sky130_fd_sc_hd__and2_1
XFILLER_0_10_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4224_ net237 VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__inv_2
X_7914_ _3091_ _3096_ _3141_ _3092_ VGND VGND VPWR VPWR _3142_ sky130_fd_sc_hd__and4bb_1
X_7845_ _4035_ net26 VGND VGND VPWR VPWR _3066_ sky130_fd_sc_hd__nor2_1
X_7776_ _2985_ _2989_ VGND VGND VPWR VPWR _2990_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_18_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4988_ _4151_ _4153_ VGND VGND VPWR VPWR _4154_ sky130_fd_sc_hd__and2_1
XFILLER_0_73_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6727_ net99 _0926_ VGND VGND VPWR VPWR _1837_ sky130_fd_sc_hd__nand2_1
X_6658_ _1763_ _1765_ VGND VGND VPWR VPWR _1766_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_61_534 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5609_ _0618_ _0528_ _0620_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__or3b_1
XFILLER_0_103_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8328_ delta\[4\] net80 VGND VGND VPWR VPWR _3591_ sky130_fd_sc_hd__xnor2_1
X_6589_ net126 net116 net99 net117 VGND VGND VPWR VPWR _1697_ sky130_fd_sc_hd__and4bb_1
X_8259_ _3277_ _3514_ _3273_ VGND VGND VPWR VPWR _3521_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_17_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput27 vA[3] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_2
Xinput16 periodTop[9] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_4
Xinput38 vB[13] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__buf_1
Xinput49 vB[9] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5960_ _1218_ net103 VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__or2_1
X_4911_ net171 net280 VGND VGND VPWR VPWR _4077_ sky130_fd_sc_hd__and2b_1
X_5891_ net301 _0925_ _0928_ _0931_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__a22o_1
X_7630_ net224 net268 VGND VGND VPWR VPWR _2830_ sky130_fd_sc_hd__or2b_1
XFILLER_0_90_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_542 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4842_ _4006_ _4007_ VGND VGND VPWR VPWR _4008_ sky130_fd_sc_hd__xor2_1
XFILLER_0_99_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7561_ _2744_ _2753_ VGND VGND VPWR VPWR _2754_ sky130_fd_sc_hd__xor2_2
X_4773_ net421 _3860_ VGND VGND VPWR VPWR _3939_ sky130_fd_sc_hd__xnor2_4
X_7492_ _2381_ VGND VGND VPWR VPWR _2678_ sky130_fd_sc_hd__clkbuf_4
X_6512_ _1554_ _1615_ VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_70_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6443_ _1531_ _1539_ VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_70_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6374_ _1457_ _1458_ _1461_ _1211_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__a31o_1
XFILLER_0_30_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5325_ _0245_ _0246_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__xnor2_1
X_8113_ _3338_ _3360_ VGND VGND VPWR VPWR _3361_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5256_ net188 net240 VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__or2b_1
X_8044_ net279 net228 VGND VGND VPWR VPWR _3285_ sky130_fd_sc_hd__nand2_1
XFILLER_0_54_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4207_ net314 _0723_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__or2_1
X_5187_ _2191_ net162 VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__nor2_1
XFILLER_0_78_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7828_ _3046_ _3030_ VGND VGND VPWR VPWR _3047_ sky130_fd_sc_hd__xnor2_1
X_7759_ _2941_ _2969_ _2970_ VGND VGND VPWR VPWR _2971_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_19_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout182 net184 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__clkbuf_4
Xfanout160 net161 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__clkbuf_2
Xfanout171 net173 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__buf_2
XFILLER_0_88_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout193 net194 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__buf_2
XFILLER_0_57_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5110_ _0111_ _0132_ _0133_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__a21oi_2
X_6090_ _1088_ _1151_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_85_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5041_ _4203_ _4204_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__nor2_1
XFILLER_0_18_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6992_ _2127_ VGND VGND VPWR VPWR _2128_ sky130_fd_sc_hd__buf_2
XFILLER_0_75_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5943_ _0973_ _0990_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__xor2_1
XFILLER_0_34_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5874_ net264 _0909_ _0914_ _0913_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__a31o_2
X_7613_ net221 net223 net276 net286 VGND VGND VPWR VPWR _2811_ sky130_fd_sc_hd__and4bb_1
X_4825_ net175 net197 net237 net256 VGND VGND VPWR VPWR _3991_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7544_ _2435_ _2501_ VGND VGND VPWR VPWR _2735_ sky130_fd_sc_hd__nor2_1
XFILLER_0_50_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4756_ net175 net197 net209 net237 VGND VGND VPWR VPWR _3922_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_16_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7475_ _2655_ _2657_ _2658_ VGND VGND VPWR VPWR _2659_ sky130_fd_sc_hd__a21oi_2
X_4687_ _3808_ _3807_ VGND VGND VPWR VPWR _3853_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6426_ _2422_ net141 net138 _1884_ VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__o22a_1
XFILLER_0_59_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6357_ _1398_ _1443_ _1444_ _1418_ VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__or4b_1
X_5308_ _0261_ _0267_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__xnor2_1
X_6288_ net319 _0926_ _1368_ _1367_ VGND VGND VPWR VPWR _1369_ sky130_fd_sc_hd__a31o_1
X_5239_ net99 _4038_ _0213_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__and3_1
X_8027_ _3257_ _3265_ VGND VGND VPWR VPWR _3266_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4610_ _3699_ _3775_ VGND VGND VPWR VPWR _3776_ sky130_fd_sc_hd__xnor2_2
X_5590_ _0611_ _0613_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4541_ _2246_ _2213_ VGND VGND VPWR VPWR _3707_ sky130_fd_sc_hd__or2b_1
X_4472_ net170 net117 VGND VGND VPWR VPWR _3619_ sky130_fd_sc_hd__or2b_1
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7260_ net306 net314 _2127_ _2129_ VGND VGND VPWR VPWR _2423_ sky130_fd_sc_hd__and4_1
X_6211_ _1278_ _1284_ VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__xnor2_1
X_7191_ _2344_ _2346_ VGND VGND VPWR VPWR _2347_ sky130_fd_sc_hd__and2_1
XFILLER_0_96_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6142_ _1023_ _1084_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_29_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6073_ _1070_ _1073_ _1133_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__a21o_1
X_5024_ _4150_ _4038_ net316 VGND VGND VPWR VPWR _4190_ sky130_fd_sc_hd__and3b_1
XFILLER_0_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6975_ _2080_ _2079_ _2107_ _2108_ _2109_ VGND VGND VPWR VPWR _2110_ sky130_fd_sc_hd__o2111a_1
X_5926_ _0936_ _0942_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__nand2_1
X_5857_ _0882_ _0893_ _0895_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_75_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5788_ net147 net183 VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__or2b_1
XFILLER_0_8_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4808_ net161 net91 VGND VGND VPWR VPWR _3974_ sky130_fd_sc_hd__or2b_1
X_7527_ _2712_ _2715_ VGND VGND VPWR VPWR _2716_ sky130_fd_sc_hd__xnor2_2
X_4739_ net308 _3900_ _3902_ _3904_ VGND VGND VPWR VPWR _3905_ sky130_fd_sc_hd__a22o_1
XFILLER_0_71_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7458_ net286 _2381_ _2595_ _2639_ VGND VGND VPWR VPWR _2640_ sky130_fd_sc_hd__a22o_1
XFILLER_0_31_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6409_ _1495_ _1500_ VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7389_ _2509_ _2522_ _2518_ VGND VGND VPWR VPWR _2564_ sky130_fd_sc_hd__and3_1
XFILLER_0_101_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_595 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_105_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6760_ _1871_ _1872_ VGND VGND VPWR VPWR _1874_ sky130_fd_sc_hd__nor2_1
X_5711_ _0729_ _0735_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__or2_1
XFILLER_0_85_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6691_ _0269_ net107 VGND VGND VPWR VPWR _1799_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5642_ _0663_ _0665_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__xnor2_1
X_8430_ net336 _0063_ net253 VGND VGND VPWR VPWR delta\[15\] sky130_fd_sc_hd__dfrtp_1
X_8361_ delta\[11\] counter\[11\] VGND VGND VPWR VPWR _3621_ sky130_fd_sc_hd__nand2_1
X_5573_ _0548_ _0596_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4524_ _3686_ _3687_ VGND VGND VPWR VPWR _3690_ sky130_fd_sc_hd__nor2_1
X_7312_ _2478_ _2479_ VGND VGND VPWR VPWR _2480_ sky130_fd_sc_hd__xor2_2
X_8292_ counter\[0\] _3552_ _3556_ _3557_ VGND VGND VPWR VPWR _3558_ sky130_fd_sc_hd__a211o_1
X_4455_ net159 net400 VGND VGND VPWR VPWR _3445_ sky130_fd_sc_hd__or2b_1
XFILLER_0_13_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7243_ _2399_ _2402_ _2392_ VGND VGND VPWR VPWR _2404_ sky130_fd_sc_hd__a21oi_1
X_4386_ _2279_ _2675_ _2301_ VGND VGND VPWR VPWR _2686_ sky130_fd_sc_hd__a21o_1
X_7174_ _2324_ _2326_ _2327_ VGND VGND VPWR VPWR _2328_ sky130_fd_sc_hd__a21oi_2
X_6125_ _1189_ _1190_ VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__nor2_1
X_6056_ net109 net284 VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__and2b_1
X_5007_ _4165_ _4171_ _4172_ VGND VGND VPWR VPWR _4173_ sky130_fd_sc_hd__a21o_1
X_6958_ _1545_ _1623_ VGND VGND VPWR VPWR _2091_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6889_ _1977_ _1984_ VGND VGND VPWR VPWR _2015_ sky130_fd_sc_hd__nand2_1
X_5909_ net111 net311 VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__or2b_1
XFILLER_0_91_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_15_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_24_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_86_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_98_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_510 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_33_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4240_ net79 _0756_ _1075_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__and3_1
XFILLER_0_93_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7930_ _2754_ _2757_ VGND VGND VPWR VPWR _3160_ sky130_fd_sc_hd__nand2_1
X_7861_ _3065_ _3081_ _3083_ VGND VGND VPWR VPWR _3084_ sky130_fd_sc_hd__a21oi_1
X_6812_ _1930_ _0870_ VGND VGND VPWR VPWR _1931_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7792_ _2998_ _2996_ VGND VGND VPWR VPWR _3008_ sky130_fd_sc_hd__or2b_1
XFILLER_0_85_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6743_ _3885_ net143 VGND VGND VPWR VPWR _1855_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6674_ _1780_ _1781_ VGND VGND VPWR VPWR _1782_ sky130_fd_sc_hd__xnor2_1
X_5625_ _0626_ _0629_ _0648_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_45_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_598 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5556_ _0579_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__inv_2
X_8344_ delta\[6\] net79 _3605_ VGND VGND VPWR VPWR _3606_ sky130_fd_sc_hd__o21ai_1
X_5487_ _0509_ _0510_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__nor2_1
X_8275_ counter\[10\] _3512_ _3537_ net77 VGND VGND VPWR VPWR _3539_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_41_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4507_ _3672_ net98 net118 _3667_ VGND VGND VPWR VPWR _3673_ sky130_fd_sc_hd__a22o_1
X_4438_ _3203_ _3247_ _3236_ VGND VGND VPWR VPWR _3258_ sky130_fd_sc_hd__a21o_1
X_7226_ net215 _2381_ _2384_ VGND VGND VPWR VPWR _2385_ sky130_fd_sc_hd__and3_1
XFILLER_0_6_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4369_ net158 net194 net265 net273 VGND VGND VPWR VPWR _2499_ sky130_fd_sc_hd__and4bb_1
X_7157_ net225 net154 VGND VGND VPWR VPWR _2309_ sky130_fd_sc_hd__and2b_1
X_6108_ _1162_ _1165_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__nand2_1
X_7088_ net204 net207 net268 net277 VGND VGND VPWR VPWR _2233_ sky130_fd_sc_hd__or4bb_1
X_6039_ _3641_ net50 VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__nor2_1
XFILLER_0_96_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer50 _3799_ VGND VGND VPWR VPWR net424 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_68_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_19 net293 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_12_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5410_ _0418_ _0425_ _0416_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_42_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6390_ _1477_ _1480_ VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__xor2_2
X_5341_ _3584_ _3650_ _0361_ _0363_ _0364_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__a32o_1
XFILLER_0_10_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8060_ _3296_ _3301_ VGND VGND VPWR VPWR _3303_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_10_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7011_ _2142_ _2143_ _2148_ VGND VGND VPWR VPWR _2149_ sky130_fd_sc_hd__a21oi_1
X_5272_ _0294_ _0295_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__nor2_1
X_4223_ net76 _0800_ _0888_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__and3_1
X_8384__1 clknet_2_0__leaf_clk VGND VGND VPWR VPWR net322 sky130_fd_sc_hd__inv_2
XFILLER_0_37_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7913_ _3089_ _3097_ _3136_ _3140_ VGND VGND VPWR VPWR _3141_ sky130_fd_sc_hd__and4_1
X_7844_ _3000_ _3064_ VGND VGND VPWR VPWR _3065_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_92_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7775_ _2925_ _2986_ _2988_ VGND VGND VPWR VPWR _2989_ sky130_fd_sc_hd__a21oi_1
X_6726_ _1792_ _1802_ VGND VGND VPWR VPWR _1836_ sky130_fd_sc_hd__nand2_1
X_4987_ _4037_ net84 net91 _4038_ VGND VGND VPWR VPWR _4153_ sky130_fd_sc_hd__a22o_1
XFILLER_0_46_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6657_ _1733_ _1764_ VGND VGND VPWR VPWR _1765_ sky130_fd_sc_hd__nor2_1
X_5608_ _0617_ _0621_ _0631_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__a21o_1
X_6588_ net126 net99 VGND VGND VPWR VPWR _1696_ sky130_fd_sc_hd__or2b_1
XFILLER_0_103_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5539_ _0561_ _0562_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__and2_1
X_8327_ _3589_ _3590_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8258_ _2080_ _3517_ _3519_ VGND VGND VPWR VPWR _3520_ sky130_fd_sc_hd__a21o_1
X_8189_ net245 net229 VGND VGND VPWR VPWR _3444_ sky130_fd_sc_hd__nand2_1
Xfanout320 net321 VGND VGND VPWR VPWR net320 sky130_fd_sc_hd__buf_4
X_7209_ _2278_ _2262_ VGND VGND VPWR VPWR _2366_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_96_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_554 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput17 rstb VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_64_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput28 vA[4] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_1
Xinput39 vB[14] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__buf_4
XFILLER_0_52_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4910_ _4036_ _4040_ VGND VGND VPWR VPWR _4076_ sky130_fd_sc_hd__xnor2_1
X_5890_ net301 _0926_ _0928_ _0931_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__nand4_2
XFILLER_0_87_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4841_ _3933_ _3936_ VGND VGND VPWR VPWR _4007_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7560_ _2745_ _2751_ VGND VGND VPWR VPWR _2753_ sky130_fd_sc_hd__xor2_2
X_4772_ _3933_ _3936_ _3937_ VGND VGND VPWR VPWR _3938_ sky130_fd_sc_hd__a21oi_2
X_7491_ _2673_ _2674_ _2676_ _0458_ net29 VGND VGND VPWR VPWR _2677_ sky130_fd_sc_hd__a2111o_1
X_6511_ _1611_ _1614_ VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_99_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6442_ _1532_ _1538_ VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_2_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8112_ _3358_ _3359_ VGND VGND VPWR VPWR _3360_ sky130_fd_sc_hd__xnor2_1
X_6373_ _1211_ _1460_ _1461_ _1462_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__and4b_1
X_5324_ _3601_ _3649_ _0347_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_11_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5255_ _0932_ net189 net188 _3885_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__o22a_1
X_8043_ _3282_ _3283_ VGND VGND VPWR VPWR _3284_ sky130_fd_sc_hd__xor2_1
X_4206_ net90 net95 net320 VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__or3_1
XFILLER_0_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5186_ counter\[3\] _0207_ _0209_ net81 VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__o22a_1
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7827_ net94 _2678_ VGND VGND VPWR VPWR _3046_ sky130_fd_sc_hd__nand2_1
XFILLER_0_81_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7758_ _2967_ _2968_ VGND VGND VPWR VPWR _2970_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6709_ _1814_ _1816_ VGND VGND VPWR VPWR _1817_ sky130_fd_sc_hd__xor2_2
X_7689_ _2879_ _2880_ VGND VGND VPWR VPWR _2894_ sky130_fd_sc_hd__nor2_1
XFILLER_0_61_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout183 net184 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout150 net157 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__buf_8
Xfanout161 net49 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__buf_2
Xfanout172 net173 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__buf_2
Xfanout194 net35 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_7_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5040_ _4189_ _4190_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__xnor2_2
X_6991_ net231 VGND VGND VPWR VPWR _2127_ sky130_fd_sc_hd__inv_2
X_5942_ _0982_ _0989_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__xnor2_1
X_5873_ _0911_ _0912_ _0913_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__a21oi_2
X_7612_ net221 net286 VGND VGND VPWR VPWR _2810_ sky130_fd_sc_hd__or2b_1
X_4824_ net175 net256 VGND VGND VPWR VPWR _3990_ sky130_fd_sc_hd__or2b_1
XFILLER_0_16_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4755_ net175 net237 VGND VGND VPWR VPWR _3921_ sky130_fd_sc_hd__or2b_1
X_7543_ _2666_ _2733_ VGND VGND VPWR VPWR _2734_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_16_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7474_ _2652_ _2654_ VGND VGND VPWR VPWR _2658_ sky130_fd_sc_hd__nor2_1
X_4686_ _3849_ _3851_ VGND VGND VPWR VPWR _3852_ sky130_fd_sc_hd__xor2_2
X_6425_ net95 _0684_ VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__nand2_1
X_6356_ _1401_ _1414_ VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__nor2_1
X_5307_ _0244_ _0254_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__xor2_1
X_8026_ _3259_ _3264_ VGND VGND VPWR VPWR _3265_ sky130_fd_sc_hd__xnor2_1
X_6287_ _1293_ _1365_ _1367_ VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__a21oi_1
X_5238_ net151 _2115_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5169_ _0190_ _0191_ _0192_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__o21a_1
XFILLER_0_98_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_627 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_89_Left_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4540_ _3703_ _3705_ VGND VGND VPWR VPWR _3706_ sky130_fd_sc_hd__xor2_1
X_4471_ net172 _3566_ VGND VGND VPWR VPWR _3610_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6210_ _1281_ _1282_ VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7190_ _2341_ _2343_ _2340_ VGND VGND VPWR VPWR _2346_ sky130_fd_sc_hd__a21o_1
X_6141_ _1200_ _1208_ VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6072_ _1013_ _1072_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__nor2_1
X_5023_ _4187_ _4188_ VGND VGND VPWR VPWR _4189_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_88_571 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6974_ net80 _2106_ VGND VGND VPWR VPWR _2109_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5925_ _0951_ _0969_ _0970_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__a21oi_1
X_5856_ _0837_ _0894_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4807_ net190 _1229_ VGND VGND VPWR VPWR _3973_ sky130_fd_sc_hd__nor2_1
XFILLER_0_35_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5787_ net105 net152 VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__or2b_1
XFILLER_0_28_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7526_ _2713_ _2714_ VGND VGND VPWR VPWR _2715_ sky130_fd_sc_hd__nor2_1
X_4738_ _3903_ _3899_ VGND VGND VPWR VPWR _3904_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7457_ _2596_ _2516_ VGND VGND VPWR VPWR _2639_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4669_ _3815_ _3816_ _3834_ VGND VGND VPWR VPWR _3835_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6408_ _1495_ _1500_ VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__nand2_1
X_7388_ _2561_ _2562_ VGND VGND VPWR VPWR _2563_ sky130_fd_sc_hd__xor2_2
X_6339_ _1408_ _1424_ VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__xnor2_1
X_8009_ net101 _2883_ _3164_ VGND VGND VPWR VPWR _3246_ sky130_fd_sc_hd__and3_1
XFILLER_0_98_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_97_Left_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_622 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5710_ _1503_ net105 _0700_ _0733_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__o31a_1
X_6690_ _1796_ _1708_ _1797_ VGND VGND VPWR VPWR _1798_ sky130_fd_sc_hd__a21o_1
X_5641_ _0664_ _0645_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8360_ delta\[11\] counter\[11\] VGND VGND VPWR VPWR _3620_ sky130_fd_sc_hd__nor2_1
X_5572_ _0569_ _0594_ _0595_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_72_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8291_ net82 _3554_ VGND VGND VPWR VPWR _3557_ sky130_fd_sc_hd__nor2_1
X_4523_ _3049_ _3038_ VGND VGND VPWR VPWR _3689_ sky130_fd_sc_hd__xnor2_1
X_7311_ _2412_ _2416_ _2415_ VGND VGND VPWR VPWR _2479_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_25_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7242_ _2392_ _2399_ _2402_ VGND VGND VPWR VPWR _2403_ sky130_fd_sc_hd__and3_1
X_4454_ _3412_ _3423_ VGND VGND VPWR VPWR _3434_ sky130_fd_sc_hd__nor2_1
X_4385_ _2290_ _2093_ VGND VGND VPWR VPWR _2675_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7173_ _2305_ _2322_ VGND VGND VPWR VPWR _2327_ sky130_fd_sc_hd__nor2_1
X_6124_ _1179_ _1184_ _1188_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__and3_1
X_6055_ net12 _0868_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__nand2_1
X_5006_ _4163_ _4164_ VGND VGND VPWR VPWR _4172_ sky130_fd_sc_hd__nor2_1
XFILLER_0_95_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6957_ counter\[3\] _2087_ _2089_ net81 VGND VGND VPWR VPWR _2090_ sky130_fd_sc_hd__o22ai_1
X_6888_ _1974_ _1976_ VGND VGND VPWR VPWR _2014_ sky130_fd_sc_hd__or2b_1
X_5908_ _3901_ net107 VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__nor2_1
XFILLER_0_36_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5839_ _0874_ _0875_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7509_ _2687_ _2695_ VGND VGND VPWR VPWR _2696_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_31_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8401__18 clknet_2_0__leaf_clk VGND VGND VPWR VPWR net339 sky130_fd_sc_hd__inv_2
XFILLER_0_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7860_ _3079_ _3080_ VGND VGND VPWR VPWR _3083_ sky130_fd_sc_hd__nor2_1
XFILLER_0_89_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6811_ net153 _0868_ VGND VGND VPWR VPWR _1930_ sky130_fd_sc_hd__nand2_1
X_7791_ _3004_ _3006_ VGND VGND VPWR VPWR _3007_ sky130_fd_sc_hd__xor2_1
X_6742_ _1794_ _1801_ _1853_ VGND VGND VPWR VPWR _1854_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_85_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6673_ _2268_ net142 VGND VGND VPWR VPWR _1781_ sky130_fd_sc_hd__nor2_1
XFILLER_0_18_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5624_ _0453_ _0646_ _0647_ _1503_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__a211o_1
X_8343_ delta\[6\] counter\[6\] _3600_ VGND VGND VPWR VPWR _3605_ sky130_fd_sc_hd__a21o_1
XFILLER_0_26_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5555_ _0577_ _0578_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__and2_1
XFILLER_0_60_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5486_ _0503_ _0507_ _0508_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__and3_1
X_8274_ net77 _3537_ _3534_ net78 VGND VGND VPWR VPWR _3538_ sky130_fd_sc_hd__o22ai_1
X_4506_ net175 VGND VGND VPWR VPWR _3672_ sky130_fd_sc_hd__inv_2
X_4437_ _3214_ _3225_ _3236_ VGND VGND VPWR VPWR _3247_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_13_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7225_ _2382_ _2342_ _2383_ VGND VGND VPWR VPWR _2384_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_1_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7156_ net251 net121 VGND VGND VPWR VPWR _2308_ sky130_fd_sc_hd__and2b_1
X_4368_ net194 net273 VGND VGND VPWR VPWR _2488_ sky130_fd_sc_hd__or2b_1
X_6107_ _1167_ _1170_ VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__xnor2_2
X_4299_ net417 _1657_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__xnor2_1
X_7087_ net204 net276 VGND VGND VPWR VPWR _2232_ sky130_fd_sc_hd__and2b_1
X_6038_ net180 _0909_ _1038_ _1037_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__a31o_1
Xrebuffer51 _2798_ VGND VGND VPWR VPWR net425 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer40 _3858_ VGND VGND VPWR VPWR net421 sky130_fd_sc_hd__buf_6
X_7989_ net199 net186 VGND VGND VPWR VPWR _3224_ sky130_fd_sc_hd__or2b_1
XFILLER_0_76_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_87_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5340_ _0353_ _0354_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__xor2_1
XFILLER_0_11_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5271_ _0263_ _0290_ _0293_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__nor3_1
X_4222_ _0800_ _0888_ net76 VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__a21oi_1
X_7010_ _2145_ _2146_ VGND VGND VPWR VPWR _2148_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7912_ _3113_ _3135_ _3138_ _3139_ VGND VGND VPWR VPWR _3140_ sky130_fd_sc_hd__a22o_1
XFILLER_0_77_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7843_ net320 _2678_ _3063_ _3062_ VGND VGND VPWR VPWR _3064_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_93_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7774_ _2924_ _2987_ VGND VGND VPWR VPWR _2988_ sky130_fd_sc_hd__nor2_1
X_4986_ _2115_ net317 VGND VGND VPWR VPWR _4152_ sky130_fd_sc_hd__nand2_1
X_6725_ _1768_ _1809_ _1834_ VGND VGND VPWR VPWR _1835_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_85_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6656_ net305 _0685_ _1734_ VGND VGND VPWR VPWR _1764_ sky130_fd_sc_hd__and3_1
X_5607_ _0629_ _0630_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__nand2_1
X_6587_ net115 net118 VGND VGND VPWR VPWR _1695_ sky130_fd_sc_hd__or2b_1
X_5538_ _0559_ _0560_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__or2_1
X_8326_ _3582_ _3583_ _3585_ VGND VGND VPWR VPWR _3590_ sky130_fd_sc_hd__o21a_1
X_8257_ net79 _3518_ VGND VGND VPWR VPWR _3519_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_52_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5469_ net119 _3751_ _2378_ net152 VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__a22o_1
X_7208_ _2328_ _2364_ VGND VGND VPWR VPWR _2365_ sky130_fd_sc_hd__xor2_2
X_8188_ _3441_ _3442_ VGND VGND VPWR VPWR _3443_ sky130_fd_sc_hd__nor2_1
Xfanout310 net10 VGND VGND VPWR VPWR net310 sky130_fd_sc_hd__clkbuf_4
Xfanout321 net1 VGND VGND VPWR VPWR net321 sky130_fd_sc_hd__buf_2
X_7139_ net251 net185 VGND VGND VPWR VPWR _2289_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_61_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput18 vA[0] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_37_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput29 vA[5] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_70_Left_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4840_ _4003_ _4004_ _4005_ VGND VGND VPWR VPWR _4006_ sky130_fd_sc_hd__a21oi_1
X_4771_ _3931_ _3932_ VGND VGND VPWR VPWR _3937_ sky130_fd_sc_hd__nor2_1
X_6510_ _1507_ _1529_ _1612_ VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__a21o_1
XFILLER_0_99_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7490_ net220 net27 net101 net121 VGND VGND VPWR VPWR _2676_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_43_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6441_ _1535_ _1537_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__nor2_1
X_6372_ _1452_ _1453_ _1457_ _1458_ VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__o2bb2a_1
X_5323_ _3643_ _3648_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__nand2_1
X_8111_ net101 _2216_ _3248_ VGND VGND VPWR VPWR _3359_ sky130_fd_sc_hd__and3_1
XFILLER_0_11_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5254_ net265 _2950_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__nand2_1
X_8042_ _3232_ _3233_ _3234_ VGND VGND VPWR VPWR _3283_ sky130_fd_sc_hd__o21ba_1
X_5185_ _0205_ _0208_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__nand2_1
XFILLER_0_64_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7826_ _3042_ _3044_ VGND VGND VPWR VPWR _3045_ sky130_fd_sc_hd__xor2_1
XFILLER_0_78_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4969_ _4132_ _4133_ _4134_ VGND VGND VPWR VPWR _4135_ sky130_fd_sc_hd__a21oi_4
X_7757_ _2967_ _2968_ VGND VGND VPWR VPWR _2969_ sky130_fd_sc_hd__xor2_1
XFILLER_0_80_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6708_ _1632_ _1750_ _1815_ VGND VGND VPWR VPWR _1816_ sky130_fd_sc_hd__a21boi_2
X_7688_ _2888_ _2892_ VGND VGND VPWR VPWR _2893_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_104_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6639_ net314 net134 _1745_ VGND VGND VPWR VPWR _1747_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_61_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8309_ _1503_ net23 _2161_ _2172_ _3575_ VGND VGND VPWR VPWR _3576_ sky130_fd_sc_hd__o311a_1
Xfanout140 net141 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__clkbuf_4
Xfanout151 net152 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__clkbuf_2
Xfanout162 net48 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__buf_4
Xfanout173 net43 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__buf_2
Xfanout184 net4 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout195 net35 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_57_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6990_ net73 _2045_ _2124_ _2125_ VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__a22o_1
X_5941_ _0983_ _0988_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_48_628 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5872_ net128 net131 net271 net281 VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4823_ net197 net237 VGND VGND VPWR VPWR _3989_ sky130_fd_sc_hd__or2b_1
X_7611_ _2622_ _2808_ VGND VGND VPWR VPWR _2809_ sky130_fd_sc_hd__and2_1
XFILLER_0_16_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4754_ net197 net209 VGND VGND VPWR VPWR _3920_ sky130_fd_sc_hd__or2b_1
X_7542_ _2668_ _2732_ VGND VGND VPWR VPWR _2733_ sky130_fd_sc_hd__xor2_2
X_7473_ _2629_ _2656_ VGND VGND VPWR VPWR _2657_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4685_ _3850_ _3773_ VGND VGND VPWR VPWR _3851_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_3_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6424_ _1517_ _1518_ VGND VGND VPWR VPWR _1519_ sky130_fd_sc_hd__xor2_2
XFILLER_0_11_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6355_ _1417_ _1412_ _1416_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__a21bo_1
X_5306_ _0289_ _0296_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__xnor2_1
X_6286_ _1291_ _1366_ VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__nor2_1
X_5237_ _0211_ _0215_ _0214_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__a21bo_1
X_8025_ _3261_ _3263_ VGND VGND VPWR VPWR _3264_ sky130_fd_sc_hd__xnor2_1
X_5168_ _4169_ _4176_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__xor2_1
XFILLER_0_98_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5099_ _3997_ net316 VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7809_ _4035_ net219 VGND VGND VPWR VPWR _3026_ sky130_fd_sc_hd__or2_1
XFILLER_0_19_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_104_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4470_ net400 _2115_ _3313_ _3593_ VGND VGND VPWR VPWR _3601_ sky130_fd_sc_hd__a31o_1
XFILLER_0_13_528 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6140_ _1204_ _1157_ VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_594 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8407__24 clknet_2_3__leaf_clk VGND VGND VPWR VPWR net345 sky130_fd_sc_hd__inv_2
X_6071_ _1054_ _1060_ _1131_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__a21bo_1
X_5022_ _4152_ _4154_ VGND VGND VPWR VPWR _4188_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_45_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6973_ net79 _2077_ _2102_ counter\[5\] VGND VGND VPWR VPWR _2108_ sky130_fd_sc_hd__a22oi_1
X_5924_ _0935_ _0950_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__nor2_1
X_5855_ _0835_ _0836_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__or2_1
XFILLER_0_75_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4806_ _3970_ _3971_ VGND VGND VPWR VPWR _3972_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_90_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5786_ _0269_ net143 VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_566 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7525_ net288 net297 _2127_ _2129_ VGND VGND VPWR VPWR _2714_ sky130_fd_sc_hd__and4_1
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4737_ net161 net310 VGND VGND VPWR VPWR _3903_ sky130_fd_sc_hd__and2b_1
XFILLER_0_9_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7456_ _2635_ _2637_ VGND VGND VPWR VPWR _2638_ sky130_fd_sc_hd__xor2_2
X_4668_ _3817_ _3833_ VGND VGND VPWR VPWR _3834_ sky130_fd_sc_hd__and2b_1
X_6407_ _1496_ _1499_ VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_101_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4599_ _3762_ _3764_ VGND VGND VPWR VPWR _3765_ sky130_fd_sc_hd__xnor2_2
X_7387_ _2300_ _2303_ VGND VGND VPWR VPWR _2562_ sky130_fd_sc_hd__xnor2_2
X_6338_ _2422_ net50 VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__nor2_1
X_6269_ _1301_ _1346_ _1347_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__a21boi_1
X_8008_ _0458_ net32 VGND VGND VPWR VPWR _3245_ sky130_fd_sc_hd__nor2_1
XFILLER_0_98_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_89_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5640_ _0632_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__inv_2
XFILLER_0_72_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5571_ _0549_ _0568_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8290_ net82 _3554_ VGND VGND VPWR VPWR _3556_ sky130_fd_sc_hd__and2_1
X_4522_ _3686_ _3687_ VGND VGND VPWR VPWR _3688_ sky130_fd_sc_hd__xor2_2
X_7310_ _2472_ _2476_ VGND VGND VPWR VPWR _2478_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_5_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_79_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4453_ _3390_ _3401_ VGND VGND VPWR VPWR _3423_ sky130_fd_sc_hd__and2_1
X_7241_ _2340_ _2341_ _2401_ _2398_ VGND VGND VPWR VPWR _2402_ sky130_fd_sc_hd__a211o_1
X_4384_ _2609_ _2631_ _2653_ VGND VGND VPWR VPWR _2664_ sky130_fd_sc_hd__a21o_1
X_7172_ _2222_ _2325_ VGND VGND VPWR VPWR _2326_ sky130_fd_sc_hd__xnor2_2
X_6123_ _1179_ _1184_ _1188_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__a21oi_2
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6054_ _1055_ _1112_ _1058_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__o21ai_2
X_5005_ _4169_ _4170_ VGND VGND VPWR VPWR _4171_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6956_ net397 _2084_ VGND VGND VPWR VPWR _2089_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5907_ _0935_ _0950_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__xor2_1
X_6887_ net267 net135 _1981_ _2012_ VGND VGND VPWR VPWR _2013_ sky130_fd_sc_hd__a31o_1
XFILLER_0_76_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5838_ _0816_ _0825_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__xor2_1
XFILLER_0_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5769_ _0791_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__inv_2
XFILLER_0_91_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7508_ _2688_ _2694_ VGND VGND VPWR VPWR _2695_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_102_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7439_ net248 net93 VGND VGND VPWR VPWR _2619_ sky130_fd_sc_hd__or2b_1
XFILLER_0_31_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8398__15 clknet_2_2__leaf_clk VGND VGND VPWR VPWR net336 sky130_fd_sc_hd__inv_2
XFILLER_0_94_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_105_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6810_ _1838_ _1842_ _1841_ VGND VGND VPWR VPWR _1929_ sky130_fd_sc_hd__a21bo_1
X_7790_ _2957_ _2958_ VGND VGND VPWR VPWR _3006_ sky130_fd_sc_hd__xor2_1
XFILLER_0_92_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6741_ _1795_ _1800_ VGND VGND VPWR VPWR _1853_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_564 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6672_ _1777_ _1778_ _1779_ VGND VGND VPWR VPWR _1780_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_58_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5623_ net39 _0623_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8342_ _3602_ _3603_ VGND VGND VPWR VPWR _3604_ sky130_fd_sc_hd__and2b_1
X_5554_ _0575_ _0576_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5485_ _0503_ _0507_ _0508_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__a21oi_1
X_8273_ _3481_ _3536_ VGND VGND VPWR VPWR _3537_ sky130_fd_sc_hd__xnor2_1
X_4505_ _1459_ net42 _3656_ VGND VGND VPWR VPWR _3671_ sky130_fd_sc_hd__or3_4
XFILLER_0_13_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4436_ net172 net169 net117 net150 VGND VGND VPWR VPWR _3236_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_1_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7224_ net220 net223 net154 net185 VGND VGND VPWR VPWR _2383_ sky130_fd_sc_hd__and4bb_1
X_4367_ net158 net265 VGND VGND VPWR VPWR _2477_ sky130_fd_sc_hd__or2b_1
X_7155_ net185 _2286_ VGND VGND VPWR VPWR _2307_ sky130_fd_sc_hd__nand2_2
XFILLER_0_6_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6106_ _0930_ _1168_ _1169_ VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__a21oi_2
X_4298_ net411 _1657_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__xnor2_1
X_7086_ net207 net268 VGND VGND VPWR VPWR _2231_ sky130_fd_sc_hd__and2b_1
X_6037_ _1040_ _1048_ _1093_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__a21boi_2
Xrebuffer30 net382 VGND VGND VPWR VPWR net383 sky130_fd_sc_hd__clkbuf_1
Xrebuffer52 _3217_ VGND VGND VPWR VPWR net426 sky130_fd_sc_hd__dlymetal6s4s_1
Xrebuffer41 _1759_ VGND VGND VPWR VPWR net394 sky130_fd_sc_hd__clkbuf_1
X_7988_ _0932_ net236 VGND VGND VPWR VPWR _3223_ sky130_fd_sc_hd__nor2_1
XFILLER_0_95_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6939_ _0902_ _2065_ _2036_ VGND VGND VPWR VPWR _2070_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_49_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_106_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_86_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5270_ _0263_ _0290_ _0293_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__o21a_1
X_4221_ net186 _0789_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__nand2_1
X_7911_ _3065_ _3081_ VGND VGND VPWR VPWR _3139_ sky130_fd_sc_hd__nand2_1
X_7842_ _3028_ _3061_ _3062_ VGND VGND VPWR VPWR _3063_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_93_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7773_ net222 net312 VGND VGND VPWR VPWR _2987_ sky130_fd_sc_hd__or2b_1
X_4985_ net163 _1873_ _4150_ VGND VGND VPWR VPWR _4151_ sky130_fd_sc_hd__or3_1
XFILLER_0_92_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6724_ _1806_ _1808_ VGND VGND VPWR VPWR _1834_ sky130_fd_sc_hd__or2b_1
XFILLER_0_73_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6655_ _1721_ _1736_ _1762_ VGND VGND VPWR VPWR _1763_ sky130_fd_sc_hd__a21o_1
XFILLER_0_103_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5606_ _0622_ _0628_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__nand2_1
X_6586_ _0458_ net61 VGND VGND VPWR VPWR _1694_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5537_ _0559_ _0560_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__nand2_1
X_8325_ _3587_ _3588_ VGND VGND VPWR VPWR _3589_ sky130_fd_sc_hd__and2b_1
XFILLER_0_14_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8256_ _3374_ _3515_ VGND VGND VPWR VPWR _3518_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_41_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5468_ net119 _2378_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__nand2_1
X_7207_ _2349_ _2363_ VGND VGND VPWR VPWR _2364_ sky130_fd_sc_hd__xnor2_2
X_8187_ _3438_ _3439_ _3440_ VGND VGND VPWR VPWR _3442_ sky130_fd_sc_hd__and3_1
X_5399_ _3724_ net399 _3799_ net387 VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__a211o_1
X_4419_ _2444_ _2565_ _2543_ VGND VGND VPWR VPWR _3049_ sky130_fd_sc_hd__a21o_1
Xfanout311 net315 VGND VGND VPWR VPWR net311 sky130_fd_sc_hd__buf_2
Xfanout300 net307 VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__clkbuf_2
X_7138_ net225 net215 VGND VGND VPWR VPWR _2288_ sky130_fd_sc_hd__or2b_1
X_7069_ _2176_ _2207_ _2211_ VGND VGND VPWR VPWR _2212_ sky130_fd_sc_hd__and3_1
XFILLER_0_91_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput19 vA[10] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__buf_1
XFILLER_0_52_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4770_ _3934_ _3935_ VGND VGND VPWR VPWR _3936_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6440_ _1533_ _1274_ _1534_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__and3_1
XFILLER_0_70_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6371_ _1206_ _1209_ _1210_ VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__nand3_1
XFILLER_0_101_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5322_ net284 _3082_ _0251_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__and3_1
X_8110_ _3353_ _3356_ VGND VGND VPWR VPWR _3358_ sky130_fd_sc_hd__xnor2_1
X_5253_ _0275_ _0276_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__xor2_1
X_8041_ _3239_ _3242_ _3281_ VGND VGND VPWR VPWR _3282_ sky130_fd_sc_hd__a21oi_1
X_5184_ _3876_ _0204_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__or2_1
XFILLER_0_3_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7825_ _3043_ _2979_ VGND VGND VPWR VPWR _3044_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_93_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4968_ net174 net196 net272 net280 VGND VGND VPWR VPWR _4134_ sky130_fd_sc_hd__and4bb_1
X_7756_ _2898_ _2905_ VGND VGND VPWR VPWR _2968_ sky130_fd_sc_hd__xor2_1
X_6707_ _1749_ _1689_ VGND VGND VPWR VPWR _1815_ sky130_fd_sc_hd__or2b_1
X_7687_ _2889_ _2891_ VGND VGND VPWR VPWR _2892_ sky130_fd_sc_hd__xor2_1
X_4899_ _4060_ _4061_ VGND VGND VPWR VPWR _4065_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_515 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6638_ net314 net134 _1745_ VGND VGND VPWR VPWR _1746_ sky130_fd_sc_hd__and3_1
X_8308_ _2174_ _3498_ VGND VGND VPWR VPWR _3575_ sky130_fd_sc_hd__or2_1
X_6569_ _1596_ _1597_ _1600_ VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__and3_1
XFILLER_0_42_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8239_ _2174_ _3498_ VGND VGND VPWR VPWR _3499_ sky130_fd_sc_hd__xor2_2
Xfanout130 net133 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__clkbuf_2
Xfanout141 net53 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__clkbuf_4
Xfanout152 net153 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__buf_2
Xfanout163 net165 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__clkbuf_4
Xfanout174 net176 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__buf_2
Xfanout185 net186 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__buf_2
Xfanout196 net198 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5940_ _0984_ _0985_ _0986_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_87_Right_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_87_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5871_ net128 net281 VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__or2b_1
X_7610_ _2617_ _2621_ _2618_ VGND VGND VPWR VPWR _2808_ sky130_fd_sc_hd__a21bo_1
X_4822_ _3970_ _3987_ _3908_ VGND VGND VPWR VPWR _3988_ sky130_fd_sc_hd__a21oi_4
X_4753_ _3843_ _3868_ VGND VGND VPWR VPWR _3919_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_55_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7541_ _2722_ _2731_ VGND VGND VPWR VPWR _2732_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7472_ _2537_ _2613_ _2628_ VGND VGND VPWR VPWR _2656_ sky130_fd_sc_hd__and3_1
X_4684_ _3667_ net209 VGND VGND VPWR VPWR _3850_ sky130_fd_sc_hd__nand2_1
X_6423_ _1258_ _1263_ _1262_ VGND VGND VPWR VPWR _1518_ sky130_fd_sc_hd__a21oi_2
XPHY_EDGE_ROW_96_Right_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6354_ _1441_ _1419_ VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__xor2_1
XFILLER_0_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5305_ _0258_ _0328_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6285_ net124 net93 VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__or2b_1
X_5236_ _0256_ _0257_ _0259_ _1042_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__o22a_1
X_8024_ _3191_ _3262_ VGND VGND VPWR VPWR _3263_ sky130_fd_sc_hd__nor2_1
XFILLER_0_52_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5167_ _4193_ _0074_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__and2_1
X_5098_ _0119_ _0121_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__xor2_1
XFILLER_0_78_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7808_ _3007_ _3012_ VGND VGND VPWR VPWR _3025_ sky130_fd_sc_hd__xnor2_1
X_7739_ _2946_ _2948_ VGND VGND VPWR VPWR _2949_ sky130_fd_sc_hd__xor2_1
XFILLER_0_19_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6070_ _1061_ _1052_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__or2b_1
X_5021_ _4183_ _4186_ VGND VGND VPWR VPWR _4187_ sky130_fd_sc_hd__nand2_1
X_6972_ counter\[5\] _2102_ _2106_ net80 VGND VGND VPWR VPWR _2107_ sky130_fd_sc_hd__o22a_1
X_5923_ _0958_ _0968_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__xnor2_2
X_5854_ _0891_ _0892_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4805_ _3959_ _3968_ _3969_ VGND VGND VPWR VPWR _3971_ sky130_fd_sc_hd__nand3_1
X_5785_ _0775_ _0776_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__xnor2_1
X_7524_ _1119_ net231 net233 _0927_ VGND VGND VPWR VPWR _2713_ sky130_fd_sc_hd__o22a_1
XFILLER_0_8_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4736_ net191 _3901_ VGND VGND VPWR VPWR _3902_ sky130_fd_sc_hd__nor2_1
X_7455_ _2636_ _2552_ VGND VGND VPWR VPWR _2637_ sky130_fd_sc_hd__xnor2_2
X_4667_ _3825_ _3831_ _3832_ VGND VGND VPWR VPWR _3833_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_43_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7386_ _2557_ _2559_ _2560_ VGND VGND VPWR VPWR _2561_ sky130_fd_sc_hd__a21boi_2
X_6406_ _1245_ _1497_ _1498_ _1244_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__o22a_1
X_4598_ net86 net179 VGND VGND VPWR VPWR _3764_ sky130_fd_sc_hd__nand2_1
X_6337_ _1402_ _1410_ VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__xor2_1
XFILLER_0_12_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6268_ _1345_ _1335_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__or2b_1
X_5219_ _0236_ _0242_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__xnor2_1
X_8007_ _3162_ _3166_ _3165_ VGND VGND VPWR VPWR _3244_ sky130_fd_sc_hd__a21bo_1
X_6199_ _1265_ _1270_ VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_79_540 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_2_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_89_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_543 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5570_ _0586_ _0592_ _0593_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__o21a_1
X_4521_ _3659_ _3660_ VGND VGND VPWR VPWR _3687_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_53_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4452_ _3390_ _3401_ VGND VGND VPWR VPWR _3412_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7240_ _2342_ _2316_ VGND VGND VPWR VPWR _2401_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4383_ net310 net179 _2642_ VGND VGND VPWR VPWR _2653_ sky130_fd_sc_hd__and3_1
X_7171_ _2238_ _2237_ VGND VGND VPWR VPWR _2325_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6122_ _1186_ _1187_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__xor2_1
X_6053_ _1056_ _1057_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__nor2_1
X_5004_ _4166_ _4159_ _4168_ VGND VGND VPWR VPWR _4170_ sky130_fd_sc_hd__nor3_1
XFILLER_0_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6955_ counter\[3\] _2087_ VGND VGND VPWR VPWR _2088_ sky130_fd_sc_hd__and2_1
X_5906_ _0944_ _0949_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__xnor2_1
X_6886_ _0858_ _1979_ _1978_ VGND VGND VPWR VPWR _2012_ sky130_fd_sc_hd__o21a_1
X_5837_ _0865_ _0871_ _0873_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__o21a_1
XFILLER_0_17_610 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_106_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5768_ _0746_ _0797_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__nand2_1
X_4719_ _2796_ VGND VGND VPWR VPWR _3885_ sky130_fd_sc_hd__buf_4
X_7507_ _2689_ _2693_ VGND VGND VPWR VPWR _2694_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_32_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5699_ net102 net135 _0692_ _0713_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__a22o_1
XFILLER_0_71_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7438_ net319 _2139_ VGND VGND VPWR VPWR _2618_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7369_ _2535_ _2540_ _2541_ VGND VGND VPWR VPWR _2542_ sky130_fd_sc_hd__a21o_1
XFILLER_0_102_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_105_Right_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_502 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6740_ _1776_ _1786_ _1784_ VGND VGND VPWR VPWR _1852_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_85_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6671_ net105 net146 net398 net259 VGND VGND VPWR VPWR _1779_ sky130_fd_sc_hd__and4bb_1
X_5622_ _2378_ _0612_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__nand2_1
X_8341_ delta\[7\] counter\[7\] VGND VGND VPWR VPWR _3603_ sky130_fd_sc_hd__nand2_1
X_5553_ _0575_ _0576_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4504_ _3657_ _3669_ VGND VGND VPWR VPWR _3670_ sky130_fd_sc_hd__xor2_1
X_5484_ _0475_ _0476_ _0477_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__o21ba_1
X_8272_ _3420_ _3424_ VGND VGND VPWR VPWR _3536_ sky130_fd_sc_hd__nor2_1
XFILLER_0_41_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4435_ net169 net150 VGND VGND VPWR VPWR _3225_ sky130_fd_sc_hd__or2b_1
X_7223_ net223 net154 VGND VGND VPWR VPWR _2382_ sky130_fd_sc_hd__or2b_1
X_4366_ _2455_ net191 VGND VGND VPWR VPWR _2466_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7154_ net215 _2287_ _2298_ _2297_ VGND VGND VPWR VPWR _2306_ sky130_fd_sc_hd__a31o_1
XFILLER_0_67_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6105_ net124 net114 net292 net304 VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__and4bb_1
X_4297_ net413 _1657_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__xnor2_1
X_7085_ net285 _2216_ VGND VGND VPWR VPWR _2230_ sky130_fd_sc_hd__nand2_1
X_6036_ _1033_ _1039_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__nand2_1
XFILLER_0_96_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer20 net422 VGND VGND VPWR VPWR net373 sky130_fd_sc_hd__clkbuf_1
Xrebuffer42 net394 VGND VGND VPWR VPWR net395 sky130_fd_sc_hd__clkbuf_1
Xrebuffer53 _2737_ VGND VGND VPWR VPWR net427 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer31 _4126_ VGND VGND VPWR VPWR net384 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_95_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7987_ _3220_ _3171_ _3221_ VGND VGND VPWR VPWR _3222_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_49_532 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6938_ _0906_ _0905_ VGND VGND VPWR VPWR _2069_ sky130_fd_sc_hd__or2b_1
X_6869_ _1902_ _1963_ VGND VGND VPWR VPWR _1993_ sky130_fd_sc_hd__nand2_1
XFILLER_0_91_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_106_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_616 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4220_ counter\[11\] _0866_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__xor2_1
XFILLER_0_37_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7910_ _3065_ _3081_ VGND VGND VPWR VPWR _3138_ sky130_fd_sc_hd__or2_1
XFILLER_0_78_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7841_ _0149_ net219 _3028_ VGND VGND VPWR VPWR _3062_ sky130_fd_sc_hd__nor3_1
XFILLER_0_58_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7772_ net219 net312 VGND VGND VPWR VPWR _2986_ sky130_fd_sc_hd__or2b_1
X_4984_ net167 net91 VGND VGND VPWR VPWR _4150_ sky130_fd_sc_hd__or2b_1
X_6723_ net305 net134 _1766_ _1832_ VGND VGND VPWR VPWR _1833_ sky130_fd_sc_hd__a31o_1
XFILLER_0_46_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6654_ _1737_ _1720_ VGND VGND VPWR VPWR _1762_ sky130_fd_sc_hd__and2b_1
XFILLER_0_6_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5605_ _0622_ _0628_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__or2_1
XFILLER_0_104_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6585_ _1668_ _1679_ _1692_ VGND VGND VPWR VPWR _1693_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_14_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5536_ _0506_ _0504_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__xnor2_1
X_8324_ delta\[3\] counter\[3\] VGND VGND VPWR VPWR _3588_ sky130_fd_sc_hd__nand2_1
X_5467_ _0490_ net39 VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__nor2_1
XFILLER_0_78_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8255_ _3370_ _3516_ VGND VGND VPWR VPWR _3517_ sky130_fd_sc_hd__xor2_2
XFILLER_0_78_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4418_ _2851_ _3027_ VGND VGND VPWR VPWR _3038_ sky130_fd_sc_hd__xnor2_1
X_7206_ _2351_ _2362_ VGND VGND VPWR VPWR _2363_ sky130_fd_sc_hd__xnor2_2
X_8186_ _3438_ _3439_ _3440_ VGND VGND VPWR VPWR _3441_ sky130_fd_sc_hd__a21oi_1
X_5398_ _3724_ net399 VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__or2_1
Xfanout301 net304 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__buf_2
Xfanout312 net315 VGND VGND VPWR VPWR net312 sky130_fd_sc_hd__buf_2
X_4349_ _2268_ net162 VGND VGND VPWR VPWR _2279_ sky130_fd_sc_hd__nor2_1
X_7137_ _2286_ VGND VGND VPWR VPWR _2287_ sky130_fd_sc_hd__clkbuf_4
X_7068_ _2209_ _2210_ VGND VGND VPWR VPWR _2211_ sky130_fd_sc_hd__or2b_1
X_6019_ _1070_ _1073_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_64_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6370_ _1457_ _1458_ VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__nand2_1
X_5321_ _0343_ _0344_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__nand2_1
XFILLER_0_51_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8040_ _3222_ _3238_ VGND VGND VPWR VPWR _3281_ sky130_fd_sc_hd__and2b_1
XFILLER_0_11_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5252_ _0224_ _0228_ _0227_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__a21oi_1
X_5183_ net370 _0206_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__xor2_2
XFILLER_0_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7824_ net302 _2449_ VGND VGND VPWR VPWR _3043_ sky130_fd_sc_hd__nand2_1
X_4967_ net174 net280 VGND VGND VPWR VPWR _4133_ sky130_fd_sc_hd__or2b_1
X_7755_ _2963_ _2965_ _2966_ VGND VGND VPWR VPWR _2967_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6706_ _1761_ _1813_ VGND VGND VPWR VPWR _1814_ sky130_fd_sc_hd__xnor2_2
X_7686_ _2820_ _2890_ VGND VGND VPWR VPWR _2891_ sky130_fd_sc_hd__nand2_1
X_4898_ _4043_ _4063_ VGND VGND VPWR VPWR _4064_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6637_ _1742_ _1744_ VGND VGND VPWR VPWR _1745_ sky130_fd_sc_hd__xor2_1
X_6568_ _1674_ _1675_ VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__xor2_2
XFILLER_0_6_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5519_ _0542_ _0501_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__xor2_1
X_8307_ _3507_ _3513_ _3562_ _3571_ _3573_ VGND VGND VPWR VPWR _3574_ sky130_fd_sc_hd__o32a_1
X_6499_ _1598_ _1600_ VGND VGND VPWR VPWR _1601_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_100_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8238_ _2214_ _3496_ _3497_ VGND VGND VPWR VPWR _3498_ sky130_fd_sc_hd__a21oi_2
Xfanout120 net123 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__buf_2
X_8169_ _3420_ _3421_ VGND VGND VPWR VPWR _3422_ sky130_fd_sc_hd__or2_1
Xfanout131 net133 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__buf_1
Xfanout153 net157 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__clkbuf_4
Xfanout142 net52 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__buf_4
Xfanout164 net165 VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__buf_2
Xfanout186 net4 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__clkbuf_4
Xfanout175 net176 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__clkbuf_4
Xfanout197 net198 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__buf_2
XFILLER_0_69_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_100_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5870_ net131 net271 VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__or2b_1
X_4821_ _3972_ _3986_ VGND VGND VPWR VPWR _3987_ sky130_fd_sc_hd__or2b_1
XFILLER_0_47_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7540_ _2723_ _2729_ VGND VGND VPWR VPWR _2731_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_28_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4752_ net318 net179 _3917_ _3915_ VGND VGND VPWR VPWR _3918_ sky130_fd_sc_hd__a31o_2
XFILLER_0_16_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7471_ _2652_ _2654_ VGND VGND VPWR VPWR _2655_ sky130_fd_sc_hd__xor2_2
X_4683_ _3769_ net237 _3848_ _3847_ VGND VGND VPWR VPWR _3849_ sky130_fd_sc_hd__a31o_1
XFILLER_0_70_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6422_ _1511_ _1516_ VGND VGND VPWR VPWR _1517_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_101_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6353_ _1364_ _1396_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__xnor2_1
X_5304_ net274 net177 VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6284_ _3901_ net114 VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__or2_1
X_5235_ net177 _0258_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__nand2_1
X_8023_ net288 _2163_ _3193_ VGND VGND VPWR VPWR _3262_ sky130_fd_sc_hd__and3_1
XFILLER_0_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_3_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5166_ _0072_ _0073_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__and2b_1
X_5097_ _0120_ _0089_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7807_ _3010_ _3018_ VGND VGND VPWR VPWR _3024_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_19_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5999_ _0993_ _1051_ _0996_ VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__o21ai_1
X_7738_ _2947_ _2867_ VGND VGND VPWR VPWR _2948_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_46_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_49_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7669_ net219 net294 VGND VGND VPWR VPWR _2872_ sky130_fd_sc_hd__or2b_1
XFILLER_0_100_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_58_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_67_Left_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Left_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5020_ _3652_ net84 _4183_ _4185_ VGND VGND VPWR VPWR _4186_ sky130_fd_sc_hd__nand4_2
XFILLER_0_88_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6971_ _2103_ _2105_ VGND VGND VPWR VPWR _2106_ sky130_fd_sc_hd__or2_1
XFILLER_0_88_563 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5922_ _0959_ _0967_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__xor2_1
XFILLER_0_48_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5853_ _0880_ _0881_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_85_Left_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5784_ _0814_ _0815_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__xor2_1
XFILLER_0_28_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4804_ _3959_ _3968_ _3969_ VGND VGND VPWR VPWR _3970_ sky130_fd_sc_hd__a21o_1
X_7523_ net306 _2162_ VGND VGND VPWR VPWR _2712_ sky130_fd_sc_hd__nand2_1
X_4735_ _3827_ VGND VGND VPWR VPWR _3901_ sky130_fd_sc_hd__buf_4
X_7454_ net260 _2286_ VGND VGND VPWR VPWR _2636_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4666_ _3824_ _3823_ VGND VGND VPWR VPWR _3832_ sky130_fd_sc_hd__or2b_1
XFILLER_0_71_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4597_ net86 net179 _3762_ _3760_ VGND VGND VPWR VPWR _3763_ sky130_fd_sc_hd__a31o_1
X_7385_ _2553_ _2556_ VGND VGND VPWR VPWR _2560_ sky130_fd_sc_hd__nand2_1
X_6405_ net112 net257 VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__and2b_1
XFILLER_0_12_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6336_ _1363_ _1421_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_86_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6267_ _1335_ _1345_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_86_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5218_ _0237_ _0241_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__xnor2_2
X_8006_ _3239_ _3242_ VGND VGND VPWR VPWR _3243_ sky130_fd_sc_hd__xor2_1
X_6198_ _1266_ _1269_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__xnor2_1
X_5149_ net198 _4035_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__nor2_1
XFILLER_0_98_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_97_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4520_ _3666_ _3684_ _3685_ VGND VGND VPWR VPWR _3686_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_31_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_103_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4451_ _1119_ net39 VGND VGND VPWR VPWR _3401_ sky130_fd_sc_hd__nor2_1
X_8387__4 clknet_2_1__leaf_clk VGND VGND VPWR VPWR net325 sky130_fd_sc_hd__inv_2
X_7170_ _2305_ _2322_ VGND VGND VPWR VPWR _2324_ sky130_fd_sc_hd__xor2_2
X_4382_ _2609_ _2631_ VGND VGND VPWR VPWR _2642_ sky130_fd_sc_hd__xor2_1
X_6121_ _0952_ _0957_ VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_21_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6052_ _1094_ _1110_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__xor2_2
X_5003_ _4166_ _4159_ _4168_ VGND VGND VPWR VPWR _4169_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_93_Left_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_511 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6954_ _1817_ _2086_ VGND VGND VPWR VPWR _2087_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5905_ _0945_ _0948_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_48_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6885_ _1997_ _2002_ _2007_ _2009_ _2010_ VGND VGND VPWR VPWR _2011_ sky130_fd_sc_hd__o311a_1
XFILLER_0_48_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5836_ _0807_ _0872_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__nor2_1
X_5767_ _0736_ _0743_ _0744_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__nand3_1
XFILLER_0_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5698_ _0715_ _0718_ _0720_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__o21ai_1
X_7506_ _2690_ _2691_ _2692_ VGND VGND VPWR VPWR _2693_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_16_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4718_ net45 _1031_ VGND VGND VPWR VPWR _3884_ sky130_fd_sc_hd__nor2_1
X_7437_ _2528_ _2616_ VGND VGND VPWR VPWR _2617_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4649_ _3804_ _3813_ _3814_ VGND VGND VPWR VPWR _3815_ sky130_fd_sc_hd__a21o_1
XFILLER_0_102_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7368_ _2523_ _2524_ VGND VGND VPWR VPWR _2541_ sky130_fd_sc_hd__xnor2_1
X_6319_ _1374_ _1378_ VGND VGND VPWR VPWR _1403_ sky130_fd_sc_hd__xnor2_1
X_7299_ _2454_ _2464_ VGND VGND VPWR VPWR _2465_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_99_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_98_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6670_ net146 net259 VGND VGND VPWR VPWR _1778_ sky130_fd_sc_hd__or2b_1
X_5621_ _0631_ _0617_ _0621_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__and3_1
XFILLER_0_73_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8340_ delta\[7\] counter\[7\] VGND VGND VPWR VPWR _3602_ sky130_fd_sc_hd__nor2_1
X_5552_ _0327_ _0341_ _0343_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__o21a_1
XFILLER_0_26_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8271_ net78 _3534_ VGND VGND VPWR VPWR _3535_ sky130_fd_sc_hd__and2_1
X_4503_ net98 _3668_ _3656_ VGND VGND VPWR VPWR _3669_ sky130_fd_sc_hd__and3_1
XFILLER_0_26_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5483_ _0504_ _0506_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__or2b_1
X_4434_ net172 net117 VGND VGND VPWR VPWR _3214_ sky130_fd_sc_hd__or2b_1
XFILLER_0_13_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7222_ net29 VGND VGND VPWR VPWR _2381_ sky130_fd_sc_hd__inv_2
X_4365_ net284 VGND VGND VPWR VPWR _2455_ sky130_fd_sc_hd__inv_2
XFILLER_0_1_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7153_ _2300_ _2303_ _2304_ VGND VGND VPWR VPWR _2305_ sky130_fd_sc_hd__a21boi_2
X_6104_ net114 net301 VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__or2b_1
X_7084_ _2223_ _2227_ _2228_ VGND VGND VPWR VPWR _2229_ sky130_fd_sc_hd__a21bo_1
X_4296_ net414 _1657_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__xnor2_1
X_6035_ _1050_ _1062_ _1091_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__a21oi_1
Xrebuffer10 net364 VGND VGND VPWR VPWR net363 sky130_fd_sc_hd__clkbuf_1
Xrebuffer21 _2737_ VGND VGND VPWR VPWR net374 sky130_fd_sc_hd__clkbuf_1
Xrebuffer43 _3794_ VGND VGND VPWR VPWR net396 sky130_fd_sc_hd__buf_6
Xrebuffer32 _4126_ VGND VGND VPWR VPWR net385 sky130_fd_sc_hd__clkbuf_1
Xrebuffer54 _4017_ VGND VGND VPWR VPWR net428 sky130_fd_sc_hd__clkbuf_1
X_7986_ _3167_ _2755_ VGND VGND VPWR VPWR _3221_ sky130_fd_sc_hd__nor2_1
X_6937_ _2058_ _2062_ _2067_ VGND VGND VPWR VPWR _2068_ sky130_fd_sc_hd__or3b_4
XFILLER_0_76_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6868_ _1953_ _1962_ VGND VGND VPWR VPWR _1992_ sky130_fd_sc_hd__or2b_1
XFILLER_0_64_514 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_91_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5819_ _0847_ _0853_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__xor2_1
XFILLER_0_106_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6799_ _1905_ _1915_ VGND VGND VPWR VPWR _1916_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_87_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_506 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7840_ _0149_ net219 VGND VGND VPWR VPWR _3061_ sky130_fd_sc_hd__or2_1
XFILLER_0_77_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7771_ net88 _2678_ VGND VGND VPWR VPWR _2985_ sky130_fd_sc_hd__nand2_1
X_4983_ _4147_ _4148_ VGND VGND VPWR VPWR _4149_ sky130_fd_sc_hd__xor2_2
XFILLER_0_73_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6722_ _1733_ _1764_ _1763_ VGND VGND VPWR VPWR _1832_ sky130_fd_sc_hd__o21a_1
X_6653_ _1742_ _1744_ _1746_ VGND VGND VPWR VPWR _1761_ sky130_fd_sc_hd__a21o_1
X_5604_ _0626_ _0627_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_12_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6584_ _1676_ _1678_ VGND VGND VPWR VPWR _1692_ sky130_fd_sc_hd__nor2_1
XFILLER_0_103_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5535_ _0316_ _0317_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__nor2_1
X_8323_ delta\[3\] counter\[3\] VGND VGND VPWR VPWR _3587_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8254_ _3374_ _3515_ _3377_ VGND VGND VPWR VPWR _3516_ sky130_fd_sc_hd__o21ba_1
X_5466_ _2191_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__buf_4
XFILLER_0_78_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4417_ _2939_ _3016_ VGND VGND VPWR VPWR _3027_ sky130_fd_sc_hd__xor2_1
X_7205_ _2360_ _2361_ VGND VGND VPWR VPWR _2362_ sky130_fd_sc_hd__nand2_1
X_8185_ _3399_ _3400_ _3402_ VGND VGND VPWR VPWR _3440_ sky130_fd_sc_hd__o21ba_1
X_5397_ _0419_ _3798_ _0201_ _0420_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__or4_4
Xfanout302 net304 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_1_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout313 net315 VGND VGND VPWR VPWR net313 sky130_fd_sc_hd__clkbuf_2
X_4348_ net265 VGND VGND VPWR VPWR _2268_ sky130_fd_sc_hd__clkinv_4
X_7136_ net26 VGND VGND VPWR VPWR _2286_ sky130_fd_sc_hd__inv_2
X_7067_ _2196_ _2197_ _2201_ VGND VGND VPWR VPWR _2210_ sky130_fd_sc_hd__o21ai_1
X_4279_ _1426_ _0811_ VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_21_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6018_ _1015_ _1071_ _1072_ _1013_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_68_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7969_ _3198_ _3200_ VGND VGND VPWR VPWR _3202_ sky130_fd_sc_hd__and2_1
XFILLER_0_64_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_30_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer1 _3783_ VGND VGND VPWR VPWR net354 sky130_fd_sc_hd__buf_6
X_5320_ _0342_ _0260_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__or2b_1
X_5251_ _0270_ _0274_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_48_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5182_ _0205_ _3874_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7823_ net312 _2449_ _3041_ _3040_ VGND VGND VPWR VPWR _3042_ sky130_fd_sc_hd__a31o_1
XFILLER_0_80_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7754_ _2960_ _2962_ VGND VGND VPWR VPWR _2966_ sky130_fd_sc_hd__nor2_1
X_6705_ _1810_ _1812_ VGND VGND VPWR VPWR _1813_ sky130_fd_sc_hd__xor2_2
X_4966_ net196 net272 VGND VGND VPWR VPWR _4132_ sky130_fd_sc_hd__or2b_1
XFILLER_0_46_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7685_ net88 _2216_ _2819_ VGND VGND VPWR VPWR _2890_ sky130_fd_sc_hd__a21o_1
X_4897_ _4034_ _4041_ _4042_ VGND VGND VPWR VPWR _4063_ sky130_fd_sc_hd__and3_1
XFILLER_0_61_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6636_ _1743_ _1643_ _1641_ VGND VGND VPWR VPWR _1744_ sky130_fd_sc_hd__a21o_1
XFILLER_0_104_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6567_ net98 _1427_ _1479_ VGND VGND VPWR VPWR _1675_ sky130_fd_sc_hd__and3_1
XFILLER_0_14_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5518_ _0540_ _0541_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__or2_1
X_8306_ _3505_ _3572_ VGND VGND VPWR VPWR _3573_ sky130_fd_sc_hd__nor2_1
X_6498_ _1477_ _1480_ _1599_ VGND VGND VPWR VPWR _1600_ sky130_fd_sc_hd__a21o_1
X_8237_ _2207_ _2211_ _2176_ VGND VGND VPWR VPWR _3497_ sky130_fd_sc_hd__a21oi_1
X_5449_ _0309_ _0310_ _0308_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__a21oi_1
X_8168_ _3417_ _3419_ VGND VGND VPWR VPWR _3421_ sky130_fd_sc_hd__and2_1
Xfanout121 net122 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__buf_4
Xfanout110 net63 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__clkbuf_4
Xfanout143 net52 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__clkbuf_2
Xfanout165 net47 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__clkbuf_2
Xfanout154 net155 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__clkbuf_4
Xfanout132 net133 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__clkbuf_2
X_7119_ _2264_ _2265_ _2266_ VGND VGND VPWR VPWR _2267_ sky130_fd_sc_hd__a21oi_1
X_8099_ _3339_ _3344_ VGND VGND VPWR VPWR _3345_ sky130_fd_sc_hd__xnor2_2
Xfanout187 net38 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__buf_4
Xfanout176 net41 VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__clkbuf_2
Xfanout198 net34 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_96_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_550 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4820_ _3973_ _3985_ _3983_ VGND VGND VPWR VPWR _3986_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_75_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4751_ _3915_ _3916_ VGND VGND VPWR VPWR _3917_ sky130_fd_sc_hd__nor2_2
X_4682_ _3845_ _3846_ _3847_ VGND VGND VPWR VPWR _3848_ sky130_fd_sc_hd__a21oi_1
X_7470_ _2571_ _2573_ VGND VGND VPWR VPWR _2654_ sky130_fd_sc_hd__xnor2_2
X_6421_ _1512_ _1513_ _1515_ VGND VGND VPWR VPWR _1516_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_11_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6352_ _1423_ _1434_ _1439_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__o21ai_1
X_5303_ _0319_ _0326_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__xnor2_1
X_6283_ _1301_ _1346_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__xnor2_2
X_5234_ _0256_ _0257_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__xor2_1
X_8022_ _3177_ _3196_ _3260_ VGND VGND VPWR VPWR _3261_ sky130_fd_sc_hd__a21bo_1
X_5165_ _0075_ _0141_ _0163_ _0188_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5096_ _3668_ net308 VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7806_ _2971_ _2973_ VGND VGND VPWR VPWR _3023_ sky130_fd_sc_hd__or2_1
XFILLER_0_38_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5998_ _0994_ _0995_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__nor2_1
X_7737_ net285 _2287_ VGND VGND VPWR VPWR _2947_ sky130_fd_sc_hd__nand2_1
X_4949_ _4093_ _4114_ VGND VGND VPWR VPWR _4115_ sky130_fd_sc_hd__nor2_1
X_7668_ _2868_ _2870_ VGND VGND VPWR VPWR _2871_ sky130_fd_sc_hd__xor2_2
XFILLER_0_19_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_104_Left_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6619_ _1722_ _1726_ VGND VGND VPWR VPWR _1727_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_61_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7599_ _2788_ _2794_ VGND VGND VPWR VPWR _2795_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_15_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_531 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_88_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6970_ _1824_ _1831_ _1897_ VGND VGND VPWR VPWR _2105_ sky130_fd_sc_hd__and3_1
X_5921_ _0964_ _0966_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5852_ _0889_ _0890_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5783_ _0303_ net55 VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4803_ _3907_ _3910_ VGND VGND VPWR VPWR _3969_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_90_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7522_ _2709_ _2710_ VGND VGND VPWR VPWR _2711_ sky130_fd_sc_hd__xor2_2
XFILLER_0_8_558 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4734_ net161 _3899_ VGND VGND VPWR VPWR _3900_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7453_ net268 _2287_ _2634_ _2633_ VGND VGND VPWR VPWR _2635_ sky130_fd_sc_hd__a31o_2
X_4665_ _3826_ _3830_ VGND VGND VPWR VPWR _3831_ sky130_fd_sc_hd__xnor2_2
X_4596_ _3760_ _3761_ VGND VGND VPWR VPWR _3762_ sky130_fd_sc_hd__and2b_1
XFILLER_0_12_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7384_ _2520_ _2558_ VGND VGND VPWR VPWR _2559_ sky130_fd_sc_hd__and2_1
X_6404_ net110 net257 VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__or2b_2
XFILLER_0_101_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6335_ _1397_ _1419_ _1420_ VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_12_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8005_ _3240_ _3194_ _3241_ VGND VGND VPWR VPWR _3242_ sky130_fd_sc_hd__a21o_1
X_6266_ _1340_ _1344_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__xnor2_2
X_5217_ _0239_ _0240_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__nor2_1
X_6197_ _1267_ _1268_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__nor2_1
X_5148_ _0171_ _0152_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5079_ _4205_ _0064_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_79_575 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4450_ _3368_ _2983_ _3379_ VGND VGND VPWR VPWR _3390_ sky130_fd_sc_hd__a21oi_1
X_4381_ _2620_ _2433_ _2400_ VGND VGND VPWR VPWR _2631_ sky130_fd_sc_hd__a21o_1
X_6120_ net315 _0926_ _1170_ _1169_ VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__a31o_1
XFILLER_0_0_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6051_ _1103_ _1109_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_56_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5002_ _4024_ _4167_ VGND VGND VPWR VPWR _4168_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6953_ net397 _2084_ _2085_ VGND VGND VPWR VPWR _2086_ sky130_fd_sc_hd__a21o_1
X_6884_ _1992_ _1993_ _1991_ VGND VGND VPWR VPWR _2010_ sky130_fd_sc_hd__a21o_1
XFILLER_0_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5904_ _0929_ _0946_ _0947_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__a21oi_1
X_5835_ _1481_ net110 net107 _1426_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__o22a_1
X_5766_ _0794_ _0795_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__nand2_1
XFILLER_0_91_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5697_ _0707_ _0710_ _0719_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__a21o_1
X_7505_ net203 net206 net185 net216 VGND VGND VPWR VPWR _2692_ sky130_fd_sc_hd__and4bb_1
X_4717_ _3878_ _3882_ _3881_ VGND VGND VPWR VPWR _3883_ sky130_fd_sc_hd__a21bo_1
X_7436_ net201 net93 VGND VGND VPWR VPWR _2616_ sky130_fd_sc_hd__or2b_1
XFILLER_0_32_626 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4648_ _3809_ _3812_ VGND VGND VPWR VPWR _3814_ sky130_fd_sc_hd__and2_1
XFILLER_0_102_525 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout1 net299 VGND VGND VPWR VPWR net419 sky130_fd_sc_hd__buf_4
XFILLER_0_31_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7367_ _2536_ _2539_ VGND VGND VPWR VPWR _2540_ sky130_fd_sc_hd__nand2_1
X_4579_ net158 net195 net420 net300 VGND VGND VPWR VPWR _3745_ sky130_fd_sc_hd__and4bb_1
X_6318_ _1366_ _1400_ _1401_ VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__a21oi_1
X_7298_ _2462_ _2463_ VGND VGND VPWR VPWR _2464_ sky130_fd_sc_hd__nand2_1
X_6249_ net87 _0926_ VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_94_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_94_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_526 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5620_ _0639_ _0641_ _0643_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__a21o_1
X_5551_ _0571_ _0574_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_81_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8270_ _3424_ _3532_ VGND VGND VPWR VPWR _3534_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4502_ _3667_ VGND VGND VPWR VPWR _3668_ sky130_fd_sc_hd__buf_4
X_5482_ _0305_ _0313_ _0505_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_13_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7221_ _2376_ _2379_ VGND VGND VPWR VPWR _2380_ sky130_fd_sc_hd__xor2_2
X_4433_ _2191_ net45 VGND VGND VPWR VPWR _3203_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_553 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4364_ _2411_ _2433_ VGND VGND VPWR VPWR _2444_ sky130_fd_sc_hd__xnor2_1
X_7152_ _2293_ _2299_ VGND VGND VPWR VPWR _2304_ sky130_fd_sc_hd__nand2_1
X_4295_ net407 _1657_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6103_ net311 _0926_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__nand2_1
X_7083_ _0932_ net223 _2225_ VGND VGND VPWR VPWR _2228_ sky130_fd_sc_hd__or3_1
X_6034_ _1032_ _1049_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__nor2_1
XFILLER_0_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer11 _3873_ VGND VGND VPWR VPWR net364 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_20_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_629 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer33 _3873_ VGND VGND VPWR VPWR net386 sky130_fd_sc_hd__clkbuf_2
Xrebuffer55 _4021_ VGND VGND VPWR VPWR net429 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer44 _1760_ VGND VGND VPWR VPWR net397 sky130_fd_sc_hd__buf_1
X_7985_ _3167_ _2755_ VGND VGND VPWR VPWR _3220_ sky130_fd_sc_hd__nand2_1
Xrebuffer22 net425 VGND VGND VPWR VPWR net375 sky130_fd_sc_hd__clkbuf_1
X_6936_ counter\[9\] _2061_ _2066_ counter\[10\] VGND VGND VPWR VPWR _2067_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_49_556 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_567 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6867_ _1989_ _1990_ VGND VGND VPWR VPWR _1991_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5818_ _0848_ _0852_ _0851_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__a21oi_1
X_6798_ _1909_ _1914_ VGND VGND VPWR VPWR _1915_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5749_ _0775_ _0776_ _0774_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_106_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7419_ net219 net223 net268 net277 VGND VGND VPWR VPWR _2597_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_99_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7770_ _2980_ _2982_ VGND VGND VPWR VPWR _2984_ sky130_fd_sc_hd__xor2_1
X_4982_ _4102_ _4104_ VGND VGND VPWR VPWR _4148_ sky130_fd_sc_hd__xnor2_2
X_6721_ _1825_ _1826_ _1827_ _1828_ _1830_ VGND VGND VPWR VPWR _1831_ sky130_fd_sc_hd__o311a_1
XFILLER_0_73_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6652_ _1751_ _1759_ VGND VGND VPWR VPWR _1760_ sky130_fd_sc_hd__xor2_1
X_5603_ _0614_ _0625_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__nand2_1
X_8322_ _3582_ _3586_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__xnor2_1
X_6583_ _1656_ _1683_ _1690_ VGND VGND VPWR VPWR _1691_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_5_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5534_ _0556_ _0557_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5465_ _0464_ _0470_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__nand2_1
X_8253_ _3378_ _3277_ _3514_ _3272_ VGND VGND VPWR VPWR _3515_ sky130_fd_sc_hd__a31o_1
X_8184_ _3406_ _3395_ VGND VGND VPWR VPWR _3439_ sky130_fd_sc_hd__or2b_1
X_4416_ _2961_ _3005_ VGND VGND VPWR VPWR _3016_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7204_ _2352_ _2359_ VGND VGND VPWR VPWR _2361_ sky130_fd_sc_hd__or2_1
X_5396_ _3877_ _3952_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__xnor2_2
Xfanout314 net315 VGND VGND VPWR VPWR net314 sky130_fd_sc_hd__clkbuf_4
Xfanout303 net304 VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__clkbuf_4
X_7135_ net95 net227 _2284_ _2282_ VGND VGND VPWR VPWR _2285_ sky130_fd_sc_hd__a31o_1
X_4347_ _2180_ _2213_ _2246_ VGND VGND VPWR VPWR _2257_ sky130_fd_sc_hd__a21o_1
XFILLER_0_94_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7066_ _2207_ _2208_ VGND VGND VPWR VPWR _2209_ sky130_fd_sc_hd__nand2_1
X_4278_ _1503_ net73 _1404_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__or3_1
X_6017_ net144 net314 VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__or2b_1
XFILLER_0_96_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7968_ _3198_ _3200_ VGND VGND VPWR VPWR _3201_ sky130_fd_sc_hd__nor2_1
X_6919_ _0805_ _2047_ VGND VGND VPWR VPWR _2048_ sky130_fd_sc_hd__xor2_1
X_7899_ _3121_ _3124_ VGND VGND VPWR VPWR _3125_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_92_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_570 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_102_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_99_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer2 net358 VGND VGND VPWR VPWR net355 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5250_ _0271_ _0272_ _0273_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__a21oi_2
X_5181_ _3876_ _0204_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7822_ _3037_ _3039_ _3040_ VGND VGND VPWR VPWR _3041_ sky130_fd_sc_hd__a21oi_1
X_7753_ _2941_ _2964_ VGND VGND VPWR VPWR _2965_ sky130_fd_sc_hd__nor2_1
X_4965_ _4113_ _4115_ VGND VGND VPWR VPWR _4131_ sky130_fd_sc_hd__xnor2_1
X_6704_ _1740_ _1748_ _1811_ VGND VGND VPWR VPWR _1812_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_80_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7684_ _2876_ _2877_ VGND VGND VPWR VPWR _2889_ sky130_fd_sc_hd__nand2_1
X_4896_ _4060_ _4061_ VGND VGND VPWR VPWR _4062_ sky130_fd_sc_hd__xor2_1
XFILLER_0_34_507 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6635_ _1639_ _1640_ VGND VGND VPWR VPWR _1743_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6566_ _1669_ _1673_ VGND VGND VPWR VPWR _1674_ sky130_fd_sc_hd__xnor2_2
X_5517_ _0529_ _0539_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__and2_1
X_8305_ _1404_ _3499_ _3506_ VGND VGND VPWR VPWR _3572_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_42_562 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8236_ _3490_ _3495_ _3493_ VGND VGND VPWR VPWR _3496_ sky130_fd_sc_hd__o21ai_2
X_6497_ _1478_ _1479_ VGND VGND VPWR VPWR _1599_ sky130_fd_sc_hd__nor2_1
X_5448_ _0459_ _0461_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__xnor2_1
Xfanout100 net7 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__buf_6
Xfanout122 net123 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__buf_4
X_8167_ _3417_ _3419_ VGND VGND VPWR VPWR _3420_ sky130_fd_sc_hd__nor2_1
X_5379_ net300 net179 _3115_ _0402_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__a31o_1
Xfanout111 net113 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__buf_2
X_8098_ _3340_ _3343_ VGND VGND VPWR VPWR _3344_ sky130_fd_sc_hd__xnor2_2
Xfanout155 net157 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout144 net147 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__buf_2
Xfanout133 net57 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__clkbuf_2
X_7118_ net248 net201 net303 net313 VGND VGND VPWR VPWR _2266_ sky130_fd_sc_hd__and4bb_1
Xfanout177 net40 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__clkbuf_4
X_7049_ net156 net186 _2128_ _2130_ VGND VGND VPWR VPWR _2190_ sky130_fd_sc_hd__and4_1
Xfanout188 net38 VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__buf_2
Xfanout199 net200 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__buf_2
Xfanout166 net46 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_92_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4750_ _3897_ _3913_ _3914_ VGND VGND VPWR VPWR _3916_ sky130_fd_sc_hd__and3_1
XFILLER_0_83_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4681_ net176 net198 net180 net209 VGND VGND VPWR VPWR _3847_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_50_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6420_ net103 net144 net287 net296 VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__and4bb_1
X_6351_ _1433_ _1435_ _1436_ _1438_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__and4_1
X_5302_ _0324_ _0325_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_59_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6282_ _1361_ _1362_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__or2b_1
XFILLER_0_3_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5233_ _0237_ _0239_ _0240_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__o21ba_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8021_ _3179_ _3195_ VGND VGND VPWR VPWR _3260_ sky130_fd_sc_hd__nand2_1
X_5164_ _0164_ _0165_ _0169_ _0186_ _0187_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__a41o_1
XFILLER_0_75_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5095_ _0114_ _0118_ _0117_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__a21o_1
XFILLER_0_91_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7805_ _2974_ _3021_ VGND VGND VPWR VPWR _3022_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5997_ _1032_ _1049_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__xor2_1
X_7736_ net294 _2449_ _2945_ _2944_ VGND VGND VPWR VPWR _2946_ sky130_fd_sc_hd__a31o_1
XFILLER_0_19_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4948_ _4083_ _4090_ _4092_ VGND VGND VPWR VPWR _4114_ sky130_fd_sc_hd__and3_1
X_7667_ _2869_ _2832_ VGND VGND VPWR VPWR _2870_ sky130_fd_sc_hd__xnor2_2
X_4879_ _3973_ _3985_ VGND VGND VPWR VPWR _4045_ sky130_fd_sc_hd__xnor2_1
X_6618_ _1723_ _1724_ _1725_ VGND VGND VPWR VPWR _1726_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_34_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7598_ _2792_ _2793_ VGND VGND VPWR VPWR _2794_ sky130_fd_sc_hd__nor2_2
XFILLER_0_15_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6549_ _1637_ _1655_ VGND VGND VPWR VPWR _1656_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8219_ _3472_ _3476_ VGND VGND VPWR VPWR _3477_ sky130_fd_sc_hd__nand2_1
XFILLER_0_100_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_92_Right_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5920_ net87 _0868_ _0963_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__a21o_1
XFILLER_0_48_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5851_ net259 net135 VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_100_Right_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5782_ _0782_ _0812_ _0813_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_61_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4802_ _3960_ _3967_ VGND VGND VPWR VPWR _3968_ sky130_fd_sc_hd__or2b_1
X_7521_ _2472_ _2476_ _2475_ VGND VGND VPWR VPWR _2710_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_9_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4733_ net195 net85 VGND VGND VPWR VPWR _3899_ sky130_fd_sc_hd__nand2b_1
X_7452_ _2630_ _2632_ _2633_ VGND VGND VPWR VPWR _2634_ sky130_fd_sc_hd__a21oi_1
X_4664_ _3828_ _3829_ VGND VGND VPWR VPWR _3830_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6403_ net274 _0867_ VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__nand2_1
X_4595_ _3739_ _3757_ _3759_ VGND VGND VPWR VPWR _3761_ sky130_fd_sc_hd__or3b_1
X_7383_ _2519_ _2513_ _2511_ VGND VGND VPWR VPWR _2558_ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6334_ _1364_ _1396_ VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6265_ net83 _1343_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__xor2_2
X_5216_ net258 net265 _3751_ _2378_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__and4_1
X_8004_ _3186_ _3187_ VGND VGND VPWR VPWR _3241_ sky130_fd_sc_hd__nor2_1
X_6196_ net90 net96 _0691_ _0687_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__and4_1
X_5147_ net42 _0149_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__nor2_1
X_5078_ _0085_ _0100_ _0101_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_79_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7719_ _2875_ _2924_ _2926_ VGND VGND VPWR VPWR _2927_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_34_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4380_ _2367_ _2389_ VGND VGND VPWR VPWR _2620_ sky130_fd_sc_hd__nand2_1
XFILLER_0_40_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6050_ _1104_ _1107_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__xnor2_2
X_5001_ net195 _1240_ _3974_ VGND VGND VPWR VPWR _4167_ sky130_fd_sc_hd__o21a_1
X_8403__20 clknet_2_0__leaf_clk VGND VGND VPWR VPWR net341 sky130_fd_sc_hd__inv_2
X_6952_ _1751_ net395 VGND VGND VPWR VPWR _2085_ sky130_fd_sc_hd__nor2_1
X_6883_ _1992_ _1993_ _1991_ _2008_ VGND VGND VPWR VPWR _2009_ sky130_fd_sc_hd__a31o_1
X_5903_ net124 net114 net271 net281 VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__and4bb_1
X_5834_ net153 _0868_ _0870_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__and3_1
XFILLER_0_76_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5765_ net214 net136 _0793_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__a21o_1
X_5696_ _0715_ _0718_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_98_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7504_ net203 net216 VGND VGND VPWR VPWR _2691_ sky130_fd_sc_hd__or2b_1
X_4716_ _3879_ _3880_ _3881_ VGND VGND VPWR VPWR _3882_ sky130_fd_sc_hd__o21a_1
X_7435_ _1240_ net233 VGND VGND VPWR VPWR _2615_ sky130_fd_sc_hd__nor2_1
X_4647_ _3809_ _3812_ VGND VGND VPWR VPWR _3813_ sky130_fd_sc_hd__or2_1
XFILLER_0_12_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7366_ _2537_ _2538_ VGND VGND VPWR VPWR _2539_ sky130_fd_sc_hd__and2_1
Xfanout2 net293 VGND VGND VPWR VPWR net420 sky130_fd_sc_hd__clkbuf_4
X_6317_ _1229_ net114 _1366_ VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__nor3_1
X_4578_ net195 net300 VGND VGND VPWR VPWR _3744_ sky130_fd_sc_hd__or2b_1
XFILLER_0_12_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7297_ _2383_ _2385_ _2461_ VGND VGND VPWR VPWR _2463_ sky130_fd_sc_hd__or3_4
X_6248_ _1322_ _1324_ VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__xor2_2
X_6179_ _1242_ _1248_ VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__or2_1
XFILLER_0_67_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_568 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_89_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_89_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5550_ _0572_ _0573_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5481_ _0311_ _0312_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__or2_1
X_4501_ net42 VGND VGND VPWR VPWR _3667_ sky130_fd_sc_hd__inv_2
X_4432_ _3181_ VGND VGND VPWR VPWR _3192_ sky130_fd_sc_hd__inv_2
X_7220_ _1470_ net26 _2335_ _2377_ VGND VGND VPWR VPWR _2379_ sky130_fd_sc_hd__o31a_1
XFILLER_0_1_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4363_ _2422_ net39 VGND VGND VPWR VPWR _2433_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7151_ _2223_ _2302_ VGND VGND VPWR VPWR _2303_ sky130_fd_sc_hd__xnor2_2
X_4294_ net412 _1657_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_67_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6102_ _1162_ _1165_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__xor2_2
X_7082_ _2225_ _2226_ VGND VGND VPWR VPWR _2227_ sky130_fd_sc_hd__nand2_1
X_6033_ _1065_ _1081_ _1089_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__a21oi_1
Xrebuffer12 _3864_ VGND VGND VPWR VPWR net365 sky130_fd_sc_hd__buf_6
XFILLER_0_83_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer34 _3873_ VGND VGND VPWR VPWR net387 sky130_fd_sc_hd__clkbuf_1
X_7984_ net297 net230 _3210_ _3209_ VGND VGND VPWR VPWR _3219_ sky130_fd_sc_hd__a31o_1
Xrebuffer45 _2802_ VGND VGND VPWR VPWR net422 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer23 _3740_ VGND VGND VPWR VPWR net376 sky130_fd_sc_hd__buf_1
XFILLER_0_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6935_ _2064_ _2065_ VGND VGND VPWR VPWR _2066_ sky130_fd_sc_hd__xor2_1
Xrebuffer56 _4021_ VGND VGND VPWR VPWR net430 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_49_524 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6866_ _1988_ _1973_ VGND VGND VPWR VPWR _1990_ sky130_fd_sc_hd__or2b_1
XFILLER_0_64_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5817_ _0849_ _0850_ _0851_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__a21oi_2
X_6797_ _1910_ _1913_ VGND VGND VPWR VPWR _1914_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_8_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5748_ _2191_ net143 VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_582 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5679_ _0698_ _0701_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__or2b_1
XFILLER_0_20_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7418_ net219 net277 VGND VGND VPWR VPWR _2596_ sky130_fd_sc_hd__or2b_1
X_7349_ _2511_ _2519_ _2513_ VGND VGND VPWR VPWR _2520_ sky130_fd_sc_hd__nand3_1
X_8394__11 clknet_2_3__leaf_clk VGND VGND VPWR VPWR net332 sky130_fd_sc_hd__inv_2
XFILLER_0_67_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4981_ _4139_ _4145_ _4146_ VGND VGND VPWR VPWR _4147_ sky130_fd_sc_hd__a21boi_2
X_6720_ _1814_ _1816_ VGND VGND VPWR VPWR _1830_ sky130_fd_sc_hd__or2_1
XFILLER_0_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6651_ _1753_ _1757_ _1758_ VGND VGND VPWR VPWR _1759_ sky130_fd_sc_hd__a21oi_1
X_5602_ _0614_ _0625_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__or2_1
X_6582_ _1680_ _1682_ VGND VGND VPWR VPWR _1690_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5533_ net258 net178 VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__nand2_1
X_8321_ _3583_ _3585_ VGND VGND VPWR VPWR _3586_ sky130_fd_sc_hd__and2b_1
XFILLER_0_73_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5464_ _0457_ _0463_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__or2_1
X_8252_ _3150_ _3156_ _3279_ VGND VGND VPWR VPWR _3514_ sky130_fd_sc_hd__a21o_1
X_8183_ _3309_ _3405_ VGND VGND VPWR VPWR _3438_ sky130_fd_sc_hd__or2_1
XFILLER_0_78_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5395_ _3799_ net386 VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__xnor2_2
X_4415_ _2972_ _2994_ VGND VGND VPWR VPWR _3005_ sky130_fd_sc_hd__nor2_1
X_7203_ _2352_ _2359_ VGND VGND VPWR VPWR _2360_ sky130_fd_sc_hd__nand2_1
X_4346_ _2224_ _2235_ VGND VGND VPWR VPWR _2246_ sky130_fd_sc_hd__nor2_1
Xfanout304 net307 VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__clkbuf_4
X_7134_ _2282_ _2283_ VGND VGND VPWR VPWR _2284_ sky130_fd_sc_hd__nor2_2
Xfanout315 net10 VGND VGND VPWR VPWR net315 sky130_fd_sc_hd__clkbuf_4
X_4277_ _1492_ VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__clkbuf_4
X_7065_ _2205_ _2206_ VGND VGND VPWR VPWR _2208_ sky130_fd_sc_hd__or2_1
X_6016_ net103 net311 VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__or2b_1
XFILLER_0_69_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7967_ _2761_ _2784_ _3199_ VGND VGND VPWR VPWR _3200_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_49_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6918_ _0907_ _2039_ VGND VGND VPWR VPWR _2047_ sky130_fd_sc_hd__nor2_1
X_7898_ _3102_ _3122_ _3123_ VGND VGND VPWR VPWR _3124_ sky130_fd_sc_hd__a21o_1
XFILLER_0_37_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6849_ _1964_ _1970_ VGND VGND VPWR VPWR _1971_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_60_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_560 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer3 net355 VGND VGND VPWR VPWR net356 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_51_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5180_ _4022_ _0202_ _0203_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_48_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7821_ net224 net249 net294 net302 VGND VGND VPWR VPWR _3040_ sky130_fd_sc_hd__and4bb_1
X_7752_ _2930_ _2937_ _2940_ VGND VGND VPWR VPWR _2964_ sky130_fd_sc_hd__nor3_1
X_4964_ _4121_ _4075_ VGND VGND VPWR VPWR _4130_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_80_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6703_ _1691_ _1739_ VGND VGND VPWR VPWR _1811_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_538 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7683_ _2882_ _2886_ _2887_ VGND VGND VPWR VPWR _2888_ sky130_fd_sc_hd__a21bo_1
X_4895_ _3996_ _3999_ VGND VGND VPWR VPWR _4061_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_104_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6634_ _1637_ _1655_ _1741_ VGND VGND VPWR VPWR _1742_ sky130_fd_sc_hd__a21o_1
X_6565_ _1670_ _1671_ _1672_ VGND VGND VPWR VPWR _1673_ sky130_fd_sc_hd__a21oi_2
X_5516_ _0529_ _0539_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__nor2_1
X_8304_ _3569_ _3570_ _3541_ _3507_ VGND VGND VPWR VPWR _3571_ sky130_fd_sc_hd__a211oi_1
X_6496_ _1596_ _1597_ VGND VGND VPWR VPWR _1598_ sky130_fd_sc_hd__nand2_1
X_8235_ _3493_ _3494_ VGND VGND VPWR VPWR _3495_ sky130_fd_sc_hd__nand2_1
X_5447_ _0464_ _0470_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_100_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8166_ _3330_ _3365_ _3418_ VGND VGND VPWR VPWR _3419_ sky130_fd_sc_hd__a21oi_1
X_5378_ _2994_ _3093_ _3071_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__o21a_1
Xfanout101 net7 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__buf_2
Xfanout112 net113 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__buf_2
Xfanout123 net6 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__buf_4
Xfanout156 net157 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__buf_2
X_8097_ _2181_ _3341_ _3342_ VGND VGND VPWR VPWR _3343_ sky130_fd_sc_hd__o21a_1
Xfanout145 net147 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout134 net137 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__buf_2
X_4329_ _1972_ _2049_ VGND VGND VPWR VPWR _2060_ sky130_fd_sc_hd__xor2_2
X_7117_ net201 net302 VGND VGND VPWR VPWR _2265_ sky130_fd_sc_hd__or2b_1
Xfanout178 net40 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__clkbuf_2
X_7048_ net231 net186 VGND VGND VPWR VPWR _2189_ sky130_fd_sc_hd__or2b_1
Xfanout189 net190 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__clkbuf_4
Xfanout167 net46 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_69_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4680_ net175 net209 VGND VGND VPWR VPWR _3846_ sky130_fd_sc_hd__or2b_1
XFILLER_0_70_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6350_ net317 _0909_ _1428_ _1408_ VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__and4_1
X_5301_ net267 net177 VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_596 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6281_ _1359_ _1348_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__or2b_1
X_5232_ _0244_ _0254_ _0255_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__a21oi_1
X_8020_ net288 net228 VGND VGND VPWR VPWR _3259_ sky130_fd_sc_hd__nand2_1
X_5163_ _0139_ _0142_ _0162_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__and3_1
XFILLER_0_75_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5094_ _0115_ _0116_ _0117_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__a21oi_1
X_7804_ _3017_ _3019_ _3020_ VGND VGND VPWR VPWR _3021_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_93_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5996_ _1040_ _1048_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__xnor2_1
X_7735_ _2942_ _2943_ _2944_ VGND VGND VPWR VPWR _2945_ sky130_fd_sc_hd__a21oi_1
X_4947_ _4111_ _4112_ VGND VGND VPWR VPWR _4113_ sky130_fd_sc_hd__xor2_1
X_7666_ net276 _2286_ VGND VGND VPWR VPWR _2869_ sky130_fd_sc_hd__nand2_1
X_4878_ _4031_ _4032_ _4043_ VGND VGND VPWR VPWR _4044_ sky130_fd_sc_hd__a21oi_2
X_6617_ net104 net145 net259 net266 VGND VGND VPWR VPWR _1725_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_61_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7597_ _2789_ _2790_ _2791_ VGND VGND VPWR VPWR _2793_ sky130_fd_sc_hd__and3_1
XFILLER_0_6_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6548_ _1638_ _1654_ VGND VGND VPWR VPWR _1655_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_18_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6479_ net266 _0868_ VGND VGND VPWR VPWR _1579_ sky130_fd_sc_hd__nand2_1
XFILLER_0_100_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8218_ _3470_ _3391_ _3471_ VGND VGND VPWR VPWR _3476_ sky130_fd_sc_hd__or3_1
XFILLER_0_100_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8149_ _0269_ net232 net234 _0490_ VGND VGND VPWR VPWR _3400_ sky130_fd_sc_hd__o22a_1
XPHY_EDGE_ROW_27_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_36_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_96_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5850_ _0886_ _0887_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__and2b_1
XFILLER_0_61_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5781_ _2202_ net140 _0812_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__nor3_1
XFILLER_0_68_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4801_ _3961_ _3966_ VGND VGND VPWR VPWR _3967_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7520_ _2703_ _2707_ VGND VGND VPWR VPWR _2709_ sky130_fd_sc_hd__xnor2_2
X_4732_ _3895_ _3896_ VGND VGND VPWR VPWR _3898_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_83_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_54_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4663_ _3751_ _2378_ net86 net92 VGND VGND VPWR VPWR _3829_ sky130_fd_sc_hd__and4_1
X_7451_ net225 net251 net243 net260 VGND VGND VPWR VPWR _2633_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6402_ _1231_ _1234_ _1233_ VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__a21bo_1
X_4594_ _3739_ _3757_ _3759_ VGND VGND VPWR VPWR _3760_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_24_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7382_ _2553_ _2556_ VGND VGND VPWR VPWR _2557_ sky130_fd_sc_hd__xor2_2
XFILLER_0_12_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6333_ _1398_ _1418_ VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6264_ _1341_ _1342_ VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__xnor2_2
X_5215_ _3885_ net189 net188 _0238_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__o22a_1
X_8003_ _3186_ _3187_ VGND VGND VPWR VPWR _3240_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6195_ _1884_ net141 net138 _3901_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__o22a_1
XFILLER_0_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_63_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5146_ _0147_ _0154_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__xnor2_1
X_5077_ _0099_ _0097_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__or2b_1
XFILLER_0_94_536 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5979_ _0974_ _0981_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7718_ _2872_ _2925_ VGND VGND VPWR VPWR _2926_ sky130_fd_sc_hd__nor2_1
XFILLER_0_35_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7649_ _2848_ _2849_ VGND VGND VPWR VPWR _2850_ sky130_fd_sc_hd__xor2_1
XFILLER_0_34_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_93_591 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_508 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_606 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5000_ _4157_ _4156_ VGND VGND VPWR VPWR _4166_ sky130_fd_sc_hd__and2b_1
X_6951_ _2083_ _1827_ _1826_ VGND VGND VPWR VPWR _2084_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_76_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6882_ _1964_ _1970_ VGND VGND VPWR VPWR _2008_ sky130_fd_sc_hd__or2_1
X_5902_ net124 net271 VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__or2b_1
XFILLER_0_48_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5833_ _0865_ _0869_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5764_ net214 net136 _0793_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__nand3_1
XFILLER_0_56_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7503_ net206 net185 VGND VGND VPWR VPWR _2690_ sky130_fd_sc_hd__or2b_1
XFILLER_0_17_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5695_ _0716_ _0717_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__xor2_1
XFILLER_0_16_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4715_ net167 net163 net280 net290 VGND VGND VPWR VPWR _3881_ sky130_fd_sc_hd__or4bb_1
XFILLER_0_4_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7434_ _2612_ _2593_ VGND VGND VPWR VPWR _2614_ sky130_fd_sc_hd__xor2_2
X_4646_ _3810_ _3811_ VGND VGND VPWR VPWR _3812_ sky130_fd_sc_hd__xnor2_1
X_7365_ net321 _2128_ _2130_ net96 VGND VGND VPWR VPWR _2538_ sky130_fd_sc_hd__a22o_1
X_4577_ net158 net420 VGND VGND VPWR VPWR _3743_ sky130_fd_sc_hd__or2b_1
XFILLER_0_102_549 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6316_ _1229_ net114 VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__or2_1
X_7296_ _2383_ _2385_ _2461_ VGND VGND VPWR VPWR _2462_ sky130_fd_sc_hd__o21ai_1
X_6247_ _1323_ _1161_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__xnor2_2
X_6178_ _1242_ _1248_ VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__and2_1
XFILLER_0_99_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5129_ net42 _0149_ _0152_ _0150_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__o31a_1
XFILLER_0_79_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_593 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5480_ net72 _0502_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_81_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4500_ _2686_ _3665_ VGND VGND VPWR VPWR _3666_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_26_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_1 _0691_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4431_ _3170_ _2807_ _2774_ VGND VGND VPWR VPWR _3181_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7150_ _2227_ _2228_ VGND VGND VPWR VPWR _2302_ sky130_fd_sc_hd__nand2_1
X_4362_ _1840_ VGND VGND VPWR VPWR _2422_ sky130_fd_sc_hd__buf_4
X_4293_ net403 _1657_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_67_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6101_ _1164_ _0914_ VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__xnor2_2
X_7081_ net223 net243 VGND VGND VPWR VPWR _2226_ sky130_fd_sc_hd__or2b_1
X_6032_ _1029_ _1063_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__nor2_1
Xrebuffer46 _3797_ VGND VGND VPWR VPWR net399 sky130_fd_sc_hd__clkbuf_1
Xrebuffer35 _3871_ VGND VGND VPWR VPWR net388 sky130_fd_sc_hd__clkbuf_1
X_7983_ _3216_ _3217_ VGND VGND VPWR VPWR _3218_ sky130_fd_sc_hd__nand2_1
Xrebuffer24 _1177_ VGND VGND VPWR VPWR net377 sky130_fd_sc_hd__clkbuf_1
Xrebuffer13 _4019_ VGND VGND VPWR VPWR net366 sky130_fd_sc_hd__buf_1
X_6934_ _2028_ _2033_ _2035_ VGND VGND VPWR VPWR _2065_ sky130_fd_sc_hd__o21ai_2
Xrebuffer57 _3953_ VGND VGND VPWR VPWR net431 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_88_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6865_ _1973_ _1988_ VGND VGND VPWR VPWR _1989_ sky130_fd_sc_hd__or2b_1
XFILLER_0_91_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5816_ net106 net146 net183 net213 VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__and4bb_1
X_6796_ _1911_ _1912_ VGND VGND VPWR VPWR _1913_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5747_ _0772_ _0773_ _0774_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_17_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5678_ net100 _0699_ _0700_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__and3_1
X_7417_ _2594_ _2512_ VGND VGND VPWR VPWR _2595_ sky130_fd_sc_hd__or2_1
X_4629_ net423 net396 VGND VGND VPWR VPWR _3795_ sky130_fd_sc_hd__xnor2_4
X_7348_ _2516_ _2225_ VGND VGND VPWR VPWR _2519_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7279_ net223 net121 VGND VGND VPWR VPWR _2443_ sky130_fd_sc_hd__or2b_1
XFILLER_0_86_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4980_ _4136_ _4138_ VGND VGND VPWR VPWR _4146_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6650_ _1754_ _1756_ VGND VGND VPWR VPWR _1758_ sky130_fd_sc_hd__nor2_1
X_5601_ _0623_ _0624_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__xor2_1
X_6581_ _1634_ _1687_ _1688_ VGND VGND VPWR VPWR _1689_ sky130_fd_sc_hd__a21bo_1
X_5532_ _0554_ _0555_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__and2b_1
X_8320_ delta\[2\] counter\[2\] VGND VGND VPWR VPWR _3585_ sky130_fd_sc_hd__nand2_1
X_5463_ _0485_ _0486_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__nand2_1
X_8251_ counter\[11\] _3510_ _3512_ counter\[10\] VGND VGND VPWR VPWR _3513_ sky130_fd_sc_hd__o22ai_2
X_8182_ _3433_ _3436_ VGND VGND VPWR VPWR _3437_ sky130_fd_sc_hd__nor2_1
X_5394_ _0416_ _0417_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__and2_2
X_4414_ _2983_ _2367_ VGND VGND VPWR VPWR _2994_ sky130_fd_sc_hd__nor2_1
X_7202_ _2353_ _2358_ VGND VGND VPWR VPWR _2359_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout305 net307 VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__buf_2
X_7133_ _2261_ _2280_ _2281_ VGND VGND VPWR VPWR _2283_ sky130_fd_sc_hd__and3_1
X_4345_ net172 net210 VGND VGND VPWR VPWR _2235_ sky130_fd_sc_hd__or2b_1
Xfanout316 net317 VGND VGND VPWR VPWR net316 sky130_fd_sc_hd__buf_2
X_7064_ _2205_ _2206_ VGND VGND VPWR VPWR _2207_ sky130_fd_sc_hd__nand2_1
X_4276_ _1481_ VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__buf_4
XFILLER_0_94_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6015_ _3901_ net142 VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__nor2_1
X_7966_ _2758_ _2760_ VGND VGND VPWR VPWR _3199_ sky130_fd_sc_hd__nor2_1
X_6917_ _0725_ _2042_ VGND VGND VPWR VPWR _2046_ sky130_fd_sc_hd__xnor2_1
X_7897_ _3102_ _3122_ net320 _2449_ VGND VGND VPWR VPWR _3123_ sky130_fd_sc_hd__o211a_1
X_6848_ _1965_ _1968_ _1969_ VGND VGND VPWR VPWR _1970_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_64_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6779_ _1891_ _1893_ VGND VGND VPWR VPWR _1894_ sky130_fd_sc_hd__or2_1
XFILLER_0_17_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_99_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer4 _0425_ VGND VGND VPWR VPWR net357 sky130_fd_sc_hd__buf_1
XFILLER_0_3_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7820_ net224 net302 VGND VGND VPWR VPWR _3039_ sky130_fd_sc_hd__or2b_1
XFILLER_0_86_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7751_ _2960_ _2962_ VGND VGND VPWR VPWR _2963_ sky130_fd_sc_hd__xor2_1
X_4963_ _4122_ net384 VGND VGND VPWR VPWR _4129_ sky130_fd_sc_hd__nand2_1
XFILLER_0_86_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6702_ _1768_ _1809_ VGND VGND VPWR VPWR _1810_ sky130_fd_sc_hd__xnor2_2
X_7682_ _1884_ net205 _2817_ VGND VGND VPWR VPWR _2887_ sky130_fd_sc_hd__or3_1
XFILLER_0_46_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6633_ _1638_ _1654_ VGND VGND VPWR VPWR _1741_ sky130_fd_sc_hd__nor2_1
X_4894_ _4056_ _4058_ _4059_ VGND VGND VPWR VPWR _4060_ sky130_fd_sc_hd__a21boi_1
X_6564_ net125 net115 net117 net150 VGND VGND VPWR VPWR _1672_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_14_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5515_ _0537_ _0538_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__or2_1
X_8303_ _3539_ _3538_ _3513_ VGND VGND VPWR VPWR _3570_ sky130_fd_sc_hd__a21oi_1
X_6495_ _1470_ net133 net118 _1427_ VGND VGND VPWR VPWR _1597_ sky130_fd_sc_hd__a2bb2o_1
X_5446_ _0465_ _0469_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__xnor2_1
X_8234_ _3491_ _3492_ VGND VGND VPWR VPWR _3494_ sky130_fd_sc_hd__nand2_1
XFILLER_0_89_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout102 net7 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__clkbuf_4
X_5377_ _0384_ _0395_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__xnor2_1
X_8165_ _3362_ _3364_ VGND VGND VPWR VPWR _3418_ sky130_fd_sc_hd__and2b_1
XFILLER_0_10_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout113 net62 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__buf_2
Xfanout146 net147 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__buf_2
Xfanout135 net137 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__clkbuf_4
X_8096_ net247 net200 net123 net157 VGND VGND VPWR VPWR _3342_ sky130_fd_sc_hd__or4bb_1
Xfanout124 net126 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__buf_2
X_7116_ net248 net312 VGND VGND VPWR VPWR _2264_ sky130_fd_sc_hd__or2b_1
X_4328_ _1994_ _2038_ _2027_ VGND VGND VPWR VPWR _2049_ sky130_fd_sc_hd__a21oi_1
Xfanout157 net5 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__buf_8
X_7047_ net217 _2163_ VGND VGND VPWR VPWR _2188_ sky130_fd_sc_hd__nand2_1
Xfanout179 net40 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__clkbuf_4
X_4259_ net81 _0723_ _1283_ counter\[0\] net320 VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__a32o_1
Xfanout168 net170 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__buf_2
X_7949_ _0303_ net236 VGND VGND VPWR VPWR _3180_ sky130_fd_sc_hd__nor2_1
XFILLER_0_64_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_615 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_100_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_87_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5300_ _0321_ _0323_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__xnor2_1
X_6280_ _1348_ _1359_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__and2b_1
XFILLER_0_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5231_ _0223_ _0243_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__and2b_1
X_5162_ _0180_ _0181_ _0184_ _0185_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__a31o_1
X_5093_ net176 net198 net419 net308 VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_66_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7803_ _2941_ _2969_ VGND VGND VPWR VPWR _3020_ sky130_fd_sc_hd__xor2_1
X_7734_ net226 net250 net276 net285 VGND VGND VPWR VPWR _2944_ sky130_fd_sc_hd__and4bb_1
X_5995_ _1046_ _1047_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__and2_1
XFILLER_0_47_612 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4946_ _4062_ _4064_ VGND VGND VPWR VPWR _4112_ sky130_fd_sc_hd__xnor2_1
X_7665_ net285 _2287_ _2867_ _2866_ VGND VGND VPWR VPWR _2868_ sky130_fd_sc_hd__a31o_2
XFILLER_0_19_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4877_ _4034_ _4041_ _4042_ VGND VGND VPWR VPWR _4043_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_34_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6616_ net145 net266 VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__or2b_1
X_7596_ _2789_ _2790_ _2791_ VGND VGND VPWR VPWR _2792_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_34_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6547_ _1644_ _1653_ VGND VGND VPWR VPWR _1654_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_15_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6478_ _1484_ _1487_ _1486_ VGND VGND VPWR VPWR _1578_ sky130_fd_sc_hd__a21o_1
X_5429_ net177 VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__inv_2
X_8217_ _3411_ _3413_ VGND VGND VPWR VPWR _3475_ sky130_fd_sc_hd__or2b_1
XFILLER_0_30_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8148_ net245 _2163_ VGND VGND VPWR VPWR _3399_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8079_ _3320_ _3322_ VGND VGND VPWR VPWR _3323_ sky130_fd_sc_hd__or2b_1
XFILLER_0_97_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_523 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_578 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_88_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4800_ _3962_ _3965_ VGND VGND VPWR VPWR _3966_ sky130_fd_sc_hd__or2b_1
XFILLER_0_29_623 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5780_ net139 net241 VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__or2b_1
XFILLER_0_61_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4731_ _3895_ _3896_ VGND VGND VPWR VPWR _3897_ sky130_fd_sc_hd__or2_1
XFILLER_0_44_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7450_ net251 net243 VGND VGND VPWR VPWR _2632_ sky130_fd_sc_hd__or2b_1
X_4662_ net190 _1884_ _3827_ net187 VGND VGND VPWR VPWR _3828_ sky130_fd_sc_hd__o22a_1
XFILLER_0_71_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6401_ _1116_ _1244_ _1493_ _1243_ VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__a22o_1
XFILLER_0_101_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4593_ _3758_ _1895_ _1851_ VGND VGND VPWR VPWR _3759_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_12_512 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7381_ _2555_ _2292_ VGND VGND VPWR VPWR _2556_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_101_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6332_ _1412_ _1416_ _1417_ VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__a21o_1
XFILLER_0_12_589 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6263_ _1180_ _1183_ VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__xnor2_2
X_8002_ _3222_ _3238_ VGND VGND VPWR VPWR _3239_ sky130_fd_sc_hd__xnor2_1
X_5214_ _2268_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__clkbuf_8
X_6194_ net320 _0684_ VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__nand2_1
X_5145_ _0160_ _0166_ _0168_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__nor3_1
XFILLER_0_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_98_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5076_ _0097_ _0099_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_39_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5978_ _0991_ _1003_ _1028_ VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__a21oi_1
X_4929_ net174 net272 VGND VGND VPWR VPWR _4095_ sky130_fd_sc_hd__and2b_1
X_7717_ net222 net302 VGND VGND VPWR VPWR _2925_ sky130_fd_sc_hd__or2b_1
XFILLER_0_35_604 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7648_ _2644_ _2645_ VGND VGND VPWR VPWR _2849_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_34_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7579_ _2768_ _2772_ VGND VGND VPWR VPWR _2773_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_15_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6950_ _1545_ _1623_ VGND VGND VPWR VPWR _2083_ sky130_fd_sc_hd__nand2_1
X_5901_ net291 _0925_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__nand2_1
XFILLER_0_88_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6881_ _1894_ _2006_ VGND VGND VPWR VPWR _2007_ sky130_fd_sc_hd__and2_1
X_5832_ _1470_ net112 _0806_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__o21a_1
X_5763_ _0791_ _0792_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__nor2_1
XFILLER_0_91_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7502_ net244 _2216_ VGND VGND VPWR VPWR _2689_ sky130_fd_sc_hd__nand2_1
X_4714_ net163 net290 VGND VGND VPWR VPWR _3880_ sky130_fd_sc_hd__and2b_1
X_5694_ net100 _0685_ _0688_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__and3_1
XFILLER_0_16_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7433_ _2593_ _2612_ VGND VGND VPWR VPWR _2613_ sky130_fd_sc_hd__or2b_1
XFILLER_0_32_618 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4645_ _2147_ _3727_ _3725_ _2104_ VGND VGND VPWR VPWR _3811_ sky130_fd_sc_hd__a22oi_1
XFILLER_0_102_517 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7364_ _0149_ _1218_ net231 net233 VGND VGND VPWR VPWR _2537_ sky130_fd_sc_hd__or4_1
X_4576_ net191 _1840_ VGND VGND VPWR VPWR _3742_ sky130_fd_sc_hd__nor2_1
X_6315_ _1383_ _1385_ VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7295_ _2456_ _2460_ VGND VGND VPWR VPWR _2461_ sky130_fd_sc_hd__xnor2_1
X_6246_ net271 _0916_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__nand2_1
X_6177_ _1243_ _1247_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__xnor2_1
X_5128_ _0150_ _0151_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5059_ _0080_ _0082_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_518 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_607 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold60 delta\[10\] VGND VGND VPWR VPWR net413 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_82_Left_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_548 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_551 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4430_ _2752_ _2763_ VGND VGND VPWR VPWR _3170_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_2 _2538_ VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_91_Left_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4361_ _2367_ _2389_ _2400_ VGND VGND VPWR VPWR _2411_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_545 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6100_ net264 _0916_ VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__nand2_1
X_4292_ net405 _1657_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7080_ net220 net260 VGND VGND VPWR VPWR _2225_ sky130_fd_sc_hd__or2b_1
X_6031_ _1011_ _1018_ _1080_ _1087_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__a31o_1
Xrebuffer36 _0420_ VGND VGND VPWR VPWR net389 sky130_fd_sc_hd__buf_1
X_7982_ _3158_ _3213_ VGND VGND VPWR VPWR _3217_ sky130_fd_sc_hd__xor2_1
Xrebuffer25 _1353_ VGND VGND VPWR VPWR net378 sky130_fd_sc_hd__clkbuf_1
Xrebuffer14 _3777_ VGND VGND VPWR VPWR net367 sky130_fd_sc_hd__buf_6
X_6933_ _0902_ _2063_ VGND VGND VPWR VPWR _2064_ sky130_fd_sc_hd__nand2_1
XFILLER_0_88_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer47 _3793_ VGND VGND VPWR VPWR net423 sky130_fd_sc_hd__buf_6
X_6864_ _1985_ _1987_ VGND VGND VPWR VPWR _1988_ sky130_fd_sc_hd__xor2_1
XFILLER_0_9_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5815_ net146 net213 VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__or2b_1
XFILLER_0_36_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6795_ net259 net266 _0691_ _0687_ VGND VGND VPWR VPWR _1912_ sky130_fd_sc_hd__and4_1
X_5746_ net105 net146 net120 net153 VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_32_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5677_ net146 net120 VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__or2b_1
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4628_ _3718_ _3720_ VGND VGND VPWR VPWR _3794_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7416_ net222 net277 VGND VGND VPWR VPWR _2594_ sky130_fd_sc_hd__or2b_1
XFILLER_0_102_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7347_ _2511_ _2513_ _2515_ _2517_ VGND VGND VPWR VPWR _2518_ sky130_fd_sc_hd__a211o_1
X_4559_ net163 net273 VGND VGND VPWR VPWR _3725_ sky130_fd_sc_hd__or2b_1
X_7278_ _0490_ net29 VGND VGND VPWR VPWR _2442_ sky130_fd_sc_hd__nor2_1
X_6229_ net130 net419 VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__or2b_1
XFILLER_0_99_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_529 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_94_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5600_ net100 _3082_ _0492_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__and3_1
XFILLER_0_73_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6580_ _1684_ _1686_ VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__or2b_1
X_5531_ _0551_ _0552_ _0553_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__or3b_1
XFILLER_0_54_573 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8250_ _3474_ _3508_ VGND VGND VPWR VPWR _3512_ sky130_fd_sc_hd__xnor2_1
X_5462_ net213 net177 _0484_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__a21o_1
X_7201_ _2354_ _2355_ _2357_ VGND VGND VPWR VPWR _2358_ sky130_fd_sc_hd__o21a_1
X_8181_ _2196_ _3435_ VGND VGND VPWR VPWR _3436_ sky130_fd_sc_hd__nand2_1
X_5393_ _0413_ _0415_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__nand2_1
X_4413_ net187 net283 VGND VGND VPWR VPWR _2983_ sky130_fd_sc_hd__or2b_1
XFILLER_0_10_621 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4344_ net169 net181 VGND VGND VPWR VPWR _2224_ sky130_fd_sc_hd__or2b_1
XFILLER_0_1_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7132_ _2261_ _2280_ _2281_ VGND VGND VPWR VPWR _2282_ sky130_fd_sc_hd__a21oi_1
X_7063_ _2155_ _2159_ VGND VGND VPWR VPWR _2206_ sky130_fd_sc_hd__xnor2_1
Xfanout317 net318 VGND VGND VPWR VPWR net317 sky130_fd_sc_hd__clkbuf_2
Xfanout306 net307 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__buf_2
XFILLER_0_94_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4275_ _1470_ VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__buf_4
X_6014_ _1008_ _1013_ _1016_ _1012_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__a211o_1
X_7965_ _3174_ _3197_ VGND VGND VPWR VPWR _3198_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6916_ _2043_ _2044_ VGND VGND VPWR VPWR _2045_ sky130_fd_sc_hd__nor2_1
X_7896_ _0149_ net224 VGND VGND VPWR VPWR _3122_ sky130_fd_sc_hd__nor2_1
XFILLER_0_92_613 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6847_ _1966_ _1967_ VGND VGND VPWR VPWR _1969_ sky130_fd_sc_hd__or2b_1
XFILLER_0_49_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6778_ _1761_ _1813_ _1892_ VGND VGND VPWR VPWR _1893_ sky130_fd_sc_hd__a21oi_1
X_5729_ _0712_ _0714_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__nand2_1
XFILLER_0_103_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8379_ _3629_ _3636_ VGND VGND VPWR VPWR _3637_ sky130_fd_sc_hd__and2_1
XFILLER_0_102_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_576 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_102_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_87_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_95_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer5 net359 VGND VGND VPWR VPWR net358 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_584 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7750_ _2881_ _2893_ VGND VGND VPWR VPWR _2962_ sky130_fd_sc_hd__xnor2_1
X_4962_ _4122_ net385 _4127_ VGND VGND VPWR VPWR _4128_ sky130_fd_sc_hd__a21o_1
X_6701_ _1806_ _1808_ VGND VGND VPWR VPWR _1809_ sky130_fd_sc_hd__xnor2_2
X_7681_ net88 _2883_ _2885_ net313 VGND VGND VPWR VPWR _2886_ sky130_fd_sc_hd__a22o_1
X_4893_ _4053_ _4055_ VGND VGND VPWR VPWR _4059_ sky130_fd_sc_hd__nand2_1
X_6632_ _1691_ _1739_ VGND VGND VPWR VPWR _1740_ sky130_fd_sc_hd__xor2_2
X_6563_ net125 net117 VGND VGND VPWR VPWR _1671_ sky130_fd_sc_hd__or2b_1
X_5514_ _0530_ _0455_ _0536_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__and3_1
X_8302_ _3564_ _3568_ _3540_ VGND VGND VPWR VPWR _3569_ sky130_fd_sc_hd__a21o_1
X_6494_ _1470_ net129 _1479_ VGND VGND VPWR VPWR _1596_ sky130_fd_sc_hd__or3_1
X_5445_ _0466_ _0467_ _0468_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__a21oi_1
X_8233_ _3491_ _3492_ VGND VGND VPWR VPWR _3493_ sky130_fd_sc_hd__or2_1
X_8164_ _3415_ _3416_ VGND VGND VPWR VPWR _3417_ sky130_fd_sc_hd__nand2_1
X_5376_ _0398_ _0399_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__nand2_2
X_7115_ _4035_ net235 VGND VGND VPWR VPWR _2263_ sky130_fd_sc_hd__nor2_1
Xfanout103 net106 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__clkbuf_2
Xfanout147 net51 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__clkbuf_2
Xfanout136 net137 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__clkbuf_2
X_8095_ net247 net157 VGND VGND VPWR VPWR _3341_ sky130_fd_sc_hd__and2b_1
X_4327_ _2005_ _2016_ _2027_ VGND VGND VPWR VPWR _2038_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_10_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout114 net116 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__buf_2
Xfanout125 net126 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__clkbuf_4
X_7046_ _2179_ _2185_ VGND VGND VPWR VPWR _2187_ sky130_fd_sc_hd__xor2_1
X_4258_ _0723_ _1283_ net81 VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__a21oi_1
Xfanout169 net170 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__buf_2
Xfanout158 net161 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__buf_2
XFILLER_0_77_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7948_ _2744_ _2753_ _3178_ VGND VGND VPWR VPWR _3179_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_49_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7879_ net312 _2374_ _3102_ VGND VGND VPWR VPWR _3103_ sky130_fd_sc_hd__and3_1
XFILLER_0_37_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_103_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_95_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5230_ _0247_ _0252_ _0253_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__a21o_1
X_5161_ _0170_ _0179_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__nor2_1
X_5092_ net174 net308 VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_91_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7802_ _3010_ _3018_ VGND VGND VPWR VPWR _3019_ sky130_fd_sc_hd__and2b_1
X_5994_ _1044_ _1045_ _1041_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__a21o_1
X_7733_ net226 net285 VGND VGND VPWR VPWR _2943_ sky130_fd_sc_hd__or2b_1
X_4945_ _4108_ _4109_ _4110_ VGND VGND VPWR VPWR _4111_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_74_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7664_ _2864_ _2865_ _2866_ VGND VGND VPWR VPWR _2867_ sky130_fd_sc_hd__a21oi_1
X_4876_ _4031_ _4032_ VGND VGND VPWR VPWR _4042_ sky130_fd_sc_hd__xnor2_1
X_6615_ net105 net259 VGND VGND VPWR VPWR _1723_ sky130_fd_sc_hd__or2b_1
X_7595_ _2712_ _2713_ _2714_ VGND VGND VPWR VPWR _2791_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_15_521 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6546_ _1651_ _1652_ VGND VGND VPWR VPWR _1653_ sky130_fd_sc_hd__xor2_2
XFILLER_0_104_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_6477_ _1245_ _1497_ _1576_ _1496_ VGND VGND VPWR VPWR _1577_ sky130_fd_sc_hd__o22ai_4
X_5428_ _0444_ _0449_ _0450_ _0451_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__or4_1
X_8216_ _3466_ _3473_ VGND VGND VPWR VPWR _3474_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_2_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8147_ _3396_ _3397_ VGND VGND VPWR VPWR _3398_ sky130_fd_sc_hd__xnor2_1
X_5359_ _0381_ _0382_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__and2b_1
XFILLER_0_100_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8078_ _3257_ _3265_ _3321_ VGND VGND VPWR VPWR _3322_ sky130_fd_sc_hd__a21bo_1
X_7029_ _2160_ _2165_ _2167_ VGND VGND VPWR VPWR _2168_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_97_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_624 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_8392__9 clknet_2_3__leaf_clk VGND VGND VPWR VPWR net330 sky130_fd_sc_hd__inv_2
XFILLER_0_88_579 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_602 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4730_ _3825_ _3831_ VGND VGND VPWR VPWR _3896_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_28_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4661_ net91 VGND VGND VPWR VPWR _3827_ sky130_fd_sc_hd__inv_2
X_7380_ net243 _2287_ VGND VGND VPWR VPWR _2555_ sky130_fd_sc_hd__nand2_1
X_6400_ _1246_ _1245_ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__nand2_1
X_4592_ _1818_ _1829_ VGND VGND VPWR VPWR _3758_ sky130_fd_sc_hd__nand2_1
X_6331_ _1373_ _1389_ VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6262_ net87 _0926_ _1330_ _1329_ VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__a31o_1
X_5213_ net274 _3082_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__nand2_1
X_8001_ _3231_ _3237_ VGND VGND VPWR VPWR _3238_ sky130_fd_sc_hd__xor2_1
X_6193_ _1257_ _1264_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__xnor2_1
X_5144_ _0161_ _0156_ _0159_ _0167_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__a31o_1
XFILLER_0_19_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5075_ _4201_ _0098_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_79_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_557 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5977_ _0973_ _0990_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__nor2_1
X_4928_ net196 net263 VGND VGND VPWR VPWR _4094_ sky130_fd_sc_hd__or2b_1
X_7716_ net219 net302 VGND VGND VPWR VPWR _2924_ sky130_fd_sc_hd__or2b_1
X_7647_ _2844_ _2846_ _2847_ VGND VGND VPWR VPWR _2848_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_47_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_608 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4859_ _3975_ _3980_ _3977_ VGND VGND VPWR VPWR _4025_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_105_537 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7578_ _2769_ _2770_ _2771_ VGND VGND VPWR VPWR _2772_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_70_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6529_ _1631_ _1633_ VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_30_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_106_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_104_581 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5900_ _0936_ _0942_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__xor2_1
XFILLER_0_88_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_527 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6880_ _1998_ _1999_ _2000_ VGND VGND VPWR VPWR _2006_ sky130_fd_sc_hd__a21o_1
XFILLER_0_88_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5831_ _0867_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__clkbuf_4
X_5762_ _0788_ _0790_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__and2_1
XFILLER_0_29_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_101_Left_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7501_ _2442_ _2447_ _2446_ VGND VGND VPWR VPWR _2688_ sky130_fd_sc_hd__a21o_1
X_4713_ net167 net280 VGND VGND VPWR VPWR _3879_ sky130_fd_sc_hd__and2b_1
XFILLER_0_44_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5693_ net120 net135 VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__nand2_1
X_7432_ _2600_ _2601_ _2611_ VGND VGND VPWR VPWR _2612_ sky130_fd_sc_hd__a21o_1
XFILLER_0_31_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4644_ _2115_ net283 VGND VGND VPWR VPWR _3810_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_565 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7363_ _2534_ _2526_ VGND VGND VPWR VPWR _2536_ sky130_fd_sc_hd__xnor2_1
X_4575_ _1994_ _2038_ VGND VGND VPWR VPWR _3741_ sky130_fd_sc_hd__xnor2_2
X_7294_ _2457_ _2458_ _2459_ VGND VGND VPWR VPWR _2460_ sky130_fd_sc_hd__o21a_1
XFILLER_0_12_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6314_ _1370_ _1394_ VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__xnor2_1
X_6245_ net281 _0909_ _1314_ _1313_ VGND VGND VPWR VPWR _1322_ sky130_fd_sc_hd__a31o_1
X_6176_ _1116_ _1244_ _1245_ _1246_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__a22o_1
X_5127_ _4097_ net309 net84 _3672_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5058_ _4190_ _0081_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__nor2_1
XFILLER_0_94_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_516 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold50 delta\[14\] VGND VGND VPWR VPWR net403 sky130_fd_sc_hd__dlygate4sd3_1
Xhold61 delta\[11\] VGND VGND VPWR VPWR net414 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_85_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_3 net33 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4360_ _1119_ net187 _1818_ VGND VGND VPWR VPWR _2400_ sky130_fd_sc_hd__nor3_1
XFILLER_0_1_513 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4291_ _1646_ VGND VGND VPWR VPWR _1657_ sky130_fd_sc_hd__buf_4
XFILLER_0_67_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6030_ _1066_ _1079_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__nor2_1
XFILLER_0_83_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer15 net388 VGND VGND VPWR VPWR net368 sky130_fd_sc_hd__clkbuf_1
X_7981_ net306 net230 _2794_ _2792_ VGND VGND VPWR VPWR _3216_ sky130_fd_sc_hd__a31o_1
Xrebuffer26 _2330_ VGND VGND VPWR VPWR net379 sky130_fd_sc_hd__clkbuf_1
X_6932_ _2036_ VGND VGND VPWR VPWR _2063_ sky130_fd_sc_hd__inv_2
Xrebuffer37 _2734_ VGND VGND VPWR VPWR net390 sky130_fd_sc_hd__clkbuf_1
Xrebuffer48 _2668_ VGND VGND VPWR VPWR net401 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6863_ _1927_ _1952_ _1986_ VGND VGND VPWR VPWR _1987_ sky130_fd_sc_hd__a21boi_1
X_5814_ net106 net183 VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__or2b_1
X_6794_ _0303_ net140 net139 _0238_ VGND VGND VPWR VPWR _1911_ sky130_fd_sc_hd__o22a_1
XFILLER_0_106_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5745_ net146 net152 VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__or2b_1
XFILLER_0_72_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_96_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_574 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5676_ net142 VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__inv_2
X_4627_ _3765_ _3791_ _3792_ VGND VGND VPWR VPWR _3793_ sky130_fd_sc_hd__a21bo_1
X_7415_ _2540_ _2592_ VGND VGND VPWR VPWR _2593_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4558_ _2664_ _3723_ VGND VGND VPWR VPWR _3724_ sky130_fd_sc_hd__xnor2_1
X_7346_ _2516_ _2225_ VGND VGND VPWR VPWR _2517_ sky130_fd_sc_hd__nor2_1
X_4489_ _3642_ _3654_ VGND VGND VPWR VPWR _3655_ sky130_fd_sc_hd__nand2_1
X_7277_ _2380_ _2387_ _2440_ VGND VGND VPWR VPWR _2441_ sky130_fd_sc_hd__a21oi_2
X_6228_ _1301_ _1302_ VGND VGND VPWR VPWR _1303_ sky130_fd_sc_hd__nor2_1
X_6159_ _1223_ _1227_ VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_94_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_105_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5530_ _0551_ _0552_ _0553_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_26_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5461_ _0269_ _0453_ _0484_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__or3b_1
XFILLER_0_81_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4412_ _2455_ net189 net187 _1108_ VGND VGND VPWR VPWR _2972_ sky130_fd_sc_hd__o22a_1
X_7200_ net203 net206 net260 net270 VGND VGND VPWR VPWR _2357_ sky130_fd_sc_hd__or4bb_4
X_8180_ _2186_ _2194_ _2195_ VGND VGND VPWR VPWR _3435_ sky130_fd_sc_hd__nand3_1
X_5392_ _0413_ _0415_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__or2_1
XFILLER_0_1_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_99_Right_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4343_ net172 _2191_ _2202_ net169 VGND VGND VPWR VPWR _2213_ sky130_fd_sc_hd__o22ai_1
X_7131_ _2254_ _2255_ _2256_ VGND VGND VPWR VPWR _2281_ sky130_fd_sc_hd__o21ba_1
X_7062_ _2200_ _2201_ _2204_ VGND VGND VPWR VPWR _2205_ sky130_fd_sc_hd__and3_1
X_4274_ _1459_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__buf_4
Xfanout318 net321 VGND VGND VPWR VPWR net318 sky130_fd_sc_hd__buf_2
Xfanout307 net11 VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__clkbuf_4
X_6013_ _1014_ _1015_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__or2_1
X_7964_ _3177_ _3196_ VGND VGND VPWR VPWR _3197_ sky130_fd_sc_hd__xor2_1
X_6915_ net102 net136 _0713_ _0721_ _0724_ VGND VGND VPWR VPWR _2044_ sky130_fd_sc_hd__a32o_1
XFILLER_0_89_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_7895_ _3119_ _3120_ VGND VGND VPWR VPWR _3121_ sky130_fd_sc_hd__xnor2_1
X_6846_ _1966_ _1967_ VGND VGND VPWR VPWR _1968_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_9_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_91_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_6777_ _1810_ _1812_ VGND VGND VPWR VPWR _1892_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5728_ _0750_ _0751_ _0753_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__and3_1
XFILLER_0_45_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_102_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5659_ _0655_ _0675_ _0672_ _0680_ _0682_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__o221a_1
X_8447_ net353 _0000_ net255 VGND VGND VPWR VPWR rising sky130_fd_sc_hd__dfstp_1
XFILLER_0_32_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_8378_ _3630_ _3632_ VGND VGND VPWR VPWR _3636_ sky130_fd_sc_hd__nand2_1
X_7329_ _2496_ _2497_ VGND VGND VPWR VPWR _2498_ sky130_fd_sc_hd__nor2_2
XFILLER_0_82_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_541 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_552 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_90_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer6 net360 VGND VGND VPWR VPWR net359 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_600 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4961_ _4124_ _4125_ VGND VGND VPWR VPWR _4127_ sky130_fd_sc_hd__nor2_1
X_6700_ _1718_ _1738_ _1807_ VGND VGND VPWR VPWR _1808_ sky130_fd_sc_hd__a21o_1
X_4892_ _4057_ _4030_ VGND VGND VPWR VPWR _4058_ sky130_fd_sc_hd__xnor2_1
X_7680_ net205 VGND VGND VPWR VPWR _2885_ sky130_fd_sc_hd__inv_2
XFILLER_0_80_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6631_ _1718_ _1738_ VGND VGND VPWR VPWR _1739_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_104_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8301_ _3520_ _3548_ _3567_ _3530_ VGND VGND VPWR VPWR _3568_ sky130_fd_sc_hd__or4b_1
X_6562_ net115 net150 VGND VGND VPWR VPWR _1670_ sky130_fd_sc_hd__or2b_1
X_5513_ _0530_ _0455_ _0536_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__a21oi_1
X_6493_ _1593_ _1594_ VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__nor2_1
XFILLER_0_42_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5444_ net152 net183 _3751_ _2378_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__and4_1
X_8232_ _3459_ _3433_ _3436_ _3461_ VGND VGND VPWR VPWR _3492_ sky130_fd_sc_hd__o31a_1
XFILLER_0_42_599 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_605 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8163_ _3382_ _3383_ _3414_ VGND VGND VPWR VPWR _3416_ sky130_fd_sc_hd__or3_1
X_5375_ _0378_ _0397_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__nand2_1
Xfanout104 net106 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__buf_1
X_7114_ _2239_ _2260_ VGND VGND VPWR VPWR _2262_ sky130_fd_sc_hd__xnor2_2
Xfanout137 net56 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__buf_2
X_8094_ _0490_ net236 VGND VGND VPWR VPWR _3340_ sky130_fd_sc_hd__nor2_1
X_4326_ net158 net195 net420 net283 VGND VGND VPWR VPWR _2027_ sky130_fd_sc_hd__and4bb_1
Xfanout126 net59 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__buf_2
XFILLER_0_10_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout115 net116 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__clkbuf_4
X_7045_ _2179_ _2185_ VGND VGND VPWR VPWR _2186_ sky130_fd_sc_hd__or2_1
X_4257_ net96 net320 net90 VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__o21ai_1
Xfanout159 net160 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__buf_2
Xfanout148 net149 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__buf_6
X_7947_ _2745_ _2751_ VGND VGND VPWR VPWR _3178_ sky130_fd_sc_hd__nand2_1
X_7878_ net249 net88 VGND VGND VPWR VPWR _3102_ sky130_fd_sc_hd__and2b_1
X_6829_ _1947_ _1948_ VGND VGND VPWR VPWR _1949_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_577 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_522 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_555 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5160_ _0145_ _0177_ _0182_ _0114_ _0183_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__o221a_1
XFILLER_0_75_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5091_ net198 net419 VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__or2b_1
XFILLER_0_91_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7801_ _3014_ _3015_ VGND VGND VPWR VPWR _3018_ sky130_fd_sc_hd__xnor2_1
X_5993_ _1041_ _1044_ _1045_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__nand3_1
XFILLER_0_93_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7732_ net250 net276 VGND VGND VPWR VPWR _2942_ sky130_fd_sc_hd__or2b_1
X_4944_ _4106_ _4107_ VGND VGND VPWR VPWR _4110_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7663_ net226 net250 net268 net276 VGND VGND VPWR VPWR _2866_ sky130_fd_sc_hd__and4bb_1
X_4875_ _4036_ _4040_ VGND VGND VPWR VPWR _4041_ sky130_fd_sc_hd__nand2_1
X_6614_ _1031_ net142 VGND VGND VPWR VPWR _1722_ sky130_fd_sc_hd__nor2_1
XFILLER_0_61_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_7594_ _2718_ _2701_ VGND VGND VPWR VPWR _2790_ sky130_fd_sc_hd__or2b_1
XFILLER_0_104_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6545_ _1564_ _1568_ _1567_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_54_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8215_ _3468_ _3469_ _3472_ VGND VGND VPWR VPWR _3473_ sky130_fd_sc_hd__o21a_1
X_6476_ _1244_ _1498_ VGND VGND VPWR VPWR _1576_ sky130_fd_sc_hd__nor2_1
X_5427_ counter\[0\] _0443_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__nor2_1
X_8146_ _3340_ _3343_ _3342_ VGND VGND VPWR VPWR _3397_ sky130_fd_sc_hd__a21bo_1
X_5358_ _3379_ _3423_ _0379_ _0380_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__or4_1
XFILLER_0_10_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8077_ _3255_ _3256_ VGND VGND VPWR VPWR _3321_ sky130_fd_sc_hd__or2b_1
X_4309_ net314 VGND VGND VPWR VPWR _1840_ sky130_fd_sc_hd__inv_2
X_7028_ _2150_ _2154_ _2166_ VGND VGND VPWR VPWR _2167_ sky130_fd_sc_hd__o21ai_1
X_5289_ _0311_ _0312_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_97_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_8415__32 clknet_2_1__leaf_clk VGND VGND VPWR VPWR net353 sky130_fd_sc_hd__inv_2
XFILLER_0_45_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_547 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_519 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4660_ _2950_ net318 VGND VGND VPWR VPWR _3826_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4591_ _3740_ _3756_ VGND VGND VPWR VPWR _3757_ sky130_fd_sc_hd__and2b_1
X_6330_ _1401_ _1414_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_23_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_101_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_86_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6261_ _1337_ _1339_ VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__xor2_2
X_5212_ _0229_ _0235_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__xnor2_1
X_8000_ _3232_ _3235_ VGND VGND VPWR VPWR _3237_ sky130_fd_sc_hd__xnor2_1
X_6192_ _1258_ _1263_ VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__xnor2_1
X_5143_ _0146_ _0158_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__nor2_1
X_5074_ _4186_ _4202_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__and2_1
XFILLER_0_59_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5976_ _1005_ _1025_ _1026_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_47_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7715_ _2882_ _2922_ VGND VGND VPWR VPWR _2923_ sky130_fd_sc_hd__xor2_1
X_4927_ _4083_ _4090_ _4092_ VGND VGND VPWR VPWR _4093_ sky130_fd_sc_hd__a21oi_2
X_7646_ _2841_ _2843_ VGND VGND VPWR VPWR _2847_ sky130_fd_sc_hd__nor2_1
XFILLER_0_35_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4858_ _3974_ _3979_ net317 VGND VGND VPWR VPWR _4024_ sky130_fd_sc_hd__and3b_1
XFILLER_0_105_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7577_ net246 net199 net244 net261 VGND VGND VPWR VPWR _2771_ sky130_fd_sc_hd__and4bb_1
X_4789_ net168 net272 VGND VGND VPWR VPWR _3955_ sky130_fd_sc_hd__or2b_1
X_6528_ net90 net134 VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_6459_ _1494_ _1502_ _1501_ VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_100_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_100_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_8129_ _3215_ _3218_ _3270_ VGND VGND VPWR VPWR _3378_ sky130_fd_sc_hd__a21o_1
XFILLER_0_97_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_97_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_93_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_88_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_88_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5830_ net107 VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__inv_2
X_5761_ _0788_ _0790_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_7500_ _2456_ _2685_ _2459_ VGND VGND VPWR VPWR _2687_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_17_617 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4712_ net162 _1983_ VGND VGND VPWR VPWR _3878_ sky130_fd_sc_hd__nor2_1
X_5692_ _0712_ _0714_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__or2_1
XFILLER_0_16_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7431_ _2602_ _2610_ VGND VGND VPWR VPWR _2611_ sky130_fd_sc_hd__and2b_1
XFILLER_0_44_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_533 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4643_ _3805_ _3807_ _3808_ VGND VGND VPWR VPWR _3809_ sky130_fd_sc_hd__a21bo_1
X_4574_ _3737_ _3738_ VGND VGND VPWR VPWR _3740_ sky130_fd_sc_hd__xnor2_2
X_7362_ _2526_ _2534_ VGND VGND VPWR VPWR _2535_ sky130_fd_sc_hd__or2b_1
XFILLER_0_97_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_97_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7293_ net203 net206 net216 net244 VGND VGND VPWR VPWR _2459_ sky130_fd_sc_hd__or4bb_4
X_6313_ _1364_ _1396_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__nand2_1
X_6244_ _1317_ _1319_ _1320_ VGND VGND VPWR VPWR _1321_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6175_ net109 net275 VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__or2b_1
XFILLER_0_99_609 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5126_ net198 _1884_ _0116_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__or3_1
X_5057_ net163 _1218_ _4150_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__o21a_1
XFILLER_0_79_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_539 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5959_ _3827_ net144 VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__or2_1
XFILLER_0_75_583 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_561 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7629_ net249 net260 VGND VGND VPWR VPWR _2828_ sky130_fd_sc_hd__or2b_1
XFILLER_0_43_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_101_585 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold62 delta\[4\] VGND VGND VPWR VPWR net415 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 delta\[1\] VGND VGND VPWR VPWR net404 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_97_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XANTENNA_4 net106 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_1_569 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4290_ _1635_ VGND VGND VPWR VPWR _1646_ sky130_fd_sc_hd__buf_2
XFILLER_0_67_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer16 _3877_ VGND VGND VPWR VPWR net369 sky130_fd_sc_hd__clkbuf_1
X_7980_ _3158_ _3213_ VGND VGND VPWR VPWR _3215_ sky130_fd_sc_hd__or2_1
Xrebuffer27 _2583_ VGND VGND VPWR VPWR net380 sky130_fd_sc_hd__clkbuf_1
X_6931_ net77 _2061_ _2057_ net78 VGND VGND VPWR VPWR _2062_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_88_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer38 _2734_ VGND VGND VPWR VPWR net391 sky130_fd_sc_hd__clkbuf_1
Xrebuffer49 _1475_ VGND VGND VPWR VPWR net402 sky130_fd_sc_hd__clkbuf_1
X_6862_ _1944_ _1951_ VGND VGND VPWR VPWR _1986_ sky130_fd_sc_hd__or2b_1
XFILLER_0_76_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5813_ _0932_ net143 VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_625 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_91_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_6793_ net278 _0685_ VGND VGND VPWR VPWR _1910_ sky130_fd_sc_hd__nand2_1
X_5744_ net105 net120 VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__or2b_1
XFILLER_0_72_520 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5675_ _0694_ _0697_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_89_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_597 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4626_ _3766_ _3790_ VGND VGND VPWR VPWR _3792_ sky130_fd_sc_hd__or2b_1
X_7414_ _2536_ _2539_ VGND VGND VPWR VPWR _2592_ sky130_fd_sc_hd__or2_1
X_7345_ net222 net270 VGND VGND VPWR VPWR _2516_ sky130_fd_sc_hd__or2b_1
XFILLER_0_102_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4557_ _3693_ _3722_ VGND VGND VPWR VPWR _3723_ sky130_fd_sc_hd__xor2_1
X_4488_ net150 _3652_ _3610_ _3653_ VGND VGND VPWR VPWR _3654_ sky130_fd_sc_hd__a22o_1
X_7276_ _2376_ _2379_ VGND VGND VPWR VPWR _2440_ sky130_fd_sc_hd__and2_1
X_6227_ _1297_ _1300_ VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__nor2_1
X_6158_ _1224_ _1225_ _1226_ VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__a21oi_2
X_5109_ _0131_ _0130_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__and2b_1
X_6089_ _1090_ _1150_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__xor2_1
XFILLER_0_95_601 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_94_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_105_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_90_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_572 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5460_ _0482_ _0483_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__xor2_1
XFILLER_0_26_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4411_ net419 _2950_ VGND VGND VPWR VPWR _2961_ sky130_fd_sc_hd__nand2_1
X_5391_ _2664_ _3723_ _0414_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__a21oi_1
X_4342_ net210 VGND VGND VPWR VPWR _2202_ sky130_fd_sc_hd__inv_2
XFILLER_0_1_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7130_ _2262_ _2278_ VGND VGND VPWR VPWR _2280_ sky130_fd_sc_hd__or2b_1
XFILLER_0_94_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_7061_ _2149_ _2203_ VGND VGND VPWR VPWR _2204_ sky130_fd_sc_hd__nor2_1
X_4273_ net98 VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__inv_2
Xfanout319 net320 VGND VGND VPWR VPWR net319 sky130_fd_sc_hd__buf_4
Xfanout308 net309 VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__clkbuf_4
X_6012_ _1240_ net141 VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__nor2_1
.ends
