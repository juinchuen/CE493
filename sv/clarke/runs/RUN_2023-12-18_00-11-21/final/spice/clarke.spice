* NGSPICE file created from clarke.ext - technology: sky130A

.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=2.89
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=2.89
.ends

.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.05
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.05
.ends

.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=0.59
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=0.59
.ends

.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
X0 VPWR a_75_212# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 a_75_212# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 a_75_212# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND a_75_212# X VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_199_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_113_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.147 ps=1.29 w=1 l=0.15
X2 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X3 VPWR A1 a_113_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.29 as=0.14 ps=1.28 w=1 l=0.15
X4 a_113_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A2 a_199_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0959 ps=0.945 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
X0 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_161_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X2 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_161_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A a_161_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_161_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_465_47# A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.157 ps=1.32 w=1 l=0.15
X2 a_109_297# B1 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 a_193_297# B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.102 ps=0.965 w=0.65 l=0.15
X5 a_205_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X6 VPWR A2 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.165 ps=1.33 w=1 l=0.15
X7 a_193_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X8 a_27_47# B1 a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X9 a_109_297# C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 VGND C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND A2 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A a_113_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_113_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 a_81_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.257 ps=1.44 w=0.65 l=0.15
X1 a_299_297# B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_299_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 a_384_47# A1 a_81_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
X0 a_27_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_560_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X2 VGND B a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0991 ps=0.955 w=0.65 l=0.15
X3 Y B a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_297# a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_474_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X7 VGND A a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# B a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X12 a_474_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_560_47# a_27_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X14 VPWR A a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X15 Y a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X16 VPWR a_27_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X17 a_560_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_382_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X1 a_297_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X2 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.327 pd=1.65 as=0.28 ps=2.56 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.327 ps=1.65 w=1 l=0.15
X6 a_382_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.195 ps=1.39 w=1 l=0.15
X7 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
X0 VGND C a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 a_277_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_47# B a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.135 ps=1.27 w=1 l=0.15
X8 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_277_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_109_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.97
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.97
.ends

.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
X0 X a_35_297# a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.26 ps=2.52 w=1 l=0.15
X1 X B a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.25 pd=1.42 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_117_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 VPWR B a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.25 ps=1.42 w=0.65 l=0.15
X7 a_285_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A a_117_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
X0 VPWR B a_207_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.228 pd=1.74 as=0.0609 ps=0.71 w=0.42 l=0.15
X1 X a_207_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.228 ps=1.74 w=1 l=0.15
X2 a_297_47# a_27_413# a_207_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0504 pd=0.66 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_207_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.99 w=0.65 l=0.15
X4 a_207_413# a_27_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0609 pd=0.71 as=0.0714 ps=0.76 w=0.42 l=0.15
X5 VPWR A_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0714 pd=0.76 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VGND B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.99 as=0.0504 ps=0.66 w=0.42 l=0.15
X7 a_27_413# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
X0 VPWR A a_49_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VGND a_285_47# a_391_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.5
X2 X a_391_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VGND A a_49_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR a_285_47# a_391_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.5
X5 a_285_47# a_49_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X6 a_285_47# a_49_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X7 X a_391_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
X0 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.157 ps=1.17 w=0.42 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.157 pd=1.17 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X6 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
X0 X a_299_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X1 VPWR a_193_47# a_299_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 VGND a_193_47# a_299_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X6 X a_299_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
X0 VPWR a_505_21# a_535_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_505_21# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.0693 ps=0.75 w=0.42 l=0.15
X2 a_218_374# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0767 pd=0.785 as=0.158 ps=1.39 w=0.42 l=0.15
X3 VGND a_505_21# a_439_47# VNB sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.11 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 a_76_199# A0 a_218_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.193 pd=1.34 as=0.0767 ps=0.785 w=0.42 l=0.15
X5 a_505_21# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.145 ps=1.11 w=0.42 l=0.15
X6 a_439_47# A0 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0997 ps=0.895 w=0.42 l=0.15
X7 a_535_374# A1 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.193 ps=1.34 w=0.42 l=0.15
X8 a_76_199# A1 a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0997 pd=0.895 as=0.0693 ps=0.75 w=0.42 l=0.15
X9 a_218_47# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.113 ps=1.04 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.158 pd=1.39 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.04 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
X0 a_377_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.365 ps=1.73 w=1 l=0.15
X1 a_47_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.3 ps=2.6 w=1 l=0.15
X2 a_129_47# B a_47_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_285_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 Y a_47_47# a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_129_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0683 ps=0.86 w=0.65 l=0.15
X6 VPWR A a_47_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.365 pd=1.73 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_47_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.165 ps=1.33 w=1 l=0.15
X8 Y B a_377_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.42 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0703 pd=0.755 as=0.111 ps=1.37 w=0.42 l=0.15
X6 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.14 ps=1.28 w=1 l=0.15
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0703 ps=0.755 w=0.42 l=0.15
X8 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.165 ps=1.33 w=1 l=0.15
X9 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_298_297# a_27_413# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.265 ps=2.53 w=1 l=0.15
X1 a_215_297# a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.136 ps=1.1 w=0.65 l=0.15
X2 a_298_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.258 ps=1.45 w=0.65 l=0.15
X4 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X6 a_382_47# A1 a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.136 pd=1.1 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VPWR A1 a_298_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND A2 a_382_47# VNB sky130_fd_pr__nfet_01v8 ad=0.258 pd=1.45 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
X0 VPWR B a_59_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 X a_59_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.475 pd=2.95 as=0.167 ps=1.39 w=1 l=0.15
X2 VGND B a_145_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_59_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X4 X a_59_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.112 ps=1.04 w=0.65 l=0.15
X5 a_145_75# A a_59_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VPWR C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 a_181_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VGND C a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.132 pd=1.14 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 a_27_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X6 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.132 ps=1.14 w=0.65 l=0.15
X7 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X1 a_80_21# C1 a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X2 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_300_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.26 ps=1.45 w=0.65 l=0.15
X6 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_80_21# A1 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 a_472_297# B1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X9 a_80_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X3 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X4 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X5 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.301 ps=2.66 w=1 l=0.15
X7 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X8 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X10 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X12 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X13 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X14 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X15 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X16 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X17 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X18 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X20 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X21 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X22 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.209 ps=2.02 w=0.65 l=0.15
X23 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X24 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X25 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X26 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X27 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 Y A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.174 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.182 pd=1.92 as=0.174 ps=1.39 w=0.7 l=0.15
X2 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X3 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.272 ps=2.56 w=1 l=0.15
X15 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X17 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X19 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X24 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.257 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X30 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X38 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X2 a_193_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y A a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X4 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 a_109_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
X0 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X5 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X17 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X21 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X23 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X36 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X39 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_93_21# A1 a_346_47# VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.146 ps=1.1 w=0.65 l=0.15
X1 a_93_21# B1 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.185 ps=1.37 w=1 l=0.15
X2 a_584_47# B1 a_93_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.143 ps=1.09 w=0.65 l=0.15
X3 VPWR a_93_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.243 pd=1.49 as=0.33 ps=2.66 w=1 l=0.15
X4 VGND B2 a_584_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 a_256_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.167 ps=1.16 w=0.65 l=0.15
X6 a_250_297# B2 a_93_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 VGND a_93_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.167 pd=1.16 as=0.214 ps=1.96 w=0.65 l=0.15
X8 a_250_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.243 ps=1.49 w=1 l=0.15
X9 VPWR A2 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.225 pd=1.45 as=0.165 ps=1.33 w=1 l=0.15
X10 a_250_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.225 ps=1.45 w=1 l=0.15
X11 a_346_47# A2 a_256_47# VNB sky130_fd_pr__nfet_01v8 ad=0.146 pd=1.1 as=0.0975 ps=0.95 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
X0 a_109_93# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_215_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 VGND a_109_93# a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND A a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 VPWR A a_369_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_369_297# B a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_215_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X7 a_297_297# a_109_93# a_215_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_109_93# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 X a_215_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.1 ps=0.985 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
X0 VGND A a_68_297# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_68_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_68_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR A a_150_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 X a_68_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.34 pd=2.68 as=0.146 ps=1.34 w=1 l=0.15
X5 a_150_297# B a_68_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_223_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 Y A1 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X3 a_223_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X4 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 VGND A2 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_223_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X7 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.123 ps=1.03 w=0.65 l=0.15
X8 VPWR A2 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 a_658_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.201 ps=1.27 w=0.65 l=0.15
X10 VPWR A1 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_223_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 a_658_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 Y a_27_47# a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_223_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X15 VPWR A2 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.155 ps=1.31 w=1 l=0.15
X16 VPWR A1 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 a_658_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VGND B1_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.27 ps=2.13 w=0.65 l=0.15
X19 a_223_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X20 a_658_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 VGND A2 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.27 as=0.091 ps=0.93 w=0.65 l=0.15
X23 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X24 Y A1 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X25 Y a_27_47# a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_806_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_47# B1 a_1314_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=2.09 as=0.104 ps=0.97 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X17 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.0943 ps=0.94 w=0.65 l=0.15
X19 Y C1 a_978_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_27_47# B1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 a_806_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.675 pd=3.35 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.091 ps=0.93 w=0.65 l=0.15
X27 a_978_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.091 ps=0.93 w=0.65 l=0.15
X28 a_1314_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X31 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0683 ps=0.86 w=0.65 l=0.15
X1 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=2.1 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A1 a_114_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
X3 a_114_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.185 ps=1.87 w=0.65 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.28 ps=2.56 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X10 a_285_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.091 ps=0.93 w=0.65 l=0.15
X11 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
X0 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X5 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X7 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
X0 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_470_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_470_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_470_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.106 ps=0.975 w=0.65 l=0.15
X6 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X8 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X10 a_470_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.162 ps=1.33 w=1 l=0.15
X11 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 VPWR B a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X13 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X16 X a_112_47# a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 a_470_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X18 X B a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_300_297# a_27_413# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X3 Y a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.102 ps=0.99 w=0.65 l=0.15
X4 VPWR A1 a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 a_384_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.143 ps=1.09 w=0.65 l=0.15
X6 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.111 ps=1.37 w=0.42 l=0.15
X7 a_300_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
X0 X a_29_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.148 ps=1.34 w=1 l=0.15
X1 a_111_297# C a_29_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_29_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.102 ps=0.99 w=0.65 l=0.15
X3 a_183_297# B a_111_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 VPWR A a_183_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X5 a_29_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VGND C a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.149 ps=1.33 w=1 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.149 pd=1.33 as=0.166 ps=1.8 w=0.64 l=0.15
X3 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X4 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.091 ps=0.93 w=0.65 l=0.15
X1 Y B1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.175 ps=1.35 w=1 l=0.15
X4 a_29_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y A2 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND A1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 a_112_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X8 a_112_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.14 ps=1.28 w=1 l=0.15
X9 a_29_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X11 a_29_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_286_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X2 a_286_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X3 Y A2 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 VGND A1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X6 VGND A2 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X7 a_487_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# B1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR A1 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_27_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X13 a_487_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X14 a_286_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.745 as=0.111 ps=1.37 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.162 ps=1.33 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
X0 X a_61_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.167 ps=1.39 w=1 l=0.15
X1 VPWR a_61_75# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.195 ps=1.39 w=1 l=0.15
X2 VPWR B a_61_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 VGND B a_147_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 X a_61_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.112 ps=1.04 w=0.65 l=0.15
X5 VGND a_61_75# X VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.127 ps=1.04 w=0.65 l=0.15
X6 a_61_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X7 a_147_75# A a_61_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.35 as=0.265 ps=2.53 w=1 l=0.15
X1 a_209_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.172 ps=1.35 w=1 l=0.15
X2 a_303_47# A2 a_209_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.104 ps=0.97 w=0.65 l=0.15
X3 a_209_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.112 ps=0.995 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.172 ps=1.83 w=0.65 l=0.15
X5 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.107 ps=0.98 w=0.65 l=0.15
X6 a_80_21# A1 a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X7 VPWR A2 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.16 ps=1.32 w=1 l=0.15
X8 a_80_21# B1 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X9 a_209_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
X0 a_297_47# a_27_47# a_193_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_369_47# B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0441 ps=0.63 w=0.42 l=0.15
X2 VPWR D a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.0662 ps=0.735 w=0.42 l=0.15
X3 X a_193_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.103 ps=1 w=0.65 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND D a_469_47# VNB sky130_fd_pr__nfet_01v8 ad=0.103 pd=1 as=0.0609 ps=0.71 w=0.42 l=0.15
X6 X a_193_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR B a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.128 pd=1.03 as=0.0987 ps=0.89 w=0.42 l=0.15
X8 a_193_413# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.128 ps=1.03 w=0.42 l=0.15
X9 a_193_413# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0987 pd=0.89 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 a_469_47# C a_369_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.0735 ps=0.77 w=0.42 l=0.15
X11 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 VGND A4 a_321_47# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_321_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.123 ps=1.03 w=0.65 l=0.15
X2 a_103_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=1.52 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR a_103_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.425 ps=2.85 w=1 l=0.15
X4 VGND a_103_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.247 ps=2.06 w=0.65 l=0.15
X5 VGND A2 a_321_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X6 a_321_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.127 ps=1.04 w=0.65 l=0.15
X7 a_511_297# A3 a_393_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.22 ps=1.44 w=1 l=0.15
X8 a_619_297# A2 a_511_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X9 a_321_47# B1 a_103_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X10 a_393_297# A4 a_103_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.22 pd=1.44 as=0.26 ps=1.52 w=1 l=0.15
X11 VPWR A1 a_619_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.195 ps=1.39 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 a_78_199# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 VPWR A1 a_493_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X2 a_493_297# A2 a_78_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.235 ps=1.47 w=1 l=0.15
X3 VPWR a_78_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.373 pd=1.75 as=0.28 ps=2.56 w=1 l=0.15
X4 VGND A2 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X5 a_78_199# B2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.235 pd=1.47 as=0.117 ps=1.24 w=1 l=0.15
X6 a_215_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_215_47# B2 a_78_199# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_292_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.117 pd=1.24 as=0.373 ps=1.75 w=1 l=0.15
X9 VGND a_78_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_4 A B_N VGND VNB VPB VPWR X
X0 VPWR a_219_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.295 pd=2.59 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.202 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.17 pd=1.34 as=0.105 ps=1.21 w=1 l=0.15
X3 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.111 ps=0.99 w=0.65 l=0.15
X5 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X6 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=0.99 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_219_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND a_219_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.17 ps=1.34 w=1 l=0.15
X11 VGND a_219_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.214 pd=1.96 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.202 ps=1.4 w=0.65 l=0.15
X13 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_388_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.127 pd=1.25 as=0.153 ps=1.3 w=1 l=0.15
X1 a_105_352# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_297_47# a_105_352# Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A1 a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.127 ps=1.25 w=1 l=0.15
X5 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X6 VPWR B1_N a_105_352# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.178 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 Y a_105_352# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.178 ps=1.4 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 a_79_21# A1 a_348_47# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.133 ps=1.06 w=0.65 l=0.15
X1 a_79_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X2 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.2 pd=1.26 as=0.091 ps=0.93 w=0.65 l=0.15
X3 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 a_79_21# C1 a_585_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X5 VPWR A2 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.26 ps=2.52 w=1 l=0.15
X6 a_299_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.195 ps=1.39 w=1 l=0.15
X7 a_585_297# B1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X8 a_348_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.2 ps=1.26 w=0.65 l=0.15
X9 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.115 ps=1 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
X0 a_27_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y A a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y A a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_445_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X12 a_445_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_445_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X17 a_445_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X23 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
X0 Y a_251_21# a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y a_251_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X5 VGND a_251_21# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X7 VPWR B_N a_251_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X8 VGND B_N a_251_21# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_27_297# a_251_21# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_222_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X1 VPWR A1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.105 ps=1.21 w=1 l=0.15
X2 VGND a_79_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_222_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.186 ps=1.41 w=0.42 l=0.15
X4 VGND A2 a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_448_47# a_222_93# a_79_199# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_79_199# a_222_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.3 ps=2.6 w=1 l=0.15
X7 a_544_297# A2 a_79_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X8 a_448_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.186 pd=1.41 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VGND A1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
X1 a_510_47# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.143 ps=1.09 w=0.65 l=0.15
X2 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.175 ps=1.35 w=1 l=0.15
X3 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.22 ps=1.44 w=1 l=0.15
X4 a_79_21# A2 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.22 pd=1.44 as=0.162 ps=1.33 w=1 l=0.15
X5 a_297_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X6 a_79_21# C1 a_510_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.114 ps=1 w=0.65 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X8 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
X9 a_215_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.106 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.28 ps=2.56 w=1 l=0.15
X1 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X4 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.177 ps=1.36 w=1 l=0.15
X7 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.105 ps=1.21 w=1 l=0.15
X9 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR A2 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 a_277_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X2 a_79_21# B1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X3 a_277_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_361_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_277_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.127 ps=1.04 w=0.65 l=0.15
X9 a_79_21# A1 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X8 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X11 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=1.37 as=0.0588 ps=0.7 w=0.42 l=0.15
X18 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X20 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X21 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X22 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X23 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X25 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X26 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X27 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X28 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X29 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X30 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X31 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X32 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X33 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X34 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X35 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X36 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X37 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X38 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X39 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0578 ps=0.695 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
X0 X a_80_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_475_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X2 X a_80_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_762_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.31 ps=1.62 w=1 l=0.15
X5 a_475_47# B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VGND A2 a_475_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 X a_80_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X10 a_80_21# A2 a_762_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_80_21# B1 a_475_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X12 a_80_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.15 ps=1.3 w=1 l=0.15
X13 a_475_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.117 ps=1.01 w=0.65 l=0.15
X14 X a_80_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 VPWR A1 a_934_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X16 a_934_297# A2 a_80_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 VPWR B1 a_80_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=1.62 as=0.14 ps=1.28 w=1 l=0.15
X18 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND A1 a_475_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.117 ps=1.01 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
X0 VPWR A a_94_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.198 pd=1.39 as=0.305 ps=2.61 w=1 l=0.15
X1 a_294_47# B a_185_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.128 ps=1.04 w=0.65 l=0.15
X2 a_185_47# A a_94_47# VNB sky130_fd_pr__nfet_01v8 ad=0.128 pd=1.04 as=0.198 ps=1.91 w=0.65 l=0.15
X3 VPWR a_94_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND C a_294_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 a_94_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.198 ps=1.39 w=1 l=0.15
X6 X a_94_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X7 X a_94_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 VPWR C a_94_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X9 X a_94_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X10 VGND a_94_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X11 VPWR a_94_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND a_94_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 X a_94_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.26 ps=1.45 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.4 ps=1.8 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.205 pd=1.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.135 ps=1.27 w=1 l=0.15
X5 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_109_297# C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_39_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=1 w=0.65 l=0.15
X2 VPWR a_39_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_39_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.156 ps=1.36 w=1 l=0.15
X4 VGND a_39_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.156 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VGND A a_39_297# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=1 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_39_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_206_369# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.146 ps=1.34 w=0.42 l=0.15
X1 a_206_369# A2_N a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 VGND B2 a_489_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_585_369# B2 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0672 ps=0.74 w=0.42 l=0.15
X4 a_489_47# a_206_369# a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_489_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VPWR A2_N a_206_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.209 pd=1.35 as=0.129 ps=1.18 w=0.42 l=0.15
X7 a_76_199# a_206_369# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.74 as=0.209 ps=1.35 w=0.42 l=0.15
X8 a_205_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0662 pd=0.735 as=0.0986 ps=0.98 w=0.42 l=0.15
X9 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.26 ps=2.52 w=1 l=0.15
X10 VPWR B1 a_585_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0986 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X1 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0926 ps=0.935 w=0.65 l=0.15
X2 VPWR A1 a_307_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.105 ps=1.21 w=1 l=0.15
X3 a_307_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.233 ps=1.47 w=1 l=0.15
X4 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.233 pd=1.47 as=0.112 ps=1.23 w=1 l=0.15
X6 a_109_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.112 pd=1.23 as=0.26 ps=2.52 w=1 l=0.15
X7 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
X0 a_109_93# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_209_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X2 a_109_93# A_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_296_53# a_109_93# a_209_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.108 ps=1.36 w=0.42 l=0.15
X4 VPWR C a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0744 ps=0.815 w=0.42 l=0.15
X5 a_368_53# B a_296_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_209_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.122 ps=1.08 w=0.65 l=0.15
X7 a_209_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VPWR a_109_93# a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.108 ps=1.36 w=0.42 l=0.15
X9 VGND C a_368_53# VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.08 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 Y B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X1 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.135 ps=1.27 w=1 l=0.15
X3 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_381_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_109_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VGND A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0683 ps=0.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_197_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0798 pd=0.8 as=0.0609 ps=0.71 w=0.42 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.312 ps=1.68 w=1 l=0.15
X3 a_303_47# C a_197_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0798 ps=0.8 w=0.42 l=0.15
X4 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.68 as=0.0588 ps=0.7 w=0.42 l=0.15
X6 VGND D a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.196 pd=1.33 as=0.0693 ps=0.75 w=0.42 l=0.15
X7 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X8 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.196 ps=1.33 w=0.65 l=0.15
X9 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4b_4 A_N B C D VGND VNB VPB VPWR Y
X0 a_991_47# C a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_991_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y a_27_47# a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 a_991_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_47# a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_633_47# B a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_633_47# B a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND D a_991_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND D a_991_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_215_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X15 a_215_47# B a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_215_47# B a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X18 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VPWR D Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 a_633_47# C a_991_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X24 a_633_47# C a_991_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_215_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X30 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X31 a_991_47# C a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X32 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X33 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
X0 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X1 a_109_53# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_215_297# a_109_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_392_297# C a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0452 pd=0.635 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_465_297# B a_392_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.064 pd=0.725 as=0.0452 ps=0.635 w=0.42 l=0.15
X6 a_215_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 VPWR A a_465_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.064 ps=0.725 w=0.42 l=0.15
X8 a_297_297# a_109_53# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_109_53# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X10 VGND C a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.064 ps=0.725 w=0.42 l=0.15
X11 VGND A a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_8 A B VGND VNB VPB VPWR Y
X0 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.135 ps=1.27 w=1 l=0.15
X24 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X29 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X31 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 a_676_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.213 ps=1.42 w=1 l=0.15
X1 a_512_47# B1 a_409_47# VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.119 ps=1.01 w=0.65 l=0.15
X2 a_306_47# D1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.198 ps=1.91 w=0.65 l=0.15
X3 VGND A2 a_512_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.198 ps=1.26 w=0.65 l=0.15
X4 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.218 ps=1.43 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.305 ps=1.61 w=1 l=0.15
X6 VPWR A1 a_676_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.105 ps=1.21 w=1 l=0.15
X7 a_512_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_409_47# C1 a_306_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.119 ps=1.01 w=0.65 l=0.15
X9 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.382 pd=1.76 as=0.26 ps=2.52 w=1 l=0.15
X10 a_79_21# D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.218 pd=1.43 as=0.382 ps=1.76 w=1 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.172 ps=1.83 w=0.65 l=0.15
X2 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X3 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X5 a_326_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.127 ps=1.04 w=0.65 l=0.15
X6 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.635 pd=3.27 as=0.195 ps=1.39 w=1 l=0.15
X7 Y C1 a_326_47# VNB sky130_fd_pr__nfet_01v8 ad=0.393 pd=2.51 as=0.0683 ps=0.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.16 ps=1.32 w=1 l=0.15
X1 a_27_297# B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X2 VGND A2 a_373_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.114 ps=1 w=0.65 l=0.15
X3 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X4 a_27_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.253 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.253 ps=2.52 w=1 l=0.15
X6 a_373_47# A1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.96 w=0.65 l=0.15
X8 a_109_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 Y a_61_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.183 ps=1.24 w=0.65 l=0.15
X1 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_217_297# a_61_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_479_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X4 a_217_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X5 Y a_61_47# a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 VPWR A1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_61_47# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VGND A2 a_637_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_61_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A1 a_479_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0683 ps=0.86 w=0.65 l=0.15
X11 VGND B1_N a_61_47# VNB sky130_fd_pr__nfet_01v8 ad=0.183 pd=1.24 as=0.126 ps=1.44 w=0.42 l=0.15
X12 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X13 a_637_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 X a_79_204# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A1 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_473_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.195 ps=1.39 w=1 l=0.15
X3 X a_79_204# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X4 VGND C1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.104 ps=0.97 w=0.65 l=0.15
X5 a_79_204# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0926 ps=0.935 w=0.65 l=0.15
X6 VPWR a_79_204# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X7 a_473_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X8 a_473_297# B1 a_727_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.16 ps=1.32 w=1 l=0.15
X9 X a_79_204# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X10 VGND B1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.127 ps=1.04 w=0.65 l=0.15
X11 a_79_204# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.109 ps=0.985 w=0.65 l=0.15
X12 VGND a_79_204# X VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.0959 ps=0.945 w=0.65 l=0.15
X13 a_1123_47# A1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_555_297# B1 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X15 VPWR A2 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X16 VGND A2 a_1123_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.091 ps=0.93 w=0.65 l=0.15
X17 a_951_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.14 ps=1.08 w=0.65 l=0.15
X18 VPWR a_79_204# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_79_204# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X20 a_79_204# A1 a_951_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 a_79_204# C1 a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 a_727_297# C1 a_79_204# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X23 X a_79_204# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
X0 a_558_47# a_381_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X1 VGND X a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_841_47# a_664_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VPWR A a_62_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A a_62_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_558_47# a_381_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X6 X a_62_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR X a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_841_47# a_664_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X9 X a_62_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X10 VPWR a_558_47# a_664_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND a_558_47# a_664_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32oi_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.338 pd=1.67 as=0.135 ps=1.27 w=1 l=0.15
X5 a_1249_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_1249_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.252 pd=1.5 as=0.338 ps=1.67 w=1 l=0.15
X12 a_803_47# A2 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X16 a_803_47# A2 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X20 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X21 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_1249_47# A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.133 ps=1.06 w=0.65 l=0.15
X23 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 a_1249_47# A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.252 ps=1.5 w=1 l=0.15
X28 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X30 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X32 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X35 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 VGND A3 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X37 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VGND A3 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_397_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR B1_N a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X2 Y A2 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VGND A2 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND A1 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_28_297# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X6 Y a_28_297# a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VPWR a_28_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_397_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X9 a_229_47# a_28_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y a_28_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X11 a_229_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_229_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A1 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X4 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X5 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X6 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X8 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.301 ps=2.66 w=1 l=0.15
X9 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X10 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X11 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X12 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X13 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X14 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X15 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X16 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X17 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X18 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X19 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X20 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X21 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X22 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X23 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X24 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.209 ps=2.02 w=0.65 l=0.15
X25 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X26 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X27 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X28 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X29 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
X0 VPWR A a_304_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X1 a_304_297# B a_220_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND C a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X3 a_220_297# C a_114_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X4 a_32_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_32_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X11 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X13 a_114_297# D a_32_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.26 ps=2.52 w=1 l=0.15
X14 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
X0 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X1 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND B a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
X0 VPWR A a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_218_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.156 ps=1.16 w=0.42 l=0.15
X2 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.156 pd=1.16 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_300_297# a_27_53# a_218_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_218_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 VPWR a_218_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_218_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X7 VGND a_218_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 VGND A a_218_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
X0 VPWR S a_591_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.0672 ps=0.85 w=0.64 l=0.15
X1 a_591_369# A0 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.85 as=0.131 ps=1.05 w=0.64 l=0.15
X2 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.178 pd=1.41 as=0.135 ps=1.27 w=1 l=0.15
X3 a_79_21# A1 a_306_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.131 pd=1.05 as=0.229 ps=1.36 w=0.64 l=0.15
X4 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND S a_578_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0578 ps=0.695 w=0.42 l=0.15
X6 a_306_369# a_257_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.229 pd=1.36 as=0.178 ps=1.41 w=0.64 l=0.15
X7 a_79_21# A0 a_288_47# VNB sky130_fd_pr__nfet_01v8 ad=0.173 pd=1.25 as=0.0683 ps=0.745 w=0.42 l=0.15
X8 a_288_47# a_257_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.745 as=0.097 ps=0.975 w=0.42 l=0.15
X9 a_257_199# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 a_578_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.173 ps=1.25 w=0.42 l=0.15
X11 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X12 a_257_199# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.173 pd=1.82 as=0.0864 ps=0.91 w=0.64 l=0.15
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_75_199# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.135 ps=1.07 w=0.65 l=0.15
X1 a_208_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.112 ps=0.995 w=0.65 l=0.15
X2 a_315_47# A2 a_208_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.17 as=0.125 ps=1.03 w=0.65 l=0.15
X3 VGND B1 a_75_199# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.07 as=0.106 ps=0.975 w=0.65 l=0.15
X4 a_75_199# A1 a_315_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.17 w=0.65 l=0.15
X5 a_75_199# C1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.207 ps=1.41 w=1 l=0.15
X6 a_544_297# B1 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.207 pd=1.41 as=0.162 ps=1.33 w=1 l=0.15
X7 VPWR a_75_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.285 ps=2.57 w=1 l=0.15
X8 a_201_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.142 ps=1.28 w=1 l=0.15
X9 VPWR A2 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.165 ps=1.33 w=1 l=0.15
X10 a_201_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.305 ps=1.61 w=1 l=0.15
X11 VGND a_75_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X6 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X11 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 a_103_199# B1 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.107 ps=0.98 w=0.65 l=0.15
X1 VPWR a_103_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.36 ps=2.72 w=1 l=0.15
X2 a_337_297# A2 a_253_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_103_199# A3 a_337_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.165 ps=1.33 w=1 l=0.15
X4 a_253_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.195 ps=1.39 w=1 l=0.15
X5 VPWR B1 a_103_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.345 pd=2.69 as=0.213 ps=1.42 w=1 l=0.15
X6 VGND a_103_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.234 ps=2.02 w=0.65 l=0.15
X7 a_253_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X8 a_253_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X9 VGND A2 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X1 X a_80_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 VGND a_80_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=0.99 as=0.091 ps=0.93 w=0.65 l=0.15
X3 a_386_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.157 ps=1.32 w=1 l=0.15
X4 X a_80_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_80_199# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.162 pd=1.15 as=0.111 ps=0.99 w=0.65 l=0.15
X6 a_386_297# B1 a_80_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_458_47# A1 a_80_199# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.162 ps=1.15 w=0.65 l=0.15
X8 VPWR A1 a_386_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X9 VGND A2 a_458_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.123 ps=1.03 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 VPWR a_82_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.186 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X1 a_646_47# B2 a_82_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_574_369# a_313_47# a_82_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0976 pd=0.945 as=0.166 ps=1.8 w=0.64 l=0.15
X3 a_574_369# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X4 VGND a_82_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.09 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR B2 a_574_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.0976 ps=0.945 w=0.64 l=0.15
X6 X a_82_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.172 ps=1.83 w=0.65 l=0.15
X7 X a_82_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.265 ps=2.53 w=1 l=0.15
X8 a_313_47# A2_N a_313_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.17 pd=1.81 as=0.0672 ps=0.85 w=0.64 l=0.15
X9 a_313_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.12 ps=1.09 w=0.42 l=0.15
X10 a_313_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.85 as=0.186 ps=1.43 w=0.64 l=0.15
X11 VGND A2_N a_313_47# VNB sky130_fd_pr__nfet_01v8 ad=0.142 pd=1.1 as=0.0567 ps=0.69 w=0.42 l=0.15
X12 a_82_21# a_313_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.142 ps=1.1 w=0.42 l=0.15
X13 VGND B1 a_646_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X7 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.38 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X11 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X18 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.385 pd=1.77 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X9 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.385 ps=1.77 w=1 l=0.15
X14 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X21 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X31 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a221o_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.135 ps=1.27 w=1 l=0.15
X1 a_465_47# A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.157 ps=1.32 w=1 l=0.15
X3 a_109_297# B1 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 a_193_297# B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.965 w=0.65 l=0.15
X6 a_205_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X7 VPWR A2 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.165 ps=1.33 w=1 l=0.15
X8 a_193_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X9 a_27_47# B1 a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X10 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_109_297# C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X12 VGND C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X13 VGND A2 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.135 ps=1.27 w=1 l=0.15
X3 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X17 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_803_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_803_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 VGND A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X30 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X31 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 Y A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.109 ps=0.985 w=0.65 l=0.15
X4 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_949_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 Y C1 a_949_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.15 ps=1.3 w=1 l=0.15
X10 a_781_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_27_297# B1 a_781_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_781_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_1301_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.15 ps=1.3 w=1 l=0.15
X16 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 Y C1 a_781_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.14 ps=1.28 w=1 l=0.15
X18 a_109_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_109_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_109_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.091 ps=0.93 w=0.65 l=0.15
X27 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X28 a_27_297# B1 a_1301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X29 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0894 ps=0.925 w=0.65 l=0.15
X30 a_109_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X31 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
X0 a_27_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_27_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_277_297# B a_205_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VPWR A a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 a_205_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X6 VPWR a_27_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=2.61 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND a_27_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.91 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X9 VGND C a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0693 ps=0.75 w=0.42 l=0.15
X10 a_109_297# D a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND A a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd2_1 A VGND VNB VPB VPWR X
X0 VPWR A a_49_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VPWR a_221_47# a_327_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.18
X2 X a_327_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X3 VGND A a_49_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_327_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X5 a_221_47# a_49_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.18
X6 a_221_47# a_49_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.18
X7 VGND a_221_47# a_327_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.18
.ends

.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_33_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND A1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_33_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_797_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_797_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y B2 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR B1 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_33_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 a_33_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_33_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_33_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_797_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.16 ps=1.32 w=1 l=0.15
X17 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR B1 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND A2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_33_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 a_797_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.135 ps=1.27 w=1 l=0.15
X24 Y B2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 Y B2 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 Y B1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.104 ps=0.97 w=0.65 l=0.15
X27 Y B2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 Y B1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_33_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.29 ps=2.58 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32o_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 VPWR A3 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_299_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X2 a_352_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.21 ps=1.29 w=0.65 l=0.15
X3 a_549_47# A1 a_21_199# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.107 ps=0.98 w=0.65 l=0.15
X4 X a_21_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_21_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.21 pd=1.29 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_665_47# A2 a_549_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.14 ps=1.08 w=0.65 l=0.15
X7 VPWR A1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X8 a_299_297# B1 a_21_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_21_199# B2 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 VGND A3 a_665_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR a_21_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X12 X a_21_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_21_199# B1 a_352_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.115 ps=1 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
X0 Y C a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 a_281_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X6 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X10 a_281_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_297# B a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VGND A2 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR A1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_37_297# B1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_485_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_292_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VPWR A2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X8 a_485_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X11 a_37_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 Y A1 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X13 Y C1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_292_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X15 a_292_297# B1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_56_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A2 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_139_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.266 ps=2.12 w=0.65 l=0.15
X4 a_311_297# B1 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X5 Y C1 a_311_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X7 Y A1 a_139_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.117 ps=1.01 w=0.65 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.41 pd=1.82 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.175 ps=1.35 w=1 l=0.15
X4 a_277_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.41 ps=1.82 w=1 l=0.15
X10 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.18 ps=1.36 w=1 l=0.15
X11 a_277_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.114 ps=1 w=0.65 l=0.15
X13 Y A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.0975 ps=0.95 w=0.65 l=0.15
X14 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_277_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_277_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_277_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X5 a_277_47# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X6 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND a_277_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND a_277_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_193_47# A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_361_47# A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 X a_277_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A3 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X15 X a_277_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X16 a_277_47# A1 a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_445_47# A2 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND B1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_27_297# B1 a_277_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X21 VPWR a_277_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.5 pd=3 as=0.135 ps=1.27 w=1 l=0.15
X22 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X23 a_277_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
X0 VPWR a_30_53# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.315 pd=2.63 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND a_30_53# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_30_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X3 a_112_297# C a_30_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_30_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 VGND A a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 a_30_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 VGND C a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_184_297# B a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X9 VPWR A a_184_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X16 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X17 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X20 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
.ends

.subckt clarke VGND VPWR a[0] a[10] a[11] a[12] a[13] a[14] a[15] a[16] a[17] a[18]
+ a[1] a[2] a[3] a[4] a[5] a[6] a[7] a[8] a[9] alpha[0] alpha[10] alpha[11] alpha[12]
+ alpha[13] alpha[14] alpha[15] alpha[16] alpha[17] alpha[18] alpha[1] alpha[2] alpha[3]
+ alpha[4] alpha[5] alpha[6] alpha[7] alpha[8] alpha[9] b[0] b[10] b[11] b[12] b[13]
+ b[14] b[15] b[16] b[17] b[18] b[1] b[2] b[3] b[4] b[5] b[6] b[7] b[8] b[9] beta[0]
+ beta[10] beta[11] beta[12] beta[13] beta[14] beta[15] beta[16] beta[17] beta[18]
+ beta[1] beta[2] beta[3] beta[4] beta[5] beta[6] beta[7] beta[8] beta[9] clk done
+ rstb start
XFILLER_0_27_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer7 _0670_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1270_ _0399_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__buf_1
X_1606_ _0729_ net105 _0707_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_13_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1537_ _0663_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__buf_6
XFILLER_0_38_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1399_ _0517_ _0519_ _0525_ _0504_ _0528_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__a221o_1
X_1468_ _0595_ _0596_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1322_ _0434_ _0435_ _0451_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__a21o_1
X_1253_ _0336_ _0351_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__xnor2_2
X_1184_ _0306_ _0313_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_20_Left_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1940_ _0087_ _0089_ _0095_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__o21a_1
X_1871_ _0987_ _0988_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1305_ _0413_ _0412_ _0395_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1236_ _0290_ _0291_ _0296_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__nand3_2
X_1167_ _0279_ _0280_ _0286_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__a21o_1
X_1098_ _0226_ _0227_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1021_ _0159_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__clkbuf_1
X_1923_ _0054_ _0056_ _0052_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__o21a_1
X_1785_ _0904_ _0905_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__xor2_1
X_1854_ _0924_ _0949_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__and2b_1
X_1219_ _0345_ _0348_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__and2b_1
XFILLER_0_47_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold30 net65 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_51_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1570_ _0679_ _0680_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__or2b_1
Xrebuffer17 _0715_ VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__clkbuf_1
Xrebuffer28 _0568_ VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_16_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1004_ net52 net12 net83 VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__mux2_1
X_1837_ _0615_ _0286_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__nand2_1
X_1906_ _0063_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__inv_2
X_1768_ _0886_ _0889_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__xnor2_1
X_1699_ _0802_ _0822_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput64 net64 VGND VGND VPWR VPWR beta[13] sky130_fd_sc_hd__clkbuf_4
Xoutput75 net75 VGND VGND VPWR VPWR beta[6] sky130_fd_sc_hd__clkbuf_4
Xoutput53 net53 VGND VGND VPWR VPWR alpha[3] sky130_fd_sc_hd__clkbuf_4
Xoutput42 net42 VGND VGND VPWR VPWR alpha[10] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1622_ _0745_ _0746_ _0747_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__a21oi_1
X_1484_ _0610_ _0611_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__nor2_1
X_1553_ _0371_ _0636_ _0635_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_43_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer8 _0722_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1536_ net130 _0569_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__and2_1
X_1605_ _0707_ _0729_ _0730_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__and3_1
X_1398_ _0517_ _0525_ _0527_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__a21o_1
X_1467_ _0593_ _0594_ _0549_ _0550_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__a211o_1
X_2019_ clknet_2_3__leaf_clk _0023_ net89 VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1321_ _0437_ _0449_ _0450_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__o21ai_1
X_1252_ _0378_ _0381_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__and2_1
X_1183_ _0309_ _0312_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__xor2_4
XFILLER_0_24_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1519_ _0644_ _0645_ _0605_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_4_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1870_ _0985_ _0986_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1304_ _0413_ _0395_ _0412_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__nand3_1
X_1235_ _0342_ _0341_ _0307_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__a21o_1
X_1166_ _0295_ _0245_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__xnor2_4
X_1097_ _0221_ _0225_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1999_ clknet_2_1__leaf_clk _0003_ net88 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_33_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1020_ net42 net2 net83 VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__mux2_1
X_1922_ _0072_ _0078_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__xnor2_1
X_1784_ _0631_ _0632_ _0878_ _0876_ _0672_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__a32o_1
X_1853_ _0946_ _0971_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__xnor2_2
X_1149_ _0264_ net95 _0275_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__nand3_1
X_1218_ _0345_ _0346_ _0347_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__or3b_1
XFILLER_0_47_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold31 net67 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer18 _0715_ VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__clkbuf_1
X_1003_ _0150_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer29 _0177_ VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_44_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1905_ _0972_ _0997_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__or2_1
XFILLER_0_32_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1836_ _0561_ _0319_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__nand2_1
X_1767_ _0833_ _0887_ _0888_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__a21oi_1
X_1698_ _0820_ _0821_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput65 net65 VGND VGND VPWR VPWR beta[14] sky130_fd_sc_hd__clkbuf_4
Xoutput76 net76 VGND VGND VPWR VPWR beta[7] sky130_fd_sc_hd__clkbuf_4
Xoutput54 net54 VGND VGND VPWR VPWR alpha[4] sky130_fd_sc_hd__clkbuf_4
Xoutput43 net43 VGND VGND VPWR VPWR alpha[11] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_41_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1621_ _0654_ _0685_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__nand2_1
X_1552_ _0661_ _0678_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__xnor2_2
X_1483_ _0404_ _0609_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__and2_1
XFILLER_0_17_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1819_ _0935_ _0938_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__xnor2_1
Xrebuffer9 _0723_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1535_ _0272_ _0626_ _0628_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__a21boi_4
X_1604_ _0725_ _0726_ _0728_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1397_ _0503_ _0526_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__nand2_1
X_1466_ _0549_ net81 _0593_ _0594_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_49_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2018_ clknet_2_0__leaf_clk _0022_ net89 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_9_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1320_ _0446_ _0448_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__or2b_1
X_1251_ _0378_ _0379_ _0380_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__nand3_1
X_1182_ _0200_ _0216_ _0311_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_46_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1449_ _0278_ _0288_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__nor2_2
X_1518_ _0605_ _0644_ _0645_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__and3_1
XFILLER_0_51_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1303_ net92 _0432_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__and2_1
X_1096_ _0221_ _0225_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__and2_1
X_1234_ _0307_ _0342_ _0341_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__nand3_1
X_1165_ _0236_ _0239_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__nand2_4
XFILLER_0_42_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1998_ clknet_2_1__leaf_clk _0002_ net88 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_33_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1921_ _0049_ _0077_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__xnor2_1
X_1852_ _0969_ _0970_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_16_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1783_ _0675_ _0811_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__xnor2_1
X_1148_ _0264_ _0277_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_1_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1079_ _0207_ _0208_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__nand2_1
X_1217_ _0193_ _0202_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__xor2_2
Xhold32 net66 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_21_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer19 _0620_ VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__clkbuf_1
X_1002_ net51 net11 net83 VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__mux2_1
X_1904_ _0060_ _0061_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__nand2_1
X_1835_ _0952_ _0953_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1766_ _0849_ _0851_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__nor2_1
X_1697_ _0763_ _0781_ _0780_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_12_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput66 net66 VGND VGND VPWR VPWR beta[15] sky130_fd_sc_hd__clkbuf_4
Xoutput77 net77 VGND VGND VPWR VPWR beta[8] sky130_fd_sc_hd__clkbuf_4
Xoutput55 net55 VGND VGND VPWR VPWR alpha[5] sky130_fd_sc_hd__clkbuf_4
Xoutput44 net44 VGND VGND VPWR VPWR alpha[12] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_26_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1551_ _0676_ _0677_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__xor2_2
X_1482_ _0404_ _0609_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__nor2_1
X_1620_ _0741_ _0742_ _0744_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__o21ai_1
X_2034_ clknet_2_2__leaf_clk _0038_ net91 VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dfrtp_1
X_1818_ _0907_ _0937_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__xor2_1
XFILLER_0_32_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1749_ _0574_ _0869_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_37_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_48_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1603_ _0725_ _0726_ _0728_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__nand3_2
X_1465_ _0591_ _0592_ _0229_ _0232_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__a211o_1
X_1534_ _0342_ _0341_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__and2_1
XFILLER_0_38_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1396_ _0502_ _0497_ _0501_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__or3_1
X_2017_ clknet_2_3__leaf_clk _0021_ net87 VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_49_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1250_ _0348_ _0377_ _0376_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__a21o_1
X_1181_ _0188_ _0310_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__and2_1
XFILLER_0_24_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1448_ _0574_ _0575_ _0319_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1517_ _0642_ _0643_ _0606_ _0589_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__a211o_1
X_1379_ _0495_ _0508_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__or2_1
XFILLER_0_28_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout90 net39 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_24_Left_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1302_ _0428_ _0431_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__nor2_1
X_1233_ _0356_ _0359_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_19_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1164_ _0289_ _0293_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__xnor2_2
X_1095_ _0224_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__buf_2
XFILLER_0_51_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1997_ clknet_2_0__leaf_clk _0001_ net87 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_2_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1920_ _0042_ _0076_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__xnor2_2
X_1851_ _0940_ _0943_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__nor2_1
X_1782_ _0834_ _0872_ _0870_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_24_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1216_ _0325_ _0344_ _0343_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__a21oi_1
X_1147_ _0272_ _0276_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__xor2_4
X_1078_ net92 _0206_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__or2_1
XFILLER_0_47_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold33 net79 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_32_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1001_ _0149_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1834_ _0770_ _0771_ _0876_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__a21oi_1
X_1903_ _0994_ _0059_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__or2_1
X_1765_ _0849_ _0851_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__nand2_1
X_1696_ _0809_ _0819_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_11_Left_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput67 net67 VGND VGND VPWR VPWR beta[16] sky130_fd_sc_hd__clkbuf_4
Xoutput78 net78 VGND VGND VPWR VPWR beta[9] sky130_fd_sc_hd__clkbuf_4
Xoutput56 net56 VGND VGND VPWR VPWR alpha[6] sky130_fd_sc_hd__clkbuf_4
Xoutput45 net45 VGND VGND VPWR VPWR alpha[13] sky130_fd_sc_hd__clkbuf_4
X_1550_ _0286_ _0632_ _0631_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__a21bo_1
X_1481_ _0607_ _0608_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__nand2_1
X_2033_ clknet_2_2__leaf_clk _0037_ net91 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_43_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1817_ _0727_ _0936_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__xnor2_1
X_1748_ _0574_ _0869_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__or2_1
XFILLER_0_7_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1679_ _0307_ _0293_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__nand2_2
XFILLER_0_13_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1602_ _0264_ _0675_ _0727_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1395_ _0521_ _0524_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__nand2_1
X_1464_ _0229_ _0232_ _0591_ _0592_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_22_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1533_ _0658_ _0659_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__nor2_1
X_2016_ clknet_2_0__leaf_clk _0020_ net87 VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_9_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1180_ _0213_ _0214_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_42_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1516_ _0606_ _0589_ _0642_ _0643_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__o211ai_2
X_1447_ _0319_ _0574_ _0575_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__nand3_2
XFILLER_0_4_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1378_ _0225_ _0363_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout91 net39 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_51_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1232_ _0361_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__clkbuf_4
X_1301_ _0206_ _0362_ _0430_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_19_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1163_ _0292_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__buf_4
X_1094_ _0222_ _0223_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__and2_1
XFILLER_0_51_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1996_ clknet_2_3__leaf_clk _0000_ net90 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_41_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1850_ _0966_ _0968_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__xor2_2
X_1781_ _0885_ _0866_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__and2b_1
XFILLER_0_46_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1146_ _0274_ _0275_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__and2_2
X_1215_ _0325_ _0343_ _0344_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__and3_1
XFILLER_0_47_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1077_ net92 _0206_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__nand2_1
X_1979_ _0130_ _0131_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__or2_1
Xhold34 net50 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_46_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1000_ net41 net92 net82 VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__mux2_1
X_1902_ _0994_ _0059_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1833_ _0876_ _0770_ _0771_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__and3_1
X_1764_ _0866_ _0885_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__xnor2_1
X_1695_ _0817_ _0818_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__xnor2_1
X_1129_ net23 net5 VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__nand2_1
Xoutput57 net57 VGND VGND VPWR VPWR alpha[7] sky130_fd_sc_hd__clkbuf_4
Xoutput46 net46 VGND VGND VPWR VPWR alpha[14] sky130_fd_sc_hd__clkbuf_4
Xoutput79 net79 VGND VGND VPWR VPWR done sky130_fd_sc_hd__clkbuf_4
Xoutput68 net68 VGND VGND VPWR VPWR beta[17] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1480_ _0200_ _0206_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__or2_1
X_2032_ clknet_2_3__leaf_clk _0036_ net91 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1816_ _0561_ _0299_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__xnor2_1
X_1747_ _0867_ _0868_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__or2_1
X_1678_ _0390_ _0310_ _0762_ _0760_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__a31o_1
XFILLER_0_7_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1601_ _0662_ _0674_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1532_ _0607_ _0657_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__and2_1
X_1394_ _0514_ _0522_ _0523_ _0432_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__and4b_1
X_1463_ _0589_ _0590_ _0551_ _0552_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_9_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2015_ clknet_2_3__leaf_clk _0019_ net87 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_6_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1515_ _0640_ _0641_ _0613_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__a21o_1
X_1446_ _0572_ _0573_ _0560_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__a21o_1
X_1377_ _0493_ _0506_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout92 net1 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__buf_2
XFILLER_0_51_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1162_ _0290_ _0291_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__and2_1
X_1231_ net97 _0222_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__xnor2_4
X_1300_ _0224_ _0429_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__and2_1
X_1093_ net20 net11 VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__or2_1
X_1995_ _0769_ _0141_ _0145_ _0146_ _0147_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__o41a_1
XFILLER_0_27_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1429_ _0556_ _0557_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__nor2_1
XFILLER_0_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1780_ _0882_ _0884_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__nor2_1
XFILLER_0_24_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1145_ _0259_ _0261_ _0273_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__nand3_2
XFILLER_0_1_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1214_ _0323_ _0324_ _0310_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__a21o_1
X_1076_ _0205_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__clkbuf_4
X_1978_ _0130_ _0131_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold35 net48 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_21_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1901_ _0057_ _0058_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__xnor2_1
X_1832_ net85 net121 _0950_ _0951_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__o22a_1
XFILLER_0_32_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1694_ _0328_ _0776_ _0775_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__a21boi_1
X_1763_ _0882_ _0884_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__xnor2_1
X_1128_ net23 net5 VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__or2_1
X_1059_ _0183_ _0184_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__or2b_4
Xoutput69 net69 VGND VGND VPWR VPWR beta[18] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_43_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput58 net58 VGND VGND VPWR VPWR alpha[8] sky130_fd_sc_hd__clkbuf_4
Xoutput47 net47 VGND VGND VPWR VPWR alpha[15] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_26_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2031_ clknet_2_2__leaf_clk _0035_ net91 VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__dfrtp_1
X_1815_ _0933_ _0934_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1746_ _0286_ _0296_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__nor2_1
X_1677_ _0791_ _0798_ _0790_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_31_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1600_ _0723_ _0724_ _0561_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__a21o_1
X_1462_ _0551_ _0552_ _0589_ _0590_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__a211o_2
X_1531_ _0607_ _0657_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__nor2_1
XFILLER_0_38_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1393_ net1 _0400_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_9_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2014_ clknet_2_3__leaf_clk _0018_ net87 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__dfrtp_1
X_1729_ _0849_ _0851_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1445_ _0560_ _0572_ _0573_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__nand3_4
X_1514_ _0613_ _0640_ _0641_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__nand3_1
X_1376_ _0474_ _0480_ _0492_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout82 net84 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__buf_4
XFILLER_0_35_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1161_ _0243_ _0281_ _0242_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__a21o_1
X_1092_ net20 net11 VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__nand2_2
X_1230_ _0356_ _0359_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__nor2b_2
XFILLER_0_51_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1994_ net86 net69 VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__or2_1
XFILLER_0_27_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1428_ _0442_ _0555_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__nor2_1
X_1359_ _0485_ _0487_ _0488_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_18_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1213_ _0307_ _0341_ _0342_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__a21bo_1
X_1144_ _0259_ _0261_ _0273_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__a21o_1
X_1075_ _0204_ net115 VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__xnor2_1
X_1977_ _0876_ _0111_ _0093_ _0114_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__a31o_1
XFILLER_0_30_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold36 net45 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_46_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1900_ _0989_ _0991_ _0987_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__o21a_1
X_1831_ _0922_ _0926_ _0949_ _0601_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__a31o_1
X_1693_ _0289_ _0816_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__xor2_1
X_1762_ _0838_ _0848_ _0883_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__a21oi_1
X_1127_ _0255_ _0252_ _0256_ _0246_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__o211a_1
X_1058_ net116 _0187_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_7_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput59 net59 VGND VGND VPWR VPWR alpha[9] sky130_fd_sc_hd__clkbuf_4
Xoutput48 net48 VGND VGND VPWR VPWR alpha[16] sky130_fd_sc_hd__clkbuf_4
X_2030_ clknet_2_2__leaf_clk _0034_ net91 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__dfrtp_1
X_1814_ _0675_ _0766_ _0841_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__a21oi_1
X_1745_ _0283_ _0284_ _0296_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__and3_1
XFILLER_0_4_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1676_ _0800_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_15_Left_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1392_ net1 _0513_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__or2_1
X_1461_ _0587_ _0588_ _0559_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__a21oi_2
X_1530_ _0372_ _0656_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2013_ clknet_2_3__leaf_clk _0017_ net87 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_49_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1728_ _0809_ _0819_ _0850_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__a21oi_2
X_1659_ _0756_ net107 _0782_ _0783_ VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__o211a_1
XFILLER_0_48_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1444_ _0570_ _0571_ _0562_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__o21ai_2
X_1375_ _0503_ _0504_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1513_ _0637_ _0638_ _0639_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__a21o_1
XFILLER_0_45_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_18_Left_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout83 net84 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_19_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1160_ _0242_ _0243_ _0281_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__nand3_2
X_1091_ _0199_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__inv_2
X_1993_ _0116_ _0117_ _0134_ _0601_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__a31o_1
XFILLER_0_42_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1358_ _0483_ _0484_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__nor2_1
X_1427_ _0442_ _0555_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__and2_1
X_1289_ _0416_ _0418_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_3_Left_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1212_ _0337_ _0340_ _0338_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__nand3_2
XFILLER_0_46_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1143_ _0268_ _0270_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__or2_4
XFILLER_0_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1074_ _0176_ _0172_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__or2b_1
X_1976_ _0124_ _0129_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_45_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold37 net53 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_37_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1830_ _0922_ _0926_ _0949_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__a21oi_1
X_1761_ _0845_ _0847_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1692_ _0814_ _0815_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__xnor2_1
X_1126_ _0249_ _0247_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__or2b_1
XFILLER_0_35_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1057_ _0171_ net131 _0185_ _0186_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__a31o_2
X_1959_ _0091_ _0110_ _0113_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_11_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput49 net49 VGND VGND VPWR VPWR alpha[17] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_27_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap80 _0798_ VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__buf_1
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
X_1813_ _0723_ _0724_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__and2_1
X_1744_ _0578_ _0836_ _0865_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_7_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1675_ net74 _0799_ net85 VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1109_ _0237_ _0235_ _0238_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__o21a_4
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_32_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1391_ _0517_ _0520_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__and2_1
X_1460_ _0559_ _0587_ _0588_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__and3_4
X_2012_ clknet_2_1__leaf_clk _0016_ net89 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_9_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1727_ _0818_ _0817_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__and2b_1
X_1658_ _0780_ _0781_ _0763_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__a21o_1
XFILLER_0_13_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1589_ _0667_ _0713_ _0714_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__and3_1
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1512_ _0637_ _0638_ _0639_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__nand3_1
X_1443_ _0562_ _0570_ _0571_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__or3_4
X_1374_ _0481_ _0490_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_45_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout84 net40 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__buf_2
X_1090_ _0217_ _0219_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__nor2_1
X_1992_ _0766_ _0142_ _0144_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_27_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1288_ _0393_ _0416_ _0417_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__nand3_1
X_1357_ _0362_ _0486_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__xnor2_1
X_1426_ _0553_ _0554_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__and2_1
XFILLER_0_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1142_ _0267_ _0271_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__xnor2_4
X_1211_ _0337_ _0338_ _0340_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__a21o_1
X_1073_ _0193_ _0202_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__or2_2
X_1975_ _0127_ _0128_ _0875_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__and3_1
XFILLER_0_11_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1409_ _0493_ _0494_ _0537_ _0538_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_16_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1691_ _0615_ _0771_ _0770_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__a21boi_1
X_1760_ _0873_ _0881_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__xnor2_1
X_1125_ _0241_ _0243_ _0240_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__a21o_1
XFILLER_0_7_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1056_ _0169_ _0184_ _0183_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__a21oi_1
X_1958_ _0111_ _0112_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__xor2_1
X_1889_ _0264_ _0664_ _0045_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_43_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xmax_cap81 _0550_ VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__buf_1
X_1812_ _0904_ _0905_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__nand2_1
X_1743_ _0803_ _0837_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__or2b_1
X_1674_ _0792_ net80 VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1039_ net33 net15 VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__nand2_1
X_1108_ _0180_ _0212_ _0211_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1390_ _0516_ _0512_ _0514_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__or3_1
XFILLER_0_49_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2011_ clknet_2_1__leaf_clk _0015_ net88 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_9_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1588_ _0622_ _0670_ _0666_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__a21o_1
X_1726_ _0838_ _0848_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__xnor2_2
X_1657_ _0763_ _0780_ _0781_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__nand3_1
XFILLER_0_0_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_2_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_39_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1442_ _0568_ _0569_ _0272_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__a21oi_2
X_1511_ _0440_ _0581_ _0580_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__a21bo_1
X_1373_ _0497_ _0501_ _0502_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_4_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1709_ _0830_ _0822_ _0831_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__o21ba_1
Xfanout85 net40 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_36_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1991_ _0124_ _0143_ _0132_ _0128_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__o211a_1
X_1425_ _0390_ _0362_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__or2_1
X_1287_ _0381_ _0415_ _0414_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__a21o_1
X_1356_ net92 _0225_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__or2_1
XFILLER_0_18_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1141_ _0261_ _0269_ _0270_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__a21oi_2
X_1210_ _0290_ _0291_ _0319_ _0296_ _0339_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__a32o_1
X_1072_ _0195_ _0199_ _0201_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__o21a_1
X_1974_ _0673_ _0840_ _0111_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__or3_1
Xhold28 net75 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__dlygate4sd3_1
X_1408_ _0493_ _0494_ _0505_ _0507_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__o22ai_1
X_1339_ _0467_ _0468_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1690_ _0812_ _0813_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1124_ net93 _0239_ _0253_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__a21o_1
X_1055_ _0183_ _0184_ _0170_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__and3b_1
X_1957_ _0840_ _0093_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1888_ _0264_ _0664_ _0045_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__and3_1
XFILLER_0_11_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1811_ _0327_ _0910_ _0286_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__or3b_1
XFILLER_0_40_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1742_ _0832_ _0853_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__or2b_1
X_1673_ _0794_ _0795_ _0797_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__nor3_1
XFILLER_0_7_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1038_ net33 net15 VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__or2_1
X_1107_ _0169_ _0184_ _0183_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__a21o_1
XFILLER_0_13_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2010_ clknet_2_0__leaf_clk _0014_ net87 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_45_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1725_ _0845_ _0847_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__xor2_2
X_1587_ _0711_ _0712_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__or2_1
X_1656_ _0777_ _0778_ _0779_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__a21o_1
XFILLER_0_48_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1441_ _0272_ _0568_ _0569_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__and3_1
XFILLER_0_10_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1510_ _0635_ _0636_ _0371_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1372_ _0485_ _0487_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__xor2_1
XFILLER_0_14_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1708_ net134 _0821_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1639_ _0672_ _0718_ _0719_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__and3_1
Xfanout86 net40 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__buf_2
XFILLER_0_36_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1990_ _0129_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__inv_2
XFILLER_0_42_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_50_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1355_ _0483_ _0484_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__xnor2_1
X_1424_ _0390_ _0362_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__nand2_1
X_1286_ _0381_ _0414_ _0415_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__nand3_1
XFILLER_0_25_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1140_ net24 net6 VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1071_ _0179_ _0200_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__nand2_1
X_1973_ _0126_ _0840_ _0111_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__or3b_1
XFILLER_0_15_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold29 net61 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__dlygate4sd3_1
X_1407_ _0505_ _0507_ _0529_ _0536_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__a22oi_1
X_1338_ _0206_ _0315_ _0220_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__a21oi_1
X_1269_ _0392_ _0398_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_7_Left_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1123_ _0242_ _0245_ _0252_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__or3_4
X_1054_ net34 net16 VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__nand2_1
X_1956_ net113 _0109_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__xnor2_2
X_1887_ _0841_ _0044_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1810_ _0631_ _0909_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__or2_1
X_1741_ _0861_ _0858_ _0862_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__o21ai_1
X_1672_ _0547_ _0598_ _0651_ _0796_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__and4_1
XFILLER_0_17_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1106_ _0235_ _0177_ _0171_ _0185_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__nand4b_4
X_1037_ _0167_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__clkbuf_1
X_1939_ _0090_ _0094_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__xor2_1
XFILLER_0_16_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1724_ _0289_ _0816_ _0846_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1586_ net10 net29 VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__nor2_2
X_1655_ _0777_ _0778_ _0779_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__nand3_1
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_36_Left_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1440_ _0266_ _0564_ _0567_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__nand3_4
X_1371_ _0486_ _0498_ _0500_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__and3_1
XFILLER_0_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1707_ _0802_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__inv_2
X_1638_ _0699_ _0762_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__xnor2_1
X_1569_ _0372_ _0656_ _0658_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout87 net89 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_35_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1285_ _0378_ _0380_ _0379_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__a21o_1
X_1354_ _0347_ _0362_ _0203_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__a21boi_1
X_1423_ _0234_ _0333_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_39_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1070_ _0194_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__buf_4
X_1972_ _0709_ _0125_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_23_Left_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1406_ _0519_ _0534_ _0535_ _0528_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__or4b_1
X_1268_ _0357_ _0389_ _0391_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__and3_1
X_1337_ _0199_ _0313_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_36_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1199_ _0327_ _0328_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1122_ _0248_ _0251_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__or2_1
XFILLER_0_20_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1053_ net34 net16 VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__nor2_1
X_1955_ _0664_ _0981_ _0876_ _0109_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__o211ai_2
X_1886_ _0042_ _0043_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1740_ _0824_ _0854_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__nand2_1
X_1671_ _0748_ _0749_ _0687_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__o21a_1
XFILLER_0_40_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1105_ _0182_ _0211_ _0212_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__or3_4
X_1036_ net126 net10 net82 VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__mux2_1
X_1938_ _0093_ _0088_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__xor2_1
X_1869_ _0985_ _0986_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_10_Left_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1723_ _0815_ _0814_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__and2b_1
X_1654_ _0707_ _0730_ _0729_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__a21bo_1
X_1585_ net10 net29 VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__and2_1
X_1019_ _0158_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1370_ _0497_ _0499_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__nor2_1
X_1706_ net85 _0828_ _0829_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__a21oi_1
X_1637_ _0760_ _0761_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__and2b_1
XFILLER_0_5_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1499_ _0625_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__clkbuf_4
X_1568_ _0692_ _0689_ _0693_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__o21a_1
XFILLER_0_36_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout88 net89 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_35_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1422_ _0314_ _0332_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__nand2_1
X_1284_ _0395_ _0412_ _0413_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__a21bo_1
X_1353_ _0206_ _0315_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__xnor2_1
X_0999_ _0148_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1971_ _0627_ _0672_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__nor2_1
X_1405_ _0517_ _0527_ _0525_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__and3_1
X_1198_ _0304_ _0303_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__and2_2
Xinput1 a[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_2
X_1267_ _0375_ _0374_ _0363_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__a21o_1
X_1336_ _0464_ _0465_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_40_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1121_ _0249_ _0250_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__nand2_8
X_1052_ _0181_ _0180_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__nand2_1
X_1954_ _0664_ _0981_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__nand2_2
XFILLER_0_28_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1885_ _0561_ _0627_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1319_ _0446_ _0448_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__xor2_1
XFILLER_0_2_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1670_ _0748_ _0749_ _0650_ _0687_ _0688_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__o2111a_1
X_1104_ _0232_ _0233_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1035_ _0166_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__clkbuf_1
X_1937_ _0091_ _0092_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__and2_1
XFILLER_0_33_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1868_ _0954_ _0960_ _0952_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__a21oi_1
X_1799_ _0901_ _0902_ _0918_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__or3_1
XFILLER_0_3_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1584_ _0664_ _0673_ _0709_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__a21oi_1
X_1722_ _0839_ _0844_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__xnor2_2
X_1653_ _0775_ _0776_ _0328_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1018_ net59 net19 net82 VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__mux2_1
XFILLER_0_39_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1705_ net85 net120 VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1636_ _0323_ _0759_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__nand2_1
X_1567_ _0648_ _0686_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__or2_1
X_1498_ net130 _0569_ _0625_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__a21o_1
Xfanout89 net39 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__buf_2
XFILLER_0_19_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1421_ _0203_ _0209_ _0354_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__nor3_1
X_1283_ _0396_ _0411_ _0397_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__nand3_1
X_1352_ _0466_ _0469_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__xor2_1
XFILLER_0_25_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0998_ net125 net85 VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__or2_1
XFILLER_0_1_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1619_ _0741_ _0742_ _0744_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__or3_4
XFILLER_0_32_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1970_ _0840_ _0109_ _0627_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__mux2_1
X_1404_ _0531_ _0532_ _0525_ _0533_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__o211ai_1
X_1335_ _0461_ _0463_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1266_ _0375_ _0363_ _0374_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__nand3_1
Xinput2 a[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_1
X_1197_ _0295_ _0245_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__xor2_4
XFILLER_0_46_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1120_ net3 net21 VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__or2_4
X_1051_ net17 net35 VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__or2_4
X_1884_ _0561_ _0627_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__nand2_1
X_1953_ _0601_ net124 _0106_ _0108_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__a22o_1
X_1318_ _0400_ _0447_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__xnor2_1
X_1249_ _0360_ _0362_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__xor2_1
XFILLER_0_34_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1103_ _0207_ _0231_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__and2_1
X_1034_ net49 net9 net82 VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__mux2_1
X_1936_ _0814_ _0073_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__or2_1
X_1867_ _0981_ _0984_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__xnor2_1
X_1798_ _0901_ _0902_ _0918_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_3_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1721_ _0842_ _0843_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__and2b_1
X_1583_ net112 _0708_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__nor2_1
X_1652_ _0328_ _0775_ _0776_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__nand3_1
X_1017_ _0157_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__clkbuf_1
X_1919_ _0840_ _0075_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_8_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1704_ _0801_ _0827_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__xnor2_1
X_1497_ _0621_ _0624_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__xor2_2
X_1635_ _0323_ _0759_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__nor2_1
X_1566_ _0648_ _0686_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__and2_1
XFILLER_0_51_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1351_ net92 net98 _0225_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__and3_1
X_1420_ _0334_ _0353_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__and2b_1
X_1282_ _0396_ _0397_ _0411_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__a21o_1
XFILLER_0_41_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1618_ _0655_ _0684_ _0743_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__a21oi_1
X_1549_ _0264_ _0675_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__xor2_2
XFILLER_0_5_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1265_ _0393_ _0394_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__nor2_1
X_1403_ _0521_ _0524_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__or2_1
X_1334_ _0461_ _0463_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 a[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__clkbuf_2
X_1196_ _0323_ _0325_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_27_Left_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1050_ net35 net17 VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__nand2_1
X_1883_ _0667_ _0711_ _0714_ _0981_ _0984_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__a32o_1
X_1952_ _0601_ _0107_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1317_ _0407_ _0408_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__xor2_1
X_1248_ _0348_ _0376_ _0377_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__nand3_1
XFILLER_0_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1179_ _0307_ _0308_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__xnor2_4
X_1102_ _0207_ _0231_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__nor2_1
X_1033_ _0165_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__clkbuf_1
X_1935_ _0814_ _0073_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__nand2_1
X_1866_ _0956_ _0983_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__xnor2_1
X_1797_ _0903_ _0917_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_31_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1651_ _0772_ _0773_ _0774_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__a21o_1
X_1720_ _0627_ _0841_ _0812_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__or3_1
X_1582_ _0668_ _0671_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1016_ net58 net18 net83 VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_14_Left_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1918_ _0073_ _0074_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__nor2_1
X_1849_ _0907_ _0937_ _0967_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__o21a_1
XFILLER_0_5_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1634_ _0757_ _0758_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__nand2_1
X_1703_ _0788_ _0826_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__xor2_2
XFILLER_0_5_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1496_ _0622_ _0623_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1565_ _0691_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1350_ _0472_ _0473_ _0464_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__a21o_1
X_1281_ _0400_ _0409_ _0410_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_41_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1617_ _0682_ _0683_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__and2b_1
X_1548_ _0662_ _0674_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__xor2_4
X_1479_ _0200_ _0206_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1402_ _0191_ _0439_ _0464_ _0523_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__and4_1
XFILLER_0_23_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1264_ _0225_ _0392_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__nor2_1
X_1333_ net92 _0361_ _0462_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__a21oi_1
Xinput4 a[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__clkbuf_2
Xclkbuf_2_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_1195_ _0310_ _0323_ _0324_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__nand3_1
XFILLER_0_14_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_2_Left_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1951_ _0102_ _0105_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__nor2_1
X_1882_ _0040_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1316_ _0439_ _0444_ _0445_ VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__a21boi_2
X_1247_ _0345_ _0346_ _0347_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__o21bai_1
X_1178_ _0215_ _0296_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__xnor2_4
XPHY_EDGE_ROW_44_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1101_ _0229_ _0230_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__or2_1
X_1032_ net127 net8 net82 VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__mux2_1
X_1934_ _0561_ _0627_ _0076_ _0075_ _0876_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__a32o_1
XFILLER_0_33_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput40 start VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__buf_2
X_1865_ _0770_ _0982_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__xnor2_2
X_1796_ _0914_ _0916_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__xor2_1
XFILLER_0_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1650_ _0772_ _0773_ _0774_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__nand3_1
X_1581_ _0323_ _0324_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__and2_1
XFILLER_0_13_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1015_ _0156_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1917_ _0615_ _0672_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1848_ _0727_ _0936_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__nand2_1
X_1779_ _0889_ _0886_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__and2b_1
XFILLER_0_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_31_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1702_ _0824_ _0825_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__nor2_1
X_1564_ net72 _0690_ net84 VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__mux2_1
X_1633_ _0191_ _0327_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__nand2_1
X_1495_ net27 net9 VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__or2_1
XFILLER_0_39_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1280_ _0407_ _0408_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1547_ _0664_ _0673_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_41_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1616_ net106 _0740_ _0695_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__a21oi_1
X_1478_ _0582_ _0583_ _0586_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__nor3_1
XFILLER_0_49_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1401_ _0530_ _0200_ _0466_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__and3b_1
X_1194_ _0316_ _0317_ _0322_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__a21o_1
X_1263_ _0225_ _0392_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__and2_1
X_1332_ net92 net98 _0225_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__o21a_1
Xinput5 a[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__buf_2
XFILLER_0_46_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1950_ _0102_ _0105_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1881_ net63 _0039_ net86 VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__mux2_1
XFILLER_0_22_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1315_ _0406_ _0443_ _0441_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__or3_1
X_1246_ _0363_ _0374_ _0375_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__a21bo_1
X_1177_ _0188_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__buf_4
XFILLER_0_42_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1100_ _0220_ _0228_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__nor2_1
X_1031_ _0164_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__clkbuf_1
X_1933_ _0048_ _0088_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__and2_1
X_1864_ _0264_ _0810_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__xnor2_2
X_1795_ _0873_ _0881_ _0915_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__a21oi_1
Xinput30 b[1] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__buf_1
XFILLER_0_3_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1229_ _0357_ _0358_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1580_ _0698_ _0705_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1014_ net57 net17 net83 VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__mux2_1
X_1916_ _0615_ _0672_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__and2_1
X_1847_ _0964_ _0965_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__nand2_1
X_1778_ _0797_ _0895_ _0896_ _0898_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__a211o_4
XFILLER_0_8_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1701_ _0784_ _0786_ _0823_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__nor3_1
X_1494_ net27 net9 VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1632_ _0200_ _0296_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__nand2_1
X_1563_ _0687_ _0689_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_44_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1546_ _0665_ _0672_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_5_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1477_ _0226_ _0558_ _0556_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__a21o_1
X_1615_ _0695_ _0739_ _0740_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__and3_1
XFILLER_0_49_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2029_ clknet_2_2__leaf_clk _0033_ net91 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1331_ _0430_ _0460_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__or2_1
X_1400_ _0390_ _0199_ _0481_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__or3b_1
XFILLER_0_36_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1193_ _0316_ _0317_ _0322_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__nand3_4
X_1262_ _0357_ _0389_ _0391_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__a21oi_2
Xinput6 a[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_6
XFILLER_0_14_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1529_ _0307_ _0199_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1880_ _0979_ _0997_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1314_ _0406_ _0441_ _0443_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__o21ai_2
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1245_ _0364_ _0373_ _0365_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__nand3_1
X_1176_ _0294_ _0305_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1030_ net47 net7 net84 VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__mux2_1
X_1863_ net108 net119 VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__nor2_2
X_1932_ _0840_ _0077_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__nor2_1
Xinput20 b[0] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput31 b[2] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_1
X_1794_ _0879_ _0880_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1228_ _0221_ _0205_ _0179_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__o21ai_1
X_1159_ _0278_ _0288_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__xor2_4
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1013_ _0155_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1915_ _0765_ _0044_ _0046_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__o21ba_1
X_1846_ _0961_ _0963_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__nand2_1
X_1777_ _0890_ _0897_ _0894_ _0857_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__a22o_1
XFILLER_0_8_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1700_ _0784_ _0786_ _0823_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__o21a_1
X_1631_ net102 _0732_ _0734_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__nor3_1
X_1493_ _0617_ _0619_ net111 VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__and3_1
X_1562_ _0547_ _0598_ _0651_ _0688_ _0650_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__a32oi_4
XFILLER_0_29_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1829_ _0919_ _0948_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__xor2_1
XFILLER_0_26_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1614_ _0737_ _0738_ _0696_ _0697_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__o211ai_2
X_1545_ _0668_ _0671_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__xor2_4
XFILLER_0_5_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1476_ _0603_ _0597_ _0600_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__o21a_1
XFILLER_0_49_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2028_ clknet_2_2__leaf_clk _0032_ net90 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_17_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1330_ _0224_ _0429_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__nor2_1
X_1261_ _0390_ _0388_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__xnor2_1
X_1192_ _0318_ _0320_ _0321_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__o21bai_2
Xinput7 a[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_1
X_1459_ _0582_ _0583_ _0586_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__o21ai_1
X_1528_ _0390_ _0362_ _0612_ _0610_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__a31o_1
XFILLER_0_37_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1244_ _0364_ _0365_ _0373_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__a21o_1
X_1313_ _0221_ _0313_ _0442_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__a21oi_1
X_1175_ _0296_ _0303_ _0304_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_2_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_6_Left_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1931_ _0072_ _0078_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__nor2_1
Xinput21 b[10] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_2
X_1862_ _0940_ _0943_ _0969_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__o21ai_1
X_1793_ _0912_ _0913_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__and2_1
Xinput32 b[3] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__buf_1
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput10 a[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__clkbuf_4
X_1158_ _0279_ _0287_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__and2_2
X_1227_ _0221_ _0206_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__nand2_1
X_1089_ _0179_ _0192_ _0218_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_28_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1012_ net56 net16 net82 VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1914_ _0058_ _0057_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__or2b_1
XFILLER_0_8_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1845_ _0961_ _0963_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__or2_1
X_1776_ _0864_ _0862_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_9_Left_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1630_ _0754_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__inv_2
X_1492_ _0236_ _0239_ _0253_ _0618_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__a211o_1
X_1561_ _0548_ _0596_ _0595_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_44_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1759_ _0879_ _0880_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__xor2_1
X_1828_ _0946_ _0947_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__or2_1
XFILLER_0_35_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_35_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1544_ _0622_ net99 VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__nand2_2
XFILLER_0_41_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1613_ _0696_ _0697_ _0737_ _0738_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__a211o_4
X_1475_ _0386_ _0355_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__or2b_1
XFILLER_0_49_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2027_ clknet_2_2__leaf_clk _0031_ net90 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_32_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1191_ _0283_ _0284_ _0319_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__and3_1
X_1260_ _0179_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__clkbuf_4
Xinput8 a[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_46_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1527_ _0605_ _0645_ _0644_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__a21bo_1
X_1389_ _0505_ _0518_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__nand2_1
X_1458_ _0582_ _0583_ _0586_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__or3_1
XFILLER_0_20_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_38_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1174_ _0287_ _0297_ _0302_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__nand3_1
X_1243_ _0200_ _0371_ _0372_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__a21o_1
X_1312_ _0309_ _0312_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_22_Left_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1930_ net86 net122 _0085_ _0086_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__o22a_1
Xinput22 b[11] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__buf_1
X_1861_ _0972_ _0975_ _0978_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__o21ai_1
X_1792_ _0906_ _0911_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__or2_1
Xinput33 b[4] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__buf_1
XFILLER_0_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput11 a[1] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1157_ _0279_ _0280_ _0286_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__nand3_1
X_1226_ _0195_ _0199_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__xnor2_2
X_1088_ _0188_ _0200_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__and2_1
XFILLER_0_30_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1011_ _0154_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__clkbuf_1
X_1913_ _0061_ _0067_ _0060_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__a21bo_1
X_1844_ _0935_ _0938_ _0962_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__a21oi_1
X_1775_ _0794_ _0795_ _0827_ _0894_ _0792_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_8_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1209_ _0293_ _0299_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_47_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1560_ _0648_ _0686_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__xor2_2
X_1491_ _0257_ _0618_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__or2_4
XFILLER_0_44_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1827_ _0928_ _0929_ _0945_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__and3_1
X_1689_ _0810_ _0811_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__and2_1
X_1758_ _0839_ _0843_ _0842_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1543_ _0617_ _0619_ _0620_ _0669_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__a31o_1
XFILLER_0_41_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1612_ _0735_ _0736_ _0706_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_1_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1474_ net84 _0599_ _0600_ _0602_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__a31o_1
XFILLER_0_5_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2026_ clknet_2_2__leaf_clk _0030_ net90 VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_36_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput9 a[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_2
X_1190_ _0283_ _0284_ _0319_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_39_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1526_ _0653_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
X_1457_ _0584_ _0313_ _0585_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__a21oi_1
X_1388_ _0503_ _0504_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2009_ clknet_2_1__leaf_clk _0013_ net88 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__dfrtp_2
XFILLER_0_28_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1311_ _0390_ _0440_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__nor2_1
X_1173_ _0287_ _0297_ _0302_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1242_ _0369_ _0370_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__and2_1
XFILLER_0_19_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1509_ _0371_ _0635_ _0636_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__nand3_1
XFILLER_0_33_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1860_ _0946_ _0971_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__nand2_1
Xinput23 b[12] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_1
X_1791_ _0906_ _0911_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__nand2_1
Xinput34 b[5] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__buf_1
Xinput12 a[2] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_1
X_1156_ _0285_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__clkbuf_4
X_1225_ _0210_ _0354_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__xnor2_1
X_1087_ _0200_ _0216_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__xnor2_4
X_1989_ net114 _0708_ _0765_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__a21o_1
XFILLER_0_23_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1010_ net55 net15 net83 VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__mux2_1
X_1912_ _0069_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__clkbuf_1
X_1843_ _0934_ _0933_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__and2b_1
XFILLER_0_8_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1774_ _0792_ _0827_ _0894_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__and3_1
XFILLER_0_12_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1208_ _0321_ _0320_ _0318_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__o21ai_1
X_1139_ net23 net5 _0268_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_7_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1490_ _0260_ _0267_ _0273_ _0567_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__or4_4
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1826_ _0928_ _0929_ _0945_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_4_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1688_ _0810_ _0811_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1757_ _0874_ _0878_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1611_ _0706_ _0735_ _0736_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__and3_4
X_1542_ net27 net9 VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__nor2_1
X_1473_ _0601_ net70 VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__and2_1
X_2025_ clknet_2_2__leaf_clk _0029_ net90 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dfrtp_1
X_1809_ _0917_ _0903_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__or2b_1
X_1387_ _0512_ _0514_ _0516_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__o21ai_2
X_1525_ net71 _0652_ net84 VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__mux2_1
X_1456_ _0294_ _0305_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2008_ clknet_2_0__leaf_clk _0012_ net88 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_9_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1310_ _0404_ _0405_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__and2_1
X_1241_ _0369_ _0370_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__xor2_4
X_1172_ _0299_ _0300_ _0301_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_2_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1439_ _0266_ _0564_ _0567_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__a21o_1
X_1508_ _0633_ _0634_ _0574_ _0576_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_17_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1790_ _0867_ _0910_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_33_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput13 a[3] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__clkbuf_2
Xinput24 b[13] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_1
Xinput35 b[6] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_6
X_1224_ _0334_ _0353_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__xor2_1
X_1155_ _0283_ _0284_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__and2_1
X_1086_ _0188_ _0215_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__xnor2_4
X_1988_ _0138_ _0135_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_2_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_1842_ _0954_ _0960_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__xnor2_1
X_1911_ net64 _0068_ net86 VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__mux2_1
X_1773_ _0855_ _0891_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__and2_1
XFILLER_0_12_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1207_ _0318_ _0321_ _0320_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__or3_1
XFILLER_0_18_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1138_ net24 net6 VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__and2_4
X_1069_ _0197_ _0198_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_38_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1756_ _0875_ _0877_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__and2_1
X_1825_ _0943_ _0944_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1687_ _0765_ _0766_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1610_ net102 _0732_ _0734_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1541_ _0666_ _0667_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__nor2b_2
X_1472_ net82 VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__inv_2
X_2024_ clknet_2_3__leaf_clk _0028_ net90 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_17_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1808_ _0916_ _0914_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__or2b_1
X_1739_ _0824_ _0854_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1524_ _0604_ _0651_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__xnor2_1
X_1386_ _0515_ _0500_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__xnor2_1
X_1455_ _0294_ _0305_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__nand2_1
X_2007_ clknet_2_1__leaf_clk _0011_ net88 VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_45_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1171_ _0263_ _0283_ _0284_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__and3_1
X_1240_ _0327_ _0339_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_27_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1507_ _0574_ _0576_ _0633_ _0634_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__a211o_1
XFILLER_0_49_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1438_ _0565_ _0566_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__or2b_2
X_1369_ _0360_ _0496_ _0495_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__nor3_1
Xinput25 b[14] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__buf_1
Xinput36 b[7] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__buf_1
Xinput14 a[4] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_1
XFILLER_0_24_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_26_Left_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1154_ _0249_ _0282_ _0248_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__a21o_1
X_1223_ _0336_ _0351_ _0352_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__a21o_1
X_1085_ _0213_ _0214_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__xor2_4
X_1987_ _0140_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1910_ _0062_ _0067_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__xnor2_1
X_1841_ _0955_ _0959_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__xnor2_1
X_1772_ _0893_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1137_ _0265_ _0266_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__nand2_2
X_1206_ _0210_ _0335_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__nor2_1
XFILLER_0_18_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1068_ _0172_ net94 _0176_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1755_ _0672_ _0876_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__nand2_1
X_1686_ net130 _0569_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__nand2_2
X_1824_ _0930_ _0931_ _0942_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_29_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_13_Left_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1540_ net28 net10 VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__nand2_2
XFILLER_0_41_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1471_ _0547_ _0598_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__nand2_1
X_2023_ clknet_2_3__leaf_clk _0027_ net90 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dfrtp_1
X_1807_ net85 _0925_ _0926_ _0927_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__a31o_1
XFILLER_0_40_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1738_ _0860_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1669_ _0747_ _0693_ _0793_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1523_ _0595_ _0650_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__xnor2_2
X_1454_ _0580_ _0581_ _0440_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_22_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1385_ _0486_ _0498_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__nand2_1
X_2006_ clknet_2_0__leaf_clk _0010_ net87 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_45_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1170_ _0283_ _0284_ _0263_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_6_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1437_ net26 net8 VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__nand2_1
X_1506_ _0631_ _0632_ _0286_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__a21oi_1
X_1368_ net92 _0225_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__nand2_1
X_1299_ _0206_ _0361_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_1_Left_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput26 b[15] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_1
Xinput37 b[8] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_1
Xinput15 a[5] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__buf_1
X_1153_ _0249_ _0248_ _0282_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__nand3_2
X_1222_ _0349_ _0350_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__nor2_1
X_1084_ _0181_ _0187_ _0180_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__a21boi_4
X_1986_ net68 _0139_ net86 VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__mux2_2
XFILLER_0_23_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_43_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1840_ net101 _0958_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__xor2_1
X_1771_ net77 _0892_ net85 VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1136_ net25 net7 VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__nand2_2
X_1205_ _0203_ _0209_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__and2_1
X_1067_ _0171_ _0196_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__nand2_2
X_1969_ _0601_ net123 _0122_ _0123_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__a22o_1
XFILLER_0_7_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1823_ _0930_ _0931_ _0942_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__a21oi_2
X_1754_ _0712_ _0716_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__nor2_2
X_1685_ _0757_ _0808_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__xnor2_2
X_1119_ net21 net3 VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__nand2_2
XFILLER_0_50_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1470_ _0547_ _0598_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2022_ clknet_2_3__leaf_clk _0026_ net90 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dfrtp_1
X_1806_ _0601_ net78 VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__and2_1
XFILLER_0_31_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1599_ _0561_ net136 _0724_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__nand3_1
X_1737_ net76 _0859_ net85 VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__mux2_1
X_1668_ _0745_ _0746_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__nand2_1
X_1522_ _0648_ _0649_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__and2_2
X_1453_ _0440_ _0580_ _0581_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__and3_1
X_1384_ net1 _0513_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__and2_1
X_2005_ clknet_2_1__leaf_clk _0009_ net88 VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_13_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1436_ net26 net8 VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__nor2_1
X_1505_ _0286_ _0631_ _0632_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__and3_1
X_1367_ _0360_ _0495_ _0496_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__o21a_1
XFILLER_0_10_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1298_ _0389_ _0427_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__nand2_1
XFILLER_0_41_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput27 b[16] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__buf_1
Xinput38 b[9] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__buf_1
Xinput16 a[6] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__clkbuf_2
X_1221_ _0349_ _0350_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__xor2_2
X_1152_ _0241_ _0243_ _0281_ _0251_ _0240_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__a311o_1
X_1083_ _0211_ _0212_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__nor2_4
X_1985_ _0135_ _0138_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__xor2_1
XFILLER_0_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1419_ _0386_ _0355_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__and2b_1
X_1770_ _0863_ _0891_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__xor2_1
X_1204_ _0234_ _0333_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_18_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1135_ net25 net7 VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__or2_1
X_1066_ net32 net14 VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1968_ _0099_ _0107_ _0121_ net86 VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__o31a_1
X_1899_ _0054_ _0056_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__xor2_1
XFILLER_0_11_250 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1753_ _0708_ _0840_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1822_ _0940_ _0941_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1684_ _0806_ _0807_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1118_ _0246_ _0247_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1049_ _0170_ _0178_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_43_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2021_ clknet_2_3__leaf_clk _0025_ net90 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1805_ _0924_ _0899_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__or2b_1
X_1736_ _0855_ _0858_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1598_ _0721_ net100 _0710_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1667_ _0790_ _0791_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1452_ _0576_ _0577_ _0579_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__a21o_1
X_1383_ _0509_ _0511_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__xnor2_1
X_1521_ _0646_ _0647_ _0591_ _0593_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_22_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2004_ clknet_2_1__leaf_clk _0008_ net88 VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_42_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1719_ _0841_ _0812_ _0627_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__o21a_1
XFILLER_0_6_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1504_ _0629_ _0630_ _0614_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__a21o_1
X_1435_ _0261_ _0269_ _0563_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__a21o_1
X_1366_ _0347_ _0361_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__xor2_1
X_1297_ _0362_ _0388_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput28 b[17] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_1
Xinput39 rstb VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_2
Xinput17 a[7] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_24_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1151_ _0236_ _0239_ _0245_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__a21o_2
X_1220_ _0315_ _0330_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__xnor2_2
X_1082_ net36 net18 VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__nor2_1
X_1984_ _0105_ _0136_ _0137_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__o21a_1
XFILLER_0_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1418_ _0423_ _0542_ _0546_ _0387_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__a2bb2o_2
X_1349_ _0476_ _0478_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1134_ _0263_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__clkbuf_8
X_1203_ _0314_ _0332_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__xor2_1
XFILLER_0_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1065_ _0179_ _0194_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_50_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1967_ _0099_ _0107_ _0121_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__o21ai_1
X_1898_ _0615_ _0286_ _0983_ _0055_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__a31oi_4
XFILLER_0_29_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1821_ _0932_ _0912_ _0939_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__and3_1
X_1752_ _0631_ _0632_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__nand2_1
X_1683_ _0304_ _0805_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__and2_1
X_1117_ net22 net4 VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__or2_1
XFILLER_0_28_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1048_ _0171_ net131 VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__nand2_2
X_2020_ clknet_2_3__leaf_clk _0024_ net90 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_31_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_17_Left_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1804_ _0899_ _0924_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__or2b_1
XFILLER_0_31_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1735_ net80 _0856_ _0857_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__o21ba_1
X_1666_ _0788_ _0789_ _0745_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__o21a_1
X_1597_ _0710_ _0721_ _0722_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__or3_4
XFILLER_0_0_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1520_ _0591_ _0593_ _0646_ _0647_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__a211o_1
XFILLER_0_22_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1451_ _0576_ _0577_ _0579_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__nand3_1
X_1382_ _0509_ _0511_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__and2b_1
XFILLER_0_26_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2003_ clknet_2_0__leaf_clk _0007_ net87 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_9_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1718_ net110 _0840_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__nor2_1
X_1649_ _0561_ _0724_ _0723_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_13_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1503_ _0614_ _0629_ _0630_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__nand3_4
XFILLER_0_35_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1434_ _0267_ _0270_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__or2_1
X_1296_ _0419_ _0421_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__xor2_1
X_1365_ _0225_ _0363_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__and2_1
XFILLER_0_10_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput18 a[8] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__buf_1
Xinput29 b[18] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__buf_1
X_1150_ net95 _0275_ _0263_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__a21o_1
X_1081_ net36 net18 VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__and2_1
X_1983_ _0096_ _0099_ _0120_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_15_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1417_ _0426_ _0456_ _0422_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1348_ _0433_ _0477_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__xnor2_1
X_1279_ _0407_ _0408_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_5_Left_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1133_ _0261_ _0262_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__and2_1
X_1202_ _0315_ _0330_ _0331_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__a21bo_1
X_1064_ _0189_ _0190_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__xnor2_2
X_1966_ _0096_ _0120_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__xor2_1
XFILLER_0_7_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_47_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1897_ _0770_ _0982_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__and2b_1
XFILLER_0_11_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1820_ _0932_ _0912_ _0939_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_29_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1751_ _0834_ _0872_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__xor2_1
X_1682_ _0304_ _0805_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1116_ net22 net4 VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__nand2_1
X_1047_ net32 net14 _0172_ _0175_ _0176_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__a221o_2
X_1949_ _0067_ _0103_ _0104_ _0083_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__a22oi_4
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_8_Left_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1803_ _0922_ _0923_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1596_ _0627_ _0717_ _0720_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__and3_4
X_1665_ _0745_ _0788_ _0789_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__nor3_1
X_1734_ _0788_ _0790_ _0826_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_34_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1450_ _0289_ _0293_ _0578_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__a21o_1
X_1381_ _0510_ _0398_ _0392_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_26_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2002_ clknet_2_1__leaf_clk _0006_ net88 VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_13_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1717_ _0768_ _0719_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__nand2_4
X_1648_ _0615_ _0770_ _0771_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__nand3_1
XFILLER_0_13_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1579_ _0703_ _0704_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__nor2_1
Xrebuffer30 _0215_ VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_51_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1502_ _0626_ _0628_ _0615_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__a21o_1
X_1433_ _0561_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1295_ _0423_ _0424_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__or2_1
X_1364_ _0457_ _0475_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_5_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput19 a[9] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_24_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1080_ _0203_ _0209_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__nor2_1
X_1982_ _0101_ _0121_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_21_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1347_ _0453_ _0452_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__and2b_1
X_1416_ _0545_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__clkbuf_1
X_1278_ _0191_ _0371_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__xnor2_1
X_1201_ _0326_ _0329_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1132_ _0260_ _0254_ _0257_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__nand3_1
X_1063_ _0179_ _0192_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__xnor2_2
X_1965_ _0118_ _0119_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__and2_1
XFILLER_0_47_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1896_ _0052_ _0053_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1750_ _0870_ _0871_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__nand2_1
X_1681_ _0803_ _0804_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1115_ _0243_ _0244_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__nand2_4
XFILLER_0_0_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1046_ net31 net13 VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__and2_1
X_1948_ _0071_ _0060_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__nand2_1
X_1879_ _0980_ _0996_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__xor2_1
XFILLER_0_28_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_2_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_15_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1802_ _0900_ _0921_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__or2_1
X_1733_ _0792_ _0827_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__nand2_1
X_1595_ net117 _0720_ _0627_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_40_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1664_ _0786_ _0787_ _0739_ _0753_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__o211a_1
XFILLER_0_48_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1029_ _0163_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1380_ net1 VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__inv_2
XFILLER_0_22_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2001_ clknet_2_1__leaf_clk _0005_ net88 VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_42_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1716_ _0574_ _0575_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__and2_1
X_1647_ _0770_ _0771_ _0615_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1578_ _0342_ _0702_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__and2_1
Xrebuffer20 _0665_ VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__buf_1
Xrebuffer31 _0215_ VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_44_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1501_ _0615_ _0626_ _0628_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__nand3_2
X_1432_ _0276_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__buf_4
X_1363_ _0474_ _0480_ _0492_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__nand3_1
XFILLER_0_37_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1294_ _0387_ _0422_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__and2_1
XFILLER_0_24_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1981_ _0118_ _0134_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__xor2_1
XFILLER_0_2_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1346_ _0457_ _0475_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__nand2_1
X_1415_ net60 _0544_ net82 VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1277_ _0368_ _0402_ _0403_ _0406_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__a31o_1
XFILLER_0_14_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1200_ _0326_ _0329_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__xor2_2
XFILLER_0_18_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1131_ _0254_ _0257_ _0260_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__a21o_1
XFILLER_0_34_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1062_ _0188_ _0191_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__xnor2_2
X_1964_ _0116_ _0117_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__or2_1
X_1895_ _0041_ _0051_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__or2_1
XFILLER_0_43_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1329_ _0445_ _0444_ _0439_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_49_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1680_ _0307_ _0293_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__or2_1
XFILLER_0_20_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1114_ net37 net19 VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1045_ net20 net11 _0173_ _0174_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__a31o_1
X_1947_ _0062_ _0084_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__nor2_1
X_1878_ _0994_ _0995_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1801_ _0900_ _0921_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1732_ _0824_ _0854_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__xor2_1
X_1663_ _0739_ _0753_ _0786_ _0787_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__a211oi_4
X_1594_ _0718_ _0719_ _0672_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1028_ net46 net6 net83 VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__mux2_1
XFILLER_0_30_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2000_ clknet_2_0__leaf_clk _0004_ net87 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_42_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1646_ _0764_ _0722_ _0767_ _0769_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__or4_2
X_1715_ _0803_ _0837_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1577_ _0342_ _0702_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__nor2_1
Xrebuffer21 net112 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__dlygate4sd2_1
Xrebuffer32 _0820_ VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__buf_2
Xrebuffer10 _0731_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_50_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1500_ _0568_ _0569_ _0627_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__nand3_1
X_1431_ _0272_ net96 _0275_ _0277_ _0264_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__a32o_1
X_1293_ _0387_ _0422_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__nor2_1
X_1362_ _0481_ _0490_ _0491_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1629_ _0307_ _0221_ _0705_ _0703_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__a31o_1
XFILLER_0_17_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1980_ _0132_ _0133_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__and2_1
XFILLER_0_48_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer1 _0236_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1345_ _0472_ _0474_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1414_ _0425_ _0543_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__xnor2_1
X_1276_ _0390_ _0404_ _0405_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__and3_1
X_1130_ _0258_ _0259_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1061_ _0189_ _0190_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__xor2_4
X_1963_ _0116_ _0117_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__nand2_1
X_1894_ _0041_ _0051_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1328_ _0445_ _0439_ _0444_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__and3_1
X_1259_ _0361_ _0388_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1044_ net30 net12 VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__and2_1
X_1113_ net37 net19 VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__nand2_2
XFILLER_0_0_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1946_ _0101_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__inv_2
XFILLER_0_43_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1877_ _0992_ _0993_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1800_ _0919_ _0920_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__and2_1
XFILLER_0_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1731_ _0832_ _0853_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__xnor2_2
X_1662_ _0784_ _0785_ _0755_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__o21a_1
XFILLER_0_25_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1593_ _0667_ _0714_ _0713_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1027_ _0162_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__clkbuf_1
X_1929_ _0070_ _0084_ net86 VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1645_ _0764_ _0722_ _0767_ _0769_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__o22ai_4
X_1714_ _0578_ _0836_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__xor2_2
X_1576_ _0699_ _0701_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer11 net135 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer33 _0714_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer22 net113 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1430_ _0226_ _0558_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__xor2_1
X_1292_ _0419_ _0421_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__and2_1
X_1361_ _0489_ _0482_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__and2b_1
XFILLER_0_26_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1559_ _0654_ _0685_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__xnor2_2
X_1628_ _0695_ _0739_ _0740_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__nand3_2
XFILLER_0_32_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer2 _0175_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1413_ _0426_ _0456_ _0542_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_2_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1344_ _0464_ _0472_ _0473_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__nand3_1
XFILLER_0_3_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1275_ _0368_ _0403_ _0402_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1060_ _0170_ _0171_ _0177_ net15 net33 VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__a32o_2
XPHY_EDGE_ROW_25_Left_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1962_ _0112_ _0077_ _0090_ _0094_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__a22o_1
XFILLER_0_34_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1893_ _0049_ _0050_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__or2_1
X_1189_ _0251_ _0298_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__xnor2_4
X_1327_ _0437_ _0449_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__xor2_1
X_1258_ _0199_ _0206_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_46_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1112_ _0240_ _0241_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__or2b_4
X_1043_ net30 net12 VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__xor2_1
X_1945_ _0099_ _0100_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1876_ _0992_ _0993_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1592_ _0667_ _0713_ net104 VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__nand3_1
X_1730_ _0833_ _0852_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__xnor2_2
X_1661_ _0755_ _0784_ _0785_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__nor3_2
XFILLER_0_0_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_28_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1026_ net128 net5 net82 VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__mux2_1
X_1928_ _0070_ _0084_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__and2_1
X_1859_ _0977_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_31_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_12_Left_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1713_ _0834_ _0835_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__and2_1
X_1644_ _0768_ net103 VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__nor2_2
X_1575_ _0700_ net133 VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer12 _0714_ VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__buf_1
Xrebuffer34 _0723_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__clkbuf_1
Xrebuffer23 _0175_ VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__clkbuf_1
X_1009_ _0153_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput70 net70 VGND VGND VPWR VPWR beta[1] sky130_fd_sc_hd__clkbuf_4
X_1360_ _0482_ _0489_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_37_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1291_ _0420_ _0384_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_26_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1489_ _0266_ _0566_ _0616_ _0565_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__a31o_1
X_1558_ _0655_ _0684_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__xor2_2
X_1627_ _0752_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer3 _0274_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__buf_1
XFILLER_0_47_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1412_ _0479_ _0539_ _0426_ _0541_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__o211ai_1
X_1343_ _0458_ _0459_ _0471_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1274_ _0368_ _0402_ _0403_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__nand3_1
XFILLER_0_9_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Left_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1961_ _0114_ _0115_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__nor2_1
X_1892_ _0840_ _0048_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__and2_1
XFILLER_0_34_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1326_ _0418_ _0454_ _0455_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__and3_1
X_1188_ _0293_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__inv_2
X_1257_ _0355_ _0386_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_42_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1111_ net38 net2 VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__nand2_1
X_1042_ net31 net13 VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__or2_1
X_1944_ _0081_ _0098_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__nor2_1
X_1875_ _0966_ _0968_ _0964_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__o21a_1
XFILLER_0_3_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1309_ _0432_ _0438_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1591_ _0708_ _0715_ _0716_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__or3_4
X_1660_ _0782_ _0783_ _0756_ net107 VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__a211oi_2
X_1025_ _0161_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__clkbuf_1
X_1927_ _0071_ _0083_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__xor2_1
X_1858_ net62 _0976_ net85 VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__mux2_1
X_1789_ _0631_ _0909_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1643_ _0712_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__inv_2
X_1712_ net132 _0299_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1574_ _0390_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__inv_2
XFILLER_0_21_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer13 _0730_ VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer24 _0182_ VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__clkbuf_2
X_1008_ net54 net14 net83 VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput60 net60 VGND VGND VPWR VPWR beta[0] sky130_fd_sc_hd__clkbuf_4
Xoutput71 net71 VGND VGND VPWR VPWR beta[2] sky130_fd_sc_hd__clkbuf_4
X_1290_ _0360_ _0362_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1626_ net73 _0751_ net85 VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__mux2_1
X_1488_ _0269_ _0563_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__or2_1
X_1557_ _0682_ _0683_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_27_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer4 _0274_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1411_ _0476_ _0478_ _0456_ _0540_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_3_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1342_ _0458_ _0459_ _0471_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__or3_1
X_1273_ _0366_ _0367_ _0310_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__a21o_1
X_1609_ _0731_ _0732_ _0734_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__or3_4
X_1960_ _0091_ _0110_ _0113_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__and3_1
X_1891_ _0840_ _0048_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1325_ _0416_ _0417_ _0393_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__a21o_1
X_1256_ _0360_ _0362_ _0384_ _0385_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__a31oi_2
X_1187_ _0301_ _0300_ _0299_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_6_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1110_ net38 net2 VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1041_ net32 net14 VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__or2_2
X_1943_ _0081_ _0098_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__and2_1
XFILLER_0_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1874_ _0989_ _0991_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1308_ _0428_ _0431_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__and2_1
X_1239_ _0366_ _0368_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__nand2_2
XFILLER_0_19_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1590_ _0667_ net104 _0713_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_0_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1024_ net44 net4 net83 VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__mux2_1
XFILLER_0_48_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1926_ _0081_ _0082_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__nor2_1
X_1857_ _0972_ _0975_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__xor2_1
X_1788_ _0907_ _0908_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1642_ _0765_ _0766_ _0708_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__a21oi_2
X_1711_ _0310_ _0319_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__nand2_2
X_1573_ _0390_ _0310_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer25 _0717_ VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__clkbuf_1
X_1007_ _0152_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__clkbuf_1
Xrebuffer14 _0739_ VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1909_ _0899_ _0973_ _0064_ _0066_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__a31o_4
XFILLER_0_8_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput61 net61 VGND VGND VPWR VPWR beta[10] sky130_fd_sc_hd__clkbuf_4
Xoutput72 net72 VGND VGND VPWR VPWR beta[3] sky130_fd_sc_hd__clkbuf_4
Xoutput50 net50 VGND VGND VPWR VPWR alpha[18] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1556_ _0613_ _0641_ _0640_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__a21bo_1
X_1625_ _0694_ _0750_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__xnor2_1
X_1487_ _0272_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_23_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1410_ _0418_ _0455_ _0454_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_2_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer5 _0173_ VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_48_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1341_ _0466_ _0469_ _0470_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__a21oi_1
X_1272_ _0307_ _0308_ _0401_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__a21o_1
X_1539_ net28 net10 VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__nor2_1
X_1608_ _0661_ _0678_ _0733_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_49_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1890_ _0046_ _0047_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1186_ _0301_ _0299_ _0300_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__or3_2
X_1324_ _0433_ _0452_ _0453_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__a21o_1
X_1255_ _0382_ _0383_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1040_ _0168_ _0169_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__and2_2
X_1942_ _0096_ _0097_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1873_ _0723_ _0958_ _0990_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_3_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1169_ _0251_ _0298_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__xor2_4
X_1307_ _0433_ _0436_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__or2_1
X_1238_ _0310_ _0366_ _0367_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__nand3_2
XFILLER_0_34_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1023_ _0160_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1925_ _0079_ _0080_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__and2_1
X_1856_ _0899_ _0973_ _0974_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__a21oi_1
X_1787_ _0264_ _0293_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1641_ _0712_ net109 net118 VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__a21oi_2
X_1710_ _0200_ _0296_ _0808_ _0806_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__a31o_1
XFILLER_0_6_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1572_ _0307_ _0221_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_16_Left_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer26 _0716_ VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__clkbuf_1
Xrebuffer15 _0737_ VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__buf_1
X_1006_ net129 net13 net82 VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1839_ _0956_ _0957_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__nand2_1
X_1908_ _0974_ _0064_ _0065_ _0996_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__a22o_1
XFILLER_0_4_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput62 net62 VGND VGND VPWR VPWR beta[11] sky130_fd_sc_hd__clkbuf_4
Xoutput73 net73 VGND VGND VPWR VPWR beta[4] sky130_fd_sc_hd__clkbuf_4
Xoutput51 net51 VGND VGND VPWR VPWR alpha[1] sky130_fd_sc_hd__clkbuf_4
X_1555_ _0660_ _0681_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__xnor2_2
X_1624_ _0748_ _0749_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__or2_1
X_1486_ _0562_ _0571_ _0570_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__o21bai_2
Xrebuffer6 net97 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__clkbuf_1
X_1340_ _0468_ _0467_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__and2b_1
X_1271_ _0215_ _0327_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1538_ _0625_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__inv_2
X_1607_ _0676_ _0677_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__and2_1
X_1469_ _0548_ _0597_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_19_Left_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1323_ _0434_ _0451_ _0435_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__and3_1
X_1254_ _0382_ _0383_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__xor2_2
X_1185_ _0217_ _0219_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__xor2_4
XFILLER_0_6_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Left_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1941_ _0087_ _0095_ _0089_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__nor3_1
X_1872_ _0561_ _0319_ _0959_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__and3_1
XFILLER_0_28_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1306_ net92 _0432_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_46_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1168_ _0242_ _0281_ _0255_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__o21ai_4
X_1099_ _0220_ _0228_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__and2_1
XFILLER_0_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1237_ _0290_ _0291_ _0296_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__a21o_1
XFILLER_0_42_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1022_ net43 net3 net83 VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__mux2_1
X_1924_ _0079_ _0080_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__nor2_1
X_1855_ _0919_ _0922_ _0948_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__a21oi_1
X_1786_ _0264_ _0293_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1640_ _0712_ _0715_ _0716_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__or3_2
XFILLER_0_21_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1571_ _0660_ _0681_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__nand2_1
Xrebuffer27 _0716_ VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__clkbuf_1
Xrebuffer16 _0715_ VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__clkbuf_1
X_1005_ _0151_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__clkbuf_1
X_1838_ _0615_ _0286_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__or2_1
X_1907_ _0980_ _0978_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1769_ _0864_ _0890_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_33_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput52 net52 VGND VGND VPWR VPWR alpha[2] sky130_fd_sc_hd__clkbuf_4
Xoutput41 net41 VGND VGND VPWR VPWR alpha[0] sky130_fd_sc_hd__clkbuf_4
Xoutput63 net63 VGND VGND VPWR VPWR beta[12] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput74 net74 VGND VGND VPWR VPWR beta[5] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1485_ _0553_ _0612_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__xnor2_1
X_1554_ _0679_ _0680_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__xnor2_2
X_1623_ _0747_ _0745_ _0746_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__and3_1
.ends
