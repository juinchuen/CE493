* NGSPICE file created from inverse_clarke.ext - technology: sky130A

.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
X0 VPWR a_505_21# a_535_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_505_21# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.0693 ps=0.75 w=0.42 l=0.15
X2 a_218_374# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0767 pd=0.785 as=0.158 ps=1.39 w=0.42 l=0.15
X3 VGND a_505_21# a_439_47# VNB sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.11 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 a_76_199# A0 a_218_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.193 pd=1.34 as=0.0767 ps=0.785 w=0.42 l=0.15
X5 a_505_21# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.145 ps=1.11 w=0.42 l=0.15
X6 a_439_47# A0 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0997 ps=0.895 w=0.42 l=0.15
X7 a_535_374# A1 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.193 ps=1.34 w=0.42 l=0.15
X8 a_76_199# A1 a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0997 pd=0.895 as=0.0693 ps=0.75 w=0.42 l=0.15
X9 a_218_47# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.113 ps=1.04 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.158 pd=1.39 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.04 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.05
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.05
.ends

.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=0.59
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=0.59
.ends

.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=2.89
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=2.89
.ends

.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
X0 VPWR a_75_212# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 a_75_212# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 a_75_212# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND a_75_212# X VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.97
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.97
.ends

.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_109_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.42 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0703 pd=0.755 as=0.111 ps=1.37 w=0.42 l=0.15
X6 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.14 ps=1.28 w=1 l=0.15
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0703 ps=0.755 w=0.42 l=0.15
X8 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.165 ps=1.33 w=1 l=0.15
X9 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_470_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_470_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_470_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.106 ps=0.975 w=0.65 l=0.15
X6 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X8 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X10 a_470_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.162 ps=1.33 w=1 l=0.15
X11 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 VPWR B a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X13 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X16 X a_112_47# a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 a_470_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X18 X B a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
X0 VGND A a_68_297# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_68_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_68_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR A a_150_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 X a_68_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.34 pd=2.68 as=0.146 ps=1.34 w=1 l=0.15
X5 a_150_297# B a_68_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
X0 a_27_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_560_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X2 VGND B a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0991 ps=0.955 w=0.65 l=0.15
X3 Y B a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_297# a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_474_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X7 VGND A a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# B a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X12 a_474_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_560_47# a_27_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X14 VPWR A a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X15 Y a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X16 VPWR a_27_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X17 a_560_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X7 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.38 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X11 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X18 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X21 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
X0 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_161_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X2 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_161_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A a_161_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_161_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.149 ps=1.33 w=1 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.149 pd=1.33 as=0.166 ps=1.8 w=0.64 l=0.15
X3 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X4 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X3 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X4 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X5 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.301 ps=2.66 w=1 l=0.15
X7 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X8 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X10 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X12 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X13 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X14 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X15 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X16 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X17 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X18 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X20 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X21 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X22 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.209 ps=2.02 w=0.65 l=0.15
X23 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X24 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X25 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X26 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X27 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
X0 X a_35_297# a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.26 ps=2.52 w=1 l=0.15
X1 X B a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.25 pd=1.42 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_117_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 VPWR B a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.25 ps=1.42 w=0.65 l=0.15
X7 a_285_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A a_117_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
X0 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X5 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X17 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X21 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X23 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X36 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X39 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A a_113_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_113_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.35 as=0.265 ps=2.53 w=1 l=0.15
X1 a_209_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.172 ps=1.35 w=1 l=0.15
X2 a_303_47# A2 a_209_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.104 ps=0.97 w=0.65 l=0.15
X3 a_209_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.112 ps=0.995 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.172 ps=1.83 w=0.65 l=0.15
X5 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.107 ps=0.98 w=0.65 l=0.15
X6 a_80_21# A1 a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X7 VPWR A2 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.16 ps=1.32 w=1 l=0.15
X8 a_80_21# B1 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X9 a_209_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
X0 a_377_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.365 ps=1.73 w=1 l=0.15
X1 a_47_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.3 ps=2.6 w=1 l=0.15
X2 a_129_47# B a_47_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_285_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 Y a_47_47# a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_129_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0683 ps=0.86 w=0.65 l=0.15
X6 VPWR A a_47_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.365 pd=1.73 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_47_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.165 ps=1.33 w=1 l=0.15
X8 Y B a_377_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
X0 VPWR B a_59_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 X a_59_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.475 pd=2.95 as=0.167 ps=1.39 w=1 l=0.15
X2 VGND B a_145_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_59_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X4 X a_59_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.112 ps=1.04 w=0.65 l=0.15
X5 a_145_75# A a_59_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VPWR C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 a_181_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VGND C a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.132 pd=1.14 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 a_27_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X6 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.132 ps=1.14 w=0.65 l=0.15
X7 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 Y A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.174 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.182 pd=1.92 as=0.174 ps=1.39 w=0.7 l=0.15
X2 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X3 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_199_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_113_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.147 ps=1.29 w=1 l=0.15
X2 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X3 VPWR A1 a_113_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.29 as=0.14 ps=1.28 w=1 l=0.15
X4 a_113_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A2 a_199_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0959 ps=0.945 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
X0 VPWR A a_49_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VGND a_285_47# a_391_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.5
X2 X a_391_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VGND A a_49_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR a_285_47# a_391_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.5
X5 a_285_47# a_49_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X6 a_285_47# a_49_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X7 X a_391_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.745 as=0.111 ps=1.37 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.162 ps=1.33 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X2 a_193_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y A a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X4 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 a_109_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0683 ps=0.86 w=0.65 l=0.15
X1 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=2.1 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A1 a_114_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
X3 a_114_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.185 ps=1.87 w=0.65 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.28 ps=2.56 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X10 a_285_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.091 ps=0.93 w=0.65 l=0.15
X11 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_382_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X1 a_297_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X2 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.327 pd=1.65 as=0.28 ps=2.56 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.327 ps=1.65 w=1 l=0.15
X6 a_382_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.195 ps=1.39 w=1 l=0.15
X7 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X8 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X11 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=1.37 as=0.0588 ps=0.7 w=0.42 l=0.15
X18 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X20 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X21 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X22 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X23 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X25 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X26 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X27 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X28 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X29 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X30 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X31 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X32 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X33 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X34 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X35 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X36 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X37 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X38 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X39 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0578 ps=0.695 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
X0 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X5 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X7 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 a_81_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.257 ps=1.44 w=0.65 l=0.15
X1 a_299_297# B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_299_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 a_384_47# A1 a_81_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.272 ps=2.56 w=1 l=0.15
X15 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X17 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X19 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X24 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.257 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X30 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X38 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_222_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X1 VPWR A1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.105 ps=1.21 w=1 l=0.15
X2 VGND a_79_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_222_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.186 ps=1.41 w=0.42 l=0.15
X4 VGND A2 a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_448_47# a_222_93# a_79_199# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_79_199# a_222_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.3 ps=2.6 w=1 l=0.15
X7 a_544_297# A2 a_79_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X8 a_448_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.186 pd=1.41 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
X0 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.157 ps=1.17 w=0.42 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.157 pd=1.17 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X6 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 a_103_199# B1 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.107 ps=0.98 w=0.65 l=0.15
X1 VPWR a_103_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.36 ps=2.72 w=1 l=0.15
X2 a_337_297# A2 a_253_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_103_199# A3 a_337_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.165 ps=1.33 w=1 l=0.15
X4 a_253_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.195 ps=1.39 w=1 l=0.15
X5 VPWR B1 a_103_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.345 pd=2.69 as=0.213 ps=1.42 w=1 l=0.15
X6 VGND a_103_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.234 ps=2.02 w=0.65 l=0.15
X7 a_253_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X8 a_253_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X9 VGND A2 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_300_297# a_27_413# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X3 Y a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.102 ps=0.99 w=0.65 l=0.15
X4 VPWR A1 a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 a_384_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.143 ps=1.09 w=0.65 l=0.15
X6 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.111 ps=1.37 w=0.42 l=0.15
X7 a_300_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
X0 X a_29_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.148 ps=1.34 w=1 l=0.15
X1 a_111_297# C a_29_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_29_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.102 ps=0.99 w=0.65 l=0.15
X3 a_183_297# B a_111_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 VPWR A a_183_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X5 a_29_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VGND C a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.091 ps=0.93 w=0.65 l=0.15
X1 Y B1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.175 ps=1.35 w=1 l=0.15
X4 a_29_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y A2 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND A1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 a_112_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X8 a_112_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.14 ps=1.28 w=1 l=0.15
X9 a_29_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X11 a_29_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
X0 a_558_47# a_381_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X1 VGND X a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_841_47# a_664_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VPWR A a_62_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A a_62_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_558_47# a_381_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X6 X a_62_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR X a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_841_47# a_664_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X9 X a_62_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X10 VPWR a_558_47# a_664_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND a_558_47# a_664_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
X0 VPWR B a_207_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.228 pd=1.74 as=0.0609 ps=0.71 w=0.42 l=0.15
X1 X a_207_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.228 ps=1.74 w=1 l=0.15
X2 a_297_47# a_27_413# a_207_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0504 pd=0.66 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_207_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.99 w=0.65 l=0.15
X4 a_207_413# a_27_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0609 pd=0.71 as=0.0714 ps=0.76 w=0.42 l=0.15
X5 VPWR A_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0714 pd=0.76 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VGND B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.99 as=0.0504 ps=0.66 w=0.42 l=0.15
X7 a_27_413# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_298_297# a_27_413# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.265 ps=2.53 w=1 l=0.15
X1 a_215_297# a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.136 ps=1.1 w=0.65 l=0.15
X2 a_298_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.258 ps=1.45 w=0.65 l=0.15
X4 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X6 a_382_47# A1 a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.136 pd=1.1 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VPWR A1 a_298_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND A2 a_382_47# VNB sky130_fd_pr__nfet_01v8 ad=0.258 pd=1.45 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
X0 X a_299_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X1 VPWR a_193_47# a_299_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 VGND a_193_47# a_299_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X6 X a_299_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.16 ps=1.32 w=1 l=0.15
X1 a_27_297# B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X2 VGND A2 a_373_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.114 ps=1 w=0.65 l=0.15
X3 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X4 a_27_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.253 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.253 ps=2.52 w=1 l=0.15
X6 a_373_47# A1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.96 w=0.65 l=0.15
X8 a_109_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_397_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR B1_N a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X2 Y A2 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VGND A2 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND A1 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_28_297# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X6 Y a_28_297# a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VPWR a_28_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_397_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X9 a_229_47# a_28_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y a_28_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X11 a_229_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_229_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A1 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
X0 a_109_93# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_209_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X2 a_109_93# A_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_296_53# a_109_93# a_209_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.108 ps=1.36 w=0.42 l=0.15
X4 VPWR C a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0744 ps=0.815 w=0.42 l=0.15
X5 a_368_53# B a_296_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_209_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.122 ps=1.08 w=0.65 l=0.15
X7 a_209_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VPWR a_109_93# a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.108 ps=1.36 w=0.42 l=0.15
X9 VGND C a_368_53# VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.08 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
X0 VGND C a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 a_277_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_47# B a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.135 ps=1.27 w=1 l=0.15
X8 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_277_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
X0 a_109_93# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_215_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 VGND a_109_93# a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND A a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 VPWR A a_369_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_369_297# B a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_215_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X7 a_297_297# a_109_93# a_215_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_109_93# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 X a_215_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.1 ps=0.985 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y A1 a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.119 ps=1.01 w=0.65 l=0.15
X1 a_181_47# A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.0683 ps=0.86 w=0.65 l=0.15
X2 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.106 ps=0.975 w=0.65 l=0.15
X3 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.162 ps=1.33 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.153 ps=1.3 w=1 l=0.15
X6 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.117 ps=1.01 w=0.65 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.41 pd=1.82 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.175 ps=1.35 w=1 l=0.15
X4 a_277_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.41 ps=1.82 w=1 l=0.15
X10 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.18 ps=1.36 w=1 l=0.15
X11 a_277_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.114 ps=1 w=0.65 l=0.15
X13 Y A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.0975 ps=0.95 w=0.65 l=0.15
X14 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_465_47# A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.157 ps=1.32 w=1 l=0.15
X2 a_109_297# B1 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 a_193_297# B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.102 ps=0.965 w=0.65 l=0.15
X5 a_205_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X6 VPWR A2 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.165 ps=1.33 w=1 l=0.15
X7 a_193_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X8 a_27_47# B1 a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X9 a_109_297# C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 VGND C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND A2 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
X0 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_206_369# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.146 ps=1.34 w=0.42 l=0.15
X1 a_206_369# A2_N a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 VGND B2 a_489_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_585_369# B2 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0672 ps=0.74 w=0.42 l=0.15
X4 a_489_47# a_206_369# a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_489_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VPWR A2_N a_206_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.209 pd=1.35 as=0.129 ps=1.18 w=0.42 l=0.15
X7 a_76_199# a_206_369# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.74 as=0.209 ps=1.35 w=0.42 l=0.15
X8 a_205_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0662 pd=0.735 as=0.0986 ps=0.98 w=0.42 l=0.15
X9 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.26 ps=2.52 w=1 l=0.15
X10 VPWR B1 a_585_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0986 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2111oi_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
X0 a_316_297# C1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.172 ps=1.35 w=1 l=0.15
X1 Y D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.481 ps=2.78 w=0.65 l=0.15
X2 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.02 as=0.125 ps=1.03 w=0.65 l=0.15
X3 a_420_297# B1 a_316_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=1.58 as=0.185 ps=1.37 w=1 l=0.15
X4 VPWR A1 a_420_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.29 ps=1.58 w=1 l=0.15
X5 VGND A2 a_568_47# VNB sky130_fd_pr__nfet_01v8 ad=0.192 pd=1.89 as=0.0845 ps=0.91 w=0.65 l=0.15
X6 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.192 pd=1.24 as=0.12 ps=1.02 w=0.65 l=0.15
X7 a_420_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.138 ps=1.27 w=1 l=0.15
X8 a_217_297# D1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.35 as=0.755 ps=3.51 w=1 l=0.15
X9 a_568_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0845 pd=0.91 as=0.192 ps=1.24 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
X0 Y C a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 a_281_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X6 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X10 a_281_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_297# B a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 Y a_61_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.183 ps=1.24 w=0.65 l=0.15
X1 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_217_297# a_61_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_479_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X4 a_217_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X5 Y a_61_47# a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 VPWR A1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_61_47# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VGND A2 a_637_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_61_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A1 a_479_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0683 ps=0.86 w=0.65 l=0.15
X11 VGND B1_N a_61_47# VNB sky130_fd_pr__nfet_01v8 ad=0.183 pd=1.24 as=0.126 ps=1.44 w=0.42 l=0.15
X12 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X13 a_637_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
X0 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X1 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND B a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.221 pd=1.98 as=0.198 ps=1.26 w=0.65 l=0.15
X1 Y A3 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.393 pd=1.78 as=0.135 ps=1.27 w=1 l=0.15
X2 a_193_297# A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.393 ps=1.78 w=1 l=0.15
X5 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_39_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=1 w=0.65 l=0.15
X2 VPWR a_39_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_39_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.156 ps=1.36 w=1 l=0.15
X4 VGND a_39_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.156 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VGND A a_39_297# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=1 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_39_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
X0 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.165 ps=1.33 w=1 l=0.15
X2 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_193_47# C a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_277_47# B a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
X0 X a_61_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.167 ps=1.39 w=1 l=0.15
X1 VPWR a_61_75# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.195 ps=1.39 w=1 l=0.15
X2 VPWR B a_61_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 VGND B a_147_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 X a_61_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.112 ps=1.04 w=0.65 l=0.15
X5 VGND a_61_75# X VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.127 ps=1.04 w=0.65 l=0.15
X6 a_61_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X7 a_147_75# A a_61_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 a_78_199# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 VPWR A1 a_493_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X2 a_493_297# A2 a_78_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.235 ps=1.47 w=1 l=0.15
X3 VPWR a_78_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.373 pd=1.75 as=0.28 ps=2.56 w=1 l=0.15
X4 VGND A2 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X5 a_78_199# B2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.235 pd=1.47 as=0.117 ps=1.24 w=1 l=0.15
X6 a_215_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_215_47# B2 a_78_199# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_292_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.117 pd=1.24 as=0.373 ps=1.75 w=1 l=0.15
X9 VGND a_78_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X1 a_80_21# C1 a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X2 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_300_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.26 ps=1.45 w=0.65 l=0.15
X6 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_80_21# A1 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 a_472_297# B1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X9 a_80_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.26 ps=1.45 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.4 ps=1.8 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.205 pd=1.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.135 ps=1.27 w=1 l=0.15
X5 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_109_297# C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR A2 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 a_277_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X2 a_79_21# B1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X3 a_277_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_361_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_277_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.127 ps=1.04 w=0.65 l=0.15
X9 a_79_21# A1 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_226_47# A2_N a_226_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_489_413# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_226_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.167 ps=1.43 w=0.42 l=0.15
X3 VPWR B2 a_489_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_489_413# a_226_47# a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_76_199# a_226_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.139 ps=1.08 w=0.42 l=0.15
X6 VGND B1 a_556_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_556_47# B2 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VGND A2_N a_226_47# VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.08 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_226_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.12 ps=1.09 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.43 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.09 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311o_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_277_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.325 ps=1.65 w=1 l=0.15
X2 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_861_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.211 ps=1.3 w=0.65 l=0.15
X4 a_27_297# B1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_1059_47# A2 a_861_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_1059_47# A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_277_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0943 ps=0.94 w=0.65 l=0.15
X9 a_27_297# C1 a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.211 pd=1.3 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A3 a_861_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VGND C1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_109_47# A1 a_1059_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_109_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 VPWR A3 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X21 VPWR A2 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.325 pd=1.65 as=0.135 ps=1.27 w=1 l=0.15
X22 a_109_47# C1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X23 VPWR A1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X24 a_277_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 a_277_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X26 a_109_47# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X27 a_861_47# A2 a_1059_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_77_199# B2 a_227_47# VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.127 ps=1.04 w=0.65 l=0.15
X1 a_323_297# A2 a_227_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.165 ps=1.33 w=1 l=0.15
X2 a_227_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_227_47# B1 a_77_199# VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.133 ps=1.06 w=0.65 l=0.15
X4 VGND a_77_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR B1 a_539_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.205 ps=1.41 w=1 l=0.15
X6 a_227_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X7 VPWR a_77_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=2.67 w=1 l=0.15
X8 a_77_199# A3 a_323_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X9 VGND A2 a_227_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 a_227_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_539_297# B2 a_77_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=1.41 as=0.195 ps=1.39 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VGND A1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
X1 a_510_47# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.143 ps=1.09 w=0.65 l=0.15
X2 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.175 ps=1.35 w=1 l=0.15
X3 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.22 ps=1.44 w=1 l=0.15
X4 a_79_21# A2 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.22 pd=1.44 as=0.162 ps=1.33 w=1 l=0.15
X5 a_297_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X6 a_79_21# C1 a_510_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.114 ps=1 w=0.65 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X8 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
X9 a_215_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.106 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
X0 Y a_53_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.192 ps=1.38 w=1 l=0.15
X1 a_232_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.192 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A_N a_53_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A_N a_53_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_316_47# B a_232_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y a_53_93# a_316_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.125 ps=1.03 w=0.65 l=0.15
X7 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 VGND A2 a_660_47# VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.0829 ps=0.905 w=0.65 l=0.15
X1 VGND C1 a_85_193# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.101 ps=0.96 w=0.65 l=0.15
X2 a_414_297# C1 a_334_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.125 ps=1.25 w=1 l=0.15
X3 VGND a_85_193# X VNB sky130_fd_pr__nfet_01v8 ad=0.275 pd=1.5 as=0.214 ps=1.96 w=0.65 l=0.15
X4 a_334_297# D1 a_85_193# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.125 pd=1.25 as=0.385 ps=2.77 w=1 l=0.15
X5 a_516_297# B1 a_414_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=1.56 as=0.18 ps=1.36 w=1 l=0.15
X6 a_516_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.135 ps=1.27 w=1 l=0.15
X7 a_660_47# A1 a_85_193# VNB sky130_fd_pr__nfet_01v8 ad=0.0829 pd=0.905 as=0.185 ps=1.22 w=0.65 l=0.15
X8 a_85_193# D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.275 ps=1.5 w=0.65 l=0.15
X9 VPWR A1 a_516_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=1.56 w=1 l=0.15
X10 a_85_193# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.22 as=0.117 ps=1.01 w=0.65 l=0.15
X11 VPWR a_85_193# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.29 ps=2.58 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 a_465_47# A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND A4 a_561_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X2 VPWR A3 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X3 a_297_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X4 a_297_297# A4 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X5 VPWR A1 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_381_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.184 ps=1.22 w=0.65 l=0.15
X7 a_297_297# B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X8 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X9 a_79_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.184 pd=1.22 as=0.161 ps=1.14 w=0.65 l=0.15
X10 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.161 pd=1.14 as=0.169 ps=1.82 w=0.65 l=0.15
X11 a_561_47# A3 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.28 ps=2.56 w=1 l=0.15
X1 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X4 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.177 ps=1.36 w=1 l=0.15
X7 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.105 ps=1.21 w=1 l=0.15
X9 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
X0 VGND a_91_199# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.221 ps=1.98 w=0.65 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A a_245_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.135 ps=1.27 w=1 l=0.15
X3 a_91_199# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_245_297# B a_161_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_91_199# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.146 ps=1.34 w=0.42 l=0.15
X7 a_161_297# a_91_199# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.32 ps=2.64 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_388_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.127 pd=1.25 as=0.153 ps=1.3 w=1 l=0.15
X1 a_105_352# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_297_47# a_105_352# Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A1 a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.127 ps=1.25 w=1 l=0.15
X5 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X6 VPWR B1_N a_105_352# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.178 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 Y a_105_352# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.178 ps=1.4 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.172 ps=1.83 w=0.65 l=0.15
X2 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X3 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X5 a_326_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.127 ps=1.04 w=0.65 l=0.15
X6 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.635 pd=3.27 as=0.195 ps=1.39 w=1 l=0.15
X7 Y C1 a_326_47# VNB sky130_fd_pr__nfet_01v8 ad=0.393 pd=2.51 as=0.0683 ps=0.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_56_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A2 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_139_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.266 ps=2.12 w=0.65 l=0.15
X4 a_311_297# B1 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X5 Y C1 a_311_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X7 Y A1 a_139_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 X a_79_204# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A1 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_473_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.195 ps=1.39 w=1 l=0.15
X3 X a_79_204# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X4 VGND C1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.104 ps=0.97 w=0.65 l=0.15
X5 a_79_204# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0926 ps=0.935 w=0.65 l=0.15
X6 VPWR a_79_204# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X7 a_473_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X8 a_473_297# B1 a_727_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.16 ps=1.32 w=1 l=0.15
X9 X a_79_204# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X10 VGND B1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.127 ps=1.04 w=0.65 l=0.15
X11 a_79_204# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.109 ps=0.985 w=0.65 l=0.15
X12 VGND a_79_204# X VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.0959 ps=0.945 w=0.65 l=0.15
X13 a_1123_47# A1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_555_297# B1 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X15 VPWR A2 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X16 VGND A2 a_1123_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.091 ps=0.93 w=0.65 l=0.15
X17 a_951_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.14 ps=1.08 w=0.65 l=0.15
X18 VPWR a_79_204# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_79_204# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X20 a_79_204# A1 a_951_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 a_79_204# C1 a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 a_727_297# C1 a_79_204# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X23 X a_79_204# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
X0 VPWR a_30_53# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.315 pd=2.63 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND a_30_53# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_30_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X3 a_112_297# C a_30_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_30_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 VGND A a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 a_30_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 VGND C a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_184_297# B a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X9 VPWR A a_184_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311a_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 X a_91_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.32 ps=2.64 w=1 l=0.15
X1 a_91_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.15 ps=1.3 w=1 l=0.15
X2 a_360_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.137 ps=1.07 w=0.65 l=0.15
X3 VPWR B1 a_91_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.138 ps=1.27 w=1 l=0.15
X4 a_360_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.312 ps=1.62 w=1 l=0.15
X5 VGND A2 a_360_47# VNB sky130_fd_pr__nfet_01v8 ad=0.137 pd=1.07 as=0.114 ps=1 w=0.65 l=0.15
X6 a_360_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.203 ps=1.27 w=0.65 l=0.15
X7 VPWR a_91_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.62 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND a_91_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.203 pd=1.27 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 X a_91_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.208 ps=1.94 w=0.65 l=0.15
X10 a_677_47# B1 a_360_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.119 ps=1.01 w=0.65 l=0.15
X11 a_460_297# A2 a_360_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.21 pd=1.42 as=0.175 ps=1.35 w=1 l=0.15
X12 a_91_21# C1 a_677_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X13 a_91_21# A3 a_460_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.21 ps=1.42 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_240_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_51_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A1 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_51_297# B2 a_245_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.412 pd=1.83 as=0.105 ps=1.21 w=1 l=0.15
X4 a_149_47# C1 a_51_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.201 ps=1.92 w=0.65 l=0.15
X5 a_240_47# B1 a_149_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0991 ps=0.955 w=0.65 l=0.15
X6 VPWR A1 a_512_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X7 X a_51_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.165 ps=1.33 w=1 l=0.15
X8 a_149_47# B2 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_245_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X10 VPWR C1 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.34 ps=2.68 w=1 l=0.15
X11 a_512_297# A2 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.412 ps=1.83 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
X0 a_176_21# a_27_47# a_626_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X1 a_626_297# B a_542_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_542_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X8 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X12 a_176_21# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X13 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X1 X a_80_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 VGND a_80_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=0.99 as=0.091 ps=0.93 w=0.65 l=0.15
X3 a_386_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.157 ps=1.32 w=1 l=0.15
X4 X a_80_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_80_199# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.162 pd=1.15 as=0.111 ps=0.99 w=0.65 l=0.15
X6 a_386_297# B1 a_80_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_458_47# A1 a_80_199# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.162 ps=1.15 w=0.65 l=0.15
X8 VPWR A1 a_386_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X9 VGND A2 a_458_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.123 ps=1.03 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VGND A2 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR A1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_37_297# B1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_485_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_292_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VPWR A2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X8 a_485_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X11 a_37_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 Y A1 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X13 Y C1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_292_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X15 a_292_297# B1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
X0 VPWR A1 a_485_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_485_297# a_297_93# a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X2 a_297_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.108 ps=1.01 w=0.42 l=0.15
X3 a_581_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X4 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.01 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_79_21# a_297_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X6 VGND A2 a_581_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.182 pd=1.51 as=0.14 ps=1.28 w=1 l=0.15
X8 a_297_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.182 ps=1.51 w=0.42 l=0.15
X9 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X10 a_485_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X11 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_197_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0798 pd=0.8 as=0.0609 ps=0.71 w=0.42 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.312 ps=1.68 w=1 l=0.15
X3 a_303_47# C a_197_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0798 ps=0.8 w=0.42 l=0.15
X4 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.68 as=0.0588 ps=0.7 w=0.42 l=0.15
X6 VGND D a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.196 pd=1.33 as=0.0693 ps=0.75 w=0.42 l=0.15
X7 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X8 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.196 ps=1.33 w=0.65 l=0.15
X9 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_75_199# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.135 ps=1.07 w=0.65 l=0.15
X1 a_208_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.112 ps=0.995 w=0.65 l=0.15
X2 a_315_47# A2 a_208_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.17 as=0.125 ps=1.03 w=0.65 l=0.15
X3 VGND B1 a_75_199# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.07 as=0.106 ps=0.975 w=0.65 l=0.15
X4 a_75_199# A1 a_315_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.17 w=0.65 l=0.15
X5 a_75_199# C1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.207 ps=1.41 w=1 l=0.15
X6 a_544_297# B1 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.207 pd=1.41 as=0.162 ps=1.33 w=1 l=0.15
X7 VPWR a_75_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.285 ps=2.57 w=1 l=0.15
X8 a_201_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.142 ps=1.28 w=1 l=0.15
X9 VPWR A2 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.165 ps=1.33 w=1 l=0.15
X10 a_201_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.305 ps=1.61 w=1 l=0.15
X11 VGND a_75_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_4 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 VGND a_415_21# a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_415_21# A2_N a_717_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_717_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VGND A2_N a_415_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_193_47# a_415_21# a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR a_193_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_193_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_193_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_415_21# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X11 a_415_21# A2_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_193_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_193_47# B2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VGND a_193_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND A1_N a_415_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND a_193_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_109_47# B2 a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_193_47# a_415_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR a_193_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_27_297# a_415_21# a_193_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X23 X a_193_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 VPWR A1_N a_717_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X26 a_717_297# A2_N a_415_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_109_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
X0 VGND A_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X1 Y a_27_93# a_206_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_206_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR a_27_93# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X5 VPWR A_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
X0 a_388_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.148 ps=1.34 w=0.42 l=0.15
X1 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X4 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X7 a_176_21# a_27_47# a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 a_472_297# B a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.102 ps=0.99 w=0.42 l=0.15
X10 a_176_21# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311a_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.305 ps=1.61 w=1 l=0.15
X1 a_467_47# C1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_467_47# B1 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND A1 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.135 ps=1.27 w=1 l=0.15
X6 a_79_21# C1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_717_47# B1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VGND A3 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.27 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_1147_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR A1 a_1147_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_1147_297# A2 a_875_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X18 a_79_21# A3 a_875_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X19 a_875_297# A3 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 a_875_297# A2 a_1147_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 a_717_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.201 ps=1.27 w=0.65 l=0.15
X23 a_717_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_717_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X26 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd2_1 A VGND VNB VPB VPWR X
X0 VPWR A a_49_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VPWR a_221_47# a_327_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.18
X2 X a_327_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X3 VGND A a_49_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_327_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X5 a_221_47# a_49_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.18
X6 a_221_47# a_49_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.18
X7 VGND a_221_47# a_327_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.18
.ends

.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_286_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X2 a_286_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X3 Y A2 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 VGND A1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X6 VGND A2 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X7 a_487_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# B1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR A1 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_27_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X13 a_487_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X14 a_286_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_12 A VGND VNB VPB VPWR X
X0 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR A a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_109_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 VPWR A a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VGND A a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 a_109_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.135 ps=1.27 w=1 l=0.15
X24 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_109_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X29 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 a_109_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X31 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
X0 VPWR A a_304_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X1 a_304_297# B a_220_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND C a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X3 a_220_297# C a_114_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X4 a_32_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_32_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X11 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X13 a_114_297# D a_32_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.26 ps=2.52 w=1 l=0.15
X14 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311ai_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
X0 VGND A2 a_138_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_138_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X2 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.185 ps=1.37 w=1 l=0.15
X3 a_138_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A3 a_222_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.225 pd=1.45 as=0.135 ps=1.27 w=1 l=0.15
X5 Y C1 a_458_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0683 ps=0.86 w=0.65 l=0.15
X6 a_222_297# A2 a_138_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.225 ps=1.45 w=1 l=0.15
X8 a_458_47# B1 a_138_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.198 ps=1.26 w=0.65 l=0.15
X9 a_138_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_8 A B VGND VNB VPB VPWR Y
X0 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.135 ps=1.27 w=1 l=0.15
X24 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X29 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X31 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_27_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_277_297# B a_205_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VPWR A a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X5 a_205_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X6 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X7 VGND C a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0693 ps=0.75 w=0.42 l=0.15
X8 a_109_297# D a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X9 VGND A a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
X0 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X1 a_109_53# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_215_297# a_109_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_392_297# C a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0452 pd=0.635 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_465_297# B a_392_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.064 pd=0.725 as=0.0452 ps=0.635 w=0.42 l=0.15
X6 a_215_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 VPWR A a_465_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.064 ps=0.725 w=0.42 l=0.15
X8 a_297_297# a_109_53# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_109_53# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X10 VGND C a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.064 ps=0.725 w=0.42 l=0.15
X11 VGND A a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.385 pd=1.77 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X9 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.385 ps=1.77 w=1 l=0.15
X14 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X21 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X31 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111ai_4 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
X0 a_27_47# C1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_803_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_47# C1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0943 ps=0.94 w=0.65 l=0.15
X4 a_1163_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0959 ps=0.945 w=0.65 l=0.15
X7 Y D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 Y A2 a_1163_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_1163_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.147 ps=1.29 w=1 l=0.15
X10 a_445_47# B1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR D1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_445_47# B1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 Y D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR A1 a_1163_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_47# D1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_47# D1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0959 ps=0.945 w=0.65 l=0.15
X18 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X20 a_1163_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 a_803_47# B1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.237 pd=1.48 as=0.135 ps=1.27 w=1 l=0.15
X24 VPWR A1 a_1163_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 a_803_47# B1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y D1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.237 ps=1.48 w=1 l=0.15
X28 a_445_47# C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_803_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 a_1163_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.253 ps=2.52 w=1 l=0.15
X32 Y A2 a_1163_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.253 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X33 a_445_47# C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X34 a_803_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.0878 ps=0.92 w=0.65 l=0.15
X35 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 a_803_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.0878 ps=0.92 w=0.65 l=0.15
X37 VPWR D1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 Y D1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X39 VGND A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
D0 VNB DIODE sky130_fd_pr__diode_pw2nd_05v5 pj=2.64e+06 area=4.347e+11
.ends

.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X16 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X17 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X20 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
X0 a_204_297# A1 a_396_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.16 ps=1.32 w=1 l=0.15
X1 VPWR a_396_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_396_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR S a_314_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_204_297# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.162 ps=1.33 w=1 l=0.15
X5 a_396_47# A0 a_314_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.26 ps=2.52 w=1 l=0.15
X6 a_206_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.109 ps=0.985 w=0.65 l=0.15
X7 X a_396_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_396_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_396_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_490_47# A1 a_396_47# VNB sky130_fd_pr__nfet_01v8 ad=0.275 pd=1.5 as=0.104 ps=0.97 w=0.65 l=0.15
X11 VGND S a_490_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.275 ps=1.5 w=0.65 l=0.15
X12 VGND a_396_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_396_47# A0 a_206_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.26 ps=1.45 w=0.65 l=0.15
X14 VGND a_396_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR S a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X16 X a_396_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND S a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_33_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND A1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_33_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_797_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_797_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y B2 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR B1 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_33_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 a_33_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_33_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_33_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_797_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.16 ps=1.32 w=1 l=0.15
X17 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR B1 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND A2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_33_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 a_797_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.135 ps=1.27 w=1 l=0.15
X24 Y B2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 Y B2 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 Y B1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.104 ps=0.97 w=0.65 l=0.15
X27 Y B2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 Y B1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_33_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.29 ps=2.58 w=1 l=0.15
.ends

.subckt inverse_clarke VGND VPWR a[0] a[10] a[11] a[12] a[13] a[14] a[15] a[16] a[17]
+ a[18] a[1] a[2] a[3] a[4] a[5] a[6] a[7] a[8] a[9] alpha[0] alpha[10] alpha[11]
+ alpha[12] alpha[13] alpha[14] alpha[15] alpha[16] alpha[17] alpha[18] alpha[1] alpha[2]
+ alpha[3] alpha[4] alpha[5] alpha[6] alpha[7] alpha[8] alpha[9] b[0] b[10] b[11]
+ b[12] b[13] b[14] b[15] b[16] b[17] b[18] b[1] b[2] b[3] b[4] b[5] b[6] b[7] b[8]
+ b[9] beta[0] beta[10] beta[11] beta[12] beta[13] beta[14] beta[15] beta[16] beta[17]
+ beta[18] beta[1] beta[2] beta[3] beta[4] beta[5] beta[6] beta[7] beta[8] beta[9]
+ c[0] c[10] c[11] c[12] c[13] c[14] c[15] c[16] c[17] c[18] c[1] c[2] c[3] c[4] c[5]
+ c[6] c[7] c[8] c[9] clk done rstb start
X_2037_ net78 _1193_ net104 VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__mux2_1
X_2106_ _0909_ _1208_ _0105_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__nor3_1
XFILLER_0_32_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_37_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer7 net162 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1270_ net118 _0435_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1606_ net215 _0770_ net105 VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout105 net106 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__clkbuf_4
X_1537_ _0700_ _0702_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__xor2_2
X_1468_ net147 net116 VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__or2_1
X_1399_ _0541_ net160 VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__xnor2_2
Xfanout149 net23 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_1_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout127 net128 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__buf_8
Xfanout116 net117 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__buf_6
Xfanout138 net28 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__buf_2
XFILLER_0_20_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2440_ clknet_3_2__leaf_clk _0016_ net108 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2371_ _0353_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_38_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1322_ _0479_ _0487_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__xor2_2
X_1253_ net118 net131 VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__xor2_1
XFILLER_0_54_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1940_ _1096_ _1098_ VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_28_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1871_ _0974_ _0976_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2423_ net103 _0395_ _0396_ _0397_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__a31o_1
XFILLER_0_24_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_24_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1236_ net43 net3 net104 VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__mux2_1
X_2354_ _1103_ _0339_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_36_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2285_ _0275_ _0280_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__xnor2_1
X_1305_ _0463_ _0470_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_30_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2070_ _0684_ _0070_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__and2_1
XFILLER_0_56_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1923_ net141 _0902_ _0903_ VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__and3_1
X_1785_ _0921_ _0923_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__nor2_1
X_1854_ net148 net145 VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__nand2_1
X_2406_ _0382_ _0383_ net103 VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__o21ai_1
X_1219_ _0401_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__clkbuf_1
X_2337_ _0325_ _0323_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__or2_1
X_2199_ _0156_ _0170_ _0196_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__a21oi_1
X_2268_ _0263_ _0264_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__and2_1
XFILLER_0_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold63 net94 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 net50 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__dlygate4sd3_1
Xhold41 net69 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_30_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1570_ _0729_ _0734_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_21_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2122_ _0122_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__inv_2
Xrebuffer17 _0499_ VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__clkbuf_2
Xrebuffer28 _0448_ VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__clkbuf_2
X_2053_ _0685_ _0851_ VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1768_ _0928_ _0886_ _0888_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__nand3_1
X_1837_ _0928_ _0988_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__or2_1
X_1906_ net226 _0632_ _0688_ VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1699_ _0803_ _0805_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_11_Left_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput53 net53 VGND VGND VPWR VPWR a[3] sky130_fd_sc_hd__clkbuf_4
Xoutput75 net75 VGND VGND VPWR VPWR b[6] sky130_fd_sc_hd__clkbuf_4
Xoutput64 net64 VGND VGND VPWR VPWR b[13] sky130_fd_sc_hd__clkbuf_4
Xoutput42 net42 VGND VGND VPWR VPWR a[10] sky130_fd_sc_hd__clkbuf_4
Xoutput86 net86 VGND VGND VPWR VPWR c[16] sky130_fd_sc_hd__clkbuf_4
Xoutput97 net97 VGND VGND VPWR VPWR c[9] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1622_ net114 net118 VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__nand2_1
X_1553_ _0716_ _0718_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__nand2_1
X_1484_ _0644_ _0649_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_1_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2036_ _1190_ _1192_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__xnor2_1
X_2105_ _0909_ _1208_ _0105_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__o21a_1
XFILLER_0_43_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_6__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_6__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_2_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer8 _0441_ VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1605_ _0724_ _0769_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__xnor2_1
X_1536_ _0622_ _0651_ _0701_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_14_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout106 net107 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__buf_2
XFILLER_0_38_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout139 net140 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__clkbuf_4
X_1467_ net147 net116 VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__nand2_1
Xfanout117 net37 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__buf_6
X_1398_ _0548_ _0563_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__nand2_1
Xfanout128 net33 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__buf_8
X_2019_ _1173_ _1175_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_9_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2370_ net80 _0352_ net104 VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__mux2_1
X_1321_ _0485_ _0486_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__nor2_2
X_1252_ net169 net131 net154 VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_49_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_58_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1519_ net149 net223 VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__xor2_4
XFILLER_0_4_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1870_ _1012_ _1029_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__xor2_2
XFILLER_0_51_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2353_ _0330_ _0338_ _1047_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__o21ai_1
X_2422_ _0721_ net220 VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__and2_1
XFILLER_0_10_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1235_ _0409_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2284_ _0277_ _0278_ _0279_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__o21ba_1
X_1304_ _0466_ _0469_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__xor2_2
XFILLER_0_19_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1999_ net2 _1147_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__xor2_2
X_1922_ net146 net143 VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__nor2_1
X_1784_ _0927_ _0925_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__or2b_1
XFILLER_0_12_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1853_ net150 net146 VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__nand2_2
XFILLER_0_21_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2405_ _0376_ net100 net99 _0269_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__o31a_1
X_2336_ _0875_ _0876_ _0877_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__a21boi_1
X_1218_ net212 net12 net105 VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__mux2_1
X_2198_ _0156_ _0170_ _0196_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__and3_1
X_2267_ _0252_ _0223_ _0262_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__or3_1
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold64 net61 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 net49 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 net68 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2121_ _0100_ _0071_ _0121_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__o21ai_2
Xrebuffer29 _0443_ VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__buf_1
Xrebuffer18 _0538_ VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__clkbuf_1
X_2052_ _0685_ _0851_ VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__and2_1
X_1905_ _1063_ _1010_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__or2_1
X_1767_ _0886_ _0888_ _0928_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__a21o_1
X_1836_ _0947_ _0987_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1698_ _0803_ _0805_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__nand2_1
X_2319_ _0311_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_50_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput54 net54 VGND VGND VPWR VPWR a[4] sky130_fd_sc_hd__clkbuf_4
Xoutput76 net76 VGND VGND VPWR VPWR b[7] sky130_fd_sc_hd__clkbuf_4
Xoutput43 net43 VGND VGND VPWR VPWR a[11] sky130_fd_sc_hd__buf_2
Xoutput65 net65 VGND VGND VPWR VPWR b[14] sky130_fd_sc_hd__clkbuf_4
Xoutput98 net98 VGND VGND VPWR VPWR done sky130_fd_sc_hd__clkbuf_4
Xoutput87 net87 VGND VGND VPWR VPWR c[17] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1552_ _0712_ _0713_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__nor2_1
XFILLER_0_26_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1621_ _0779_ _0784_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__xnor2_2
X_1483_ _0645_ _0648_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__xnor2_2
X_2104_ _0103_ _0104_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__xor2_1
X_2035_ _1153_ _1191_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1819_ _0912_ _0914_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__nor2_1
XFILLER_0_23_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer9 net117 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_3_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout107 net40 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__clkbuf_4
X_1604_ _0767_ _0768_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__and2_1
X_1535_ net178 _0650_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__and2b_1
XFILLER_0_1_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout118 net119 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__buf_8
Xfanout129 net130 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__buf_8
X_1466_ _0630_ _0631_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__xnor2_4
X_1397_ net154 net125 _0561_ _0562_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__a31o_1
X_2018_ _1126_ _1133_ _1174_ VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_55_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1320_ _0480_ _0481_ _0484_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__nor3_1
X_1251_ _0417_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1518_ net223 net153 VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__nand2_2
X_1449_ _0613_ _0614_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_33_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2352_ _1046_ _0334_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__nand2_1
X_2421_ _0393_ _0394_ _0305_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__o21ai_1
X_1303_ _0467_ _0468_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__and2_1
XFILLER_0_10_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2283_ _0277_ _0278_ _0965_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__a21bo_1
X_1234_ net42 net2 net101 VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1998_ _0828_ net197 _1155_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1852_ _1010_ _1011_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__or2_1
X_1921_ _1073_ _1079_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__xor2_2
X_1783_ _0942_ _0943_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__and2_1
X_2404_ _0269_ _0381_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__nor2_1
X_2335_ _0828_ net193 _0324_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__a21bo_1
X_2266_ _0252_ _0223_ _0262_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__o21ai_1
X_1217_ _0400_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__clkbuf_1
X_2197_ _0193_ _0195_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold65 net48 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 net77 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 net71 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_38_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2120_ _0119_ _0120_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__nor2_1
X_2051_ net143 _1071_ VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__or2_1
Xrebuffer19 net225 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_16_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1835_ _0828_ net199 _0994_ _0995_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__a22o_1
XFILLER_0_44_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1904_ _1008_ _1007_ VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__and2b_1
X_1766_ _0925_ _0927_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__xor2_1
X_1697_ _0841_ _0859_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__xnor2_2
X_2249_ _0234_ _0229_ _0231_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__nand3_1
X_2318_ net203 _0310_ net106 VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__mux2_1
XFILLER_0_50_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput77 net77 VGND VGND VPWR VPWR b[8] sky130_fd_sc_hd__clkbuf_4
Xoutput55 net55 VGND VGND VPWR VPWR a[5] sky130_fd_sc_hd__clkbuf_4
Xoutput44 net44 VGND VGND VPWR VPWR a[12] sky130_fd_sc_hd__clkbuf_4
Xoutput66 net66 VGND VGND VPWR VPWR b[15] sky130_fd_sc_hd__clkbuf_4
Xoutput88 net88 VGND VGND VPWR VPWR c[18] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1551_ _0712_ _0713_ _0716_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__o21bai_2
XFILLER_0_41_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1620_ _0782_ _0783_ VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__nor2_1
X_1482_ _0646_ _0647_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__xnor2_2
X_2103_ net142 net140 net138 _1121_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__a31o_1
X_2034_ _1149_ _1145_ _1146_ VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__and3b_1
XFILLER_0_32_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1818_ _0912_ _0914_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1749_ _0908_ _0910_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__xor2_2
XFILLER_0_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout108 net109 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__clkbuf_4
X_1603_ _0766_ _0764_ _0765_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__nand3_2
X_1534_ _0667_ _0699_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__xnor2_2
X_1465_ net223 net152 VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__xor2_4
XFILLER_0_1_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout119 net36 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__buf_6
XFILLER_0_54_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2017_ _1123_ _1125_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__or2b_1
X_1396_ _0559_ _0560_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__and2_1
XFILLER_0_49_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1250_ net206 net10 net101 VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__mux2_1
X_1448_ net20 _0551_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__xnor2_1
X_1517_ _0681_ _0682_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__and2_1
X_1379_ _0543_ net156 _0544_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_4_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2420_ _0393_ _0305_ _0394_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__or3_1
XFILLER_0_36_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1233_ _0408_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__clkbuf_1
X_2351_ _0337_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__clkbuf_1
X_1302_ net153 net123 VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__or2_1
X_2282_ net137 _1074_ _1121_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__a21o_1
X_1997_ _1153_ _0720_ _1154_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__or3b_1
XFILLER_0_51_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_28_Left_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1851_ _1005_ _1009_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__nor2_1
X_1920_ _1074_ _1075_ _1077_ _1078_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__a31o_1
X_1782_ net16 _0931_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__nand2_1
X_2403_ _0376_ net222 net221 VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__or3_1
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1216_ net51 net11 net105 VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__mux2_1
X_2334_ _0720_ _0322_ _0323_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__or3_1
X_2196_ _0194_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__inv_2
X_2265_ _1019_ _0261_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold55 net41 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 net76 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__dlygate4sd3_1
Xhold66 net88 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__dlygate4sd3_1
X_2050_ _0631_ _0798_ _0853_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__a21oi_1
X_1834_ _0938_ _0993_ _0941_ _0721_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__a31oi_1
X_1765_ net128 net130 _0868_ _0926_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_32_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1903_ _1004_ _1034_ _1061_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__a21oi_2
X_1696_ _0856_ _0858_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__xnor2_1
X_2248_ _0202_ _0203_ _0235_ _0237_ _0129_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__a221o_1
X_2317_ _0718_ _0309_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__xnor2_1
X_2179_ _0174_ _0176_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__nor2_1
Xoutput56 net56 VGND VGND VPWR VPWR a[6] sky130_fd_sc_hd__clkbuf_4
Xoutput78 net78 VGND VGND VPWR VPWR b[9] sky130_fd_sc_hd__clkbuf_4
Xoutput45 net45 VGND VGND VPWR VPWR a[13] sky130_fd_sc_hd__clkbuf_4
Xoutput89 net89 VGND VGND VPWR VPWR c[1] sky130_fd_sc_hd__clkbuf_4
Xoutput67 net67 VGND VGND VPWR VPWR b[16] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1550_ _0715_ net1 VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__or2b_1
XFILLER_0_1_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1481_ _0484_ net184 VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__xor2_2
X_2033_ _1188_ _1189_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__and2_1
X_2102_ _0745_ _0907_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__xor2_1
XFILLER_0_57_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1817_ _0957_ _0977_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__xnor2_2
X_1748_ _0848_ _0851_ _0909_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_15_Left_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1679_ net150 net114 VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1602_ _0764_ _0765_ _0766_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__a21o_1
Xfanout109 net110 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_38_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1533_ _0695_ _0698_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__xor2_2
X_1464_ net152 net115 VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__nand2_4
X_1395_ _0559_ _0560_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__xor2_1
X_2016_ _1166_ _1172_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_51_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1516_ net145 net115 VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__or2_1
XFILLER_0_49_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1378_ _0458_ _0488_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__and2b_1
XFILLER_0_4_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1447_ _0473_ _0506_ net129 _0467_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__o2bb2a_1
XPHY_EDGE_ROW_45_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2350_ net217 _0336_ net107 VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__mux2_1
X_1232_ net216 net19 net104 VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__mux2_1
X_1301_ net153 net123 VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__nand2_1
X_2281_ _0213_ _0254_ _0276_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_19_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1996_ _1106_ _1105_ _1152_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__or3_1
XFILLER_0_42_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2479_ clknet_3_2__leaf_clk _0055_ net108 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_18_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_3_Left_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1781_ net16 _0931_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__or2_1
X_1850_ _1005_ _1009_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__and2_1
XFILLER_0_21_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2402_ _0357_ _0361_ _0379_ _0377_ _0204_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__a2111oi_1
X_2333_ _0320_ _0321_ _0881_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__a21oi_1
X_1215_ _0399_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_46_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2195_ _0171_ _0172_ _0192_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__nor3_2
X_2264_ _0259_ _0260_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1979_ _1069_ _1135_ _1136_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__a21oi_2
Xhold56 net95 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 net74 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 net85 VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_38_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1902_ _1030_ _1033_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__and2_1
X_1833_ _0938_ _0941_ _0993_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__a21o_1
X_1764_ _0865_ _0867_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__nor2_1
X_2316_ net1 _0715_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__nor2_1
X_1695_ _0792_ _0802_ _0857_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_20_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2247_ _0161_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__inv_2
X_2178_ _0174_ _0176_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__and2_1
XFILLER_0_25_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput46 net46 VGND VGND VPWR VPWR a[14] sky130_fd_sc_hd__clkbuf_4
Xoutput57 net57 VGND VGND VPWR VPWR a[7] sky130_fd_sc_hd__clkbuf_4
Xoutput79 net79 VGND VGND VPWR VPWR c[0] sky130_fd_sc_hd__buf_2
Xoutput68 net68 VGND VGND VPWR VPWR b[17] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_34_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1480_ net124 net129 _0608_ _0606_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__a31o_1
X_2032_ _1186_ _1187_ _1156_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2101_ _0064_ _0066_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1816_ _0974_ _0976_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__xnor2_1
X_1678_ _0835_ _0840_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__xnor2_2
X_1747_ net141 _0849_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_32_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1601_ net12 _0708_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__xor2_2
X_1532_ _0696_ _0649_ _0697_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1463_ _0599_ _0602_ _0628_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__a21o_1
X_1394_ _0526_ _0535_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__xnor2_1
X_2015_ _1167_ _1171_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_9_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1515_ net145 net115 VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__nand2_1
X_1446_ _0594_ _0611_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__xnor2_1
X_1377_ _0541_ _0542_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__and2_4
XFILLER_0_45_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1231_ _0407_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__clkbuf_1
X_1300_ _0464_ _0465_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__xnor2_4
X_2280_ _0256_ _0253_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__or2b_1
XFILLER_0_19_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1995_ _1106_ _1105_ _1152_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__o21a_1
X_2478_ clknet_3_0__leaf_clk _0054_ net109 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dfrtp_1
X_1429_ net114 _0498_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1780_ _0933_ _0940_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2332_ _0881_ _0320_ _0321_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__and3_1
X_2401_ _0355_ _0161_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1214_ net209 net1 net105 VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2194_ _0171_ _0172_ _0192_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__o21ai_1
X_2263_ _0257_ _0258_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1978_ _1085_ _1087_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__nor2_1
Xhold57 net56 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 net89 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 net72 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_38_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1901_ _1058_ _1059_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__nand2_2
X_1832_ _0991_ _0992_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__or2_1
XFILLER_0_44_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1694_ _0799_ _0801_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__nand2_1
X_1763_ _0425_ _0924_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__xnor2_2
X_2246_ _0163_ _0166_ _0202_ _0203_ _0238_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__a221o_1
X_2315_ _0721_ _0306_ _0307_ _0308_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__o31ai_1
X_2177_ _1071_ _0175_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput58 net58 VGND VGND VPWR VPWR a[8] sky130_fd_sc_hd__clkbuf_4
Xoutput47 net47 VGND VGND VPWR VPWR a[15] sky130_fd_sc_hd__clkbuf_4
Xoutput69 net69 VGND VGND VPWR VPWR b[18] sky130_fd_sc_hd__clkbuf_4
X_2100_ _0061_ _0063_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__and2b_1
X_2031_ _1156_ _1186_ _1187_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__nand3_2
XFILLER_0_25_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1815_ _0901_ _0911_ _0975_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_4_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1677_ _0836_ _0839_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__xor2_2
X_1746_ _0904_ _0907_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__xor2_2
X_2229_ _0188_ _0190_ _0225_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__nor3_1
XFILLER_0_48_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1600_ _0725_ _0706_ _0763_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__a21o_1
XFILLER_0_38_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1531_ _0627_ _0643_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__and2_1
X_1462_ net153 _0597_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1393_ _0549_ _0557_ _0558_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_54_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2014_ _1169_ _1170_ VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__xor2_1
X_1729_ _0889_ _0890_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__or2_2
XFILLER_0_13_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1514_ _0678_ _0679_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__nor2_1
X_1445_ _0604_ _0610_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1376_ _0418_ _0456_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__xor2_1
XFILLER_0_33_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1230_ net214 net18 net107 VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__mux2_1
XFILLER_0_19_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1994_ _1150_ _1151_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__nand2_2
XFILLER_0_27_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2477_ clknet_3_1__leaf_clk _0053_ net109 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1428_ _0592_ _0508_ _0593_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__a21bo_1
X_1359_ net122 VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__inv_2
XFILLER_0_33_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2400_ _0135_ _0160_ _0204_ _0377_ _0368_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__a2111oi_1
XFILLER_0_21_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1213_ _0398_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__clkbuf_1
X_2331_ _0822_ _0774_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__or2b_1
X_2262_ _0257_ _0258_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__nor2_1
X_2193_ _0190_ _0191_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1977_ _1085_ _1087_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold58 net52 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 net87 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 net73 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__dlygate4sd3_1
X_1900_ net17 _0942_ net18 VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__o21ai_1
X_1831_ _0989_ _0990_ _0944_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1693_ _0845_ _0855_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__xnor2_2
X_1762_ _0921_ _0923_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__xor2_2
X_2245_ _0242_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__clkbuf_1
X_2314_ _0828_ net195 VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__nand2_1
X_2176_ _0850_ _1077_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__xor2_1
Xoutput59 net59 VGND VGND VPWR VPWR a[9] sky130_fd_sc_hd__clkbuf_4
Xoutput48 net48 VGND VGND VPWR VPWR a[16] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2030_ _1142_ _1145_ _1185_ VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__nand3_2
XFILLER_0_43_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1814_ _0908_ _0910_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__nand2_1
X_1745_ _0905_ _0906_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_17_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1676_ _0466_ _0838_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__xor2_2
X_2159_ _0074_ _0126_ _0122_ _0124_ VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__a31o_1
X_2228_ _0188_ _0190_ _0225_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__o21a_1
XFILLER_0_16_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1530_ _0627_ _0643_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__or2_1
X_1461_ _0625_ _0610_ _0626_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__a21bo_1
X_1392_ _0555_ _0556_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__nand2_1
X_2013_ _0631_ _0798_ VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_57_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_19_Left_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1728_ _0840_ _0835_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__and2b_1
XFILLER_0_13_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1659_ _0774_ _0822_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__xor2_2
XFILLER_0_36_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1513_ net169 net124 _0677_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__a21oi_1
X_1444_ _0605_ _0609_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1375_ _0524_ _0539_ _0540_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_45_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_7__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_7__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_35_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1993_ _1149_ _1145_ _1146_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_41_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2476_ clknet_3_1__leaf_clk _0052_ net39 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_50_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1427_ _0497_ net174 VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__nand2_1
X_1358_ net133 net122 VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__nand2_1
X_1289_ _0449_ _0454_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_18_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1212_ net202 net105 VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__or2_1
X_2330_ _0315_ _0316_ _0823_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__a21o_1
X_2192_ _0188_ _0189_ _0849_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__o21a_1
X_2261_ _0218_ _0219_ _0216_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__o21a_1
XFILLER_0_1_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1976_ _1126_ _1133_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold59 net46 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 net98 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 net90 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__dlygate4sd3_1
X_2459_ clknet_3_0__leaf_clk _0035_ net109 VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_38_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_7_Left_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1830_ _0944_ _0989_ _0990_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__and3_1
XFILLER_0_4_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1761_ _0834_ _0864_ _0922_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__a21oi_2
X_2313_ _0304_ _0302_ _0305_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__and3_1
X_1692_ _0852_ _0854_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__xor2_2
X_2244_ net65 _0241_ net102 VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__mux2_1
X_2175_ _0797_ _0968_ _1020_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__a21o_1
XFILLER_0_7_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1959_ net146 net143 VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__and2_1
Xoutput49 net49 VGND VGND VPWR VPWR a[17] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_26_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_40_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1813_ _0961_ _0973_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__xnor2_2
X_1744_ net141 net140 VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__xor2_4
X_1675_ _0425_ _0837_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2089_ _1152_ _1188_ _1189_ _0084_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__nand4_1
X_2158_ _0156_ _0157_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__and2_2
X_2227_ _0223_ _0224_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1460_ _0596_ _0603_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1391_ _0555_ _0556_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2012_ _1117_ _1119_ net145 _1168_ VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_9_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1658_ _0820_ _0821_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__and2_1
X_1727_ _0839_ _0836_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__and2b_1
X_1589_ _0751_ _0753_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_36_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1512_ net169 net124 _0677_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__and3_1
XFILLER_0_10_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1374_ _0537_ net172 VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__nand2_1
X_1443_ _0606_ _0608_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__and2b_1
XFILLER_0_45_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1992_ _1145_ _1146_ _1149_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__a21o_1
X_2475_ clknet_3_2__leaf_clk _0051_ net108 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_2_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1357_ _0485_ _0522_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__xnor2_2
X_1426_ _0497_ _0504_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__or2_1
X_1288_ _0435_ _0453_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_33_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2191_ _0849_ _0188_ _0189_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__nor3_1
X_2260_ _0253_ _0256_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_23_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1975_ _1131_ _1132_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__and2_1
XFILLER_0_15_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2458_ clknet_3_2__leaf_clk _0034_ net109 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__dfrtp_1
Xhold38 net66 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__dlygate4sd3_1
X_1409_ net127 _0517_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__nand2_1
X_2389_ _0135_ _0160_ _0363_ _0368_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__a22o_1
Xhold49 net79 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_46_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1691_ _0795_ _0798_ _0853_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__a21o_1
X_1760_ _0860_ _0863_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__and2_1
X_2312_ _0304_ _0302_ _0305_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__a21oi_1
X_2243_ _0238_ _0240_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__xnor2_1
X_2174_ _0150_ _0149_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__or2b_1
XFILLER_0_7_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1889_ _0944_ _0989_ _0990_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__nand3_1
XFILLER_0_43_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1958_ _1114_ _1067_ _1115_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_57_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1674_ net123 net173 VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__or2_1
X_1812_ _0969_ _0972_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__xnor2_2
X_1743_ net144 net141 VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__nand2_2
X_2226_ _0905_ _0222_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__and2_1
X_2088_ _1054_ _1056_ _1057_ _1103_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__a31o_1
X_2157_ _0116_ _0119_ _0155_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__or3_1
XFILLER_0_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_10_Left_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1390_ _0528_ _0531_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__xor2_1
XFILLER_0_22_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2011_ net139 net136 VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1657_ _0819_ _0775_ _0777_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__nand3_1
X_1726_ _0832_ _0872_ _0887_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__a21o_1
X_1588_ _0680_ _0690_ _0752_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_0_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2209_ _0156_ _0193_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__and2_1
XFILLER_0_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1511_ _0633_ _0676_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__xnor2_1
X_1442_ _0501_ _0607_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1373_ _0537_ _0538_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__nor2_1
XFILLER_0_41_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1709_ _0869_ _0871_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__or2_1
XFILLER_0_36_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1991_ _1147_ _1148_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__nand2_1
XFILLER_0_42_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2474_ clknet_3_1__leaf_clk _0050_ net110 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_2_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1425_ _0510_ _0520_ _0590_ VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__a21o_1
X_1356_ _0492_ _0521_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__xnor2_2
X_1287_ _0428_ _0452_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_49_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2190_ _0147_ _0173_ _0187_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__and3_1
XFILLER_0_7_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1974_ _1127_ _1130_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__nand2_1
XFILLER_0_55_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2457_ clknet_3_3__leaf_clk _0033_ net109 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__dfrtp_1
X_2388_ _0354_ _0128_ _0135_ _0160_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__o22a_1
Xhold39 net91 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__dlygate4sd3_1
X_1408_ _0569_ _0570_ _0573_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__nor3_2
X_1339_ _0497_ _0504_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_46_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1690_ net145 _0796_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2242_ _0168_ _0204_ _0239_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__a21bo_1
X_2311_ net136 _0294_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__xnor2_1
X_2173_ net149 net146 _0154_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__and3_1
XFILLER_0_43_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1957_ _1065_ _1068_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__or2b_1
X_1888_ _1046_ _1047_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__and2_1
XFILLER_0_11_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1811_ _0904_ _0907_ _0971_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_4_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1673_ net114 net118 _0791_ _0790_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__a31o_1
X_1742_ _0902_ _0903_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__and2_1
X_2225_ _0905_ _0222_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2087_ _0088_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__clkbuf_1
X_2156_ _0116_ _0119_ _0155_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__o21ai_2
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2010_ _0598_ _0746_ _0800_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__a21oi_1
X_1725_ _0869_ _0871_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__and2_1
X_1656_ _0775_ _0777_ _0819_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__a21o_1
X_1587_ _0687_ _0689_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__nand2_1
X_2208_ _0206_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__clkbuf_1
X_2139_ _0797_ _0968_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_48_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1510_ net116 net121 VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__xor2_1
XFILLER_0_10_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1441_ net120 net127 VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1372_ _0432_ _0437_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__xor2_2
XFILLER_0_45_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1708_ net130 net132 _0814_ _0870_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_5_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1639_ _0792_ _0802_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_51_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1990_ net19 _1058_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__nand2_1
XFILLER_0_42_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2473_ clknet_3_3__leaf_clk _0049_ net110 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dfrtp_1
X_1424_ _0495_ _0509_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__and2_1
X_1355_ _0510_ _0520_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__xor2_2
X_1286_ _0450_ _0451_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__and2_1
XFILLER_0_33_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1973_ _1127_ _1130_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__or2_1
X_2387_ _0367_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__clkbuf_1
X_2456_ clknet_3_1__leaf_clk _0032_ net110 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__dfrtp_1
X_1338_ _0500_ _0503_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__xor2_1
X_1407_ _0551_ _0553_ _0571_ _0572_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__a211o_1
XFILLER_0_38_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1269_ net154 net131 VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2241_ _0197_ _0198_ _0201_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__or3b_1
X_2310_ _0297_ _0299_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__or2_1
X_2172_ _0153_ _0151_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__and2b_1
X_1887_ _1045_ _1043_ _1044_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__or3_4
XFILLER_0_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1956_ _1066_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__inv_2
X_2439_ clknet_3_2__leaf_clk _0015_ net108 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_19_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1741_ net146 net134 VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__or2_1
X_1810_ net144 net141 _0970_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1672_ _0444_ _0530_ _0462_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__a21o_1
X_2155_ _0796_ _0154_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__xnor2_1
X_2224_ _0220_ _0221_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__xnor2_1
X_2086_ net218 _0087_ net104 VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1939_ net120 net118 _1038_ _1097_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__a31o_2
XPHY_EDGE_ROW_48_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_57_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1724_ _0775_ _0777_ _0885_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__a21o_1
X_1655_ _0818_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__inv_2
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1586_ _0740_ _0750_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__xnor2_2
X_2207_ net64 _0205_ net102 VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__mux2_1
X_2069_ _0684_ _0070_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2138_ _0745_ _0907_ _0971_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_8_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1371_ net133 _0525_ _0535_ _0536_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__a31o_1
X_1440_ net173 _0501_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__nor2_1
Xclkbuf_3_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_45_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1707_ _0811_ _0813_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__and2b_1
X_1638_ _0799_ _0801_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__xor2_2
X_1569_ _0732_ _0733_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__and2b_1
XFILLER_0_51_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2472_ clknet_3_3__leaf_clk _0048_ net113 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_2_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1423_ _0485_ net168 _0588_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__a21o_1
X_1354_ _0518_ _0519_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__and2_1
X_1285_ net133 net130 VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__or2_1
XFILLER_0_18_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1972_ _1128_ _1129_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__xnor2_1
X_2455_ clknet_3_3__leaf_clk _0031_ net110 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2386_ net82 _0366_ net101 VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1337_ _0501_ _0502_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__and2_1
X_1406_ _0551_ _0553_ _0557_ _0549_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__a2bb2o_1
X_1268_ _0433_ net131 net154 VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_52_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_27_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2240_ _0235_ _0237_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__and2_1
X_2171_ _0074_ _0126_ _0122_ _0124_ _0169_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__a311o_4
XFILLER_0_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1886_ _1043_ _1044_ _1045_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_28_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1955_ _1064_ _1091_ _1112_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__a21o_1
X_2438_ clknet_3_2__leaf_clk _0014_ net108 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__dfrtp_1
X_2369_ _0084_ _0351_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1740_ net146 net134 VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__nand2_1
X_1671_ _0782_ _0833_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__or2_2
XFILLER_0_0_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2085_ _0084_ _0086_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__xnor2_1
X_2154_ _0151_ _0153_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__xnor2_1
X_2223_ _0185_ _0186_ _0183_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__a21oi_1
X_1938_ _1035_ _1037_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__nor2_1
X_1869_ _1026_ _1028_ VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_39_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1723_ _0818_ _0872_ _0873_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__nand3_1
X_1654_ _0815_ _0817_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__xor2_1
X_2206_ _0168_ _0204_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__xor2_1
XFILLER_0_28_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1585_ _0747_ _0749_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__xor2_2
X_2068_ _0067_ _0069_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__xnor2_1
X_2137_ _0970_ _1207_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Left_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1370_ _0533_ _0534_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__and2b_1
XFILLER_0_30_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1706_ _0422_ _0868_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__xor2_1
XFILLER_0_5_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1637_ _0743_ _0746_ _0800_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__a21o_1
X_1499_ _0655_ net176 VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__and2b_1
X_1568_ _0730_ _0678_ _0731_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__or3_1
XFILLER_0_51_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2471_ clknet_3_6__leaf_clk _0047_ net113 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dfrtp_1
X_1422_ _0492_ _0521_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__and2b_1
XFILLER_0_2_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1353_ _0472_ _0511_ _0517_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__or3_1
X_1284_ net133 net130 VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1971_ _0598_ _0746_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__xnor2_1
X_2454_ clknet_3_3__leaf_clk _0030_ net110 VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__dfrtp_1
X_2385_ _0161_ _0365_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1405_ _0549_ _0557_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__nor2_1
Xinput1 alpha[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_1
X_1336_ net223 net120 VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__or2_1
X_1267_ net118 VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__inv_2
XFILLER_0_14_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_2_Left_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2170_ _0158_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__inv_2
XFILLER_0_7_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1954_ _1090_ _1089_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__and2b_1
X_1885_ net17 _0942_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__xor2_1
XFILLER_0_51_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2437_ clknet_3_1__leaf_clk _0013_ net110 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__dfrtp_1
X_2368_ _0085_ _0347_ _0350_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2299_ net8 net9 _0232_ _0293_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__o31a_1
XFILLER_0_2_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1319_ _0480_ _0481_ _0484_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__o21a_1
XFILLER_0_34_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1670_ _0779_ _0784_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__and2b_1
X_2222_ _0218_ _0219_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__xnor2_1
X_2084_ _0085_ _1192_ _1188_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__o21a_1
XFILLER_0_48_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2153_ _0111_ _0112_ _0152_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__o21ba_1
X_1937_ _1094_ _1095_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__nor2_2
XFILLER_0_16_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1868_ _0961_ _0973_ _1027_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__a21oi_2
X_1799_ net150 _0959_ _0902_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__mux2_1
XFILLER_0_22_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1722_ _0877_ _0875_ _0876_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__nand3_2
X_1653_ net30 net132 _0761_ _0816_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1584_ _0683_ _0686_ _0748_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__a21o_1
X_2205_ _0202_ _0203_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__nand2_2
XFILLER_0_48_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2067_ _1173_ _1175_ _0068_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__o21a_1
X_2136_ _0110_ _0108_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__and2b_1
XFILLER_0_56_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_31_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1705_ _0865_ _0867_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__xor2_2
XFILLER_0_14_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1567_ _0730_ _0678_ _0731_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__o21a_1
X_1636_ net147 _0744_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__nor2_1
X_2119_ net149 net223 _0118_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__a21oi_1
X_1498_ _0620_ _0663_ net175 VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__a21o_1
XFILLER_0_36_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2470_ clknet_3_6__leaf_clk _0046_ net113 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dfrtp_1
X_1421_ _0546_ _0584_ _0586_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__or3_4
X_1352_ _0472_ net187 _0517_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__o21ai_2
X_1283_ net185 net182 VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_41_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1619_ _0780_ _0738_ _0781_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__nor3_1
XFILLER_0_49_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1970_ _1014_ _1081_ _1082_ _1074_ net146 VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__o32a_1
XFILLER_0_23_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2453_ clknet_3_3__leaf_clk _0029_ net110 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dfrtp_1
X_2384_ _0354_ _0128_ _0363_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__o21ai_1
X_1335_ net223 net120 VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__nand2_1
X_1404_ net154 net125 _0561_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__a21oi_1
Xinput2 alpha[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_36_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1266_ _0424_ _0431_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_6_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1884_ _1042_ _0999_ _1000_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__and3_1
X_1953_ _1062_ _1092_ VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__and2b_1
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2436_ clknet_3_3__leaf_clk _0012_ net110 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__dfrtp_1
X_2298_ net10 VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__inv_2
X_2367_ _1186_ _1187_ _1156_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__a21bo_1
X_1318_ _0482_ _0483_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__and2_2
X_1249_ _0416_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_19_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2152_ _0113_ _0114_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__and2b_1
X_2221_ net137 net136 _0175_ _0177_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__a31oi_2
X_2083_ _1188_ _1189_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__nand2_2
XFILLER_0_48_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1936_ net116 net36 _1093_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__a21oi_1
X_1867_ _0972_ _0969_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__and2b_1
XFILLER_0_3_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1798_ net150 net146 VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__xor2_1
X_2419_ _0383_ _0389_ _0286_ _0300_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__o211a_1
XFILLER_0_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_44_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1721_ _0828_ net200 _0880_ _0883_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__a22o_1
X_1652_ _0758_ _0760_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__nor2_1
X_1583_ net149 _0684_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_53_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2135_ net5 _0097_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__xnor2_4
X_2204_ _0201_ _0197_ _0198_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__or3_4
XFILLER_0_28_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2066_ _1176_ _1177_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__or2b_1
XFILLER_0_8_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1919_ net135 _0965_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1704_ _0778_ _0810_ _0866_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_30_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1497_ _0658_ _0659_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__nand2_1
X_1635_ _0795_ _0798_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__xor2_2
X_1566_ _0427_ _0550_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__xor2_1
X_2118_ net149 net223 _0118_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__and3_1
X_2049_ _1203_ _1204_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1420_ _0585_ _0566_ _0567_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__nand3b_1
X_1351_ _0512_ _0516_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__and2b_1
XFILLER_0_25_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1282_ _0444_ _0447_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__xor2_2
XFILLER_0_41_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1618_ _0780_ _0738_ _0781_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__o21a_1
X_1549_ _0714_ _0657_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2452_ clknet_3_7__leaf_clk _0028_ net111 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dfrtp_1
X_2383_ _0828_ net194 _0364_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__a21o_1
X_1334_ _0498_ _0499_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__xnor2_2
X_1403_ net154 net125 _0561_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__and3_1
X_1265_ _0427_ _0430_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 alpha[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_1
XFILLER_0_36_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1883_ _0999_ _1000_ _1042_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__a21oi_1
X_1952_ _1096_ _1098_ _1109_ VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_28_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2435_ clknet_3_2__leaf_clk _0011_ net108 VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_3_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2366_ _0349_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__clkbuf_1
X_1248_ net207 net9 net101 VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__mux2_1
X_2297_ _0282_ _0283_ _0284_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__or3b_1
X_1317_ net133 net20 VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__or2_1
XFILLER_0_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2082_ _0082_ _0083_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__nand2_2
X_2151_ _0149_ _0150_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__xnor2_1
X_2220_ _0216_ _0217_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__nand2_1
XFILLER_0_17_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1935_ net116 net36 _1093_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__and3_1
XFILLER_0_31_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1797_ net148 net152 VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__nand2_1
X_1866_ _1018_ _1025_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__xnor2_2
X_2418_ _0296_ _0299_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__and2_1
X_2349_ _1048_ _0335_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1720_ _0881_ _0882_ net106 VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__o21a_1
X_1651_ _0529_ _0814_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__xnor2_1
X_1582_ _0743_ _0746_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__xor2_2
X_2134_ _0099_ _0128_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__and2_1
X_2203_ _0197_ _0198_ _0201_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__o21ai_2
X_2065_ _0064_ _0066_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_28_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1918_ net138 _1070_ _1076_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__a21o_1
X_1849_ _1007_ _1008_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_35_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1703_ _0809_ _0807_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__and2b_1
XFILLER_0_30_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1634_ _0796_ _0797_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__xnor2_4
X_1496_ _0568_ _0587_ _0657_ _0660_ _0661_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__a2111o_1
X_1565_ net121 _0633_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_18_Left_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2117_ _0116_ _0117_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__nor2_1
X_2048_ _1076_ _1201_ _1202_ VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__nor3_1
XFILLER_0_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1350_ _0482_ _0515_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__nand2_1
X_1281_ _0446_ _0445_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__and2_4
XFILLER_0_1_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1617_ net186 _0530_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__xor2_1
X_1548_ _0663_ _0568_ _0587_ _0660_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__a31o_1
X_1479_ net154 _0551_ _0554_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__a21o_1
XFILLER_0_32_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2451_ clknet_3_6__leaf_clk _0027_ net113 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dfrtp_1
X_1402_ _0490_ _0546_ _0566_ _0567_ net165 VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__o32a_1
XFILLER_0_23_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput4 alpha[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_1
X_2382_ _0362_ _0363_ net104 VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__and3b_1
X_1333_ net114 net163 VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__xor2_2
X_1264_ _0429_ _0428_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__and2_4
XFILLER_0_52_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1882_ _1040_ _1041_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__nand2_1
X_1951_ _1096_ _1098_ _1040_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_3_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2434_ clknet_3_3__leaf_clk _0010_ net110 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__dfrtp_1
X_2365_ net97 _0348_ net104 VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__mux2_1
X_1247_ _0415_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__clkbuf_1
X_2296_ net103 _0288_ _0289_ _0290_ _0291_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__a41o_1
X_1316_ net133 net20 VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__nand2_2
XFILLER_0_2_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap99 net221 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_6_Left_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2081_ _0081_ _0077_ _0078_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__or3_1
X_2150_ _0103_ _0104_ _0106_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_33_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1934_ _1062_ _1092_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__xnor2_1
Xinput40 start VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_24_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1796_ _0951_ _0956_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_3_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1865_ _1021_ _1024_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__xnor2_2
X_2417_ net101 _0391_ _0392_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__a21oi_1
X_2348_ _0330_ _0334_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__and2b_1
X_2279_ net142 net139 _0261_ _0259_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__a31o_1
X_1650_ _0811_ _0813_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__xnor2_2
X_1581_ _0744_ _0745_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__xnor2_4
X_2202_ _0199_ _0200_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2133_ _0133_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2064_ _1169_ _1170_ _0065_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__o21a_1
XFILLER_0_48_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1917_ net137 net136 VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__and2b_1
X_1779_ _0929_ _0930_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__and2_1
XFILLER_0_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1848_ net225 _0632_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1564_ _0513_ _0514_ _0421_ _0423_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__a31o_1
X_1633_ net144 net146 VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__xor2_4
XFILLER_0_5_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1702_ _0834_ _0864_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_55_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1495_ _0658_ _0659_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__and2_1
X_2116_ _0101_ _0102_ _0115_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__nor3_1
X_2047_ _1076_ _1201_ _1202_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__o21a_1
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_35_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1280_ net114 net126 VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__or2_4
XFILLER_0_25_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1547_ _0711_ _0706_ _0707_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__and3_1
XFILLER_0_41_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1616_ net169 _0681_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__nor2_1
XFILLER_0_49_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1478_ _0627_ _0643_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_20_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2450_ clknet_3_6__leaf_clk _0026_ net113 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dfrtp_1
X_2381_ _0357_ _0361_ _0355_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__a21o_1
X_1401_ _0543_ net157 VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput5 alpha[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__buf_2
XFILLER_0_36_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1332_ net163 net119 VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__nand2_1
X_1263_ net116 net129 VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__or2_1
XFILLER_0_52_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1950_ _0999_ _1000_ _1107_ VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1881_ _1001_ _1002_ _1039_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__or3_1
X_2433_ clknet_3_6__leaf_clk _0009_ net113 VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__dfrtp_1
X_2364_ _1190_ _0347_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__xnor2_1
X_1315_ net154 net131 _0453_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_22_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1246_ net219 net8 net101 VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__mux2_1
X_2295_ _0721_ net67 VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__and2_1
XFILLER_0_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2080_ _0077_ _0078_ _0081_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_33_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1933_ _1064_ _1091_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__xor2_2
XFILLER_0_24_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1795_ _0954_ _0955_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput30 beta[1] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__buf_2
X_1864_ net141 _1022_ _1023_ VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__a21o_1
X_2416_ net101 net190 VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__nor2_1
X_2347_ _0989_ _0990_ _0944_ VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__a21bo_1
X_2278_ _0251_ _0268_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__nor2_1
XFILLER_0_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1229_ _0406_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_15_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1580_ net148 net147 VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__xor2_4
XFILLER_0_21_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2132_ net62 _0132_ net104 VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__mux2_1
X_2201_ net5 _0097_ net6 VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2063_ _1167_ _1171_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__or2b_1
XFILLER_0_21_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1847_ net148 net152 _0960_ _1006_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__a31o_1
X_1916_ net141 net135 VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__or2_1
X_1778_ _0828_ net201 _0938_ _0939_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__a22o_1
XFILLER_0_8_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_40_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1701_ _0860_ _0863_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__xor2_2
X_1632_ net149 net147 VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__nand2_4
X_1494_ _0658_ _0659_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__nor2_1
XFILLER_0_30_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1563_ _0668_ _0672_ _0671_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__a21bo_1
X_2115_ _0101_ _0102_ _0115_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__o21a_1
X_2046_ _0967_ _1070_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__xor2_1
XFILLER_0_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1546_ _0706_ _0707_ _0711_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__a21oi_2
X_1477_ _0637_ _0642_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1615_ _0427_ _0550_ _0440_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__a21oi_2
X_2029_ _1142_ _1145_ _1185_ VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__a21o_1
XFILLER_0_32_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2380_ _0355_ _0357_ _0361_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__and3_1
X_1331_ _0466_ _0469_ _0496_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__a21o_1
X_1400_ _0564_ _0565_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__or2_1
Xinput6 alpha[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_1
X_1262_ net116 net129 VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__nand2_2
XFILLER_0_54_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1529_ _0675_ _0694_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__xnor2_2
Xclkbuf_3_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_52_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1880_ _1001_ _1002_ _1039_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_43_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2432_ clknet_3_7__leaf_clk _0008_ net111 VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__dfrtp_1
X_2363_ _1151_ _0344_ _1150_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__a21bo_1
X_2294_ _0243_ _0248_ _0285_ _0286_ _0269_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__a221o_1
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1314_ net133 _0428_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__nor2_1
X_1245_ _0414_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput20 beta[0] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__clkbuf_2
Xinput31 beta[2] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_1
X_1932_ _1089_ _1090_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__xnor2_2
X_1863_ _1022_ _0906_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__nor2_1
X_2415_ _0300_ _0390_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__xnor2_1
X_1794_ _0952_ _0899_ _0953_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__or3_1
X_1228_ net57 net17 net105 VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__mux2_1
X_2346_ _0333_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__clkbuf_1
X_2277_ net103 _0272_ _0273_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2200_ net5 net6 _0097_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__or3_1
X_2131_ _0130_ _0131_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__nor2_1
X_2062_ _0061_ _0063_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__xor2_1
XFILLER_0_29_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1777_ _0884_ _0880_ _0937_ _0721_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__a31oi_1
XFILLER_0_8_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1846_ net150 _0902_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__nor2_1
X_1915_ net141 net135 VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__nand2_2
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2329_ _0721_ _0317_ _0318_ _0319_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_35_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1631_ _0793_ _0794_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__and2_1
X_1700_ _0785_ _0861_ _0862_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__a21o_1
X_1562_ net30 net20 _0703_ _0726_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__a31o_1
X_1493_ net164 _0458_ _0488_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__nor3b_1
X_2114_ _0113_ _0114_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__xnor2_1
X_2045_ _1071_ _1163_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1829_ _0945_ _0929_ _0988_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__nand3_2
XFILLER_0_4_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1614_ _0729_ _0733_ _0732_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__a21o_1
XFILLER_0_26_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1545_ _0710_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__inv_2
X_1476_ _0640_ _0641_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2028_ _1183_ _1184_ VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1330_ net117 _0464_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__nor2_1
X_1261_ _0425_ _0426_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__xnor2_4
Xinput7 alpha[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_1
X_1528_ _0691_ _0693_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__xnor2_2
X_1459_ _0596_ _0603_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__or2_1
XFILLER_0_20_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2431_ clknet_3_6__leaf_clk _0007_ net113 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_3_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1244_ net47 net7 net101 VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__mux2_1
X_2362_ _0346_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__clkbuf_1
X_2293_ _0285_ _0286_ _0274_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__a21bo_1
X_1313_ _0461_ _0478_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__xor2_2
XFILLER_0_2_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput10 alpha[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_1
XFILLER_0_24_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1793_ _0952_ _0899_ _0953_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput21 beta[10] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_1
X_1931_ _1010_ _1011_ _1029_ _1028_ _1026_ VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__o32a_1
Xinput32 beta[3] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__clkbuf_1
X_1862_ net138 VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__inv_2
X_2414_ _0383_ _0389_ _0286_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__o21a_1
XFILLER_0_24_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1227_ _0405_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__clkbuf_1
X_2345_ net93 _0332_ net107 VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__mux2_1
X_2276_ net103 net192 VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__nor2_1
XFILLER_0_15_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2130_ _0096_ _0129_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__nor2_1
X_2061_ _1166_ _1172_ _0062_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_44_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1914_ _1070_ _1071_ _1072_ VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__a21oi_2
X_1776_ _0884_ _0880_ _0937_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__a21o_1
XFILLER_0_8_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1845_ net183 _0599_ _0628_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__a21o_1
X_2328_ _0828_ net191 VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2259_ _0213_ _0254_ _0255_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_7_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1630_ net150 net140 VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__or2_1
XFILLER_0_39_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1561_ _0700_ _0702_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__nor2_1
X_1492_ _0589_ _0619_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__xor2_1
X_2044_ _0630_ _1181_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__nor2_1
X_2113_ _1206_ _0058_ _1211_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_29_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1828_ _0945_ _0929_ _0988_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__a21o_1
X_1759_ _0891_ _0920_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_35_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1544_ _0708_ _0709_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__and2_1
XFILLER_0_41_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1613_ _0727_ _0762_ _0776_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_1_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1475_ net121 net128 _0639_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__a21oi_1
X_2027_ _1157_ _1158_ _1182_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__o21a_1
XFILLER_0_32_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_39_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput8 alpha[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_1
XFILLER_0_36_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1260_ net120 net123 VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__xor2_4
XFILLER_0_52_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1527_ _0637_ _0640_ _0641_ _0692_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__o31a_1
XFILLER_0_10_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1458_ _0612_ _0616_ _0623_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__o21a_1
X_1389_ _0551_ _0553_ _0554_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__a21o_1
XFILLER_0_37_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2430_ clknet_3_7__leaf_clk _0006_ net111 VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__dfrtp_1
X_2361_ net96 _0345_ net107 VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__mux2_1
X_1243_ _0413_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
X_2292_ _0274_ _0287_ _0271_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__or3b_1
XFILLER_0_37_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1312_ _0471_ _0477_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_42_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1930_ _1069_ _1088_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__xnor2_2
Xinput11 alpha[1] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_26_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput22 beta[11] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__clkbuf_1
X_1792_ net183 _0599_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__xor2_1
Xinput33 beta[4] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__buf_6
X_1861_ _0964_ _0968_ _1020_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__a21oi_2
X_2344_ _0330_ _0331_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__nor2_1
X_2413_ _0385_ _0268_ _0285_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__a21bo_1
X_1226_ net211 net16 net107 VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__mux2_1
X_2275_ _0270_ _0271_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__or2b_1
XFILLER_0_30_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2060_ _1165_ _1164_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__or2b_1
XFILLER_0_56_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1913_ net139 _1071_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__nor2_2
X_1775_ _0935_ _0936_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__and2_1
X_1844_ _0954_ _1003_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2327_ _0823_ _0315_ _0316_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__and3_1
X_2258_ net140 _1159_ _0213_ _0254_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__o211ai_1
X_2189_ _0147_ _0173_ _0187_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_47_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1560_ _0665_ _0704_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1491_ _0620_ _0656_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__xnor2_1
X_2112_ _0111_ _0112_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__xnor2_1
X_2043_ _1178_ _1180_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1827_ _0947_ _0987_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_32_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1689_ _0848_ _0851_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__xor2_2
X_1758_ _0916_ _0919_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_20_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_13_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1543_ net11 net1 VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__nand2_1
X_1612_ _0727_ _0762_ _0665_ _0704_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__o211a_1
X_1474_ net121 net128 _0639_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__and3_1
XFILLER_0_5_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2026_ _1157_ _1158_ _1182_ VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__nor3_1
XFILLER_0_9_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput9 alpha[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_1
XFILLER_0_52_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1457_ _0594_ _0611_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__nand2_1
X_1526_ _0629_ _0636_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__nand2_1
X_1388_ net129 _0513_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__nor2_1
XFILLER_0_45_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2009_ _1164_ _1165_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_51_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2360_ _1152_ _0344_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_51_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2291_ _0285_ _0286_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_47_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1311_ _0450_ net166 VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_11_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1242_ net213 net6 net102 VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_56_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1509_ _0673_ _0674_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__or2_1
XFILLER_0_33_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1860_ net137 _1019_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_1_Left_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput12 alpha[2] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__clkbuf_2
X_1791_ net152 _0846_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__nor2_1
Xinput23 beta[12] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_1
Xinput34 beta[5] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
X_2412_ _0388_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__clkbuf_1
X_2343_ _0936_ _0326_ _0993_ _0329_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__a211oi_1
X_2274_ _0243_ _0248_ _0269_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__a21o_1
X_1225_ _0404_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__clkbuf_1
X_1989_ net19 _1058_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__or2_2
XFILLER_0_47_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1912_ net137 net135 VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__nand2_4
X_1843_ _0951_ _0956_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__or2b_1
X_1774_ _0934_ _0929_ _0930_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__nand3_2
X_2326_ _0315_ _0316_ _0823_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__a21oi_1
X_2257_ net138 _1074_ _1070_ _1071_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__a22o_1
X_2188_ _0185_ _0186_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__xnor2_1
Xclone15 net36 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1490_ _0652_ _0655_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__xor2_1
X_2042_ _0999_ _1000_ _1107_ _1195_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__a211o_1
X_2111_ _1205_ _0060_ _1203_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1826_ _0442_ _0986_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_52_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1757_ _0841_ _0917_ _0918_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__a21oi_2
X_1688_ _0849_ _0850_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__xnor2_4
X_2309_ _0828_ net196 _0303_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1611_ _0662_ _0664_ _0705_ _0763_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__a211o_4
XPHY_EDGE_ROW_30_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1542_ net11 net1 VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__or2_2
X_1473_ _0600_ _0638_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2025_ _0630_ _1181_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__xor2_1
XFILLER_0_49_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1809_ net140 VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__inv_2
XFILLER_0_55_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1525_ _0680_ _0690_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__xnor2_2
X_1456_ _0613_ _0614_ _0621_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__o21ai_2
X_1387_ _0549_ _0552_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__nand2_1
X_2008_ _1120_ _1122_ _1072_ VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_45_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1241_ _0412_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2290_ _0284_ _0282_ _0283_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__or3_2
X_1310_ _0475_ _0472_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__and2b_1
XFILLER_0_2_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1508_ _0671_ _0672_ _0668_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__a21oi_1
X_1439_ net124 net129 VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput13 alpha[3] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_1
X_1790_ net159 net180 _0595_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__a21oi_2
X_2411_ net86 _0387_ net101 VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__mux2_1
Xinput24 beta[13] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_1
XFILLER_0_24_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput35 beta[6] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_1
X_1224_ net55 net15 net105 VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__mux2_1
X_2342_ _0325_ _0329_ _0323_ _0993_ _0936_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__o311a_2
X_2273_ _0243_ _0248_ _0269_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__and3_1
XFILLER_0_42_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1988_ _1144_ _1108_ _1110_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__nand3_2
XFILLER_0_15_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1773_ _0929_ _0930_ _0934_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__a21o_1
X_1911_ net139 net135 VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__xnor2_2
X_1842_ net120 net123 _0986_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__and3_1
X_2325_ _0764_ _0765_ _0766_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__a21bo_1
X_2187_ _0138_ _0141_ _0140_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__o21bai_1
X_2256_ _0208_ _0210_ _0209_ net134 VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_18_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2041_ _1142_ _1183_ _1195_ _1110_ _1196_ VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__o221a_1
X_2110_ _0108_ _0110_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__xor2_1
X_1756_ _0856_ _0858_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__nor2_1
X_1825_ _0983_ _0985_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__xor2_2
X_2308_ _0301_ _0720_ _0302_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__or3b_4
XFILLER_0_29_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1687_ net144 net141 VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__xor2_4
X_2239_ _0234_ _0236_ _0231_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__or3b_4
XFILLER_0_50_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1610_ _0772_ _0773_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__and2_2
XFILLER_0_41_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1541_ _0662_ _0664_ _0705_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__nand3_1
X_1472_ net119 net124 VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__xor2_1
XFILLER_0_49_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2024_ _1178_ _1180_ VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_31_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1739_ _0899_ _0900_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__nor2_1
X_1808_ _0964_ _0968_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__xor2_2
XFILLER_0_48_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1524_ _0687_ _0689_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__xor2_2
XFILLER_0_10_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1455_ net132 _0482_ _0615_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__or3_1
X_1386_ net154 net125 VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__or2b_1
XFILLER_0_37_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2007_ _1071_ _1163_ VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__xor2_1
XFILLER_0_45_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1240_ net45 net5 net101 VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1507_ _0668_ _0671_ _0672_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__and3_1
XFILLER_0_37_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1438_ _0596_ _0603_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__xnor2_1
X_1369_ _0533_ _0534_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__xnor2_1
Xinput14 alpha[4] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__clkbuf_2
Xinput36 beta[7] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_2
Xinput25 beta[14] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__buf_1
X_2410_ _0287_ _0386_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__xnor2_1
X_2341_ _0934_ _0940_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__nor2_1
X_1223_ _0403_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__clkbuf_1
X_2272_ _0251_ _0268_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1987_ _1108_ _1110_ _1144_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__a21o_2
XFILLER_0_2_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1910_ _1065_ _1068_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__xnor2_2
X_1772_ _0933_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__inv_2
XFILLER_0_44_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1841_ _0983_ _0985_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__nor2_1
X_2324_ _0767_ _0768_ _0312_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__a21o_1
X_2255_ _0220_ _0221_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__nor2_1
X_2186_ _0183_ _0184_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2040_ _1184_ VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__inv_2
XFILLER_0_44_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap100 net222 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__clkbuf_1
X_1686_ net144 net146 VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__nand2_4
X_1755_ _0856_ _0858_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__nand2_1
X_1824_ _0891_ _0920_ _0984_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__a21oi_2
X_2307_ _0289_ _0290_ _0292_ _0300_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__a31o_1
X_2238_ _0170_ _0207_ _0228_ _0194_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__a211oi_2
X_2169_ _0131_ _0161_ _0167_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__a21o_1
XFILLER_0_35_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1540_ _0662_ _0664_ _0705_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__a21o_1
XFILLER_0_34_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1471_ _0629_ _0636_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2023_ _1116_ _1138_ _1179_ VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_9_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1807_ _0965_ _0966_ _0967_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__a21bo_2
XFILLER_0_9_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_17_Left_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1669_ _0815_ _0817_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__nand2_1
X_1738_ net150 net114 _0898_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1454_ _0589_ _0619_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__nand2_1
X_1523_ _0632_ _0635_ _0688_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__a21o_1
X_1385_ _0513_ _0550_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__xnor2_4
X_2006_ _1161_ _1162_ VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xwire1 _0380_ VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1506_ _0669_ _0640_ _0670_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__or3_1
X_1437_ _0599_ _0602_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_43_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1299_ net117 net118 VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__xor2_4
X_1368_ _0419_ _0421_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_52_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput15 alpha[5] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__buf_1
Xinput26 beta[15] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput37 beta[8] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_1
X_2340_ _0328_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__clkbuf_1
X_2271_ _0266_ _0267_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__nand2_2
X_1222_ net54 net14 net105 VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1986_ _1142_ _1143_ VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2469_ clknet_3_6__leaf_clk _0045_ net113 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_28_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_5_Left_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_4__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_4__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_1840_ _0775_ _0777_ _0885_ _0997_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__a211o_4
X_1771_ _0931_ _0932_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__and2_1
X_2254_ _0249_ _0250_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__or2_1
X_2323_ net106 _0313_ _0314_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2185_ _1072_ _0144_ _0182_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__nor3_1
XFILLER_0_50_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1969_ net171 _0686_ _0748_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1823_ _0919_ _0916_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__and2b_1
XFILLER_0_4_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1754_ _0896_ _0915_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__xnor2_2
X_1685_ _0846_ _0847_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__and2_1
X_2237_ _0229_ _0231_ _0234_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__a21bo_1
X_2306_ _0289_ _0290_ _0292_ _0300_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__and4_1
X_2168_ _0163_ _0166_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__nand2_1
X_2099_ _0067_ _0069_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__nor2_1
XFILLER_0_35_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1470_ _0632_ _0635_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__xor2_1
XFILLER_0_1_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2022_ _1134_ _1137_ VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1806_ net142 net137 VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1668_ _0723_ _0717_ _0768_ _0830_ _0824_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__a311o_1
X_1599_ _0725_ _0706_ _0763_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__nand3_2
XFILLER_0_40_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1737_ net150 net114 _0898_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__and3_1
XFILLER_0_48_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_34_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1453_ _0518_ _0618_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__xnor2_1
X_1522_ net223 _0630_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__nor2_1
XFILLER_0_26_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2005_ net144 net140 _1160_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__a21o_1
X_1384_ net129 net131 VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__xor2_4
XFILLER_0_42_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xwire2 _0378_ VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1505_ _0669_ _0640_ _0670_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__o21ai_1
X_1436_ _0600_ _0601_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__and2_1
X_1367_ _0528_ _0531_ _0532_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_53_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1298_ net120 net118 VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__nand2_2
XFILLER_0_33_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput16 alpha[6] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__buf_1
Xinput27 beta[16] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput38 beta[9] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__buf_1
X_1221_ _0402_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__clkbuf_1
X_2270_ _0226_ _0236_ _0265_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__or3_1
XFILLER_0_59_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1985_ _1111_ _1094_ _1141_ VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__or3_1
XFILLER_0_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_21_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2468_ clknet_3_4__leaf_clk _0044_ net113 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dfrtp_1
X_2399_ _0235_ _0237_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1419_ _0543_ _0489_ _0564_ _0565_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__a2bb2o_4
XFILLER_0_28_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1770_ net14 _0772_ net15 VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__o21ai_1
X_2253_ net8 _0232_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__and2_1
X_2322_ net106 net189 VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2184_ _1072_ _0144_ _0182_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__o21a_1
XFILLER_0_18_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1899_ net17 net18 _0942_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__or3_1
XFILLER_0_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1968_ _1123_ _1125_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__xnor2_1
Xclone19 net127 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__buf_4
X_1822_ _0950_ _0982_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__xnor2_2
X_1753_ _0912_ _0914_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__xnor2_1
X_1684_ net148 net138 VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__or2_1
X_2236_ _0232_ _0233_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__and2_1
X_2167_ _0135_ _0160_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__or2b_1
XFILLER_0_45_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2305_ _0297_ _0299_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_29_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2098_ _0097_ _0098_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__and2_1
XFILLER_0_0_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2021_ _1176_ _1177_ VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__xor2_1
XFILLER_0_32_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1805_ net139 net137 net142 VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__o21ba_1
X_1736_ _0846_ _0897_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__xnor2_1
X_1667_ _0820_ _0821_ _0774_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_40_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1598_ _0727_ _0762_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2219_ _0109_ _0180_ _0215_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__nand3_1
XFILLER_0_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1452_ _0591_ _0617_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__xor2_1
X_1383_ net125 net154 VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__nand2b_1
X_1521_ _0683_ _0686_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__xor2_2
XFILLER_0_22_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2004_ net144 net140 _1160_ VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__nand3_1
XFILLER_0_42_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1719_ _0829_ _0831_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1504_ _0515_ _0421_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1435_ net149 net119 VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1366_ net173 _0529_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__nor2_1
X_1297_ _0444_ _0447_ _0462_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__a21o_1
XFILLER_0_33_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput39 rstb VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_2
Xinput17 alpha[7] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput28 beta[17] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__clkbuf_1
X_1220_ net53 net13 net105 VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__mux2_1
X_1984_ _1111_ _1094_ _1141_ VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__o21ai_2
X_2467_ clknet_3_4__leaf_clk _0043_ net111 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2398_ _0202_ _0375_ _0235_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__o21ai_1
X_1349_ _0513_ _0514_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1418_ _0577_ _0579_ _0582_ _0583_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__a31o_1
XFILLER_0_38_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout150 net223 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2321_ _0769_ _0312_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__xnor2_1
X_2252_ net8 _0232_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__nor2_1
X_2183_ _0180_ _0181_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__and2_1
XFILLER_0_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1898_ _1043_ _1044_ _1045_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__or3b_2
X_1967_ _1080_ _1084_ _1124_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_38_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1821_ _0978_ _0981_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__xnor2_2
X_1752_ _0845_ _0855_ _0913_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_4_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1683_ net148 net138 VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__nand2_1
X_2304_ _0275_ _0280_ _0282_ _0298_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__a211oi_2
X_2097_ net4 _0079_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__nand2_1
X_2235_ net7 _0199_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__nand2_1
X_2166_ net104 _0162_ _0163_ _0164_ _0165_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__a41o_1
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2020_ _1128_ _1129_ _1131_ VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_31_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1666_ _0774_ _0822_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__nand2_1
XFILLER_0_40_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1735_ net148 net152 VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__xor2_1
X_1804_ net139 net137 VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1597_ _0513_ _0761_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__xnor2_2
X_2149_ _0147_ _0148_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__and2_1
X_2218_ _0109_ _0180_ _0215_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1520_ _0684_ _0685_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__xnor2_4
X_1451_ _0612_ _0616_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__xor2_1
X_1382_ _0524_ _0547_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__xnor2_1
X_2003_ _1022_ _1075_ _1159_ net141 VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_45_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1718_ _0879_ _0878_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__nor2_1
X_1649_ _0728_ _0757_ _0812_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__a21o_1
XFILLER_0_36_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1503_ net124 _0600_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1434_ net149 net119 VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__nand2_1
X_1296_ net118 _0442_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__nor2_1
X_1365_ _0529_ _0530_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_41_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput18 alpha[8] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__buf_1
XFILLER_0_24_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput29 beta[18] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1983_ _0597_ _1140_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2466_ clknet_3_5__leaf_clk _0042_ net112 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dfrtp_1
X_1417_ _0574_ _0581_ _0580_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__a21oi_1
X_2397_ _0234_ _0229_ _0231_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__and3b_1
X_1348_ net30 net132 VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__or2_1
X_1279_ net114 net173 VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__nand2_1
Xfanout140 net27 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__buf_4
Xfanout151 net22 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_56_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2251_ _0096_ _0244_ _0245_ _0246_ _0247_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__o311a_4
X_2320_ _0713_ _0309_ _0712_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__o21ba_1
X_2182_ _1071_ _0179_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1966_ _1073_ _1079_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__nand2_1
XFILLER_0_55_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1897_ _1055_ _1049_ _0941_ _1048_ _0992_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__a311o_1
X_2449_ clknet_3_4__leaf_clk _0025_ net113 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_9_Left_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1820_ _0896_ _0979_ _0980_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__a21oi_2
X_1682_ _0787_ _0844_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__xnor2_2
X_1751_ _0852_ _0854_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2234_ net7 _0199_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__or2_1
X_2303_ net139 _0277_ net137 VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__o21a_1
X_2096_ net4 _0079_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__or2_2
X_2165_ _0721_ net63 VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__and2_1
X_1949_ _1042_ _1099_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_59_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1803_ _0962_ _0963_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__and2_2
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1665_ _0721_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__clkbuf_4
X_1596_ _0758_ _0760_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__xor2_2
XFILLER_0_25_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1734_ _0892_ _0895_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2217_ _0213_ _0214_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__nand2_1
X_2079_ _0079_ _0080_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__and2_1
X_2148_ _0136_ _0146_ _0137_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__or3_1
XFILLER_0_8_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1450_ _0512_ _0615_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__xor2_1
XFILLER_0_10_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1381_ _0537_ _0538_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__xor2_1
X_2002_ net134 net137 VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__or2b_1
XFILLER_0_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1717_ _0829_ _0831_ _0878_ _0879_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__a211o_1
X_1648_ _0756_ _0755_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__and2b_1
XFILLER_0_13_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1579_ net148 net150 VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__nand2_2
Xrebuffer30 _0531_ VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__dlygate4sd2_1
XFILLER_0_51_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_38_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1433_ _0597_ _0598_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_2_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1502_ _0484_ net184 _0532_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__a21o_1
X_1364_ net126 net129 VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__xor2_2
X_1295_ _0459_ _0454_ _0460_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_53_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput19 alpha[9] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__buf_1
X_1982_ _1113_ _1139_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2396_ _0374_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__clkbuf_1
X_2465_ clknet_3_4__leaf_clk _0041_ net112 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dfrtp_1
X_1347_ net30 net132 VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__nand2_4
XFILLER_0_2_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1416_ _0574_ _0580_ _0581_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__nand3_1
X_1278_ _0442_ _0443_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__xnor2_4
Xfanout152 net153 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__clkbuf_8
Xfanout130 net32 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__buf_4
Xfanout141 net142 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_37_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2250_ _0235_ _0237_ _0239_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__a21o_1
XFILLER_0_20_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2181_ _1071_ _0179_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_25_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1965_ _1120_ _1122_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__xnor2_1
X_1896_ _0935_ _0936_ _0884_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__a21o_1
X_2448_ clknet_3_5__leaf_clk _0024_ net111 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dfrtp_1
X_2379_ _0082_ _0350_ _0359_ _0360_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__a31o_1
XFILLER_0_34_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1750_ _0901_ _0911_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1681_ _0793_ _0842_ _0843_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__a21oi_2
X_2164_ _0131_ _0161_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__nand2_1
X_2302_ _0296_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__inv_2
X_2233_ _0170_ _0196_ _0228_ _0230_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__o211ai_2
XFILLER_0_29_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2095_ _0089_ _0090_ _0092_ _0095_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__o211a_1
XFILLER_0_45_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1948_ _1060_ _1102_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1879_ _0464_ _1038_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1733_ _0893_ _0894_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__xnor2_2
X_1802_ net144 net134 VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__or2_1
X_1664_ _0827_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
X_1595_ _0667_ _0699_ _0759_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_25_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2147_ _0136_ _0137_ _0146_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__o21ai_1
X_2216_ net134 _0212_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__or2_1
X_2078_ net2 _1147_ net3 VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_31_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_12_Left_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1380_ _0523_ _0545_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_22_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2001_ net115 net116 _1140_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__and3_1
XFILLER_0_53_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1716_ _0877_ _0875_ _0876_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__and3_1
XFILLER_0_5_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1647_ _0778_ _0810_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_6_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1578_ _0741_ _0742_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__and2_1
Xrebuffer20 _0504_ VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__clkbuf_1
Xrebuffer31 _0441_ VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_51_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2481_ clknet_3_0__leaf_clk _0057_ net109 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dfrtp_1
X_1363_ net130 net132 VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__nand2_2
X_1432_ net152 net115 VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__xor2_4
XFILLER_0_10_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1501_ _0646_ _0647_ _0666_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__a21bo_1
X_1294_ net158 _0448_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1981_ _1116_ _1138_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2395_ net84 _0373_ net102 VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__mux2_1
X_2464_ clknet_3_5__leaf_clk _0040_ net112 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dfrtp_1
X_1346_ net131 _0482_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__nor2_1
X_1415_ net128 _0516_ _0512_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1277_ net120 net118 VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__xor2_4
Xfanout131 net31 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__buf_4
Xfanout120 net122 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__buf_12
Xfanout142 net143 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__clkbuf_2
Xfanout153 net21 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__buf_2
XFILLER_0_37_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2180_ _0177_ _0178_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_0_Left_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1895_ _0880_ _0991_ _0992_ _1053_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__or4_4
XFILLER_0_28_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1964_ _1022_ _1121_ VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__or2_1
X_2447_ clknet_3_5__leaf_clk _0023_ net112 VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dfrtp_1
X_2378_ _0081_ _0091_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__and2b_1
X_1329_ _0493_ _0477_ _0494_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_6_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2301_ _0294_ _0295_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__or2b_1
X_1680_ net114 _0793_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__nor2_1
XFILLER_0_45_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2163_ _0134_ _0161_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__nand2_1
X_2232_ _0194_ _0207_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__or2_1
X_2094_ _0093_ _1191_ _0094_ _0084_ _1189_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__o311ai_1
XFILLER_0_0_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1947_ _1104_ _1105_ net198 _0828_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_43_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1878_ _1035_ _1037_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__xor2_1
XFILLER_0_19_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1663_ net208 _0826_ net106 VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__mux2_1
XFILLER_0_31_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1732_ net159 net179 VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_13_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1801_ net144 net134 VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__nand2_2
XFILLER_0_40_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1594_ _0695_ _0698_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2077_ net2 net3 _1147_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__or3_1
X_2146_ _0144_ _0145_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__nor2_1
X_2215_ net134 _0212_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2000_ _1139_ _1113_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__and2b_1
XFILLER_0_26_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1715_ _0875_ _0876_ _0877_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__a21oi_1
X_1646_ _0807_ _0809_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__xnor2_2
X_1577_ net153 net143 VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__or2_1
X_2129_ _0096_ _0129_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__and2_1
Xrebuffer21 _0656_ VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__clkbuf_1
Xrebuffer10 _0523_ VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__clkbuf_1
Xrebuffer32 _0444_ VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2480_ clknet_3_2__leaf_clk _0056_ net108 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_50_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1500_ _0648_ _0645_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__or2b_1
Xoutput90 net90 VGND VGND VPWR VPWR c[2] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1431_ net115 net116 VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__nand2_2
XFILLER_0_10_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1362_ _0526_ _0527_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__nand2_1
X_1293_ _0448_ _0441_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__or2_4
XFILLER_0_33_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1629_ net150 net140 VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1980_ _1134_ _1137_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__xor2_1
XFILLER_0_23_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2463_ clknet_3_5__leaf_clk _0039_ net112 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfrtp_1
Xrebuffer1 _0489_ VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__buf_1
XFILLER_0_23_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2394_ _0238_ _0372_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1345_ net133 net130 _0476_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__and3_1
X_1276_ net120 net123 VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__nand2_2
X_1414_ _0548_ _0563_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__xor2_1
Xfanout110 net39 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__clkbuf_4
Xfanout143 net26 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__clkbuf_2
Xfanout132 net31 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__buf_2
Xfanout154 net20 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__buf_2
Xfanout121 net122 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1894_ _0935_ _0936_ _1046_ _1047_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__a22o_1
X_1963_ _0970_ net135 VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__and2_1
XFILLER_0_59_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2446_ clknet_3_4__leaf_clk _0022_ net112 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dfrtp_1
X_2377_ _0343_ _1150_ _1188_ _1189_ _0358_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__a221o_1
X_1328_ net167 _0470_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__nand2_1
X_1259_ net123 net126 VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__nand2_8
XFILLER_0_46_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2300_ net8 net9 _0293_ _0232_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__or4_1
X_2231_ _0170_ _0207_ _0228_ _0194_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__a211o_1
X_2093_ _1150_ _1151_ _1060_ _1102_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__a211oi_1
X_2162_ _0134_ _0131_ _0161_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__or3_1
XFILLER_0_29_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1946_ _1054_ _1056_ _1057_ _1103_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__a31oi_2
X_1877_ _0950_ _0982_ _1036_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_3_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2429_ clknet_3_7__leaf_clk _0005_ net111 VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__dfrtp_1
X_1800_ _0958_ _0960_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_15_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1662_ _0823_ _0825_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_31_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1731_ net152 net162 _0844_ _0843_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__a31o_1
X_1593_ _0728_ _0757_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2214_ _0208_ _0211_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__xnor2_1
Xclkbuf_3_5__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_5__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_2076_ _0076_ _1197_ _1198_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__and3_1
X_2145_ net139 net136 _0143_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_46_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1929_ _1085_ _1087_ VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_55_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1714_ net14 _0772_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__xor2_2
X_1645_ _0735_ _0754_ _0808_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__o21a_1
XFILLER_0_6_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1576_ net153 net143 VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__nand2_1
Xrebuffer11 _0523_ VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__clkbuf_1
X_2128_ _0099_ _0128_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__xnor2_1
Xrebuffer22 _0652_ VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__clkbuf_1
X_2059_ _1205_ _0060_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__xnor2_1
Xrebuffer33 _0511_ VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1430_ _0500_ _0503_ _0595_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput80 net80 VGND VGND VPWR VPWR c[10] sky130_fd_sc_hd__clkbuf_4
Xoutput91 net91 VGND VGND VPWR VPWR c[3] sky130_fd_sc_hd__buf_2
X_1361_ net133 net122 VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__or2b_1
X_1292_ _0418_ _0456_ _0457_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_53_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1559_ _0723_ _0717_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__and2_1
X_1628_ _0786_ _0791_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer2 _0489_ VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2393_ _0204_ _0369_ _0202_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__o21a_1
X_2462_ clknet_3_0__leaf_clk _0038_ net109 VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_2_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1413_ net127 _0452_ _0578_ net125 VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__or4b_1
X_1344_ _0495_ _0509_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__xor2_2
X_1275_ _0427_ _0430_ _0440_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout111 net112 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__clkbuf_4
Xfanout133 net30 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__buf_2
Xfanout122 net35 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__clkbuf_4
Xfanout144 net25 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1962_ _1117_ _1119_ VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__xnor2_1
X_1893_ _1052_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_43_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2445_ clknet_3_5__leaf_clk _0021_ net112 VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dfrtp_1
X_2376_ _1149_ _1145_ _1146_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__and3_1
X_1327_ _0470_ _0463_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__or2_1
X_1258_ _0419_ _0421_ _0423_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__a21o_1
XFILLER_0_34_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_29_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2230_ _0226_ _0227_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__or2_1
X_2161_ _0135_ _0160_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__xnor2_4
X_2092_ _1156_ _1186_ _1187_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__and3_1
X_1945_ _1054_ _1056_ _1057_ _1103_ _0721_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__a41o_1
XFILLER_0_43_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1876_ _0981_ _0978_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__and2b_1
X_2428_ clknet_3_7__leaf_clk _0004_ net111 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2359_ _0342_ _0339_ _0343_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_34_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1661_ _0723_ _0717_ _0768_ _0824_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__a31o_1
X_1592_ _0755_ _0756_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__xnor2_2
X_1730_ _0425_ net181 _0837_ _0496_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__a31oi_4
XFILLER_0_56_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2144_ net139 net136 _0143_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2213_ net134 _0209_ _0210_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__a21oi_1
X_2075_ _1197_ _1198_ _0076_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_56_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1859_ net142 net139 VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__nand2_1
X_1928_ _1018_ _1025_ _1086_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_31_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1713_ _0832_ _0820_ _0874_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__nand3_2
XFILLER_0_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1644_ _0751_ _0753_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1575_ _0738_ _0739_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__nor2_1
X_2127_ _0125_ _0127_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__xor2_4
Xrebuffer23 _0617_ VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__clkbuf_1
Xrebuffer12 _0476_ VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__buf_1
XFILLER_0_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_16_Left_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2058_ _1206_ _0059_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_44_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput70 net70 VGND VGND VPWR VPWR b[1] sky130_fd_sc_hd__buf_2
X_1360_ net122 net133 VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__or2b_1
Xoutput92 net92 VGND VGND VPWR VPWR c[4] sky130_fd_sc_hd__clkbuf_4
Xoutput81 net81 VGND VGND VPWR VPWR c[11] sky130_fd_sc_hd__clkbuf_4
X_1291_ _0439_ _0455_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__nand2_1
XFILLER_0_41_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1558_ _0710_ _0706_ _0707_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__nand3_1
XFILLER_0_41_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1489_ _0653_ _0618_ _0654_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__a21boi_1
X_1627_ _0741_ _0789_ _0790_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer3 net170 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__clkbuf_1
X_2392_ _0371_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2461_ clknet_3_0__leaf_clk _0037_ net109 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dfrtp_1
X_1343_ _0505_ _0508_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__xnor2_2
X_1412_ _0436_ _0528_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1274_ net120 _0425_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__nor2_1
Xfanout112 net39 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__clkbuf_4
Xfanout101 net103 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__clkbuf_4
Xfanout123 net125 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__buf_12
Xfanout134 net135 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__buf_2
Xfanout145 net25 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_9_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_55_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1892_ net75 _1051_ net107 VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__mux2_1
X_1961_ _0970_ _0964_ _1118_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__o21ai_1
X_2375_ _0330_ _0338_ _0356_ _0085_ _1047_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__o2111ai_4
X_2444_ clknet_3_5__leaf_clk _0020_ net112 VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__dfrtp_1
X_1326_ _0479_ _0487_ _0491_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__a21oi_2
X_1257_ net124 _0422_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__nor2_1
Xclone8 net37 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__buf_4
XFILLER_0_37_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_4_Left_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2160_ _0158_ _0159_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2091_ _0081_ _0091_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1944_ _1060_ _1102_ VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_28_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1875_ _1004_ _1034_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2427_ clknet_3_7__leaf_clk _0003_ net112 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_3_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2358_ _1060_ _1102_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__or2b_1
X_2289_ _0282_ _0283_ _0284_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__o21ai_2
X_1309_ _0473_ _0474_ _0445_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_19_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1660_ _0764_ _0765_ _0766_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__a21oi_1
X_1591_ _0673_ _0674_ _0694_ _0693_ _0691_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__o32a_1
XFILLER_0_0_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_319 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2143_ _0138_ _0142_ VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__xnor2_1
X_2212_ net134 _0906_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2074_ _0074_ _0075_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout3 net151 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__clkbuf_8
X_1927_ _1021_ _1024_ VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__or2b_1
X_1858_ _1013_ _1017_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__xor2_2
X_1789_ _0948_ _0894_ _0949_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_39_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1712_ _0832_ _0820_ _0874_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__a21o_1
XFILLER_0_38_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_1 net223 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_5_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1643_ _0785_ _0806_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__xnor2_2
X_1574_ net162 net121 _0737_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__a21oi_1
X_2126_ _0074_ _0126_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__nand2_2
Xrebuffer24 _0624_ VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__clkbuf_1
X_2057_ _1211_ _0058_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__nor2_1
Xrebuffer13 _0463_ VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput93 net93 VGND VGND VPWR VPWR c[5] sky130_fd_sc_hd__clkbuf_4
Xoutput82 net82 VGND VGND VPWR VPWR c[12] sky130_fd_sc_hd__clkbuf_4
Xoutput71 net71 VGND VGND VPWR VPWR b[2] sky130_fd_sc_hd__buf_2
Xoutput60 net60 VGND VGND VPWR VPWR b[0] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_33_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1290_ _0439_ _0455_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__xor2_2
X_1626_ net161 _0741_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__nor2_1
X_1557_ net106 _0717_ _0719_ _0722_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__a31o_1
X_1488_ _0591_ net177 VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2109_ _1074_ _0109_ _1159_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__and3_1
X_2460_ clknet_3_0__leaf_clk _0036_ net109 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_23_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer4 net224 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__clkbuf_1
X_2391_ net83 _0370_ net40 VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__mux2_1
X_1342_ _0473_ _0507_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__xor2_2
X_1273_ _0432_ _0437_ _0438_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__o21ai_2
X_1411_ net127 _0517_ _0574_ _0576_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__o211ai_1
XFILLER_0_46_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout102 net103 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__clkbuf_2
Xfanout113 net39 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__clkbuf_4
X_1609_ net12 _0708_ net13 VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_1_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout146 net24 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__buf_4
Xfanout135 net136 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__clkbuf_4
Xfanout124 net125 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__buf_2
XFILLER_0_49_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1891_ _1048_ _1050_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_28_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1960_ net144 _0970_ VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__nand2_1
X_2443_ clknet_3_2__leaf_clk _0019_ net108 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__dfrtp_1
X_2374_ _0342_ _1152_ _0084_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__nor3_1
X_1256_ net128 net130 VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__nand2_1
X_1325_ _0461_ _0478_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__and2_1
XFILLER_0_46_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_20_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2090_ _0077_ _0078_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1943_ _1099_ _1101_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__xor2_4
XFILLER_0_28_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1874_ _1030_ _1033_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__xor2_2
X_2426_ clknet_3_7__leaf_clk _0002_ net111 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__dfrtp_1
X_1239_ _0411_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__clkbuf_1
X_2357_ _1060_ _1102_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__xor2_1
X_2288_ net9 _0249_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__xnor2_1
X_1308_ net127 net131 VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1590_ _0735_ _0754_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__xor2_2
XFILLER_0_0_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2073_ _1199_ _1200_ _0073_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__or3_1
X_2142_ _0140_ _0141_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__nor2_1
X_2211_ _1022_ _0906_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1788_ _0892_ _0895_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__or2b_1
XFILLER_0_12_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1857_ net148 _0962_ _1016_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__o21ai_4
X_1926_ _1080_ _1084_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__xnor2_2
X_2409_ _0385_ _0268_ _0383_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_42_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold60 net58 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_51_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1711_ _0872_ _0873_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__nand2_1
XANTENNA_2 net151 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_1642_ _0803_ _0805_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1573_ net116 net121 _0737_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__and3_1
X_2125_ _1197_ _1198_ _0076_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__a21o_1
Xrebuffer14 _0522_ VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__clkbuf_1
X_2056_ _1161_ _1207_ _1210_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__and3_1
Xrebuffer25 _0500_ VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__buf_1
X_1909_ _1066_ _1067_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_2_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput94 net94 VGND VGND VPWR VPWR c[6] sky130_fd_sc_hd__clkbuf_4
Xoutput61 net61 VGND VGND VPWR VPWR b[10] sky130_fd_sc_hd__clkbuf_4
Xoutput83 net83 VGND VGND VPWR VPWR c[13] sky130_fd_sc_hd__clkbuf_4
Xoutput50 net50 VGND VGND VPWR VPWR a[18] sky130_fd_sc_hd__clkbuf_4
Xoutput72 net72 VGND VGND VPWR VPWR b[3] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1556_ _0721_ net204 VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__and2_1
X_1625_ _0787_ _0788_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__nand2_1
X_1487_ _0518_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__inv_2
X_2039_ _1144_ _1185_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__or2_1
X_2108_ _1022_ net135 VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer5 _0426_ VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__dlygate4sd1_1
X_1410_ net130 _0484_ _0575_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__and3_1
X_2390_ _0204_ _0369_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__xor2_1
X_1341_ net129 _0467_ _0506_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__o21a_1
X_1272_ _0424_ _0431_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout103 net40 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__buf_2
X_1608_ net12 net13 _0708_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__or3_2
Xfanout136 net29 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__buf_2
X_1539_ _0665_ _0704_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__xnor2_1
Xfanout147 net24 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__clkbuf_4
Xfanout114 net38 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__buf_4
Xfanout125 net34 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1890_ _1049_ _0994_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2442_ clknet_3_0__leaf_clk _0018_ net108 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__dfrtp_1
X_2373_ _0354_ _0128_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1324_ net155 VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__inv_2
X_1255_ net123 _0420_ net126 VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__mux2_4
XFILLER_0_24_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_307 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1942_ _1040_ _1100_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__nand2_2
XFILLER_0_43_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1873_ _0957_ _1031_ _1032_ VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2356_ _0341_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__clkbuf_1
X_2425_ clknet_3_7__leaf_clk _0001_ net111 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_3_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1238_ net205 net4 net104 VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__mux2_1
X_2287_ _0263_ _0266_ _0281_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__and3_1
X_1307_ net126 net131 VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__and2_4
Xclkbuf_3_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_33_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2210_ _0850_ _1077_ _1078_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__a21oi_1
X_2072_ _1199_ _1200_ _0073_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__o21ai_2
X_2141_ _0109_ _1168_ _0139_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__and3_1
XFILLER_0_56_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1925_ _1014_ _1083_ VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__xnor2_2
X_1787_ _0893_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__inv_2
XFILLER_0_12_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1856_ _1014_ _1015_ _0962_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__a21bo_1
X_2339_ net92 _0327_ net105 VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__mux2_1
X_2408_ _0249_ _0250_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold61 net70 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__dlygate4sd3_1
Xhold50 net60 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1710_ _0869_ _0871_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1641_ _0740_ _0750_ _0804_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__a21boi_2
X_1572_ _0681_ _0736_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__xnor2_1
X_2124_ _0123_ _0124_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__nor2_2
X_2055_ _1161_ _1207_ _1210_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__a21oi_1
Xrebuffer15 _0465_ VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__dlygate4sd1_1
Xrebuffer26 _0500_ VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1839_ _0945_ _0996_ _0997_ _0888_ _0998_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__o221a_1
XFILLER_0_29_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1908_ net171 _0686_ VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput84 net84 VGND VGND VPWR VPWR c[14] sky130_fd_sc_hd__clkbuf_4
Xoutput62 net62 VGND VGND VPWR VPWR b[11] sky130_fd_sc_hd__clkbuf_4
Xoutput51 net51 VGND VGND VPWR VPWR a[1] sky130_fd_sc_hd__clkbuf_4
Xoutput95 net95 VGND VGND VPWR VPWR c[7] sky130_fd_sc_hd__clkbuf_4
Xoutput73 net73 VGND VGND VPWR VPWR b[4] sky130_fd_sc_hd__buf_2
X_1555_ _0720_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_41_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1624_ net152 net162 VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__or2_1
XFILLER_0_1_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1486_ _0622_ _0651_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__xor2_1
X_2107_ _0106_ _0107_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__nor2_1
X_2038_ _1194_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_49_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer6 _0542_ VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__clkbuf_2
X_1340_ _0467_ _0420_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1271_ _0434_ _0436_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__or2_1
Xfanout104 net40 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__clkbuf_4
X_1607_ _0771_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__clkbuf_1
X_1538_ _0482_ _0703_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__xnor2_2
X_1469_ _0633_ _0634_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__and2_1
Xfanout137 net138 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__clkbuf_4
Xfanout148 net149 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__buf_4
Xfanout126 net127 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__buf_8
Xfanout115 net38 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2441_ clknet_3_2__leaf_clk _0017_ net108 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__dfrtp_1
X_2372_ _0099_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__inv_2
X_1323_ _0458_ _0488_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__xnor2_2
X_1254_ net123 net129 VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1941_ _0999_ _1000_ _1042_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1872_ _0974_ _0976_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__nor2_1
XFILLER_0_24_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2355_ net210 _0340_ net107 VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__mux2_1
X_2424_ clknet_3_7__leaf_clk _0000_ net111 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dfrtp_1
X_2286_ _0263_ _0266_ _0281_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__a21oi_2
X_1306_ net131 _0445_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__nor2_1
X_1237_ _0410_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_35_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_8_Left_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2140_ _0109_ _1168_ _0139_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2071_ _0071_ _0072_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1855_ net148 net145 VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__or2_1
X_1924_ _1081_ _1082_ VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__nor2_1
XFILLER_0_24_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1786_ net123 net173 _0924_ _0946_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__a31o_1
X_2338_ _0937_ _0326_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__xor2_1
X_2407_ net103 net188 _0384_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__o21a_1
X_2269_ _0226_ _0236_ _0265_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_39_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold40 net81 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold62 net59 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 net44 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1640_ _0747_ _0749_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1571_ net115 net169 VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__xor2_1
X_2123_ _0100_ _0071_ _0121_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__nor3_1
Xrebuffer16 _0489_ VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__clkbuf_1
Xrebuffer27 _0466_ VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__buf_1
XFILLER_0_16_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2054_ _1208_ _1209_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__or2_1
XFILLER_0_44_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1838_ _0947_ _0987_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1907_ net149 _0962_ _1017_ _1013_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__o22ai_4
X_1769_ net14 net15 _0772_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__or3_1
XFILLER_0_12_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput52 net52 VGND VGND VPWR VPWR a[2] sky130_fd_sc_hd__clkbuf_4
Xoutput41 net41 VGND VGND VPWR VPWR a[0] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput74 net74 VGND VGND VPWR VPWR b[5] sky130_fd_sc_hd__clkbuf_4
Xoutput96 net96 VGND VGND VPWR VPWR c[8] sky130_fd_sc_hd__buf_2
Xoutput85 net85 VGND VGND VPWR VPWR c[15] sky130_fd_sc_hd__clkbuf_4
Xoutput63 net63 VGND VGND VPWR VPWR b[12] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1554_ net102 VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__inv_2
X_1485_ _0624_ _0650_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__xnor2_2
X_1623_ net152 net162 VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__nand2_1
.ends
