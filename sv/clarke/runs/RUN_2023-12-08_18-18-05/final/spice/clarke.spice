* NGSPICE file created from clarke.ext - technology: sky130A

.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=0.59
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=0.59
.ends

.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.05
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.05
.ends

.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
X0 VPWR a_75_212# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 a_75_212# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 a_75_212# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND a_75_212# X VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
X0 X a_35_297# a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.26 ps=2.52 w=1 l=0.15
X1 X B a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.25 pd=1.42 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_117_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 VPWR B a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.25 ps=1.42 w=0.65 l=0.15
X7 a_285_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A a_117_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=2.89
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=2.89
.ends

.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.091 ps=0.93 w=0.65 l=0.15
X1 Y B1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.175 ps=1.35 w=1 l=0.15
X4 a_29_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y A2 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND A1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 a_112_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X8 a_112_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.14 ps=1.28 w=1 l=0.15
X9 a_29_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X11 a_29_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A a_113_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_113_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_300_297# a_27_413# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X3 Y a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.102 ps=0.99 w=0.65 l=0.15
X4 VPWR A1 a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 a_384_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.143 ps=1.09 w=0.65 l=0.15
X6 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.111 ps=1.37 w=0.42 l=0.15
X7 a_300_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_109_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
X0 a_377_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.365 ps=1.73 w=1 l=0.15
X1 a_47_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.3 ps=2.6 w=1 l=0.15
X2 a_129_47# B a_47_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_285_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 Y a_47_47# a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_129_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0683 ps=0.86 w=0.65 l=0.15
X6 VPWR A a_47_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.365 pd=1.73 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_47_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.165 ps=1.33 w=1 l=0.15
X8 Y B a_377_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
X0 VGND A a_68_297# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_68_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_68_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR A a_150_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 X a_68_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.34 pd=2.68 as=0.146 ps=1.34 w=1 l=0.15
X5 a_150_297# B a_68_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.272 ps=2.56 w=1 l=0.15
X15 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X17 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X19 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X24 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.257 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X30 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X38 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
X0 VPWR B a_59_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 X a_59_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.475 pd=2.95 as=0.167 ps=1.39 w=1 l=0.15
X2 VGND B a_145_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_59_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X4 X a_59_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.112 ps=1.04 w=0.65 l=0.15
X5 a_145_75# A a_59_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_199_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_113_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.147 ps=1.29 w=1 l=0.15
X2 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X3 VPWR A1 a_113_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.29 as=0.14 ps=1.28 w=1 l=0.15
X4 a_113_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A2 a_199_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0959 ps=0.945 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.26 ps=1.45 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.4 ps=1.8 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.205 pd=1.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.135 ps=1.27 w=1 l=0.15
X5 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_109_297# C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.97
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.97
.ends

.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X2 a_193_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y A a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X4 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 a_109_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
X0 VGND C a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 a_277_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_47# B a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.135 ps=1.27 w=1 l=0.15
X8 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_277_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 Y A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.174 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.182 pd=1.92 as=0.174 ps=1.39 w=0.7 l=0.15
X2 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X3 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
X0 VPWR A a_49_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VGND a_285_47# a_391_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.5
X2 X a_391_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VGND A a_49_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR a_285_47# a_391_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.5
X5 a_285_47# a_49_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X6 a_285_47# a_49_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X7 X a_391_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
X0 VPWR a_505_21# a_535_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_505_21# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.0693 ps=0.75 w=0.42 l=0.15
X2 a_218_374# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0767 pd=0.785 as=0.158 ps=1.39 w=0.42 l=0.15
X3 VGND a_505_21# a_439_47# VNB sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.11 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 a_76_199# A0 a_218_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.193 pd=1.34 as=0.0767 ps=0.785 w=0.42 l=0.15
X5 a_505_21# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.145 ps=1.11 w=0.42 l=0.15
X6 a_439_47# A0 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0997 ps=0.895 w=0.42 l=0.15
X7 a_535_374# A1 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.193 ps=1.34 w=0.42 l=0.15
X8 a_76_199# A1 a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0997 pd=0.895 as=0.0693 ps=0.75 w=0.42 l=0.15
X9 a_218_47# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.113 ps=1.04 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.158 pd=1.39 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.04 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
X0 a_27_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_560_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X2 VGND B a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0991 ps=0.955 w=0.65 l=0.15
X3 Y B a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_297# a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_474_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X7 VGND A a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# B a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X12 a_474_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_560_47# a_27_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X14 VPWR A a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X15 Y a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X16 VPWR a_27_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X17 a_560_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_470_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_470_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_470_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.106 ps=0.975 w=0.65 l=0.15
X6 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X8 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X10 a_470_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.162 ps=1.33 w=1 l=0.15
X11 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 VPWR B a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X13 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X16 X a_112_47# a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 a_470_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X18 X B a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.42 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0703 pd=0.755 as=0.111 ps=1.37 w=0.42 l=0.15
X6 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.14 ps=1.28 w=1 l=0.15
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0703 ps=0.755 w=0.42 l=0.15
X8 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.165 ps=1.33 w=1 l=0.15
X9 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_4 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 X a_79_204# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A1 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_473_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.195 ps=1.39 w=1 l=0.15
X3 X a_79_204# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X4 VGND C1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.104 ps=0.97 w=0.65 l=0.15
X5 a_79_204# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0926 ps=0.935 w=0.65 l=0.15
X6 VPWR a_79_204# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X7 a_473_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X8 a_473_297# B1 a_727_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.16 ps=1.32 w=1 l=0.15
X9 X a_79_204# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X10 VGND B1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.127 ps=1.04 w=0.65 l=0.15
X11 a_79_204# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.109 ps=0.985 w=0.65 l=0.15
X12 VGND a_79_204# X VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.0959 ps=0.945 w=0.65 l=0.15
X13 a_1123_47# A1 a_79_204# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_555_297# B1 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X15 VPWR A2 a_473_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X16 VGND A2 a_1123_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.091 ps=0.93 w=0.65 l=0.15
X17 a_951_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.14 ps=1.08 w=0.65 l=0.15
X18 VPWR a_79_204# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_79_204# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X20 a_79_204# A1 a_951_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 a_79_204# C1 a_555_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 a_727_297# C1 a_79_204# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X23 X a_79_204# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.35 as=0.265 ps=2.53 w=1 l=0.15
X1 a_209_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.172 ps=1.35 w=1 l=0.15
X2 a_303_47# A2 a_209_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.104 ps=0.97 w=0.65 l=0.15
X3 a_209_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.112 ps=0.995 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.172 ps=1.83 w=0.65 l=0.15
X5 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.107 ps=0.98 w=0.65 l=0.15
X6 a_80_21# A1 a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X7 VPWR A2 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.16 ps=1.32 w=1 l=0.15
X8 a_80_21# B1 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X9 a_209_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VPWR C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 a_181_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VGND C a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.132 pd=1.14 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 a_27_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X6 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.132 ps=1.14 w=0.65 l=0.15
X7 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_4 A B C VGND VNB VPB VPWR X
X0 VPWR A a_94_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.198 pd=1.39 as=0.305 ps=2.61 w=1 l=0.15
X1 a_294_47# B a_185_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.128 ps=1.04 w=0.65 l=0.15
X2 a_185_47# A a_94_47# VNB sky130_fd_pr__nfet_01v8 ad=0.128 pd=1.04 as=0.198 ps=1.91 w=0.65 l=0.15
X3 VPWR a_94_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND C a_294_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 a_94_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.198 ps=1.39 w=1 l=0.15
X6 X a_94_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X7 X a_94_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 VPWR C a_94_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X9 X a_94_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X10 VGND a_94_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X11 VPWR a_94_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND a_94_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 X a_94_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2111oi_2 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
X0 a_467_297# B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X1 a_287_297# D1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 VPWR A2 a_467_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X3 a_923_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.112 ps=0.995 w=0.65 l=0.15
X4 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
X5 a_28_297# B1 a_467_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X7 a_28_297# C1 a_287_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X8 Y A1 a_923_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND A2 a_684_47# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.179 ps=1.2 w=0.65 l=0.15
X10 Y D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X11 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.106 ps=0.975 w=0.65 l=0.15
X12 Y D1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 a_467_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.335 pd=2.67 as=0.16 ps=1.32 w=1 l=0.15
X14 VGND D1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.091 ps=0.93 w=0.65 l=0.15
X15 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.127 ps=1.04 w=0.65 l=0.15
X16 VPWR A1 a_467_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X17 a_115_297# C1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.285 ps=2.57 w=1 l=0.15
X18 a_467_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X19 a_684_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.2 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 a_81_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.257 ps=1.44 w=0.65 l=0.15
X1 a_299_297# B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_299_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 a_384_47# A1 a_81_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
X0 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
X0 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.157 ps=1.17 w=0.42 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.157 pd=1.17 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X6 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X3 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X4 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X5 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.301 ps=2.66 w=1 l=0.15
X7 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X8 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X10 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X12 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X13 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X14 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X15 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X16 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X17 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X18 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X20 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X21 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X22 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.209 ps=2.02 w=0.65 l=0.15
X23 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X24 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X25 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X26 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X27 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_382_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X1 a_297_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X2 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.327 pd=1.65 as=0.28 ps=2.56 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.327 ps=1.65 w=1 l=0.15
X6 a_382_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.195 ps=1.39 w=1 l=0.15
X7 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.149 ps=1.33 w=1 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.149 pd=1.33 as=0.166 ps=1.8 w=0.64 l=0.15
X3 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X4 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
X0 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X5 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X7 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0683 ps=0.86 w=0.65 l=0.15
X1 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=2.1 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A1 a_114_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
X3 a_114_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.185 ps=1.87 w=0.65 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.28 ps=2.56 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X10 a_285_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.091 ps=0.93 w=0.65 l=0.15
X11 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_197_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0798 pd=0.8 as=0.0609 ps=0.71 w=0.42 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.312 ps=1.68 w=1 l=0.15
X3 a_303_47# C a_197_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0798 ps=0.8 w=0.42 l=0.15
X4 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.68 as=0.0588 ps=0.7 w=0.42 l=0.15
X6 VGND D a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.196 pd=1.33 as=0.0693 ps=0.75 w=0.42 l=0.15
X7 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X8 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.196 ps=1.33 w=0.65 l=0.15
X9 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_2 A B C_N VGND VNB VPB VPWR X
X0 a_388_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.148 ps=1.34 w=0.42 l=0.15
X1 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X4 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X7 a_176_21# a_27_47# a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 a_472_297# B a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.102 ps=0.99 w=0.42 l=0.15
X10 a_176_21# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
X0 X a_299_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X1 VPWR a_193_47# a_299_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 VGND a_193_47# a_299_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X6 X a_299_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
X0 VPWR B a_207_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.228 pd=1.74 as=0.0609 ps=0.71 w=0.42 l=0.15
X1 X a_207_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.228 ps=1.74 w=1 l=0.15
X2 a_297_47# a_27_413# a_207_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0504 pd=0.66 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_207_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.99 w=0.65 l=0.15
X4 a_207_413# a_27_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0609 pd=0.71 as=0.0714 ps=0.76 w=0.42 l=0.15
X5 VPWR A_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0714 pd=0.76 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VGND B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.99 as=0.0504 ps=0.66 w=0.42 l=0.15
X7 a_27_413# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
X0 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X5 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X17 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X21 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X23 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X36 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X39 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_397_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR B1_N a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X2 Y A2 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VGND A2 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND A1 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_28_297# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X6 Y a_28_297# a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VPWR a_28_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_397_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X9 a_229_47# a_28_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y a_28_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X11 a_229_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_229_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A1 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_226_47# A2_N a_226_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_489_413# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_226_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.167 ps=1.43 w=0.42 l=0.15
X3 VPWR B2 a_489_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_489_413# a_226_47# a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_76_199# a_226_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.139 ps=1.08 w=0.42 l=0.15
X6 VGND B1 a_556_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_556_47# B2 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VGND A2_N a_226_47# VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.08 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_226_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.12 ps=1.09 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.43 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.09 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_298_297# a_27_413# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.265 ps=2.53 w=1 l=0.15
X1 a_215_297# a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.136 ps=1.1 w=0.65 l=0.15
X2 a_298_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.258 ps=1.45 w=0.65 l=0.15
X4 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X6 a_382_47# A1 a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.136 pd=1.1 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VPWR A1 a_298_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND A2 a_382_47# VNB sky130_fd_pr__nfet_01v8 ad=0.258 pd=1.45 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
X0 X a_61_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.167 ps=1.39 w=1 l=0.15
X1 VPWR a_61_75# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.195 ps=1.39 w=1 l=0.15
X2 VPWR B a_61_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 VGND B a_147_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 X a_61_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.112 ps=1.04 w=0.65 l=0.15
X5 VGND a_61_75# X VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.127 ps=1.04 w=0.65 l=0.15
X6 a_61_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X7 a_147_75# A a_61_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
X0 X a_29_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.148 ps=1.34 w=1 l=0.15
X1 a_111_297# C a_29_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_29_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.102 ps=0.99 w=0.65 l=0.15
X3 a_183_297# B a_111_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 VPWR A a_183_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X5 a_29_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VGND C a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 a_103_199# B1 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.107 ps=0.98 w=0.65 l=0.15
X1 VPWR a_103_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.36 ps=2.72 w=1 l=0.15
X2 a_337_297# A2 a_253_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_103_199# A3 a_337_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.165 ps=1.33 w=1 l=0.15
X4 a_253_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.195 ps=1.39 w=1 l=0.15
X5 VPWR B1 a_103_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.345 pd=2.69 as=0.213 ps=1.42 w=1 l=0.15
X6 VGND a_103_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.234 ps=2.02 w=0.65 l=0.15
X7 a_253_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X8 a_253_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X9 VGND A2 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.221 pd=1.98 as=0.198 ps=1.26 w=0.65 l=0.15
X1 Y A3 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.393 pd=1.78 as=0.135 ps=1.27 w=1 l=0.15
X2 a_193_297# A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.393 ps=1.78 w=1 l=0.15
X5 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X8 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X11 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=1.37 as=0.0588 ps=0.7 w=0.42 l=0.15
X18 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X20 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X21 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X22 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X23 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X25 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X26 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X27 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X28 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X29 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X30 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X31 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X32 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X33 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X34 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X35 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X36 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X37 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X38 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X39 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0578 ps=0.695 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_4 A B C_N VGND VNB VPB VPWR X
X0 a_176_21# a_27_47# a_626_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X1 a_626_297# B a_542_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR C_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_542_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X8 X a_176_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_176_21# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VPWR a_176_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 X a_176_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X12 a_176_21# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X13 VGND a_176_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND B a_176_21# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND C_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32o_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 VPWR A3 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_299_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X2 a_352_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.21 ps=1.29 w=0.65 l=0.15
X3 a_549_47# A1 a_21_199# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.107 ps=0.98 w=0.65 l=0.15
X4 X a_21_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_21_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.21 pd=1.29 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_665_47# A2 a_549_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.14 ps=1.08 w=0.65 l=0.15
X7 VPWR A1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X8 a_299_297# B1 a_21_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_21_199# B2 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 VGND A3 a_665_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR a_21_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X12 X a_21_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_21_199# B1 a_352_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.115 ps=1 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_222_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X1 VPWR A1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.105 ps=1.21 w=1 l=0.15
X2 VGND a_79_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_222_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.186 ps=1.41 w=0.42 l=0.15
X4 VGND A2 a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_448_47# a_222_93# a_79_199# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_79_199# a_222_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.3 ps=2.6 w=1 l=0.15
X7 a_544_297# A2 a_79_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X8 a_448_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.186 pd=1.41 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_286_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X2 a_286_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X3 Y A2 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 VGND A1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X6 VGND A2 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X7 a_487_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# B1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR A1 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_27_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X13 a_487_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X14 a_286_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
X0 a_109_93# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_209_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X2 a_109_93# A_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_296_53# a_109_93# a_209_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.108 ps=1.36 w=0.42 l=0.15
X4 VPWR C a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0744 ps=0.815 w=0.42 l=0.15
X5 a_368_53# B a_296_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_209_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.122 ps=1.08 w=0.65 l=0.15
X7 a_209_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VPWR a_109_93# a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.108 ps=1.36 w=0.42 l=0.15
X9 VGND C a_368_53# VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.08 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
X0 a_109_93# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_215_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 VGND a_109_93# a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND A a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 VPWR A a_369_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_369_297# B a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_215_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X7 a_297_297# a_109_93# a_215_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_109_93# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 X a_215_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.1 ps=0.985 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.745 as=0.111 ps=1.37 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.162 ps=1.33 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VGND A1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
X1 a_510_47# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.143 ps=1.09 w=0.65 l=0.15
X2 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.175 ps=1.35 w=1 l=0.15
X3 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.22 ps=1.44 w=1 l=0.15
X4 a_79_21# A2 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.22 pd=1.44 as=0.162 ps=1.33 w=1 l=0.15
X5 a_297_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X6 a_79_21# C1 a_510_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.114 ps=1 w=0.65 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X8 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
X9 a_215_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.106 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_4 A1 A2 B1_N VGND VNB VPB VPWR X
X0 VPWR B1_N a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.38 ps=2.76 w=1 l=0.15
X1 VPWR A1 a_743_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_743_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X3 a_575_47# a_27_297# a_187_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_743_297# A2 a_187_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR a_27_297# a_187_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X6 a_187_21# A2 a_743_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_187_21# a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_187_21# a_27_297# a_575_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VGND B1_N a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.198 ps=1.91 w=0.65 l=0.15
X10 VGND A2 a_575_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR a_187_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A1 a_575_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND a_187_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 X a_187_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VPWR a_187_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 a_575_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_575_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 X a_187_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 X a_187_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 X a_187_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VGND a_187_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
X0 a_558_47# a_381_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X1 VGND X a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_841_47# a_664_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VPWR A a_62_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A a_62_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_558_47# a_381_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X6 X a_62_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR X a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_841_47# a_664_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X9 X a_62_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X10 VPWR a_558_47# a_664_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND a_558_47# a_664_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
X0 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_161_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X2 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_161_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A a_161_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_161_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 a_676_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.213 ps=1.42 w=1 l=0.15
X1 a_512_47# B1 a_409_47# VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.119 ps=1.01 w=0.65 l=0.15
X2 a_306_47# D1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.198 ps=1.91 w=0.65 l=0.15
X3 VGND A2 a_512_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.198 ps=1.26 w=0.65 l=0.15
X4 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.218 ps=1.43 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.305 ps=1.61 w=1 l=0.15
X6 VPWR A1 a_676_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.105 ps=1.21 w=1 l=0.15
X7 a_512_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_409_47# C1 a_306_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.119 ps=1.01 w=0.65 l=0.15
X9 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.382 pd=1.76 as=0.26 ps=2.52 w=1 l=0.15
X10 a_79_21# D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.218 pd=1.43 as=0.382 ps=1.76 w=1 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_388_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.127 pd=1.25 as=0.153 ps=1.3 w=1 l=0.15
X1 a_105_352# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_297_47# a_105_352# Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A1 a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.127 ps=1.25 w=1 l=0.15
X5 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X6 VPWR B1_N a_105_352# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.178 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 Y a_105_352# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.178 ps=1.4 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X1 a_80_21# C1 a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X2 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_300_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.26 ps=1.45 w=0.65 l=0.15
X6 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_80_21# A1 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 a_472_297# B1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X9 a_80_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 a_78_199# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 VPWR A1 a_493_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X2 a_493_297# A2 a_78_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.235 ps=1.47 w=1 l=0.15
X3 VPWR a_78_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.373 pd=1.75 as=0.28 ps=2.56 w=1 l=0.15
X4 VGND A2 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X5 a_78_199# B2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.235 pd=1.47 as=0.117 ps=1.24 w=1 l=0.15
X6 a_215_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_215_47# B2 a_78_199# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_292_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.117 pd=1.24 as=0.373 ps=1.75 w=1 l=0.15
X9 VGND a_78_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3b_2 A_N B C VGND VNB VPB VPWR X
X0 a_109_53# A_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_215_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.1 w=0.65 l=0.15
X2 a_109_53# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND C a_373_53# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.1 as=0.0536 ps=0.675 w=0.42 l=0.15
X4 VGND a_215_311# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR C a_215_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.0744 ps=0.815 w=0.42 l=0.15
X6 VPWR a_215_311# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_215_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X8 a_301_53# a_109_53# a_215_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_215_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 a_373_53# B a_301_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X11 VPWR a_109_53# a_215_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_4 A B C VGND VNB VPB VPWR Y
X0 a_27_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# B a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y A a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y A a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_445_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X12 a_445_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_445_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X17 a_445_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X23 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
X0 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.165 ps=1.33 w=1 l=0.15
X2 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_193_47# C a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_277_47# B a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_75_199# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.135 ps=1.07 w=0.65 l=0.15
X1 a_208_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.112 ps=0.995 w=0.65 l=0.15
X2 a_315_47# A2 a_208_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.17 as=0.125 ps=1.03 w=0.65 l=0.15
X3 VGND B1 a_75_199# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.07 as=0.106 ps=0.975 w=0.65 l=0.15
X4 a_75_199# A1 a_315_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.17 w=0.65 l=0.15
X5 a_75_199# C1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.207 ps=1.41 w=1 l=0.15
X6 a_544_297# B1 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.207 pd=1.41 as=0.162 ps=1.33 w=1 l=0.15
X7 VPWR a_75_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.285 ps=2.57 w=1 l=0.15
X8 a_201_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.142 ps=1.28 w=1 l=0.15
X9 VPWR A2 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.165 ps=1.33 w=1 l=0.15
X10 a_201_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.305 ps=1.61 w=1 l=0.15
X11 VGND a_75_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VGND A2 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR A1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_37_297# B1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_485_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_292_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VPWR A2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X8 a_485_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X11 a_37_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 Y A1 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X13 Y C1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_292_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X15 a_292_297# B1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_277_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_277_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_277_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X5 a_277_47# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X6 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND a_277_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND a_277_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_193_47# A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_361_47# A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 X a_277_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A3 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X15 X a_277_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X16 a_277_47# A1 a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_445_47# A2 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND B1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_27_297# B1 a_277_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X21 VPWR a_277_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.5 pd=3 as=0.135 ps=1.27 w=1 l=0.15
X22 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X23 a_277_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_806_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_47# B1 a_1314_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=2.09 as=0.104 ps=0.97 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X17 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.0943 ps=0.94 w=0.65 l=0.15
X19 Y C1 a_978_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_27_47# B1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 a_806_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.675 pd=3.35 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.091 ps=0.93 w=0.65 l=0.15
X27 a_978_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.091 ps=0.93 w=0.65 l=0.15
X28 a_1314_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X31 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 Y A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.109 ps=0.985 w=0.65 l=0.15
X4 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_949_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 Y C1 a_949_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.15 ps=1.3 w=1 l=0.15
X10 a_781_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_27_297# B1 a_781_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_781_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_1301_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.15 ps=1.3 w=1 l=0.15
X16 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 Y C1 a_781_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.14 ps=1.28 w=1 l=0.15
X18 a_109_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_109_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_109_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.091 ps=0.93 w=0.65 l=0.15
X27 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X28 a_27_297# B1 a_1301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X29 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0894 ps=0.925 w=0.65 l=0.15
X30 a_109_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X31 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_2 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 a_27_47# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.368 pd=1.74 as=0.14 ps=1.28 w=1 l=0.15
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.231 pd=2.01 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VPWR A1 a_373_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X4 a_182_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.165 ps=1.82 w=0.65 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.195 ps=1.39 w=1 l=0.15
X6 a_182_47# B1 a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X8 a_373_297# A2 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.368 ps=1.74 w=1 l=0.15
X9 a_110_47# C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X10 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X11 VGND A1 a_182_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_39_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=1 w=0.65 l=0.15
X2 VPWR a_39_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_39_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.156 ps=1.36 w=1 l=0.15
X4 VGND a_39_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.156 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VGND A a_39_297# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=1 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_39_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X1 X a_80_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 VGND a_80_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=0.99 as=0.091 ps=0.93 w=0.65 l=0.15
X3 a_386_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.157 ps=1.32 w=1 l=0.15
X4 X a_80_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_80_199# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.162 pd=1.15 as=0.111 ps=0.99 w=0.65 l=0.15
X6 a_386_297# B1 a_80_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_458_47# A1 a_80_199# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.162 ps=1.15 w=0.65 l=0.15
X8 VPWR A1 a_386_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X9 VGND A2 a_458_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.123 ps=1.03 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X16 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X17 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X20 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
X0 VPWR A a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_218_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.156 ps=1.16 w=0.42 l=0.15
X2 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.156 pd=1.16 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_300_297# a_27_53# a_218_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_218_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 VPWR a_218_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_218_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X7 VGND a_218_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 VGND A a_218_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32oi_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.338 pd=1.67 as=0.135 ps=1.27 w=1 l=0.15
X5 a_1249_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_1249_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.252 pd=1.5 as=0.338 ps=1.67 w=1 l=0.15
X12 a_803_47# A2 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X16 a_803_47# A2 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X20 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X21 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_1249_47# A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.133 ps=1.06 w=0.65 l=0.15
X23 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 a_1249_47# A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.252 ps=1.5 w=1 l=0.15
X28 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X30 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X32 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X35 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 VGND A3 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X37 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VGND A3 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_4 A_N B C VGND VNB VPB VPWR Y
X0 VGND C a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y a_27_47# a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y a_27_47# a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_633_47# B a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_633_47# B a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_215_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 a_215_47# B a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_215_47# B a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 a_633_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X17 a_633_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X20 a_215_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X23 VGND C a_633_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X25 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.385 pd=1.77 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X9 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.385 ps=1.77 w=1 l=0.15
X14 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X21 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X31 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 Y a_61_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.183 ps=1.24 w=0.65 l=0.15
X1 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_217_297# a_61_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_479_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X4 a_217_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X5 Y a_61_47# a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 VPWR A1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_61_47# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VGND A2 a_637_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_61_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A1 a_479_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0683 ps=0.86 w=0.65 l=0.15
X11 VGND B1_N a_61_47# VNB sky130_fd_pr__nfet_01v8 ad=0.183 pd=1.24 as=0.126 ps=1.44 w=0.42 l=0.15
X12 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X13 a_637_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR A2 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 a_277_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X2 a_79_21# B1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X3 a_277_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_361_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_277_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.127 ps=1.04 w=0.65 l=0.15
X9 a_79_21# A1 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.16 ps=1.32 w=1 l=0.15
X1 a_27_297# B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X2 VGND A2 a_373_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.114 ps=1 w=0.65 l=0.15
X3 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X4 a_27_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.253 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.253 ps=2.52 w=1 l=0.15
X6 a_373_47# A1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.96 w=0.65 l=0.15
X8 a_109_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_585_47# B1 a_266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.119 ps=1.01 w=0.65 l=0.15
X1 VGND A2 a_266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.137 pd=1.07 as=0.117 ps=1.01 w=0.65 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.62 as=0.26 ps=2.52 w=1 l=0.15
X3 a_81_21# C1 a_585_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.203 pd=1.27 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_266_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.312 ps=1.62 w=1 l=0.15
X6 a_368_297# A2 a_266_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.21 pd=1.42 as=0.18 ps=1.36 w=1 l=0.15
X7 a_266_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.137 ps=1.07 w=0.65 l=0.15
X8 a_266_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.203 ps=1.27 w=0.65 l=0.15
X9 a_81_21# A3 a_368_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.21 ps=1.42 w=1 l=0.15
X10 a_81_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.15 ps=1.3 w=1 l=0.15
X11 VPWR B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.138 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.28 ps=2.56 w=1 l=0.15
X1 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X4 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.177 ps=1.36 w=1 l=0.15
X7 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.105 ps=1.21 w=1 l=0.15
X9 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_4 A1 A2 B1 VGND VNB VPB VPWR X
X0 VGND B1 a_84_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_741_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.101 ps=0.96 w=0.65 l=0.15
X2 a_84_21# A1 a_741_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0747 ps=0.88 w=0.65 l=0.15
X3 VGND A2 a_901_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR a_84_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR A2 a_483_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_483_297# B1 a_84_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_84_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X8 a_84_21# B1 a_483_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 VGND a_84_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.265 pd=1.47 as=0.091 ps=0.93 w=0.65 l=0.15
X10 VPWR a_84_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_483_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=2.79 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR A1 a_483_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 VGND a_84_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 X a_84_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.285 ps=2.57 w=1 l=0.15
X15 a_84_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.265 ps=1.47 w=0.65 l=0.15
X16 a_483_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 X a_84_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 a_901_47# A1 a_84_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_84_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4b_4 A B C D_N VGND VNB VPB VPWR X
X0 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND a_215_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR a_215_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_109_93# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X4 a_215_297# a_109_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.165 ps=1.82 w=0.65 l=0.15
X5 VGND C a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X6 VGND A a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X8 a_215_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_109_93# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X10 VPWR A a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND a_215_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_487_297# B a_403_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_403_297# C a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X14 VPWR a_215_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X15 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X16 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_297_297# a_109_93# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
X0 VPWR A1 a_485_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_485_297# a_297_93# a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X2 a_297_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.108 ps=1.01 w=0.42 l=0.15
X3 a_581_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X4 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.01 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_79_21# a_297_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X6 VGND A2 a_581_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.182 pd=1.51 as=0.14 ps=1.28 w=1 l=0.15
X8 a_297_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.182 ps=1.51 w=0.42 l=0.15
X9 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X10 a_485_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X11 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.117 ps=1.01 w=0.65 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.41 pd=1.82 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.175 ps=1.35 w=1 l=0.15
X4 a_277_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.41 ps=1.82 w=1 l=0.15
X10 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.18 ps=1.36 w=1 l=0.15
X11 a_277_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.114 ps=1 w=0.65 l=0.15
X13 Y A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.0975 ps=0.95 w=0.65 l=0.15
X14 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311oi_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
X0 Y A1 a_194_47# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_194_47# A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
X2 Y C1 a_376_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.172 ps=1.35 w=1 l=0.15
X3 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X4 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.112 ps=0.995 w=0.65 l=0.15
X5 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.115 ps=1 w=0.65 l=0.15
X6 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.14 ps=1.28 w=1 l=0.15
X7 a_376_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.35 as=0.165 ps=1.33 w=1 l=0.15
X8 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_240_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_51_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A1 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_51_297# B2 a_245_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.412 pd=1.83 as=0.105 ps=1.21 w=1 l=0.15
X4 a_149_47# C1 a_51_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.201 ps=1.92 w=0.65 l=0.15
X5 a_240_47# B1 a_149_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0991 ps=0.955 w=0.65 l=0.15
X6 VPWR A1 a_512_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X7 X a_51_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.165 ps=1.33 w=1 l=0.15
X8 a_149_47# B2 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_245_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X10 VPWR C1 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.34 ps=2.68 w=1 l=0.15
X11 a_512_297# A2 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.412 ps=1.83 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
X0 VPWR a_29_311# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_29_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.151 ps=1.35 w=1 l=0.15
X2 VPWR A a_29_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND a_29_311# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_184_53# B a_112_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X5 VPWR C a_29_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.151 pd=1.35 as=0.0744 ps=0.815 w=0.42 l=0.15
X6 X a_29_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.13 ps=1.11 w=0.65 l=0.15
X7 a_112_53# A a_29_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_29_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 VGND C a_184_53# VNB sky130_fd_pr__nfet_01v8 ad=0.13 pd=1.11 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
X0 VGND a_91_199# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.221 ps=1.98 w=0.65 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A a_245_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.135 ps=1.27 w=1 l=0.15
X3 a_91_199# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_245_297# B a_161_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_91_199# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.146 ps=1.34 w=0.42 l=0.15
X7 a_161_297# a_91_199# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.32 ps=2.64 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
X0 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X1 a_109_53# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_215_297# a_109_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_392_297# C a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0452 pd=0.635 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_465_297# B a_392_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.064 pd=0.725 as=0.0452 ps=0.635 w=0.42 l=0.15
X6 a_215_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 VPWR A a_465_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.064 ps=0.725 w=0.42 l=0.15
X8 a_297_297# a_109_53# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_109_53# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X10 VGND C a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.064 ps=0.725 w=0.42 l=0.15
X11 VGND A a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y A3 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_449_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 Y A3 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y B1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_449_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.263 ps=2.57 w=1 l=0.15
X8 Y B1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_31_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_297# A2 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.261 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 a_31_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 a_31_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_31_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_449_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X20 VGND A2 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 VGND A2 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VGND A3 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.223 pd=1.34 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_31_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.223 ps=1.34 w=0.65 l=0.15
X25 a_27_297# A2 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND A3 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 a_31_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X28 a_449_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 a_31_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 a_31_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
X0 VPWR a_30_53# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.315 pd=2.63 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND a_30_53# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_30_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X3 a_112_297# C a_30_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_30_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 VGND A a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 a_30_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 VGND C a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_184_297# B a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X9 VPWR A a_184_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
.ends

.subckt clarke VGND VPWR a[0] a[10] a[11] a[12] a[13] a[14] a[15] a[16] a[17] a[1]
+ a[2] a[3] a[4] a[5] a[6] a[7] a[8] a[9] alpha[0] alpha[10] alpha[11] alpha[12] alpha[13]
+ alpha[14] alpha[15] alpha[16] alpha[17] alpha[1] alpha[2] alpha[3] alpha[4] alpha[5]
+ alpha[6] alpha[7] alpha[8] alpha[9] b[0] b[10] b[11] b[12] b[13] b[14] b[15] b[16]
+ b[17] b[1] b[2] b[3] b[4] b[5] b[6] b[7] b[8] b[9] beta[0] beta[10] beta[11] beta[12]
+ beta[13] beta[14] beta[15] beta[16] beta[17] beta[1] beta[2] beta[3] beta[4] beta[5]
+ beta[6] beta[7] beta[8] beta[9] clk done rstb start
XFILLER_0_17_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer7 _0338_ VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1270_ _0323_ _0326_ VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__xor2_1
XFILLER_0_3_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1606_ _0630_ _0678_ _0676_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_14_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1399_ _0477_ net134 VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__nand2_1
X_1537_ _0583_ _0606_ _0605_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__a21boi_1
X_1468_ net25 net8 VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__nor2_1
XFILLER_0_49_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1253_ _0247_ _0376_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__xnor2_1
X_1322_ net22 net5 VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__or2_1
X_1184_ _0295_ _0307_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__xor2_4
XFILLER_0_6_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1940_ _0083_ _0099_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__nand2_1
X_1871_ _0842_ _0981_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1305_ _0414_ _0415_ _0420_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__a21oi_1
X_1236_ _0284_ _0358_ _0359_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__or3_4
XFILLER_0_19_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1167_ _0288_ _0246_ _0289_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__nand3_1
X_1098_ _0190_ _0218_ _0221_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__nand3_2
X_1021_ _0146_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__clkbuf_1
X_1923_ _0055_ _0082_ _0076_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__nor3_1
XFILLER_0_16_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1785_ _0868_ _0869_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__or2_1
X_1854_ _0921_ _0965_ _0966_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_24_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1219_ _0297_ _0305_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold41 net48 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold30 net59 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_38_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1570_ _0688_ _0689_ _0683_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__o21ai_2
Xrebuffer17 _0761_ VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1004_ net118 net17 net77 VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1768_ _0862_ _0883_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1837_ _0489_ _0589_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__xnor2_2
X_1906_ _0971_ _0067_ _0042_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1699_ _0814_ _0816_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__xor2_2
XFILLER_0_35_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput75 net75 VGND VGND VPWR VPWR done sky130_fd_sc_hd__clkbuf_4
Xoutput64 net64 VGND VGND VPWR VPWR beta[16] sky130_fd_sc_hd__clkbuf_4
Xoutput42 net42 VGND VGND VPWR VPWR alpha[12] sky130_fd_sc_hd__clkbuf_4
Xoutput53 net53 VGND VGND VPWR VPWR alpha[6] sky130_fd_sc_hd__clkbuf_4
X_1622_ _0690_ _0692_ _0737_ _0741_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__a211o_4
X_1553_ _0247_ _0215_ _0634_ _0633_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__a31o_1
X_1484_ _0583_ _0605_ _0606_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__and3_1
XFILLER_0_17_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer8 _0759_ VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__buf_1
X_1605_ _0674_ _0708_ _0709_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__and3_4
X_1536_ _0655_ _0656_ _0308_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1398_ _0476_ _0478_ _0519_ _0520_ _0521_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__a2111oi_2
X_1467_ _0585_ _0589_ _0541_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__a21o_1
XFILLER_0_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1252_ net86 _0240_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__nor2_1
X_1321_ net22 net5 VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__nand2_2
XFILLER_0_46_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1183_ _0193_ _0306_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1519_ _0639_ _0640_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__nand2_4
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1870_ _0842_ _0981_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1235_ _0356_ _0357_ _0316_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__a21oi_1
X_1304_ _0206_ _0426_ _0427_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__a21oi_1
X_1166_ _0288_ _0246_ _0289_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__a21o_1
X_1097_ _0219_ _0220_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__or2b_1
XFILLER_0_34_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1999_ clknet_2_3__leaf_clk _0027_ net84 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_8_Left_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1020_ net125 net8 net78 VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__mux2_1
X_1922_ _0055_ _0076_ _0082_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__o21a_1
X_1784_ _0873_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__inv_2
X_1853_ _0910_ _0913_ _0945_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_24_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1149_ _0266_ _0268_ _0272_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__a21o_1
X_1218_ net98 _0340_ _0332_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_47_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold20 net74 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 net43 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 net53 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_42_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer18 _0693_ VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__buf_2
XFILLER_0_16_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1003_ _0137_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1905_ _0943_ _0961_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__and2_1
X_1767_ _0863_ _0882_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__xor2_2
X_1836_ _0688_ _0689_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__nor2_2
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1698_ _0776_ _0780_ _0815_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_50_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput43 net43 VGND VGND VPWR VPWR alpha[13] sky130_fd_sc_hd__clkbuf_4
Xoutput65 net65 VGND VGND VPWR VPWR beta[17] sky130_fd_sc_hd__clkbuf_4
Xoutput54 net54 VGND VGND VPWR VPWR alpha[7] sky130_fd_sc_hd__clkbuf_4
X_1552_ net79 _0672_ _0673_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__a21oi_1
X_1621_ _0739_ _0740_ _0645_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__a21oi_2
X_1483_ _0602_ _0603_ _0604_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1819_ _0694_ _0932_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_37_Left_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer9 _0302_ VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1604_ net102 VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__inv_2
X_1535_ _0308_ _0655_ _0656_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__and3_1
X_1397_ _0474_ _0475_ _0436_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_38_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1466_ _0588_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__buf_4
XFILLER_0_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1320_ _0197_ _0198_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__nor2_2
X_1251_ _0366_ _0367_ _0374_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__a21o_1
X_1182_ _0297_ _0305_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_40_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1449_ _0477_ net76 _0567_ _0566_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__a31o_1
X_1518_ net26 net9 VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__nand2_2
XFILLER_0_10_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1303_ _0265_ _0252_ _0260_ _0417_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__and4_1
XPHY_EDGE_ROW_24_Left_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1234_ _0316_ _0356_ _0357_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__and3_1
X_1165_ _0245_ _0214_ VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__xnor2_1
X_1096_ net36 net2 VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1998_ clknet_2_3__leaf_clk _0026_ net84 VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_2_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1921_ _0077_ _0081_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__xor2_1
XFILLER_0_21_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1852_ _0913_ _0914_ _0946_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__or3b_2
X_1783_ _0889_ _0897_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_21_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1217_ _0332_ _0339_ _0340_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__or3_4
X_1079_ _0200_ _0195_ _0202_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__a21o_1
X_1148_ _0269_ _0271_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold21 net71 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__dlygate4sd3_1
Xhold32 net55 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 net61 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_38_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1002_ net123 net16 net77 VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__mux2_1
Xrebuffer19 _0169_ VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_44_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1835_ _0948_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__clkbuf_1
X_1904_ _0964_ _0043_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__or2b_1
X_1697_ _0779_ _0777_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__and2b_1
X_1766_ _0878_ _0881_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_11_Left_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput66 net66 VGND VGND VPWR VPWR beta[1] sky130_fd_sc_hd__clkbuf_4
Xoutput44 net44 VGND VGND VPWR VPWR alpha[14] sky130_fd_sc_hd__clkbuf_4
Xoutput55 net55 VGND VGND VPWR VPWR alpha[8] sky130_fd_sc_hd__clkbuf_4
X_1551_ net79 net108 VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__nor2_1
X_1620_ _0685_ net100 net96 VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__a21oi_2
X_1482_ _0602_ _0603_ _0604_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__nand3_1
X_1818_ _0930_ _0931_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__nand2_1
XFILLER_0_40_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_7_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1749_ _0202_ _0297_ _0836_ _0864_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__a31o_1
XFILLER_0_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1603_ _0668_ _0712_ _0713_ _0721_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__a31o_1
X_1465_ _0586_ _0587_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__nor2_1
X_1534_ _0652_ _0653_ _0654_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__a21o_1
XFILLER_0_22_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1396_ _0518_ _0516_ _0517_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__and3_1
XFILLER_0_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1250_ _0271_ _0368_ _0370_ _0373_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__a31o_1
X_1181_ _0300_ _0304_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_6_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1448_ _0571_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__clkbuf_1
X_1517_ net26 net9 VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__or2_1
XFILLER_0_10_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1379_ _0498_ _0499_ _0501_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1233_ _0354_ _0355_ _0319_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__a21o_1
X_1302_ _0158_ _0324_ _0262_ _0382_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__and4_1
X_1164_ _0236_ _0157_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__nand2_1
X_1095_ net36 net2 VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__nor2_1
X_1997_ clknet_2_3__leaf_clk _0025_ net84 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_34_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_41_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1920_ _0075_ _0080_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__xnor2_1
X_1851_ _0962_ _0963_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__nand2_1
X_1782_ _0895_ _0896_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__nor2_2
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1216_ _0337_ net92 _0305_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_47_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1147_ _0215_ _0269_ _0270_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__nand3_2
X_1078_ _0201_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__buf_2
XFILLER_0_47_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xhold22 net67 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_30_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold44 net50 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 net45 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_16_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1001_ _0136_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1903_ _0063_ _0064_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__nor2_1
X_1765_ _0879_ _0853_ _0880_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__o21bai_2
X_1834_ net126 _0947_ net79 VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1696_ _0810_ _0813_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput67 net67 VGND VGND VPWR VPWR beta[2] sky130_fd_sc_hd__buf_2
Xoutput45 net45 VGND VGND VPWR VPWR alpha[15] sky130_fd_sc_hd__clkbuf_4
Xoutput56 net56 VGND VGND VPWR VPWR alpha[9] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_26_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1550_ _0627_ _0671_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__xnor2_1
X_1481_ _0545_ _0547_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__nand2_2
XFILLER_0_17_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1817_ _0457_ _0585_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__or2_1
XFILLER_0_17_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1748_ _0545_ _0835_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__and2b_1
X_1679_ _0795_ _0796_ net112 _0797_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_48_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1602_ net80 net110 _0722_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__o21a_1
XFILLER_0_14_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1395_ _0516_ _0517_ _0518_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__a21oi_1
X_1464_ net99 _0536_ _0534_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__a21oi_1
X_1533_ _0652_ _0653_ _0654_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__nand3_1
XFILLER_0_13_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1180_ net95 _0303_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__nand2_2
XFILLER_0_46_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1516_ _0584_ _0597_ _0596_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__a21bo_1
X_1447_ net57 _0570_ net80 VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1378_ _0498_ _0499_ _0501_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__nand3_2
XFILLER_0_45_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout80 net81 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__buf_2
XFILLER_0_3_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1301_ _0385_ _0403_ _0388_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__nor3_1
X_1232_ _0319_ _0354_ _0355_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__nand3_1
XFILLER_0_19_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1163_ _0232_ _0254_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1094_ _0184_ _0187_ _0191_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__a21o_1
X_1996_ clknet_2_3__leaf_clk _0024_ net84 VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_42_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1781_ _0193_ _0637_ _0894_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__a21oi_1
X_1850_ _0943_ _0961_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__or2_1
XFILLER_0_24_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1215_ _0305_ _0337_ _0338_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__and3_1
X_1146_ _0170_ _0175_ _0205_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__a21o_1
XFILLER_0_47_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1077_ _0170_ _0175_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__and2_1
XFILLER_0_15_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1979_ clknet_2_1__leaf_clk _0007_ net82 VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__dfrtp_1
Xhold45 net39 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 net49 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__dlygate4sd3_1
Xhold23 net65 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_21_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1000_ net128 net15 net77 VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1902_ _0040_ _0062_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__and2_1
XFILLER_0_16_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1764_ _0850_ _0852_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__nor2_1
X_1833_ _0924_ _0946_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__xnor2_1
X_1695_ _0811_ _0812_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__xnor2_2
X_1129_ _0230_ _0231_ _0212_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__o21ai_1
Xoutput57 net57 VGND VGND VPWR VPWR beta[0] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_43_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput46 net46 VGND VGND VPWR VPWR alpha[16] sky130_fd_sc_hd__clkbuf_4
Xoutput68 net68 VGND VGND VPWR VPWR beta[3] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1480_ _0600_ _0601_ _0457_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1678_ net79 VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__inv_2
X_1747_ _0831_ _0854_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__and2b_1
XFILLER_0_7_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1816_ _0457_ _0585_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1601_ _0720_ _0721_ net80 VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__o21ai_1
X_1532_ _0457_ _0601_ _0600_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_22_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1394_ _0317_ _0473_ _0472_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_38_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1463_ _0534_ _0535_ _0536_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__and3_1
XFILLER_0_9_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1515_ _0337_ _0338_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__and2_2
X_1446_ _0523_ _0569_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__xnor2_1
X_1377_ _0305_ _0500_ _0454_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__a21o_1
XFILLER_0_36_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout81 net38 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__clkbuf_4
X_1300_ _0389_ _0402_ _0423_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__a21o_1
X_1162_ _0284_ _0285_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__nand2_1
X_1231_ _0352_ _0353_ _0321_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__a21o_1
XFILLER_0_35_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1093_ _0180_ _0181_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__nand2_1
XFILLER_0_42_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1995_ clknet_2_3__leaf_clk _0023_ net84 VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_27_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1429_ _0550_ _0551_ _0531_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_2_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_28_Left_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1780_ _0193_ _0637_ _0894_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__and3_1
XFILLER_0_21_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1214_ _0298_ _0333_ _0336_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__a21o_1
X_1145_ _0170_ _0175_ _0206_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__nand3_1
XFILLER_0_47_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1076_ _0197_ _0198_ _0199_ VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__or3_1
X_1978_ clknet_2_1__leaf_clk _0006_ net82 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__dfrtp_1
Xhold24 net68 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 net44 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 net56 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_38_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1901_ _0040_ _0062_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__nor2_1
X_1832_ _0910_ _0945_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__xor2_1
X_1694_ _0586_ _0587_ _0778_ _0739_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__o31a_1
X_1763_ _0832_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__inv_2
X_1128_ _0250_ _0251_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__nor2_1
X_1059_ _0163_ _0173_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput69 net69 VGND VGND VPWR VPWR beta[4] sky130_fd_sc_hd__clkbuf_4
Xoutput58 net58 VGND VGND VPWR VPWR beta[10] sky130_fd_sc_hd__buf_2
Xoutput47 net47 VGND VGND VPWR VPWR alpha[17] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_27_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1815_ _0927_ _0928_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1677_ _0793_ _0794_ _0789_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__o21a_1
X_1746_ _0856_ _0858_ _0861_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_7_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_15_Left_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1600_ _0717_ _0719_ _0716_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_38_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1462_ _0584_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__clkbuf_4
X_1531_ _0650_ _0651_ _0637_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__a21o_1
XFILLER_0_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1393_ _0514_ _0515_ _0438_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_49_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1729_ _0844_ _0845_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__nor2_1
XFILLER_0_24_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1445_ _0566_ _0568_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__nor2_1
X_1514_ _0576_ _0635_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1376_ _0337_ net93 _0453_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__a21o_1
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout82 net83 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_19_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1161_ net1 _0250_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__or2_1
X_1230_ _0321_ _0352_ _0353_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__nand3_1
X_1092_ _0202_ _0195_ _0194_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__a21o_1
X_1994_ clknet_2_3__leaf_clk _0022_ net84 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_27_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1428_ _0531_ _0550_ _0551_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__and3_1
X_1359_ _0371_ _0482_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__or2_1
XFILLER_0_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_3_Left_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1213_ _0298_ _0333_ _0336_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__nand3_2
X_1075_ _0188_ _0191_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__xor2_4
X_1144_ _0267_ _0207_ _0206_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__a21o_1
X_1977_ clknet_2_1__leaf_clk _0005_ net83 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_45_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold36 net51 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 net63 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_16_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1900_ _0060_ _0061_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__or2_1
X_1831_ _0943_ _0944_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__nor2_1
X_1693_ _0594_ _0595_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__nand2_4
X_1762_ _0866_ _0877_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__xnor2_2
X_1127_ _0249_ _0238_ _0244_ VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__and3_1
X_1058_ _0168_ _0177_ _0178_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__nand3_1
XFILLER_0_7_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput48 net48 VGND VGND VPWR VPWR alpha[1] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput59 net59 VGND VGND VPWR VPWR beta[11] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_26_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1745_ _0829_ _0855_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__and2b_1
XFILLER_0_25_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1814_ _0742_ _0743_ _0839_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__a21oi_1
X_1676_ _0789_ _0793_ _0794_ net80 VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__o31ai_1
XPHY_EDGE_ROW_32_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1392_ _0438_ _0514_ _0515_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__or3_1
X_1461_ _0494_ _0495_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__and2_1
X_1530_ _0637_ _0650_ _0651_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__nand3_1
XFILLER_0_13_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1728_ _0840_ _0843_ _0838_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__a21oi_1
X_1659_ _0739_ _0740_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__nand2_4
XFILLER_0_48_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1444_ _0520_ _0567_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__nor2_1
X_1513_ _0633_ _0634_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__and2b_1
XFILLER_0_4_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1375_ _0496_ _0497_ _0489_ VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_45_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout83 net37 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__clkbuf_4
X_1160_ net1 _0250_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1091_ _0214_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__buf_2
X_1993_ clknet_2_3__leaf_clk _0021_ net84 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_27_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1358_ _0480_ _0481_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__nand2_1
X_1427_ _0547_ _0548_ _0549_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__a21o_1
X_1289_ _0403_ _0405_ _0412_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__a21o_1
XFILLER_0_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1212_ _0334_ _0335_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__or2b_1
X_1074_ _0166_ _0170_ _0179_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__a21oi_1
X_1143_ _0176_ _0197_ _0198_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__or3_1
XFILLER_0_47_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1976_ clknet_2_1__leaf_clk _0004_ net83 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold26 net70 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 net54 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_46_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1830_ _0925_ _0905_ _0942_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__and3_1
X_1761_ _0874_ _0876_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__xnor2_2
X_1692_ _0545_ _0546_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__nand2_1
X_1126_ _0238_ _0244_ _0249_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_7_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1057_ _0166_ _0170_ _0179_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1959_ _0100_ _0105_ _0117_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__nand3_1
Xoutput49 net49 VGND VGND VPWR VPWR alpha[2] sky130_fd_sc_hd__clkbuf_4
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
X_1744_ _0860_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_7_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1813_ _0839_ _0742_ _0743_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__and3_1
XFILLER_0_40_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1675_ _0622_ _0671_ _0791_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1109_ net19 net10 VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1391_ _0512_ _0513_ _0479_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_38_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1460_ _0228_ _0229_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__and2_1
X_1727_ _0838_ _0840_ _0843_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__and3_1
X_1658_ _0585_ _0743_ _0742_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__a21bo_1
X_1589_ _0674_ _0708_ _0709_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__nand3_2
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1512_ _0228_ _0632_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1443_ _0564_ _0565_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__and2b_1
X_1374_ _0489_ _0496_ _0497_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__or3_1
XFILLER_0_36_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout84 net85 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_19_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1090_ _0165_ _0213_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__nor2_2
X_1992_ clknet_2_3__leaf_clk _0020_ net84 VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_2_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1288_ _0399_ _0406_ _0411_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__and3_1
X_1357_ net1 _0237_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__or2_1
X_1426_ _0547_ _0548_ _0549_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__nand3_1
XFILLER_0_33_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1211_ net21 net4 VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__nand2_1
X_1142_ _0208_ _0265_ _0207_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__or3b_4
XFILLER_0_47_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1073_ _0166_ _0170_ _0179_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__and3_1
X_1975_ clknet_2_1__leaf_clk _0003_ net83 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold27 net75 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__dlygate4sd3_1
Xhold38 net41 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dlygate4sd3_1
X_1409_ net24 net7 VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__nand2_2
XFILLER_0_46_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1760_ _0837_ _0849_ _0875_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__a21o_1
X_1691_ _0769_ _0808_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__xnor2_2
X_1125_ _0246_ _0248_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__nand2_1
X_1056_ _0166_ _0170_ _0179_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__nand3_2
Xoutput39 net39 VGND VGND VPWR VPWR alpha[0] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_43_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1958_ _0107_ _0116_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__xnor2_1
X_1889_ _0839_ _0049_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__nand2_1
XFILLER_0_34_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1674_ _0760_ _0761_ _0790_ _0791_ _0792_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__a32o_2
X_1743_ net72 _0859_ net79 VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1812_ _0650_ _0893_ _0895_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__o21ba_1
X_1108_ _0212_ _0230_ _0231_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__or3_1
X_1039_ _0159_ _0162_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1390_ _0479_ _0512_ _0513_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__and3_1
XFILLER_0_38_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1588_ _0706_ _0707_ _0660_ _0662_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__o211ai_2
X_1726_ _0683_ _0842_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__nand2_2
XFILLER_0_13_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1657_ _0502_ net138 VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__and2_1
XFILLER_0_48_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_2_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_39_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1442_ _0564_ _0565_ _0520_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__and3b_1
X_1511_ _0228_ _0632_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1373_ _0494_ _0495_ _0452_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__a21oi_1
X_1709_ _0798_ _0796_ _0825_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__or3_1
Xfanout85 net37 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__clkbuf_4
X_1991_ clknet_2_3__leaf_clk _0019_ net84 VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__dfrtp_1
X_1425_ _0193_ net138 _0502_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__a21bo_1
XPHY_EDGE_ROW_50_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1287_ net86 _0409_ _0410_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__a21bo_1
X_1356_ net1 _0237_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1210_ net21 net4 VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__nor2_1
X_1072_ _0176_ _0194_ _0195_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__or3b_1
X_1141_ _0173_ _0204_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__xnor2_4
X_1974_ clknet_2_1__leaf_clk _0002_ net83 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_30_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1408_ net24 net7 VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__nor2_1
Xhold39 net46 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dlygate4sd3_1
Xhold28 net52 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__dlygate4sd3_1
X_1339_ _0460_ _0461_ _0444_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_7_Left_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1690_ _0806_ _0807_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__nor2_1
X_1124_ _0247_ _0245_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__or2_1
X_1055_ _0177_ _0178_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1957_ _0114_ _0115_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__nand2_1
X_1888_ _0839_ _0049_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__or2_1
XFILLER_0_19_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1811_ _0898_ _0901_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__or2_1
X_1673_ _0718_ _0626_ _0670_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__o21a_1
X_1742_ _0856_ _0858_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__xor2_1
XFILLER_0_25_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1107_ _0228_ _0229_ _0215_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1038_ net31 net14 VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__nor2_1
X_1725_ _0841_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_13_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1587_ _0660_ _0662_ _0706_ _0707_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__a211o_4
XFILLER_0_0_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1656_ _0729_ _0774_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_28_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_36_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1441_ _0561_ _0562_ _0563_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__a21o_1
X_1510_ _0630_ _0631_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1372_ _0452_ _0494_ _0495_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__and3_1
X_1708_ _0798_ _0796_ _0825_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_5_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1639_ _0756_ _0757_ _0726_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__a21o_1
Xfanout86 net1 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__buf_2
XFILLER_0_36_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1990_ clknet_2_0__leaf_clk _0018_ net83 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_27_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1355_ _0440_ _0469_ _0468_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__a21bo_1
X_1424_ _0545_ _0546_ _0297_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__a21o_1
X_1286_ _0407_ _0408_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_39_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1140_ _0211_ _0210_ _0158_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__a21oi_1
X_1071_ _0180_ _0181_ _0193_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__a21o_1
X_1973_ clknet_2_1__leaf_clk _0001_ net83 VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_23_Left_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1407_ _0211_ _0210_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__and2_1
Xhold29 net47 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__dlygate4sd3_1
Xhold18 net60 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dlygate4sd3_1
X_1338_ _0444_ _0460_ _0461_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__nand3_1
X_1269_ _0371_ _0372_ _0247_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_46_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1123_ _0234_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__clkbuf_4
X_1054_ net34 net17 VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__or2_1
XFILLER_0_43_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1956_ _0112_ _0113_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__or2_1
XFILLER_0_7_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1887_ _0047_ _0048_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__and2_1
XFILLER_0_11_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1741_ _0796_ _0825_ _0857_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__a21bo_1
X_1810_ _0915_ _0921_ _0913_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_40_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1672_ _0762_ _0763_ _0714_ _0715_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__o211a_1
XFILLER_0_7_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1106_ _0215_ _0228_ _0229_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__and3_1
X_1037_ net30 net13 VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1939_ _0097_ _0098_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_10_Left_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1724_ _0685_ net97 VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__or2_1
X_1586_ _0704_ _0705_ _0679_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__a21oi_1
X_1655_ _0772_ _0773_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__nor2_1
XFILLER_0_39_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1440_ _0561_ _0562_ _0563_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__and3_1
X_1371_ _0445_ _0490_ _0493_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__nand3_2
XFILLER_0_45_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1707_ _0799_ _0824_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__xor2_1
X_1638_ _0726_ _0756_ _0757_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__nand3_2
XFILLER_0_30_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1569_ _0683_ _0688_ _0689_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__or3_4
XFILLER_0_36_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1354_ _0360_ _0361_ _0314_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__a21oi_1
X_1285_ _0407_ _0408_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__xor2_1
X_1423_ _0297_ _0545_ _0546_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__nand3_2
XFILLER_0_33_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1070_ _0180_ _0181_ _0193_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__and3_1
X_1972_ clknet_2_3__leaf_clk _0000_ net84 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1268_ _0378_ _0391_ _0377_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__o21ba_1
X_1406_ _0528_ _0529_ VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__nor2_1
Xhold19 net62 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__dlygate4sd3_1
X_1337_ _0456_ _0458_ _0459_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__a21o_1
X_1199_ _0157_ _0322_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_40_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1122_ _0234_ _0245_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1053_ net34 net17 VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__nand2_1
XFILLER_0_43_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1955_ _0112_ _0113_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__nand2_1
X_1886_ _0585_ _0645_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__or2_1
XFILLER_0_34_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1671_ _0712_ _0714_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__nand2_1
X_1740_ _0799_ _0798_ _0824_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_4_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1105_ _0226_ _0227_ _0216_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__a21o_1
X_1036_ net32 net15 _0159_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__a21o_1
X_1938_ _0077_ _0081_ _0093_ _0053_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__a2bb2o_1
X_1869_ _0974_ _0980_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1723_ _0645_ _0839_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1654_ _0460_ _0771_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__and2_1
X_1585_ _0679_ _0704_ _0705_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__and3_4
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1019_ _0145_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1370_ _0445_ _0490_ _0493_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__a21o_1
XFILLER_0_45_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1637_ _0754_ _0755_ _0727_ _0706_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__a211o_4
X_1706_ _0801_ _0823_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1499_ _0572_ _0620_ _0621_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__and3_1
X_1568_ _0640_ net89 _0687_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__a21oi_2
Xfanout77 net78 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__clkbuf_4
X_1422_ _0541_ _0542_ _0543_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__o21ai_2
X_1353_ _0362_ _0435_ _0476_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__or3b_4
X_1284_ net86 _0293_ _0290_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__a21bo_1
X_0999_ _0135_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_1_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1971_ net81 net109 _0128_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__o21ba_4
XFILLER_0_15_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1405_ _0480_ _0527_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput1 a[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__dlymetal6s2s_1
X_1267_ _0366_ _0367_ _0374_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__a21oi_1
X_1198_ _0265_ _0214_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__xnor2_2
X_1336_ _0456_ _0458_ _0459_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__nand3_2
XFILLER_0_46_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1121_ _0236_ _0157_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__xor2_2
X_1052_ _0170_ _0175_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__nand2_2
XFILLER_0_28_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1954_ _0839_ _0080_ _0092_ _0095_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__a31o_1
XFILLER_0_7_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1885_ _0585_ _0645_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1319_ _0202_ _0346_ _0345_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1670_ _0760_ _0788_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1104_ _0216_ _0226_ _0227_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__nand3_2
XFILLER_0_17_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1035_ net31 net14 VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__and2_1
X_1937_ _0095_ _0096_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__nor2_1
X_1868_ _0978_ _0979_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__and2_1
X_1799_ _0886_ _0912_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__and2_1
XFILLER_0_22_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1584_ _0701_ _0702_ _0703_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__o21ai_1
X_1722_ _0685_ net97 VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__nor2_2
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1653_ _0460_ _0771_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1018_ net119 net7 net77 VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1705_ _0802_ _0822_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__xor2_1
XFILLER_0_5_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1636_ _0727_ _0706_ _0754_ _0755_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__o211ai_2
X_1567_ _0640_ _0684_ _0687_ VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__and3_4
X_1498_ _0618_ _0619_ _0564_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__a21o_1
Xfanout78 net38 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_44_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1421_ _0544_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__buf_6
X_1352_ _0436_ _0474_ _0475_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__nand3_1
X_1283_ _0241_ _0394_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0998_ net114 net14 net78 VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__mux2_1
X_1619_ _0738_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_49_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1970_ _0105_ _0117_ _0126_ _0127_ net81 VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_23_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1404_ _0480_ _0527_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__nor2_1
X_1335_ _0332_ _0340_ _0339_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__o21bai_1
X_1266_ _0378_ _0375_ _0377_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__and3b_1
X_1197_ _0293_ _0310_ _0320_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__a21o_1
Xinput2 a[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_1
XFILLER_0_46_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_27_Left_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1120_ _0241_ _0243_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__or2_1
X_1051_ _0165_ _0173_ _0168_ _0174_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__a211o_1
XFILLER_0_28_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1953_ _0108_ _0111_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__xnor2_1
X_1884_ _0974_ _0980_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__or2b_1
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1318_ _0371_ _0372_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__and2_1
X_1249_ _0247_ _0371_ _0372_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__and3_1
XFILLER_0_34_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1034_ _0157_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__clkbuf_4
X_1103_ _0224_ _0225_ _0217_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__o21ai_2
X_1936_ _0078_ _0091_ _0094_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__and3_1
X_1867_ _0739_ _0977_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__nand2_1
XFILLER_0_16_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1798_ _0886_ _0912_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__nor2_1
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1721_ _0600_ _0601_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__and2_1
X_1583_ _0701_ _0702_ _0703_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__or3_4
XFILLER_0_21_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1652_ _0769_ _0770_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1017_ _0144_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_14_Left_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1919_ _0078_ _0079_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__and2_1
XFILLER_0_8_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1704_ _0818_ _0821_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__xor2_2
XFILLER_0_5_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1497_ _0564_ _0618_ _0619_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__nand3_1
X_1635_ _0752_ _0753_ _0735_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__a21o_1
X_1566_ _0685_ _0686_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__or2b_1
XFILLER_0_36_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout79 net80 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1351_ _0472_ _0473_ _0317_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__a21o_1
X_1420_ _0541_ _0542_ _0543_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__or3_4
X_1282_ _0396_ _0398_ _0397_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_25_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0997_ _0134_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__clkbuf_1
X_1618_ _0685_ _0688_ _0689_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__or3_1
X_1549_ _0618_ _0670_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_49_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1265_ _0383_ _0380_ _0382_ VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__nand3_1
X_1403_ _0274_ _0526_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__xnor2_1
X_1334_ _0454_ _0455_ _0457_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__o21bai_1
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1196_ _0294_ _0309_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 a[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_1
XFILLER_0_46_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_2_Left_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1050_ net136 _0160_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__and2_1
X_1952_ _0843_ _0109_ _0110_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__and3_1
X_1883_ net81 net104 _0044_ _0045_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__o22a_1
XFILLER_0_11_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1317_ _0329_ _0351_ _0350_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__o21bai_1
X_1248_ _0271_ _0368_ _0370_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1179_ _0190_ _0220_ _0219_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_44_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xmax_cap76 net133 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__clkbuf_1
X_1102_ _0217_ _0224_ _0225_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__or3_4
X_1033_ _0150_ _0156_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__xnor2_4
X_1935_ _0078_ _0091_ _0094_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_3_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1866_ _0739_ _0977_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__or2_1
XFILLER_0_16_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1797_ _0910_ _0911_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1720_ _0803_ _0836_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__xnor2_2
X_1651_ _0199_ _0265_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__nand2_1
X_1582_ _0308_ _0656_ _0655_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_44_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1016_ net121 net6 net77 VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__mux2_1
X_1918_ _0779_ _0047_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__nand2_1
X_1849_ _0943_ _0961_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_31_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1634_ _0735_ _0752_ _0753_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__nand3_1
X_1703_ _0775_ _0819_ _0820_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__a21oi_2
X_1496_ _0616_ _0617_ _0573_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__a21o_1
X_1565_ net9 net27 VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1281_ _0389_ _0402_ _0401_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__a21o_1
X_1350_ _0317_ _0472_ _0473_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__nand3_1
XFILLER_0_25_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_0996_ net122 net13 net78 VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1617_ _0686_ net90 _0640_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__and3b_2
X_1548_ _0668_ _0669_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1479_ _0457_ _0600_ _0601_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__nand3_1
XFILLER_0_49_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1402_ _0524_ _0525_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1264_ _0282_ _0363_ _0384_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_46_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput4 a[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_1
X_1333_ _0305_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__buf_2
XFILLER_0_46_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1195_ _0317_ _0318_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__nor2_1
Xclkbuf_2_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_14_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1951_ _0646_ _0647_ _0842_ _0092_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__a211o_1
X_1882_ _0962_ _0970_ _0043_ _0797_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__a31o_1
XFILLER_0_22_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1316_ _0438_ _0439_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__and2_1
X_1247_ _0271_ _0368_ _0370_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__nand3_2
X_1178_ _0184_ _0187_ _0301_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__a21o_1
XFILLER_0_6_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1032_ _0151_ _0154_ _0155_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__a21oi_2
X_1101_ _0222_ _0223_ _0192_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_33_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1934_ _0092_ _0093_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__xor2_1
X_1865_ _0975_ _0976_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__or2_1
X_1796_ _0907_ _0909_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__and2_1
X_1581_ _0699_ net101 _0680_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_13_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1650_ _0193_ _0206_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1015_ _0143_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1917_ _0779_ _0047_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__or2_1
XFILLER_0_8_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1779_ _0650_ _0893_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__xor2_1
X_1848_ _0959_ _0960_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__xor2_1
XFILLER_0_49_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1633_ _0749_ _0750_ _0751_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__a21o_1
X_1702_ _0781_ _0782_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__nor2_1
X_1564_ net9 net27 VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__nor2_2
X_1495_ _0573_ _0616_ _0617_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__nand3_4
XFILLER_0_39_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1280_ _0385_ _0388_ _0403_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__o21a_1
XFILLER_0_25_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0995_ _0133_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1547_ _0666_ _0667_ _0614_ _0616_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__o211a_1
X_1616_ _0460_ _0461_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__and2_1
X_1478_ _0598_ _0599_ _0590_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1401_ _0158_ _0240_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__or2_1
X_1263_ _0385_ _0386_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__nor2_1
X_1194_ _0241_ _0290_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__and2_1
Xinput5 a[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__buf_1
X_1332_ _0454_ _0455_ _0305_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__or3b_4
XFILLER_0_46_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1950_ _0646_ _0647_ _0839_ _0092_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__nand4_1
XFILLER_0_7_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1881_ _0962_ _0970_ _0043_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__a21oi_1
X_1315_ _0247_ _0327_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1246_ _0158_ _0322_ _0369_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1177_ _0191_ _0221_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1031_ net29 net12 VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__and2_1
X_1100_ _0192_ _0222_ _0223_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__and3_1
X_1933_ _0842_ _0080_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__nor2_1
Xinput30 b[3] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__buf_1
XFILLER_0_3_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1864_ _0453_ _0682_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__nor2_1
X_1795_ _0907_ _0909_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__nor2_1
X_1229_ _0350_ _0351_ _0329_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1580_ _0680_ _0699_ _0700_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__and3_1
XFILLER_0_48_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1014_ net117 net5 net77 VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__mux2_1
X_1916_ _0891_ _0811_ _0052_ _0051_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__o31a_1
XFILLER_0_8_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1847_ _0937_ _0938_ _0940_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__o21a_1
XFILLER_0_8_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1778_ _0890_ _0892_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1701_ _0781_ _0782_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__nand2_1
X_1494_ _0614_ _0615_ _0574_ _0528_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__a211o_4
X_1632_ _0749_ _0750_ _0751_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__nand3_1
X_1563_ _0535_ _0536_ _0642_ _0643_ _0641_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__a311o_1
XPHY_EDGE_ROW_18_Left_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0994_ net130 net12 net78 VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1546_ _0614_ _0616_ _0666_ _0667_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__a211oi_2
X_1615_ _0728_ _0734_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1477_ _0590_ _0598_ _0599_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__nand3_4
XFILLER_0_49_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1400_ _0158_ _0240_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__nand2_1
X_1331_ _0337_ _0338_ _0453_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__a21oi_1
X_1262_ _0313_ _0283_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__xnor2_1
X_1193_ _0241_ _0290_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__nor2_1
Xinput6 a[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_1
XFILLER_0_46_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1529_ _0648_ _0649_ _0638_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__a21o_1
XFILLER_0_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1880_ _0971_ _0042_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__xor2_1
XFILLER_0_36_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1314_ _0247_ _0327_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1245_ _0206_ _0215_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__and2_1
X_1176_ _0298_ _0299_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__nand2_2
XFILLER_0_2_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_6_Left_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1030_ net19 net10 _0152_ _0153_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__a31o_4
XFILLER_0_33_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput20 b[10] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__buf_1
X_1932_ _0811_ _0089_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__xnor2_2
X_1863_ _0891_ _0811_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__nor2_1
Xinput31 b[4] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__clkbuf_1
X_1794_ _0866_ _0877_ _0908_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_48_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1228_ _0329_ _0350_ _0351_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__or3_4
X_1159_ _0279_ _0282_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__and2b_1
XFILLER_0_15_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1013_ _0142_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__clkbuf_1
X_1915_ _0981_ _0075_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__and2_1
X_1777_ _0332_ _0891_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__nand2_1
X_1846_ _0957_ _0958_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_9_Left_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1700_ _0809_ _0817_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__xnor2_2
X_1631_ _0680_ _0700_ _0699_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__a21bo_1
X_1493_ _0574_ _0528_ _0614_ _0615_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__o211ai_4
X_1562_ _0641_ _0644_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__xor2_2
XFILLER_0_44_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1829_ _0925_ _0905_ _0942_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_3_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_35_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0993_ _0132_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_41_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1614_ _0732_ _0733_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__and2b_1
X_1545_ _0664_ _0665_ _0579_ _0628_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__o211a_1
XFILLER_0_5_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1476_ _0596_ _0597_ _0584_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1261_ _0282_ _0363_ _0384_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__and3_1
X_1330_ _0337_ _0338_ _0453_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__and3_1
X_1192_ _0286_ _0312_ _0315_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_36_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput7 a[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_1
XFILLER_0_46_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1459_ _0524_ _0581_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__xnor2_1
X_1528_ _0638_ _0648_ _0649_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__nand3_4
XFILLER_0_37_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1313_ _0319_ _0355_ _0354_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__a21bo_1
X_1244_ _0269_ _0270_ _0215_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_22_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1175_ net20 net3 VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__or2_1
XFILLER_0_33_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput10 a[1] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_1
X_1931_ _0089_ _0090_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__nand2_1
Xinput21 b[11] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__buf_1
X_1862_ _0637_ _0589_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__nand2_1
X_1793_ _0874_ _0876_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__nand2_1
Xinput32 b[5] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__buf_1
X_1158_ _0280_ _0279_ _0281_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__or3_1
XFILLER_0_42_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1227_ _0347_ _0349_ _0331_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__a21oi_1
X_1089_ _0161_ _0164_ _0163_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1012_ net42 net4 net77 VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__mux2_1
XFILLER_0_44_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1914_ _0842_ _0053_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__nor2_1
X_1776_ _0447_ _0451_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__xor2_2
X_1845_ _0955_ _0956_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__and2_1
XFILLER_0_47_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1630_ _0747_ _0748_ _0736_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__a21o_1
X_1492_ _0612_ _0613_ net137 _0575_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__o211ai_4
X_1561_ _0594_ _0595_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__and2_2
XFILLER_0_29_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1828_ _0940_ _0941_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__nand2_1
X_1759_ _0848_ _0846_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__and2b_1
XFILLER_0_35_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0992_ net120 net11 net78 VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__mux2_1
XFILLER_0_41_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1544_ _0579_ _0628_ _0664_ _0665_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_26_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1613_ _0348_ _0731_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__nand2_1
X_1475_ _0585_ _0596_ _0597_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__nand3_2
XFILLER_0_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1260_ _0380_ _0382_ _0383_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__a21bo_1
X_1191_ _0287_ _0311_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput8 a[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_1
X_1527_ _0646_ _0647_ _0589_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__a21o_1
X_1389_ _0510_ _0511_ _0485_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__a21o_1
X_1458_ _0579_ _0580_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__and2_1
XFILLER_0_20_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1312_ _0284_ _0359_ _0358_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__o21bai_1
X_1243_ _0274_ _0273_ _0237_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__a21o_1
X_1174_ net20 net3 VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__nand2_2
XFILLER_0_42_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1930_ _0589_ _0949_ _0839_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__o21a_1
Xinput11 a[2] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_6
Xinput22 b[12] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__buf_1
X_1861_ _0949_ _0952_ _0737_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__a21oi_1
X_1792_ _0905_ _0906_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__nand2_1
Xinput33 b[6] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__buf_1
X_1157_ _0254_ _0255_ _0278_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__a21oi_1
X_1226_ _0331_ _0347_ _0349_ VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__and3_1
X_1088_ _0158_ _0210_ _0211_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_44_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1011_ _0141_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1913_ _0065_ _0070_ _0063_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__a21o_1
XFILLER_0_8_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1775_ _0297_ _0453_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__nand2_1
X_1844_ _0955_ _0956_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__nor2_1
X_1209_ _0302_ _0303_ _0300_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1560_ _0589_ _0647_ _0646_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_39_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1491_ _0555_ _0575_ _0612_ _0613_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__a211o_4
X_1827_ _0939_ _0926_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__or2b_1
X_1758_ _0870_ _0873_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__xnor2_2
X_1689_ _0502_ _0805_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__and2_1
XFILLER_0_50_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0991_ _0131_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_26_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1543_ _0662_ _0663_ _0629_ _0612_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__a211oi_2
X_1612_ _0348_ _0731_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1474_ _0594_ _0595_ _0588_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1190_ _0283_ _0313_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__and2b_1
XFILLER_0_36_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput9 a[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_46_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1457_ _0211_ _0578_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__nand2_1
X_1526_ _0589_ _0646_ _0647_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__nand3_2
X_1388_ _0485_ _0510_ _0511_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__nand3_2
XFILLER_0_26_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1311_ _0387_ _0404_ _0433_ _0434_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__o31ai_1
X_1242_ _0237_ _0274_ _0273_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__nand3_1
XFILLER_0_2_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1173_ _0296_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__buf_2
XFILLER_0_6_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1509_ _0237_ _0206_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__or2_1
XFILLER_0_33_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1860_ _0953_ _0954_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__and2_1
Xinput12 a[3] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_1
Xinput23 b[13] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__clkbuf_1
Xinput34 b[7] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__buf_1
X_1791_ _0902_ _0904_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__nand2_1
XFILLER_0_24_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1156_ _0260_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__inv_2
X_1225_ _0348_ _0346_ _0202_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__a21o_1
X_1087_ _0196_ _0203_ _0209_ VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__nand3_2
X_1989_ clknet_2_0__leaf_clk _0017_ net83 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_2_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1010_ net124 net3 net77 VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__mux2_1
X_1912_ net81 _0071_ _0072_ _0073_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__a31o_1
X_1843_ _0694_ _0932_ _0934_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_12_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1774_ _0887_ _0888_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__xnor2_2
X_1208_ _0222_ _0223_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__nand2_2
XFILLER_0_20_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1139_ _0158_ _0211_ _0210_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__and3_1
X_1490_ _0610_ _0611_ _0582_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__a21oi_2
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1826_ _0926_ _0939_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__or2b_1
XFILLER_0_20_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1757_ _0833_ _0872_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__xnor2_2
X_1688_ _0502_ _0805_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_0990_ net127 net10 net78 VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__mux2_1
XFILLER_0_26_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1611_ _0729_ _0730_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__nand2_1
X_1542_ _0629_ _0612_ _0662_ _0663_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__o211a_2
XFILLER_0_5_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1473_ _0589_ _0594_ _0595_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__nand3_1
XFILLER_0_49_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1809_ net79 _0922_ _0923_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_48_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1456_ _0211_ _0578_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__or2_2
X_1387_ _0508_ _0509_ _0486_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__a21o_1
X_1525_ _0594_ _0595_ _0645_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__a21o_2
X_2008_ clknet_2_2__leaf_clk _0036_ net85 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_45_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1310_ _0385_ _0386_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1241_ _0277_ _0276_ _0262_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__a21o_1
X_1172_ _0222_ _0223_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__and2_1
XFILLER_0_27_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1439_ _0438_ _0515_ _0514_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__o21bai_1
X_1508_ _0237_ _0206_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput13 a[4] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_26_Left_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1790_ _0902_ _0904_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__or2_1
Xinput24 b[14] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_1
Xinput35 b[8] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__buf_1
X_1224_ _0341_ _0342_ _0344_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__nand3_2
X_1155_ _0254_ _0255_ _0278_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__and3_1
X_1086_ _0196_ _0203_ _0209_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__a21o_1
X_1988_ clknet_2_0__leaf_clk _0016_ net82 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_2_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_21_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1773_ _0867_ _0778_ _0739_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__o21ai_4
X_1842_ _0953_ _0954_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__xnor2_1
X_1911_ _0797_ net129 VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__and2_1
X_1207_ _0206_ _0308_ _0330_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__a21o_1
XFILLER_0_47_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1138_ _0260_ _0261_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__nor2_1
XFILLER_0_7_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1069_ _0192_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_38_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_29_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1825_ _0937_ _0938_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__xor2_1
X_1756_ _0600_ _0871_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_13_Left_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1687_ _0803_ _0804_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1610_ _0217_ _0324_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__nand2_1
X_1541_ _0660_ _0661_ _0636_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__a21o_1
X_1472_ _0533_ _0538_ _0593_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__a21o_2
XFILLER_0_49_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1739_ _0829_ _0855_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__xnor2_2
X_1808_ net79 net106 VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1524_ _0594_ _0595_ _0645_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__nand3_2
X_1386_ _0486_ _0508_ _0509_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__nand3_2
X_1455_ _0576_ _0577_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__nand2_1
X_2007_ clknet_2_2__leaf_clk _0035_ net85 VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_45_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1240_ _0277_ _0262_ _0276_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__nand3_1
X_1171_ _0224_ _0226_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__or2b_2
XFILLER_0_42_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1507_ _0607_ _0608_ _0609_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__nor3_1
XFILLER_0_49_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1438_ _0559_ _0560_ _0483_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_37_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1369_ _0491_ _0492_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__nand2_1
XFILLER_0_33_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_1_Left_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput14 a[5] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_1
Xinput36 b[9] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
Xinput25 b[15] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_1
X_1154_ _0262_ _0276_ _0277_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__a21bo_1
X_1223_ _0176_ _0345_ _0346_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__or3b_4
X_1085_ _0206_ _0207_ _0208_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__a21o_1
X_1987_ clknet_2_0__leaf_clk _0015_ net82 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_30_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_43_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1910_ _0065_ _0070_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__or2_1
XFILLER_0_8_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1841_ _0929_ _0936_ _0927_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__a21o_1
X_1772_ _0694_ _0695_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1137_ _0257_ _0259_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__and2_1
X_1206_ _0295_ _0307_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__and2_1
X_1068_ _0188_ _0191_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1755_ _0199_ _0489_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__xnor2_2
X_1824_ _0694_ _0695_ _0888_ _0889_ _0897_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__a32oi_4
X_1686_ _0176_ _0332_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1540_ _0636_ _0660_ _0661_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__nand3_2
XPHY_EDGE_ROW_30_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1471_ _0533_ _0538_ _0593_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__nand3_4
X_1807_ _0915_ _0921_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_17_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1669_ _0767_ _0787_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__xnor2_1
X_1738_ _0831_ _0854_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1454_ _0247_ _0215_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__or2_1
X_1523_ _0641_ _0644_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__xnor2_4
X_1385_ _0506_ _0507_ _0487_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__a21o_1
X_2006_ clknet_2_2__leaf_clk _0034_ net85 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_45_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1170_ _0216_ _0226_ _0227_ _0230_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__a31o_1
XFILLER_0_42_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1437_ _0483_ _0559_ _0560_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__nand3b_4
X_1506_ _0524_ _0581_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__or2b_1
XFILLER_0_10_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1299_ _0422_ _0419_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__and2b_1
X_1368_ net23 net6 VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput26 b[16] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_1
Xinput37 rstb VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__buf_1
Xinput15 a[6] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__buf_1
XFILLER_0_24_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1153_ _0263_ _0264_ _0275_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__or3b_1
X_1222_ _0341_ _0342_ _0344_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__a21o_1
X_1084_ _0202_ _0180_ _0181_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__and3_1
X_1986_ clknet_2_0__leaf_clk _0014_ net82 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_23_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1840_ _0949_ _0952_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__xor2_1
XFILLER_0_12_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1771_ _0878_ _0881_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__or2b_1
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1136_ _0257_ _0259_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__nor2_1
X_1205_ _0327_ _0328_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__or2_1
X_1067_ _0189_ _0190_ VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__nand2_2
XFILLER_0_34_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1969_ _0107_ _0100_ _0116_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__a21o_1
XFILLER_0_38_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1823_ _0929_ _0936_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__xnor2_1
X_1754_ _0868_ _0869_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_20_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1685_ _0202_ _0297_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__nand2_1
X_1119_ _0238_ _0242_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1470_ _0591_ _0592_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__or2b_1
XFILLER_0_1_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1806_ _0793_ _0916_ _0917_ _0920_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__a211oi_4
XFILLER_0_31_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1599_ _0716_ _0717_ _0719_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__and3_1
XFILLER_0_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1668_ _0768_ _0786_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__xnor2_1
X_1737_ _0832_ _0853_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_48_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1453_ _0247_ _0215_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__nand2_1
X_1522_ _0535_ _0536_ _0642_ _0643_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__a31oi_4
X_1384_ _0487_ _0506_ _0507_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__nand3_1
X_2005_ clknet_2_2__leaf_clk _0033_ net85 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_45_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xwire2 _0522_ VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1505_ _0626_ _0622_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__or2_1
X_1436_ _0557_ _0558_ _0510_ _0512_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__o211ai_2
X_1367_ net23 net6 VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__or2_1
X_1298_ _0412_ _0416_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__or2b_1
XFILLER_0_33_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput38 start VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__buf_1
Xinput27 b[17] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__buf_1
Xinput16 a[7] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__buf_1
X_1221_ _0341_ _0342_ _0344_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__and3_1
X_1152_ _0263_ _0264_ _0275_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__o21bai_2
X_1083_ _0180_ _0181_ _0202_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__a21o_1
X_1985_ clknet_2_0__leaf_clk _0013_ net82 VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1419_ _0489_ _0497_ _0496_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__o21ba_1
X_1770_ _0885_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__clkbuf_1
X_1204_ _0323_ _0326_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__and2_1
X_1135_ net86 _0247_ _0258_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__a21oi_1
X_1066_ net35 net18 VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__nand2_2
XFILLER_0_50_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1968_ _0123_ _0125_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_7_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1899_ _0057_ _0059_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__and2_1
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1822_ _0934_ _0935_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__and2b_1
X_1753_ _0838_ _0843_ _0840_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_20_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1684_ _0444_ _0215_ _0774_ _0772_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__a31o_1
X_1118_ _0234_ _0237_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__or2_1
X_1049_ _0172_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_17_Left_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1805_ _0857_ _0918_ _0919_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_31_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1736_ _0850_ _0852_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__xnor2_2
X_1598_ _0718_ _0626_ _0670_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__o21ai_1
X_1667_ _0784_ _0785_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__xor2_1
XFILLER_0_48_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1452_ _0557_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__inv_2
X_1521_ _0532_ _0592_ _0591_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__a21o_1
X_1383_ _0504_ _0505_ _0488_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__a21o_1
X_2004_ clknet_2_2__leaf_clk _0032_ net85 VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_9_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1719_ _0545_ _0835_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_27_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1504_ _0564_ _0618_ _0619_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__and3_1
X_1435_ _0510_ _0512_ _0557_ _0558_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__a211o_4
XFILLER_0_37_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1366_ _0449_ _0450_ _0447_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__a21o_1
X_1297_ _0414_ _0415_ _0420_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__and3_1
Xinput28 b[1] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_6
Xinput17 a[8] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_1
X_1151_ _0237_ _0273_ _0274_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__a21bo_1
X_1220_ _0199_ _0306_ _0343_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__o21ai_2
X_1082_ _0205_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__clkbuf_4
X_1984_ clknet_2_0__leaf_clk _0012_ net82 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_30_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1349_ _0470_ _0471_ _0437_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__a21o_1
X_1418_ _0539_ _0540_ _0453_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_5_Left_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1134_ net86 _0152_ _0240_ VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__o21a_1
X_1203_ _0323_ _0326_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__nor2_1
XFILLER_0_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1065_ net35 net18 VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_47_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1967_ _0740_ _0124_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__nand2_1
X_1898_ _0057_ _0059_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1683_ _0768_ _0786_ _0800_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__a21oi_1
X_1752_ _0867_ _0778_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__xnor2_2
X_1821_ _0890_ _0933_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1117_ _0240_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__inv_2
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1048_ _0169_ _0171_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1666_ _0735_ _0753_ _0752_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__a21boi_1
X_1804_ _0863_ _0861_ _0882_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__o21ai_1
X_1735_ _0809_ _0817_ _0851_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__a21oi_2
X_1597_ _0618_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__inv_2
XFILLER_0_0_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_34_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1520_ _0533_ _0591_ _0592_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__o21a_1
X_1451_ _0274_ _0526_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__nor2_1
X_1382_ _0488_ _0504_ _0505_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__nand3_1
X_2003_ clknet_2_2__leaf_clk _0031_ net85 VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_45_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1649_ _0158_ _0202_ _0734_ _0732_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__a31o_1
XFILLER_0_13_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1718_ _0833_ _0834_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__and2_1
XFILLER_0_36_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1503_ _0625_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_42_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1296_ _0416_ _0419_ _0412_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__a21o_1
X_1434_ _0555_ _0556_ _0530_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__a21oi_1
X_1365_ _0337_ _0338_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__nand2_2
XFILLER_0_18_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput18 a[9] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__buf_1
XFILLER_0_24_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput29 b[2] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__clkbuf_1
X_1150_ _0266_ _0268_ _0272_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__nand3_4
X_1081_ _0173_ _0204_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__xor2_1
X_1983_ clknet_2_0__leaf_clk _0011_ net82 VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_21_Left_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1417_ _0453_ _0539_ _0540_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__and3_1
XFILLER_0_23_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1279_ _0389_ _0401_ _0402_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__nand3_2
X_1348_ _0437_ _0470_ _0471_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__nand3_1
XFILLER_0_14_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1133_ _0244_ _0256_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__nand2_1
X_1202_ _0288_ _0324_ _0325_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__a21o_1
X_1064_ _0184_ _0187_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__nand2_2
XFILLER_0_34_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1966_ _0739_ _0647_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__or2b_1
X_1897_ _0973_ _0984_ _0058_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__o21a_1
XFILLER_0_11_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1820_ _0890_ _0933_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__nor2_1
X_1682_ _0784_ _0785_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__nor2_1
X_1751_ _0650_ _0651_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__nand2_2
XFILLER_0_29_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1116_ _0233_ _0239_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__and2_2
X_1047_ net32 net15 VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__nand2_1
X_1949_ _0842_ _0089_ _0682_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1803_ _0856_ _0883_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1596_ _0622_ _0671_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__nand2_1
X_1665_ _0775_ _0783_ VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__xnor2_1
X_1734_ _0814_ _0816_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1450_ _0559_ _0561_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1381_ _0502_ _0503_ _0193_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__a21o_1
XFILLER_0_45_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2002_ clknet_2_2__leaf_clk _0030_ net85 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1648_ _0726_ _0757_ _0756_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__a21bo_1
X_1717_ _0444_ _0457_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__or2_1
X_1579_ _0696_ _0697_ _0698_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__a21o_1
XFILLER_0_47_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1502_ net66 _0624_ net80 VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__mux2_1
X_1433_ _0530_ _0555_ _0556_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__and3_4
X_1295_ net86 _0409_ _0417_ _0418_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__o211a_1
XFILLER_0_37_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1364_ _0444_ _0461_ _0460_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_18_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput19 b[0] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__buf_1
XFILLER_0_32_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1080_ _0161_ _0163_ _0164_ _0159_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__a31o_2
X_1982_ clknet_2_0__leaf_clk _0010_ net83 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1347_ _0468_ _0469_ _0440_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__a21o_1
X_1416_ _0494_ _0495_ _0537_ _0538_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__a22o_1
X_1278_ _0383_ _0380_ _0382_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__a21o_1
X_1201_ _0237_ _0157_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__nor2_1
X_1132_ _0241_ _0243_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__nand2_1
X_1063_ _0185_ _0182_ _0186_ _0177_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__o211a_1
XFILLER_0_18_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1965_ _0121_ _0108_ _0122_ _0110_ _0114_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__o311a_1
XFILLER_0_7_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1896_ _0038_ _0985_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__or2b_1
XPHY_EDGE_ROW_49_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1750_ _0865_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__inv_2
X_1681_ _0787_ _0767_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__and2b_1
X_1115_ net19 net10 VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__or2_1
X_1046_ _0160_ _0165_ _0168_ net136 VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_43_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1948_ _0097_ _0098_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1879_ _0040_ _0041_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__and2_1
XFILLER_0_19_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xclkbuf_2_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_2_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_15_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1802_ _0622_ _0671_ _0791_ _0916_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__and4_1
XFILLER_0_31_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1733_ _0837_ _0849_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_40_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1595_ _0714_ _0715_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__nand2_1
X_1664_ _0781_ _0782_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__xor2_1
XFILLER_0_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1029_ net28 net11 VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__and2_1
XFILLER_0_31_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1380_ _0193_ _0502_ _0503_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__nand3_1
X_2001_ clknet_2_2__leaf_clk _0029_ net85 VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_45_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1716_ _0444_ _0457_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__nand2_1
X_1647_ _0766_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_6_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1578_ _0696_ _0697_ _0698_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__nand3_1
Xrebuffer20 _0555_ VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_27_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1501_ _0622_ _0623_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__nor2_1
X_1432_ _0552_ _0553_ _0554_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__o21ai_1
X_1363_ _0274_ _0273_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__and2_1
X_1294_ net86 _0409_ _0250_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_37_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1981_ clknet_2_0__leaf_clk _0009_ net82 VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1346_ _0440_ _0468_ _0469_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__nand3_1
X_1415_ _0494_ _0495_ _0537_ _0538_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__nand4_1
X_1277_ _0390_ _0392_ _0400_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__nor3_1
XFILLER_0_3_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1200_ _0214_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__inv_2
XFILLER_0_18_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1131_ _0232_ _0253_ _0252_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__a21o_1
XFILLER_0_34_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1062_ _0166_ _0178_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__or2b_1
XFILLER_0_50_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1964_ _0109_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__inv_2
X_1895_ _0055_ _0056_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1329_ _0452_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__buf_4
XFILLER_0_46_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1680_ _0760_ _0788_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__and2b_1
XFILLER_0_20_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1114_ _0234_ _0237_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1045_ net15 net32 VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__or2_4
X_1947_ _0797_ net111 _0105_ _0106_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__a22o_1
XFILLER_0_9_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1878_ _0972_ _0957_ _0039_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__or3_1
X_1801_ _0789_ _0825_ _0856_ _0883_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__and4_1
X_1732_ _0846_ _0848_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__xnor2_2
X_1663_ _0736_ _0748_ _0747_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_25_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1594_ _0712_ _0713_ _0668_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__a21o_1
XFILLER_0_0_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1028_ net28 net11 VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__xor2_2
XFILLER_0_16_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2000_ clknet_2_3__leaf_clk _0028_ net85 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_45_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1646_ net69 _0765_ net80 VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1715_ _0193_ _0206_ _0808_ _0806_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__a31o_2
X_1577_ _0637_ _0651_ _0650_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__a21bo_1
Xrebuffer10 _0689_ VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__buf_1
Xrebuffer21 _0503_ VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_44_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_38_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1500_ _0620_ _0621_ _0572_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__a21oi_1
X_1293_ net86 _0293_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__xor2_1
X_1362_ _0442_ _0465_ _0464_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__a21bo_1
X_1431_ _0552_ _0553_ _0554_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__or3_4
XFILLER_0_26_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1629_ _0736_ _0747_ _0748_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__nand3_1
XFILLER_0_17_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1980_ clknet_2_1__leaf_clk _0008_ net82 VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__dfrtp_1
Xrebuffer1 _0152_ VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__buf_1
XFILLER_0_2_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1276_ _0396_ _0399_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__and2b_1
X_1345_ _0466_ _0467_ _0441_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__a21o_1
X_1414_ _0535_ _0536_ _0534_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__a21o_4
XFILLER_0_3_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1130_ _0232_ _0252_ _0253_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_25_Left_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1061_ net136 _0160_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1963_ _0843_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__inv_2
X_1894_ _0978_ _0046_ _0054_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__and3_1
XFILLER_0_11_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1259_ _0364_ _0365_ _0379_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__nand3_1
X_1328_ _0447_ _0451_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_38_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1113_ _0236_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__buf_2
X_1044_ _0166_ _0167_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__and2_1
XFILLER_0_24_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1946_ _0102_ _0104_ net81 VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__o21a_1
XFILLER_0_3_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1877_ _0972_ _0957_ _0039_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_31_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1800_ _0913_ _0914_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__or2_1
XFILLER_0_25_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1731_ _0810_ _0813_ _0847_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__o21a_1
X_1662_ _0776_ _0780_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_25_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1593_ _0668_ _0712_ _0713_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__nand3_1
XFILLER_0_0_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1027_ net29 net12 VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__or2_1
XFILLER_0_48_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1929_ _0589_ _0949_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_12_Left_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1645_ _0723_ _0764_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__xor2_1
X_1714_ _0802_ _0822_ _0830_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_6_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1576_ _0694_ _0695_ _0453_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__a21o_1
Xrebuffer11 net96 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__buf_1
XFILLER_0_44_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1430_ _0487_ _0507_ _0506_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__a21boi_1
X_1292_ _0399_ _0406_ _0411_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__a21o_1
X_1361_ _0483_ _0484_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__and2_1
XFILLER_0_41_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1628_ _0744_ _0745_ _0746_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__a21o_1
X_1559_ _0348_ _0346_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__and2_1
XFILLER_0_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer2 net87 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1413_ _0534_ _0535_ _0536_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__nand3_1
XFILLER_0_48_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1275_ _0396_ _0397_ _0398_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__or3_1
X_1344_ _0441_ _0466_ _0467_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__nand3_1
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_0_Left_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1060_ _0148_ _0182_ _0183_ _0164_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__or4b_4
XFILLER_0_50_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1962_ net81 _0118_ _0119_ _0120_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__a31o_1
XFILLER_0_7_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1893_ _0978_ _0046_ _0054_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__a21oi_1
X_1189_ _0286_ _0312_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__xor2_1
X_1258_ net88 _0381_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__and2_1
X_1327_ _0449_ _0450_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__nand2_2
XFILLER_0_46_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_42_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1112_ _0235_ _0154_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__xor2_2
XFILLER_0_17_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1043_ net33 net16 VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__or2_1
X_1945_ _0104_ _0102_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__nand2_4
XFILLER_0_9_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1876_ _0985_ _0038_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1592_ _0710_ _0711_ _0664_ _0666_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__a211o_1
X_1730_ _0811_ _0812_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__or2_1
X_1661_ _0777_ _0779_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_48_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1026_ _0148_ _0149_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__nor2_2
X_1928_ net81 _0087_ _0088_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__a21oi_1
X_1859_ _0959_ _0960_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1713_ _0818_ _0821_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__nor2_1
X_1644_ _0762_ _0763_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__or2_1
X_1575_ _0453_ _0694_ _0695_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__nand3_1
Xrebuffer12 _0339_ VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__clkbuf_1
X_1009_ _0140_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__clkbuf_1
X_1360_ _0371_ _0482_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__nand2_1
Xoutput70 net70 VGND VGND VPWR VPWR beta[5] sky130_fd_sc_hd__buf_2
XFILLER_0_10_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1291_ _0390_ _0392_ _0400_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_37_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1489_ _0582_ _0610_ _0611_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__and3_4
X_1558_ _0630_ _0678_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__xor2_1
X_1627_ _0744_ _0745_ _0746_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__nand3_1
XFILLER_0_32_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer3 _0684_ VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__buf_1
XFILLER_0_48_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1343_ _0464_ _0465_ _0442_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__a21o_1
X_1412_ _0445_ _0492_ _0491_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__a21bo_2
X_1274_ _0373_ _0393_ _0395_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_0989_ _0130_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_14_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1961_ _0797_ net64 VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__and2_1
X_1892_ _0982_ _0053_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__xnor2_1
X_1326_ _0184_ _0187_ _0301_ _0448_ VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__a211o_4
X_1188_ _0287_ _0311_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__xnor2_1
X_1257_ net86 _0233_ _0239_ VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__and3_1
XFILLER_0_46_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xmax_cap1 net134 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__clkbuf_1
X_1111_ _0155_ _0151_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__and2b_1
X_1042_ net33 net16 VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__nand2_2
XFILLER_0_43_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1944_ _0065_ _0070_ _0086_ _0103_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__a31o_1
XFILLER_0_9_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1875_ _0457_ _0585_ _0951_ _0037_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_10_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1309_ _0413_ _0421_ _0424_ _0425_ _0432_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__a311oi_1
XFILLER_0_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1591_ _0664_ _0666_ _0710_ _0711_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__o211ai_4
XFILLER_0_0_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1660_ _0589_ _0778_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__xor2_4
XFILLER_0_48_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1025_ net30 net13 VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__and2_1
X_1927_ net81 net105 VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__nor2_1
X_1858_ _0964_ _0967_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__or2b_1
X_1789_ _0600_ _0871_ _0903_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_39_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1643_ _0712_ _0760_ _0761_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__and3_1
X_1712_ _0801_ _0823_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__or2b_1
X_1574_ _0692_ _0693_ _0681_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__a21o_4
Xrebuffer13 _0535_ VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1008_ net40 net2 net77 VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput71 net71 VGND VGND VPWR VPWR beta[6] sky130_fd_sc_hd__buf_2
XFILLER_0_10_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput60 net60 VGND VGND VPWR VPWR beta[12] sky130_fd_sc_hd__clkbuf_4
X_1290_ _0390_ _0392_ _0400_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__or3_1
XFILLER_0_41_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1626_ _0453_ _0695_ _0694_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__a21bo_1
X_1488_ _0607_ _0608_ _0609_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__o21ai_1
X_1557_ _0676_ _0677_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer4 net89 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1273_ _0376_ _0381_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__or2_1
X_1342_ _0442_ _0464_ _0465_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__nand3_1
XFILLER_0_3_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1411_ _0449_ _0450_ _0493_ _0447_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__a211o_4
X_0988_ net131 net86 net78 VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1609_ _0444_ _0215_ VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1960_ _0100_ _0105_ _0117_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__a21o_1
X_1891_ _0975_ _0052_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1256_ _0364_ _0365_ _0379_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__a21o_1
X_1325_ _0298_ _0334_ _0448_ _0303_ _0335_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__o221a_1
X_1187_ _0293_ _0310_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__xor2_1
X_1110_ _0233_ net87 VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__xnor2_2
X_1041_ _0161_ _0163_ _0164_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__and3_2
XFILLER_0_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1943_ _0060_ _0063_ _0085_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__o21a_1
X_1874_ _0742_ _0950_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__and2b_1
XFILLER_0_3_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1308_ _0431_ _0405_ _0403_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__and3b_1
X_1239_ _0279_ _0281_ _0280_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_36_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1590_ _0708_ _0709_ _0674_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__a21o_1
XFILLER_0_33_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1024_ net30 net13 VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__nor2_1
X_1926_ _0074_ _0086_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__xnor2_1
X_1788_ _0444_ _0457_ _0872_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__and3_1
XFILLER_0_21_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1857_ _0969_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1642_ _0760_ net103 _0712_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__a21oi_1
X_1711_ _0797_ net107 _0828_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__a21o_1
XFILLER_0_13_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1573_ _0681_ _0692_ net135 VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__nand3_4
Xrebuffer14 _0688_ VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__clkbuf_1
X_1007_ _0139_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_16_Left_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1909_ _0065_ _0070_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput72 net72 VGND VGND VPWR VPWR beta[7] sky130_fd_sc_hd__clkbuf_4
Xoutput50 net50 VGND VGND VPWR VPWR alpha[3] sky130_fd_sc_hd__clkbuf_4
Xoutput61 net61 VGND VGND VPWR VPWR beta[13] sky130_fd_sc_hd__buf_2
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1556_ _0330_ _0675_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__or2_1
X_1625_ _0585_ _0742_ _0743_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__nand3_1
X_1487_ _0607_ _0608_ _0609_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__or3_4
X_1410_ _0532_ _0533_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__or2b_1
Xrebuffer5 _0690_ VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__buf_1
X_1272_ _0373_ _0393_ _0395_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__nor3b_1
X_1341_ _0462_ _0463_ _0443_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__a21o_1
X_0987_ _0129_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__clkbuf_1
X_1539_ _0657_ _0658_ _0659_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__o21ai_1
X_1608_ _0158_ _0202_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_19_Left_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1890_ _0050_ _0051_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__nand2_1
X_1255_ _0375_ _0377_ _0378_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1186_ _0294_ _0309_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__xor2_2
X_1324_ _0300_ _0336_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_4_Left_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1040_ _0151_ _0154_ _0149_ _0155_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__a211o_4
X_1942_ _0100_ _0101_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1873_ _0973_ _0984_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__xor2_1
XFILLER_0_3_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1307_ _0421_ _0428_ _0429_ _0430_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__or4b_1
X_1238_ _0314_ _0360_ _0361_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_46_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1169_ _0292_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__clkbuf_2
XFILLER_0_34_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1023_ _0147_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1925_ _0060_ _0085_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__xor2_1
X_1787_ _0898_ _0901_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__xnor2_1
X_1856_ net116 _0968_ net81 VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__mux2_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1710_ net79 _0826_ _0827_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__and3_1
X_1641_ _0758_ _0759_ _0724_ _0725_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__a211o_1
XFILLER_0_6_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1572_ _0690_ _0691_ _0682_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__a21o_1
XFILLER_0_21_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer15 _0700_ VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__clkbuf_1
X_1006_ net132 net18 net77 VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__mux2_1
XFILLER_0_16_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1839_ _0930_ _0951_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__xnor2_1
X_1908_ _0921_ _0965_ _0066_ _0069_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_35_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_33_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput73 net73 VGND VGND VPWR VPWR beta[8] sky130_fd_sc_hd__buf_2
Xoutput62 net62 VGND VGND VPWR VPWR beta[14] sky130_fd_sc_hd__buf_2
Xoutput40 net40 VGND VGND VPWR VPWR alpha[10] sky130_fd_sc_hd__clkbuf_4
Xoutput51 net51 VGND VGND VPWR VPWR alpha[4] sky130_fd_sc_hd__clkbuf_4
X_1555_ _0330_ _0675_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__nand2_1
X_1624_ _0742_ _0743_ _0585_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__a21o_1
X_1486_ _0531_ _0551_ _0550_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_4_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1340_ _0443_ _0462_ _0463_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__nand3_1
Xrebuffer6 _0338_ VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__clkbuf_1
X_1271_ _0240_ _0394_ _0327_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__a21o_1
X_0986_ net113 net79 VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__or2_1
X_1538_ _0657_ _0658_ _0659_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__or3_2
X_1607_ _0701_ _0702_ _0703_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__nor3_1
X_1469_ net25 net8 VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1323_ _0445_ _0446_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__nand2_2
X_1254_ _0366_ _0367_ _0374_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__and3_1
X_1185_ _0265_ _0308_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_20_Left_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1941_ _0083_ _0099_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__or2_1
X_1872_ _0982_ _0983_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__nor2_1
XFILLER_0_10_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1306_ _0422_ _0419_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__xnor2_1
X_1237_ _0358_ _0359_ _0284_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__o21ai_1
X_1168_ _0290_ _0291_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__and2_1
X_1099_ _0190_ _0218_ _0221_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1022_ net115 net9 net78 VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__mux2_1
X_1924_ _0083_ _0084_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__nor2_1
X_1855_ _0964_ _0967_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_21_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1786_ _0870_ _0899_ _0900_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__o21a_1
XFILLER_0_47_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold40 net58 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dlygate4sd3_1
X_1640_ _0724_ _0725_ _0758_ net94 VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__o211ai_4
X_1571_ _0682_ _0690_ _0691_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__nand3_4
XFILLER_0_21_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer16 _0708_ VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_29_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1005_ _0138_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_44_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1838_ _0742_ _0950_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__xnor2_2
X_1907_ _0966_ _0066_ _0068_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__o21a_1
X_1769_ net73 _0884_ net79 VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput41 net41 VGND VGND VPWR VPWR alpha[11] sky130_fd_sc_hd__clkbuf_4
Xoutput52 net52 VGND VGND VPWR VPWR alpha[5] sky130_fd_sc_hd__clkbuf_4
Xoutput74 net74 VGND VGND VPWR VPWR beta[9] sky130_fd_sc_hd__clkbuf_4
Xoutput63 net63 VGND VGND VPWR VPWR beta[15] sky130_fd_sc_hd__buf_2
XFILLER_0_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1485_ _0605_ _0606_ _0583_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__a21oi_1
X_1554_ _0158_ _0176_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__xnor2_1
X_1623_ _0737_ _0741_ net91 _0692_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__o211ai_4
.ends
