* NGSPICE file created from inverse_clarke.ext - technology: sky130A

.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0683 ps=0.86 w=0.65 l=0.15
X1 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=2.1 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A1 a_114_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
X3 a_114_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.185 ps=1.87 w=0.65 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.28 ps=2.56 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X10 a_285_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.091 ps=0.93 w=0.65 l=0.15
X11 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
X0 a_377_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.365 ps=1.73 w=1 l=0.15
X1 a_47_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.3 ps=2.6 w=1 l=0.15
X2 a_129_47# B a_47_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_285_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 Y a_47_47# a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_129_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0683 ps=0.86 w=0.65 l=0.15
X6 VPWR A a_47_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.365 pd=1.73 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_47_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.165 ps=1.33 w=1 l=0.15
X8 Y B a_377_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
X0 VPWR B a_59_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 X a_59_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.475 pd=2.95 as=0.167 ps=1.39 w=1 l=0.15
X2 VGND B a_145_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_59_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X4 X a_59_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.112 ps=1.04 w=0.65 l=0.15
X5 a_145_75# A a_59_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_109_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.97
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.97
.ends

.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A a_113_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_113_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=2.89
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=2.89
.ends

.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
X0 VPWR a_75_212# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 a_75_212# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 a_75_212# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND a_75_212# X VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.05
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.05
.ends

.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
X0 a_27_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_560_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X2 VGND B a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0991 ps=0.955 w=0.65 l=0.15
X3 Y B a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_297# a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_474_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X7 VGND A a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# B a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X12 a_474_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_560_47# a_27_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X14 VPWR A a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X15 Y a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X16 VPWR a_27_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X17 a_560_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
X0 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X5 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X7 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
X0 VGND A a_68_297# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_68_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_68_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR A a_150_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 X a_68_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.34 pd=2.68 as=0.146 ps=1.34 w=1 l=0.15
X5 a_150_297# B a_68_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_199_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_113_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.147 ps=1.29 w=1 l=0.15
X2 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X3 VPWR A1 a_113_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.29 as=0.14 ps=1.28 w=1 l=0.15
X4 a_113_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A2 a_199_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0959 ps=0.945 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=0.59
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=0.59
.ends

.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
X0 X a_35_297# a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.26 ps=2.52 w=1 l=0.15
X1 X B a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.25 pd=1.42 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_117_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 VPWR B a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.25 ps=1.42 w=0.65 l=0.15
X7 a_285_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A a_117_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_470_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_470_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_470_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.106 ps=0.975 w=0.65 l=0.15
X6 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X8 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X10 a_470_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.162 ps=1.33 w=1 l=0.15
X11 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 VPWR B a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X13 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X16 X a_112_47# a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 a_470_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X18 X B a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.35 as=0.265 ps=2.53 w=1 l=0.15
X1 a_209_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.172 ps=1.35 w=1 l=0.15
X2 a_303_47# A2 a_209_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.104 ps=0.97 w=0.65 l=0.15
X3 a_209_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.112 ps=0.995 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.172 ps=1.83 w=0.65 l=0.15
X5 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.107 ps=0.98 w=0.65 l=0.15
X6 a_80_21# A1 a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X7 VPWR A2 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.16 ps=1.32 w=1 l=0.15
X8 a_80_21# B1 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X9 a_209_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 Y a_61_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.183 ps=1.24 w=0.65 l=0.15
X1 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_217_297# a_61_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_479_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X4 a_217_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X5 Y a_61_47# a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 VPWR A1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_61_47# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VGND A2 a_637_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_61_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A1 a_479_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0683 ps=0.86 w=0.65 l=0.15
X11 VGND B1_N a_61_47# VNB sky130_fd_pr__nfet_01v8 ad=0.183 pd=1.24 as=0.126 ps=1.44 w=0.42 l=0.15
X12 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X13 a_637_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VPWR C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 a_181_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VGND C a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.132 pd=1.14 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 a_27_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X6 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.132 ps=1.14 w=0.65 l=0.15
X7 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X3 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X4 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X5 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.301 ps=2.66 w=1 l=0.15
X7 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X8 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X10 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X12 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X13 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X14 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X15 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X16 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X17 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X18 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X20 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X21 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X22 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.209 ps=2.02 w=0.65 l=0.15
X23 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X24 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X25 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X26 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X27 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.272 ps=2.56 w=1 l=0.15
X15 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X17 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X19 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X24 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.257 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X30 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X38 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 a_676_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.213 ps=1.42 w=1 l=0.15
X1 a_512_47# B1 a_409_47# VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.119 ps=1.01 w=0.65 l=0.15
X2 a_306_47# D1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.198 ps=1.91 w=0.65 l=0.15
X3 VGND A2 a_512_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.198 ps=1.26 w=0.65 l=0.15
X4 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.218 ps=1.43 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.305 ps=1.61 w=1 l=0.15
X6 VPWR A1 a_676_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.105 ps=1.21 w=1 l=0.15
X7 a_512_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_409_47# C1 a_306_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.119 ps=1.01 w=0.65 l=0.15
X9 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.382 pd=1.76 as=0.26 ps=2.52 w=1 l=0.15
X10 a_79_21# D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.218 pd=1.43 as=0.382 ps=1.76 w=1 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 a_81_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.257 ps=1.44 w=0.65 l=0.15
X1 a_299_297# B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_299_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 a_384_47# A1 a_81_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4b_1 A_N B C D VGND VNB VPB VPWR X
X0 a_297_47# a_27_47# a_193_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_369_47# B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0441 ps=0.63 w=0.42 l=0.15
X2 VPWR D a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.0662 ps=0.735 w=0.42 l=0.15
X3 X a_193_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.103 ps=1 w=0.65 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND D a_469_47# VNB sky130_fd_pr__nfet_01v8 ad=0.103 pd=1 as=0.0609 ps=0.71 w=0.42 l=0.15
X6 X a_193_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR B a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.128 pd=1.03 as=0.0987 ps=0.89 w=0.42 l=0.15
X8 a_193_413# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.128 ps=1.03 w=0.42 l=0.15
X9 a_193_413# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0987 pd=0.89 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 a_469_47# C a_369_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.0735 ps=0.77 w=0.42 l=0.15
X11 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
X0 X a_29_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.148 ps=1.34 w=1 l=0.15
X1 a_111_297# C a_29_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_29_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.102 ps=0.99 w=0.65 l=0.15
X3 a_183_297# B a_111_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 VPWR A a_183_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X5 a_29_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VGND C a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
X0 VPWR A a_49_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VGND a_285_47# a_391_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.5
X2 X a_391_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VGND A a_49_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR a_285_47# a_391_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.5
X5 a_285_47# a_49_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X6 a_285_47# a_49_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X7 X a_391_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
D0 VNB DIODE sky130_fd_pr__diode_pw2nd_05v5 pj=2.64e+06 area=4.347e+11
.ends

.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
X0 VPWR a_505_21# a_535_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_505_21# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.0693 ps=0.75 w=0.42 l=0.15
X2 a_218_374# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0767 pd=0.785 as=0.158 ps=1.39 w=0.42 l=0.15
X3 VGND a_505_21# a_439_47# VNB sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.11 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 a_76_199# A0 a_218_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.193 pd=1.34 as=0.0767 ps=0.785 w=0.42 l=0.15
X5 a_505_21# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.145 ps=1.11 w=0.42 l=0.15
X6 a_439_47# A0 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0997 ps=0.895 w=0.42 l=0.15
X7 a_535_374# A1 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.193 ps=1.34 w=0.42 l=0.15
X8 a_76_199# A1 a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0997 pd=0.895 as=0.0693 ps=0.75 w=0.42 l=0.15
X9 a_218_47# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.113 ps=1.04 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.158 pd=1.39 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.04 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_382_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X1 a_297_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X2 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.327 pd=1.65 as=0.28 ps=2.56 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.327 ps=1.65 w=1 l=0.15
X6 a_382_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.195 ps=1.39 w=1 l=0.15
X7 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 Y A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.174 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.182 pd=1.92 as=0.174 ps=1.39 w=0.7 l=0.15
X2 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X3 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.42 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0703 pd=0.755 as=0.111 ps=1.37 w=0.42 l=0.15
X6 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.14 ps=1.28 w=1 l=0.15
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0703 ps=0.755 w=0.42 l=0.15
X8 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.165 ps=1.33 w=1 l=0.15
X9 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.221 pd=1.98 as=0.198 ps=1.26 w=0.65 l=0.15
X1 Y A3 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.393 pd=1.78 as=0.135 ps=1.27 w=1 l=0.15
X2 a_193_297# A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.393 ps=1.78 w=1 l=0.15
X5 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_298_297# a_27_413# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.265 ps=2.53 w=1 l=0.15
X1 a_215_297# a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.136 ps=1.1 w=0.65 l=0.15
X2 a_298_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.258 ps=1.45 w=0.65 l=0.15
X4 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X6 a_382_47# A1 a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.136 pd=1.1 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VPWR A1 a_298_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND A2 a_382_47# VNB sky130_fd_pr__nfet_01v8 ad=0.258 pd=1.45 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
X0 Y a_53_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.192 ps=1.38 w=1 l=0.15
X1 a_232_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.192 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A_N a_53_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A_N a_53_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_316_47# B a_232_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y a_53_93# a_316_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.125 ps=1.03 w=0.65 l=0.15
X7 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X8 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X11 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=1.37 as=0.0588 ps=0.7 w=0.42 l=0.15
X18 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X20 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X21 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X22 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X23 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X25 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X26 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X27 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X28 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X29 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X30 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X31 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X32 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X33 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X34 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X35 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X36 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X37 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X38 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X39 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0578 ps=0.695 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
X0 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X5 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X17 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X21 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X23 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X36 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X39 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
X0 VPWR B a_207_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.228 pd=1.74 as=0.0609 ps=0.71 w=0.42 l=0.15
X1 X a_207_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.228 ps=1.74 w=1 l=0.15
X2 a_297_47# a_27_413# a_207_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0504 pd=0.66 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_207_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.99 w=0.65 l=0.15
X4 a_207_413# a_27_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0609 pd=0.71 as=0.0714 ps=0.76 w=0.42 l=0.15
X5 VPWR A_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0714 pd=0.76 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VGND B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.99 as=0.0504 ps=0.66 w=0.42 l=0.15
X7 a_27_413# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 a_78_199# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 VPWR A1 a_493_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X2 a_493_297# A2 a_78_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.235 ps=1.47 w=1 l=0.15
X3 VPWR a_78_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.373 pd=1.75 as=0.28 ps=2.56 w=1 l=0.15
X4 VGND A2 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X5 a_78_199# B2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.235 pd=1.47 as=0.117 ps=1.24 w=1 l=0.15
X6 a_215_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_215_47# B2 a_78_199# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_292_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.117 pd=1.24 as=0.373 ps=1.75 w=1 l=0.15
X9 VGND a_78_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
X0 VPWR S a_591_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.0672 ps=0.85 w=0.64 l=0.15
X1 a_591_369# A0 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.85 as=0.131 ps=1.05 w=0.64 l=0.15
X2 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.178 pd=1.41 as=0.135 ps=1.27 w=1 l=0.15
X3 a_79_21# A1 a_306_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.131 pd=1.05 as=0.229 ps=1.36 w=0.64 l=0.15
X4 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND S a_578_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0578 ps=0.695 w=0.42 l=0.15
X6 a_306_369# a_257_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.229 pd=1.36 as=0.178 ps=1.41 w=0.64 l=0.15
X7 a_79_21# A0 a_288_47# VNB sky130_fd_pr__nfet_01v8 ad=0.173 pd=1.25 as=0.0683 ps=0.745 w=0.42 l=0.15
X8 a_288_47# a_257_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.745 as=0.097 ps=0.975 w=0.42 l=0.15
X9 a_257_199# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 a_578_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.173 ps=1.25 w=0.42 l=0.15
X11 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X12 a_257_199# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.173 pd=1.82 as=0.0864 ps=0.91 w=0.64 l=0.15
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X16 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X17 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X20 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.26 ps=1.45 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.4 ps=1.8 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.205 pd=1.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.135 ps=1.27 w=1 l=0.15
X5 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_109_297# C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_206_369# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.146 ps=1.34 w=0.42 l=0.15
X1 a_206_369# A2_N a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 VGND B2 a_489_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_585_369# B2 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0672 ps=0.74 w=0.42 l=0.15
X4 a_489_47# a_206_369# a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_489_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VPWR A2_N a_206_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.209 pd=1.35 as=0.129 ps=1.18 w=0.42 l=0.15
X7 a_76_199# a_206_369# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.74 as=0.209 ps=1.35 w=0.42 l=0.15
X8 a_205_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0662 pd=0.735 as=0.0986 ps=0.98 w=0.42 l=0.15
X9 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.26 ps=2.52 w=1 l=0.15
X10 VPWR B1 a_585_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0986 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X2 a_193_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y A a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X4 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 a_109_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.091 ps=0.93 w=0.65 l=0.15
X1 Y B1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.175 ps=1.35 w=1 l=0.15
X4 a_29_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y A2 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND A1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 a_112_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X8 a_112_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.14 ps=1.28 w=1 l=0.15
X9 a_29_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X11 a_29_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.16 ps=1.32 w=1 l=0.15
X1 a_27_297# B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X2 VGND A2 a_373_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.114 ps=1 w=0.65 l=0.15
X3 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X4 a_27_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.253 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.253 ps=2.52 w=1 l=0.15
X6 a_373_47# A1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.96 w=0.65 l=0.15
X8 a_109_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X1 a_80_21# C1 a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X2 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_300_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.26 ps=1.45 w=0.65 l=0.15
X6 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_80_21# A1 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 a_472_297# B1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X9 a_80_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
X0 X a_61_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.167 ps=1.39 w=1 l=0.15
X1 VPWR a_61_75# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.195 ps=1.39 w=1 l=0.15
X2 VPWR B a_61_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 VGND B a_147_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 X a_61_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.112 ps=1.04 w=0.65 l=0.15
X5 VGND a_61_75# X VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.127 ps=1.04 w=0.65 l=0.15
X6 a_61_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X7 a_147_75# A a_61_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_226_47# A2_N a_226_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_489_413# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_226_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.167 ps=1.43 w=0.42 l=0.15
X3 VPWR B2 a_489_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_489_413# a_226_47# a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_76_199# a_226_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.139 ps=1.08 w=0.42 l=0.15
X6 VGND B1 a_556_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_556_47# B2 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VGND A2_N a_226_47# VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.08 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_226_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.12 ps=1.09 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.43 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.09 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o221ai_2 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
X0 Y A2 a_734_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_300_47# B2 a_28_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 a_300_47# B1 a_28_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_300_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_300_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_734_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.175 ps=1.35 w=1 l=0.15
X7 a_28_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C1 a_28_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR B1 a_382_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.135 ps=1.27 w=1 l=0.15
X11 a_382_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_28_47# B1 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_28_47# B2 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A1 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X15 Y B2 a_382_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 VPWR A1 a_734_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND A2 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_382_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X19 a_734_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2b_2 A_N B VGND VNB VPB VPWR X
X0 VPWR a_212_413# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_297_47# a_27_413# a_212_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_212_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.229 ps=1.75 w=1 l=0.15
X3 X a_212_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_212_413# a_27_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0609 pd=0.71 as=0.0767 ps=0.785 w=0.42 l=0.15
X5 VPWR A_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0767 pd=0.785 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VPWR B a_212_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.229 pd=1.75 as=0.0609 ps=0.71 w=0.42 l=0.15
X7 VGND B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VGND a_212_413# X VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_413# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
X0 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.157 ps=1.17 w=0.42 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.157 pd=1.17 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X6 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_2 A B C VGND VNB VPB VPWR Y
X0 VGND C a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 a_277_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_47# B a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.135 ps=1.27 w=1 l=0.15
X8 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_277_47# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_77_199# B2 a_227_47# VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.127 ps=1.04 w=0.65 l=0.15
X1 a_323_297# A2 a_227_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.165 ps=1.33 w=1 l=0.15
X2 a_227_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_227_47# B1 a_77_199# VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.133 ps=1.06 w=0.65 l=0.15
X4 VGND a_77_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR B1 a_539_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.205 ps=1.41 w=1 l=0.15
X6 a_227_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X7 VPWR a_77_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=2.67 w=1 l=0.15
X8 a_77_199# A3 a_323_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X9 VGND A2 a_227_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 a_227_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_539_297# B2 a_77_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=1.41 as=0.195 ps=1.39 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_2 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 VPWR a_82_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.186 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X1 a_646_47# B2 a_82_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_574_369# a_313_47# a_82_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0976 pd=0.945 as=0.166 ps=1.8 w=0.64 l=0.15
X3 a_574_369# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X4 VGND a_82_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.09 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR B2 a_574_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.0976 ps=0.945 w=0.64 l=0.15
X6 X a_82_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.172 ps=1.83 w=0.65 l=0.15
X7 X a_82_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.265 ps=2.53 w=1 l=0.15
X8 a_313_47# A2_N a_313_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.17 pd=1.81 as=0.0672 ps=0.85 w=0.64 l=0.15
X9 a_313_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.12 ps=1.09 w=0.42 l=0.15
X10 a_313_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.85 as=0.186 ps=1.43 w=0.64 l=0.15
X11 VGND A2_N a_313_47# VNB sky130_fd_pr__nfet_01v8 ad=0.142 pd=1.1 as=0.0567 ps=0.69 w=0.42 l=0.15
X12 a_82_21# a_313_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.142 ps=1.1 w=0.42 l=0.15
X13 VGND B1 a_646_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o221ai_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR Y
X0 a_109_47# B1 a_213_123# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.165 ps=1.82 w=0.65 l=0.15
X1 Y B2 a_295_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.225 pd=1.45 as=0.12 ps=1.24 w=1 l=0.15
X2 VPWR A1 a_493_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X3 a_213_123# B2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_295_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.12 pd=1.24 as=0.38 ps=1.76 w=1 l=0.15
X5 a_493_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.225 ps=1.45 w=1 l=0.15
X6 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=1.76 as=0.28 ps=2.56 w=1 l=0.15
X7 VGND A2 a_213_123# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.117 ps=1.01 w=0.65 l=0.15
X8 a_213_123# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_109_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_4 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_223_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 Y A1 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X3 a_223_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X4 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 VGND A2 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_223_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X7 Y a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.123 ps=1.03 w=0.65 l=0.15
X8 VPWR A2 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 a_658_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.201 ps=1.27 w=0.65 l=0.15
X10 VPWR A1 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_223_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 a_658_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 Y a_27_47# a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_223_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X15 VPWR A2 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.155 ps=1.31 w=1 l=0.15
X16 VPWR A1 a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 a_658_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VGND B1_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.27 ps=2.13 w=0.65 l=0.15
X19 a_223_297# a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X20 a_658_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X21 VGND A2 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.27 as=0.091 ps=0.93 w=0.65 l=0.15
X23 VGND a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X24 Y A1 a_658_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X25 Y a_27_47# a_223_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_2 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X1 X a_80_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 VGND a_80_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=0.99 as=0.091 ps=0.93 w=0.65 l=0.15
X3 a_386_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.157 ps=1.32 w=1 l=0.15
X4 X a_80_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_80_199# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.162 pd=1.15 as=0.111 ps=0.99 w=0.65 l=0.15
X6 a_386_297# B1 a_80_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_458_47# A1 a_80_199# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.162 ps=1.15 w=0.65 l=0.15
X8 VPWR A1 a_386_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X9 VGND A2 a_458_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.123 ps=1.03 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_240_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_51_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A1 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_51_297# B2 a_245_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.412 pd=1.83 as=0.105 ps=1.21 w=1 l=0.15
X4 a_149_47# C1 a_51_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.201 ps=1.92 w=0.65 l=0.15
X5 a_240_47# B1 a_149_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0991 ps=0.955 w=0.65 l=0.15
X6 VPWR A1 a_512_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X7 X a_51_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.165 ps=1.33 w=1 l=0.15
X8 a_149_47# B2 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_245_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X10 VPWR C1 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.34 ps=2.68 w=1 l=0.15
X11 a_512_297# A2 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.412 ps=1.83 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_300_297# a_27_413# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X3 Y a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.102 ps=0.99 w=0.65 l=0.15
X4 VPWR A1 a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 a_384_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.143 ps=1.09 w=0.65 l=0.15
X6 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.111 ps=1.37 w=0.42 l=0.15
X7 a_300_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor4b_1 A B C D_N VGND VNB VPB VPWR Y
X0 Y a_91_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X2 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_91_199# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A a_341_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.135 ps=1.27 w=1 l=0.15
X6 a_245_297# C a_161_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X7 a_341_297# B a_245_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X8 a_91_199# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.146 ps=1.34 w=0.42 l=0.15
X9 a_161_297# a_91_199# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.52 ps=3.04 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.28 ps=2.56 w=1 l=0.15
X1 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X4 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.177 ps=1.36 w=1 l=0.15
X7 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.105 ps=1.21 w=1 l=0.15
X9 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_2 A1 A2 B1_N VGND VNB VPB VPWR X
X0 VPWR A1 a_485_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_485_297# a_297_93# a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X2 a_297_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.108 ps=1.01 w=0.42 l=0.15
X3 a_581_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X4 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.01 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_79_21# a_297_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X6 VGND A2 a_581_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.182 pd=1.51 as=0.14 ps=1.28 w=1 l=0.15
X8 a_297_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.182 ps=1.51 w=0.42 l=0.15
X9 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X10 a_485_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X11 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
X0 VPWR A a_304_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X1 a_304_297# B a_220_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND C a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X3 a_220_297# C a_114_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X4 a_32_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_32_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X11 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X13 a_114_297# D a_32_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.26 ps=2.52 w=1 l=0.15
X14 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
X0 a_408_47# B a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_408_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y a_27_47# a_408_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.176 pd=1.39 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND C a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X6 a_218_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.12 ps=1.04 w=0.65 l=0.15
X7 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_218_47# B a_408_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X11 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.176 ps=1.39 w=1 l=0.15
X12 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.04 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_75_199# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.135 ps=1.07 w=0.65 l=0.15
X1 a_208_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.112 ps=0.995 w=0.65 l=0.15
X2 a_315_47# A2 a_208_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.17 as=0.125 ps=1.03 w=0.65 l=0.15
X3 VGND B1 a_75_199# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.07 as=0.106 ps=0.975 w=0.65 l=0.15
X4 a_75_199# A1 a_315_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.17 w=0.65 l=0.15
X5 a_75_199# C1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.207 ps=1.41 w=1 l=0.15
X6 a_544_297# B1 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.207 pd=1.41 as=0.162 ps=1.33 w=1 l=0.15
X7 VPWR a_75_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.285 ps=2.57 w=1 l=0.15
X8 a_201_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.142 ps=1.28 w=1 l=0.15
X9 VPWR A2 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.165 ps=1.33 w=1 l=0.15
X10 a_201_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.305 ps=1.61 w=1 l=0.15
X11 VGND a_75_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VGND A1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
X1 a_510_47# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.143 ps=1.09 w=0.65 l=0.15
X2 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.175 ps=1.35 w=1 l=0.15
X3 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.22 ps=1.44 w=1 l=0.15
X4 a_79_21# A2 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.22 pd=1.44 as=0.162 ps=1.33 w=1 l=0.15
X5 a_297_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X6 a_79_21# C1 a_510_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.114 ps=1 w=0.65 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X8 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
X9 a_215_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.106 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y A1 a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.119 ps=1.01 w=0.65 l=0.15
X1 a_181_47# A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.0683 ps=0.86 w=0.65 l=0.15
X2 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.106 ps=0.975 w=0.65 l=0.15
X3 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.162 ps=1.33 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.153 ps=1.3 w=1 l=0.15
X6 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.149 ps=1.33 w=1 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.149 pd=1.33 as=0.166 ps=1.8 w=0.64 l=0.15
X3 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X4 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 VGND A2 a_660_47# VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.0829 ps=0.905 w=0.65 l=0.15
X1 VGND C1 a_85_193# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.101 ps=0.96 w=0.65 l=0.15
X2 a_414_297# C1 a_334_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.125 ps=1.25 w=1 l=0.15
X3 VGND a_85_193# X VNB sky130_fd_pr__nfet_01v8 ad=0.275 pd=1.5 as=0.214 ps=1.96 w=0.65 l=0.15
X4 a_334_297# D1 a_85_193# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.125 pd=1.25 as=0.385 ps=2.77 w=1 l=0.15
X5 a_516_297# B1 a_414_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=1.56 as=0.18 ps=1.36 w=1 l=0.15
X6 a_516_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.135 ps=1.27 w=1 l=0.15
X7 a_660_47# A1 a_85_193# VNB sky130_fd_pr__nfet_01v8 ad=0.0829 pd=0.905 as=0.185 ps=1.22 w=0.65 l=0.15
X8 a_85_193# D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.275 ps=1.5 w=0.65 l=0.15
X9 VPWR A1 a_516_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=1.56 w=1 l=0.15
X10 a_85_193# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.22 as=0.117 ps=1.01 w=0.65 l=0.15
X11 VPWR a_85_193# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.29 ps=2.58 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_8 A VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X21 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VGND A2 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR A1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_37_297# B1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_485_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_292_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VPWR A2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X8 a_485_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X11 a_37_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 Y A1 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X13 Y C1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_292_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X15 a_292_297# B1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311a_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.305 ps=1.61 w=1 l=0.15
X1 a_467_47# C1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_467_47# B1 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND A1 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.135 ps=1.27 w=1 l=0.15
X6 a_79_21# C1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_717_47# B1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VGND A3 a_717_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.27 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_1147_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 VPWR A1 a_1147_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_1147_297# A2 a_875_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X18 a_79_21# A3 a_875_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X19 a_875_297# A3 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 a_875_297# A2 a_1147_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 a_717_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.201 ps=1.27 w=0.65 l=0.15
X23 a_717_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_717_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X26 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_467_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_467_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_109_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A2 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_109_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32ai_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 a_1224_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 VPWR A1 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.183 ps=1.37 w=1 l=0.15
X2 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_806_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.205 ps=1.28 w=0.65 l=0.15
X8 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.205 pd=1.28 as=0.14 ps=1.08 w=0.65 l=0.15
X10 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_806_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A3 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y A3 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X19 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.119 ps=1.01 w=0.65 l=0.15
X22 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0926 ps=0.935 w=0.65 l=0.15
X24 a_806_297# A2 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X25 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.142 ps=1.28 w=1 l=0.15
X28 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_1224_297# A2 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 a_1224_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.183 pd=1.37 as=0.135 ps=1.27 w=1 l=0.15
X32 a_806_297# A2 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 VPWR A1 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X35 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X36 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X37 a_1224_297# A2 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X38 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X39 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
X0 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_161_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X2 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_161_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A a_161_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_161_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
X0 a_109_93# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_215_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 VGND a_109_93# a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND A a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 VPWR A a_369_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_369_297# B a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_215_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X7 a_297_297# a_109_93# a_215_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_109_93# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 X a_215_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.1 ps=0.985 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.745 as=0.111 ps=1.37 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.162 ps=1.33 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y A3 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_449_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 Y A3 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 Y B1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_449_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.263 ps=2.57 w=1 l=0.15
X8 Y B1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_31_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_297# A2 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.261 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A1 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 a_31_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X14 a_31_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_31_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_449_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X20 VGND A2 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 VGND A2 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VGND A3 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.223 pd=1.34 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_31_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.223 ps=1.34 w=0.65 l=0.15
X25 a_27_297# A2 a_449_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND A3 a_31_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 a_31_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X28 a_449_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 a_31_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 a_31_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 a_465_47# A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND A4 a_561_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X2 VPWR A3 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X3 a_297_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X4 a_297_297# A4 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X5 VPWR A1 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_381_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.184 ps=1.22 w=0.65 l=0.15
X7 a_297_297# B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X8 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X9 a_79_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.184 pd=1.22 as=0.161 ps=1.14 w=0.65 l=0.15
X10 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.161 pd=1.14 as=0.169 ps=1.82 w=0.65 l=0.15
X11 a_561_47# A3 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
X0 a_204_297# A1 a_396_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.16 ps=1.32 w=1 l=0.15
X1 VPWR a_396_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_396_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR S a_314_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_204_297# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.162 ps=1.33 w=1 l=0.15
X5 a_396_47# A0 a_314_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.26 ps=2.52 w=1 l=0.15
X6 a_206_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.109 ps=0.985 w=0.65 l=0.15
X7 X a_396_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_396_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_396_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_490_47# A1 a_396_47# VNB sky130_fd_pr__nfet_01v8 ad=0.275 pd=1.5 as=0.104 ps=0.97 w=0.65 l=0.15
X11 VGND S a_490_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.275 ps=1.5 w=0.65 l=0.15
X12 VGND a_396_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_396_47# A0 a_206_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.26 ps=1.45 w=0.65 l=0.15
X14 VGND a_396_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR S a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X16 X a_396_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND S a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_585_47# B1 a_266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.119 ps=1.01 w=0.65 l=0.15
X1 VGND A2 a_266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.137 pd=1.07 as=0.117 ps=1.01 w=0.65 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.62 as=0.26 ps=2.52 w=1 l=0.15
X3 a_81_21# C1 a_585_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.203 pd=1.27 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_266_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.312 ps=1.62 w=1 l=0.15
X6 a_368_297# A2 a_266_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.21 pd=1.42 as=0.18 ps=1.36 w=1 l=0.15
X7 a_266_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.137 ps=1.07 w=0.65 l=0.15
X8 a_266_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.203 ps=1.27 w=0.65 l=0.15
X9 a_81_21# A3 a_368_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.21 ps=1.42 w=1 l=0.15
X10 a_81_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.15 ps=1.3 w=1 l=0.15
X11 VPWR B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.138 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
X0 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X1 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND B a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_197_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0798 pd=0.8 as=0.0609 ps=0.71 w=0.42 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.312 ps=1.68 w=1 l=0.15
X3 a_303_47# C a_197_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0798 ps=0.8 w=0.42 l=0.15
X4 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.68 as=0.0588 ps=0.7 w=0.42 l=0.15
X6 VGND D a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.196 pd=1.33 as=0.0693 ps=0.75 w=0.42 l=0.15
X7 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X8 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.196 ps=1.33 w=0.65 l=0.15
X9 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32ai_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X1 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X2 a_475_297# A2 a_729_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X3 a_729_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 VPWR A1 a_729_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X7 a_729_297# A2 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_475_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y A3 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X15 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.228 pd=2 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X19 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
X0 a_558_47# a_381_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X1 VGND X a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_841_47# a_664_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VPWR A a_62_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A a_62_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_558_47# a_381_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X6 X a_62_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR X a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_841_47# a_664_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X9 X a_62_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X10 VPWR a_558_47# a_664_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND a_558_47# a_664_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
X0 VPWR a_30_53# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.315 pd=2.63 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND a_30_53# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_30_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X3 a_112_297# C a_30_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_30_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 VGND A a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 a_30_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 VGND C a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_184_297# B a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X9 VPWR A a_184_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311o_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_277_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.325 ps=1.65 w=1 l=0.15
X2 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_861_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.211 ps=1.3 w=0.65 l=0.15
X4 a_27_297# B1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_1059_47# A2 a_861_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_1059_47# A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_277_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0943 ps=0.94 w=0.65 l=0.15
X9 a_27_297# C1 a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.211 pd=1.3 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A3 a_861_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VGND C1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_109_47# A1 a_1059_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_109_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 VPWR A3 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X21 VPWR A2 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.325 pd=1.65 as=0.135 ps=1.27 w=1 l=0.15
X22 a_109_47# C1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X23 VPWR A1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X24 a_277_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 a_277_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X26 a_109_47# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X27 a_861_47# A2 a_1059_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_4 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_33_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND A1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_33_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_797_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_797_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y B2 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR B1 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_33_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 a_33_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_33_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_33_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_797_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.16 ps=1.32 w=1 l=0.15
X17 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR B1 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 VGND A2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_33_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 a_797_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.135 ps=1.27 w=1 l=0.15
X24 Y B2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 Y B2 a_797_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X26 Y B1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.104 ps=0.97 w=0.65 l=0.15
X27 Y B2 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 Y B1 a_33_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_33_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.29 ps=2.58 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X7 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.38 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X11 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X18 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_39_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=1 w=0.65 l=0.15
X2 VPWR a_39_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_39_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.156 ps=1.36 w=1 l=0.15
X4 VGND a_39_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.156 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VGND A a_39_297# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=1 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_39_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X7 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X11 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X12 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X14 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X15 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X16 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.155 ps=1.31 w=1 l=0.15
X20 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
X0 VPWR D a_343_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.46 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_223_47# B_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.5 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 a_515_93# a_223_47# a_429_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 a_223_47# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.134 pd=1.48 as=0.0588 ps=0.7 w=0.42 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.168 ps=1.64 w=0.42 l=0.15
X5 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.168 ps=1.64 w=0.42 l=0.15
X6 X a_343_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.172 ps=1.46 w=1 l=0.15
X7 a_429_93# a_27_47# a_343_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.118 ps=1.4 w=0.42 l=0.15
X8 VGND D a_615_93# VNB sky130_fd_pr__nfet_01v8 ad=0.126 pd=1.11 as=0.0777 ps=0.79 w=0.42 l=0.15
X9 a_343_93# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X10 a_343_93# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.122 ps=1.42 w=0.42 l=0.15
X11 a_615_93# C a_515_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X12 X a_343_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.82 as=0.126 ps=1.11 w=0.65 l=0.15
X13 VPWR a_223_47# a_343_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR A2 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 a_277_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X2 a_79_21# B1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X3 a_277_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_361_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_277_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.127 ps=1.04 w=0.65 l=0.15
X9 a_79_21# A1 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_222_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X1 VPWR A1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.105 ps=1.21 w=1 l=0.15
X2 VGND a_79_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_222_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.186 ps=1.41 w=0.42 l=0.15
X4 VGND A2 a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_448_47# a_222_93# a_79_199# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_79_199# a_222_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.3 ps=2.6 w=1 l=0.15
X7 a_544_297# A2 a_79_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X8 a_448_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.186 pd=1.41 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
X0 a_27_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_27_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_277_297# B a_205_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VPWR A a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 a_205_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X6 VPWR a_27_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=2.61 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND a_27_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.91 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X9 VGND C a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0693 ps=0.75 w=0.42 l=0.15
X10 a_109_297# D a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND A a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311oi_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
X0 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.159 ps=1.14 w=0.65 l=0.15
X3 a_1139_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.245 pd=1.49 as=0.135 ps=1.27 w=1 l=0.15
X4 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A3 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_109_297# B1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_1139_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X13 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_109_297# B1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X16 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VPWR A3 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 a_1139_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 Y C1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_1139_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.159 pd=1.14 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X32 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y C1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.245 ps=1.49 w=1 l=0.15
X35 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X36 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X38 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X39 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32oi_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.338 pd=1.67 as=0.135 ps=1.27 w=1 l=0.15
X5 a_1249_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_1249_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.252 pd=1.5 as=0.338 ps=1.67 w=1 l=0.15
X12 a_803_47# A2 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X16 a_803_47# A2 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X20 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X21 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_1249_47# A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.133 ps=1.06 w=0.65 l=0.15
X23 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 a_1249_47# A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.252 ps=1.5 w=1 l=0.15
X28 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X30 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X32 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X35 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 VGND A3 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X37 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VGND A3 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
X0 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X1 a_109_53# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_215_297# a_109_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_392_297# C a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0452 pd=0.635 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_465_297# B a_392_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.064 pd=0.725 as=0.0452 ps=0.635 w=0.42 l=0.15
X6 a_215_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 VPWR A a_465_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.064 ps=0.725 w=0.42 l=0.15
X8 a_297_297# a_109_53# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_109_53# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X10 VGND C a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.064 ps=0.725 w=0.42 l=0.15
X11 VGND A a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_93_21# A1 a_346_47# VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.146 ps=1.1 w=0.65 l=0.15
X1 a_93_21# B1 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.185 ps=1.37 w=1 l=0.15
X2 a_584_47# B1 a_93_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.143 ps=1.09 w=0.65 l=0.15
X3 VPWR a_93_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.243 pd=1.49 as=0.33 ps=2.66 w=1 l=0.15
X4 VGND B2 a_584_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 a_256_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.167 ps=1.16 w=0.65 l=0.15
X6 a_250_297# B2 a_93_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 VGND a_93_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.167 pd=1.16 as=0.214 ps=1.96 w=0.65 l=0.15
X8 a_250_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.243 ps=1.49 w=1 l=0.15
X9 VPWR A2 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.225 pd=1.45 as=0.165 ps=1.33 w=1 l=0.15
X10 a_250_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.225 ps=1.45 w=1 l=0.15
X11 a_346_47# A2 a_256_47# VNB sky130_fd_pr__nfet_01v8 ad=0.146 pd=1.1 as=0.0975 ps=0.95 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
X0 a_109_93# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_209_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X2 a_109_93# A_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_296_53# a_109_93# a_209_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.108 ps=1.36 w=0.42 l=0.15
X4 VPWR C a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0744 ps=0.815 w=0.42 l=0.15
X5 a_368_53# B a_296_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_209_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.122 ps=1.08 w=0.65 l=0.15
X7 a_209_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VPWR a_109_93# a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.108 ps=1.36 w=0.42 l=0.15
X9 VGND C a_368_53# VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.08 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_388_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.127 pd=1.25 as=0.153 ps=1.3 w=1 l=0.15
X1 a_105_352# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_297_47# a_105_352# Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A1 a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.127 ps=1.25 w=1 l=0.15
X5 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X6 VPWR B1_N a_105_352# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.178 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 Y a_105_352# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.178 ps=1.4 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_2 A B C VGND VNB VPB VPWR Y
X0 Y C a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 a_281_297# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X6 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X10 a_281_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_297# B a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111ai_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR Y
X0 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.14 ps=1.28 w=1 l=0.15
X1 a_235_47# C1 a_163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.0683 ps=0.86 w=0.65 l=0.15
X2 a_343_47# B1 a_235_47# VNB sky130_fd_pr__nfet_01v8 ad=0.132 pd=1.05 as=0.127 ps=1.04 w=0.65 l=0.15
X3 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.203 pd=1.4 as=0.195 ps=1.39 w=1 l=0.15
X4 a_454_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.203 ps=1.4 w=1 l=0.15
X5 Y D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X6 VPWR A1 a_454_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.195 ps=1.39 w=1 l=0.15
X7 a_163_47# D1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X8 VGND A2 a_343_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.132 ps=1.05 w=0.65 l=0.15
X9 a_343_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.127 ps=1.04 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_465_47# A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.157 ps=1.32 w=1 l=0.15
X2 a_109_297# B1 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 a_193_297# B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.102 ps=0.965 w=0.65 l=0.15
X5 a_205_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X6 VPWR A2 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.165 ps=1.33 w=1 l=0.15
X7 a_193_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X8 a_27_47# B1 a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X9 a_109_297# C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 VGND C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND A2 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32a_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_429_297# A2 a_345_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND A2 a_345_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_345_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.14 ps=1.08 w=0.65 l=0.15
X5 a_345_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.305 ps=1.61 w=1 l=0.15
X6 a_629_297# B2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR B1 a_629_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.33 pd=2.66 as=0.19 ps=1.38 w=1 l=0.15
X8 a_79_21# B2 a_345_47# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_345_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.214 pd=1.96 as=0.123 ps=1.03 w=0.65 l=0.15
X10 a_79_21# A3 a_429_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X11 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X12 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_345_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.198 ps=1.26 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 Y B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X1 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.135 ps=1.27 w=1 l=0.15
X3 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_381_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_109_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VGND A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0683 ps=0.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_475_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A1 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X9 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.27 pd=1.48 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X12 a_475_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 Y A2 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X14 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.27 ps=1.48 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand4_1 A B C D VGND VNB VPB VPWR Y
X0 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.165 ps=1.33 w=1 l=0.15
X2 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_193_47# C a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_277_47# B a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o41a_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 VGND A4 a_321_47# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_321_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.123 ps=1.03 w=0.65 l=0.15
X2 a_103_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=1.52 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR a_103_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.425 ps=2.85 w=1 l=0.15
X4 VGND a_103_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.247 ps=2.06 w=0.65 l=0.15
X5 VGND A2 a_321_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X6 a_321_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.127 ps=1.04 w=0.65 l=0.15
X7 a_511_297# A3 a_393_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.22 ps=1.44 w=1 l=0.15
X8 a_619_297# A2 a_511_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X9 a_321_47# B1 a_103_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X10 a_393_297# A4 a_103_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.22 pd=1.44 as=0.26 ps=1.52 w=1 l=0.15
X11 VPWR A1 a_619_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.195 ps=1.39 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_2 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.16 ps=1.32 w=1 l=0.15
X1 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.4 ps=1.8 w=1 l=0.15
X2 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0894 ps=0.925 w=0.65 l=0.15
X3 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_470_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.138 ps=1.27 w=1 l=0.15
X6 a_384_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 a_384_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.104 ps=0.97 w=0.65 l=0.15
X8 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
X0 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22o_2 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 VPWR a_27_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.107 ps=0.98 w=0.65 l=0.15
X2 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.965 w=0.65 l=0.15
X3 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.157 ps=1.32 w=1 l=0.15
X4 a_27_297# B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X5 a_27_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_27_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X8 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.165 ps=1.33 w=1 l=0.15
X9 a_381_47# A1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X10 a_109_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
X0 X a_299_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X1 VPWR a_193_47# a_299_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 VGND a_193_47# a_299_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X6 X a_299_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.172 ps=1.83 w=0.65 l=0.15
X2 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X3 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X5 a_326_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.127 ps=1.04 w=0.65 l=0.15
X6 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.635 pd=3.27 as=0.195 ps=1.39 w=1 l=0.15
X7 Y C1 a_326_47# VNB sky130_fd_pr__nfet_01v8 ad=0.393 pd=2.51 as=0.0683 ps=0.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 a_103_199# B1 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.107 ps=0.98 w=0.65 l=0.15
X1 VPWR a_103_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.36 ps=2.72 w=1 l=0.15
X2 a_337_297# A2 a_253_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_103_199# A3 a_337_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.165 ps=1.33 w=1 l=0.15
X4 a_253_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.195 ps=1.39 w=1 l=0.15
X5 VPWR B1 a_103_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.345 pd=2.69 as=0.213 ps=1.42 w=1 l=0.15
X6 VGND a_103_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.234 ps=2.02 w=0.65 l=0.15
X7 a_253_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X8 a_253_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X9 VGND A2 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.385 pd=1.77 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X9 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.385 ps=1.77 w=1 l=0.15
X14 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X21 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X31 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2b_2 A_N B VGND VNB VPB VPWR Y
X0 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=1.67 w=1 l=0.15
X1 VGND A_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0.194 pd=1.95 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VGND B a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y a_27_93# a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 a_229_47# a_27_93# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.147 ps=1.34 w=1 l=0.15
X6 VPWR a_27_93# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.335 pd=1.67 as=0.165 ps=1.33 w=1 l=0.15
X7 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.135 ps=1.27 w=1 l=0.15
X8 a_229_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR A_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32o_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 VPWR A3 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_299_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X2 a_352_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.21 ps=1.29 w=0.65 l=0.15
X3 a_549_47# A1 a_21_199# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.107 ps=0.98 w=0.65 l=0.15
X4 X a_21_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_21_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.21 pd=1.29 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_665_47# A2 a_549_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.14 ps=1.08 w=0.65 l=0.15
X7 VPWR A1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X8 a_299_297# B1 a_21_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_21_199# B2 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 VGND A3 a_665_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR a_21_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X12 X a_21_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_21_199# B1 a_352_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.115 ps=1 w=0.65 l=0.15
.ends

.subckt inverse_clarke VGND VPWR a[0] a[10] a[11] a[12] a[13] a[14] a[15] a[16] a[17]
+ a[18] a[19] a[1] a[20] a[21] a[22] a[23] a[24] a[25] a[26] a[27] a[28] a[29] a[2]
+ a[30] a[31] a[3] a[4] a[5] a[6] a[7] a[8] a[9] alpha[0] alpha[10] alpha[11] alpha[12]
+ alpha[13] alpha[14] alpha[15] alpha[16] alpha[17] alpha[18] alpha[19] alpha[1] alpha[20]
+ alpha[21] alpha[22] alpha[23] alpha[24] alpha[25] alpha[26] alpha[27] alpha[28]
+ alpha[29] alpha[2] alpha[30] alpha[31] alpha[3] alpha[4] alpha[5] alpha[6] alpha[7]
+ alpha[8] alpha[9] b[0] b[10] b[11] b[12] b[13] b[14] b[15] b[16] b[17] b[18] b[19]
+ b[1] b[20] b[21] b[22] b[23] b[24] b[25] b[26] b[27] b[28] b[29] b[2] b[30] b[31]
+ b[3] b[4] b[5] b[6] b[7] b[8] b[9] beta[0] beta[10] beta[11] beta[12] beta[13] beta[14]
+ beta[15] beta[16] beta[17] beta[18] beta[19] beta[1] beta[20] beta[21] beta[22]
+ beta[23] beta[24] beta[25] beta[26] beta[27] beta[28] beta[29] beta[2] beta[30]
+ beta[31] beta[3] beta[4] beta[5] beta[6] beta[7] beta[8] beta[9] c[0] c[10] c[11]
+ c[12] c[13] c[14] c[15] c[16] c[17] c[18] c[19] c[1] c[20] c[21] c[22] c[23] c[24]
+ c[25] c[26] c[27] c[28] c[29] c[2] c[30] c[31] c[3] c[4] c[5] c[6] c[7] c[8] c[9]
+ clk done rstb start
X_2037_ _1143_ _1272_ _1305_ VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__a21oi_2
X_2106_ _1371_ _1373_ VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__xnor2_1
X_3155_ _0733_ _0738_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__and2_1
X_3086_ _0611_ _0672_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__nor2_1
XFILLER_0_64_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2939_ _0527_ _0528_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer7 net259 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2724_ _0316_ _0317_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__and2_1
X_2655_ net225 net220 VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_14_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2586_ _0181_ _0182_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__nor2_2
X_3207_ _0691_ _0790_ VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__or2_1
X_3138_ _0689_ _0722_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__nand2_1
X_3069_ net215 _0655_ _0586_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_18_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2440_ _1622_ _1700_ VGND VGND VPWR VPWR _1701_ sky130_fd_sc_hd__xor2_1
XFILLER_0_11_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2371_ net237 net233 VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__xor2_2
XFILLER_0_54_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2638_ _0186_ _0184_ _0233_ _1389_ VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__a31o_1
XFILLER_0_42_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2569_ _0113_ _0118_ _0165_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_10_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2707_ net223 net220 VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1940_ _1142_ net209 _1210_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__and3_1
X_1871_ net200 VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__inv_2
XFILLER_0_43_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3610_ clknet_3_1__leaf_clk _0094_ net179 VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3472_ _1021_ _0723_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__or2_1
X_2423_ net237 net228 VGND VGND VPWR VPWR _1684_ sky130_fd_sc_hd__xor2_4
XFILLER_0_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3541_ clknet_3_2__leaf_clk _0025_ net178 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__dfrtp_1
X_2354_ _1524_ _1521_ _1567_ _1616_ _1519_ VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__o2111a_1
X_2285_ _1496_ _1498_ VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__nand2_1
XFILLER_0_19_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2070_ _1302_ _1337_ VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2972_ _0506_ _0509_ _0560_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__a21oi_1
X_1923_ _1190_ _1192_ _1193_ VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__a21o_1
X_1854_ _1121_ _1124_ VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__xor2_4
X_1785_ _1075_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_56_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3524_ clknet_3_4__leaf_clk _0008_ net184 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__dfrtp_1
X_2406_ _1619_ _1652_ _1651_ VGND VGND VPWR VPWR _1667_ sky130_fd_sc_hd__a21oi_1
X_3386_ _1754_ _0947_ _0952_ _1389_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__a31o_1
X_3455_ _0529_ _0572_ _0575_ _0632_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__and4b_1
XFILLER_0_12_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2199_ _1455_ _1464_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__xnor2_2
X_2337_ _1548_ _1550_ VGND VGND VPWR VPWR _1600_ sky130_fd_sc_hd__nor2_1
X_2268_ net194 _1529_ _1530_ VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__or3_1
XFILLER_0_47_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold30 net156 VGND VGND VPWR VPWR net281 sky130_fd_sc_hd__dlygate4sd3_1
Xhold41 net75 VGND VGND VPWR VPWR net292 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 net82 VGND VGND VPWR VPWR net303 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_38_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_5 net147 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3240_ _0815_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__inv_2
X_2053_ _1312_ _1321_ VGND VGND VPWR VPWR _1322_ sky130_fd_sc_hd__xnor2_1
X_2122_ _1389_ net124 VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__and2_1
X_3171_ _0701_ _0702_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2955_ _0541_ _0543_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__xnor2_1
X_1768_ net93 net27 net174 VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__mux2_1
X_1906_ _1159_ _1175_ _1176_ VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__a21o_1
X_1837_ net195 net203 net208 VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__o21a_1
X_2886_ net11 _0336_ net13 VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__o21ai_1
X_3507_ _0892_ _1053_ _1389_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__a21o_1
X_3369_ _0938_ VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__clkbuf_1
X_3438_ _0974_ net164 _0996_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__a21o_1
XFILLER_0_35_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput75 net75 VGND VGND VPWR VPWR a[17] sky130_fd_sc_hd__clkbuf_4
Xoutput97 net97 VGND VGND VPWR VPWR a[8] sky130_fd_sc_hd__clkbuf_4
Xoutput86 net86 VGND VGND VPWR VPWR a[27] sky130_fd_sc_hd__clkbuf_4
X_2740_ _0287_ _0284_ _0333_ net177 VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__o31ai_1
X_2671_ _1633_ _0202_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3223_ _0752_ _0806_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__and2_1
X_2036_ net201 net209 _1273_ VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__and3_1
X_2105_ _1312_ _1321_ _1372_ VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3154_ _0733_ _0738_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__nor2_1
X_3085_ _0670_ _0671_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__or2_1
XFILLER_0_49_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2938_ _0526_ _0522_ _0523_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_17_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2869_ net232 net226 _0403_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__and3_1
Xclkbuf_3_6__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_6__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_23_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer8 net260 VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2723_ net236 _0314_ _0315_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__or3_1
X_2585_ _0179_ _0180_ _0144_ VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_1_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2654_ net227 _0248_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__xnor2_4
X_3137_ _0689_ _0722_ VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__nor2_1
X_3206_ _0788_ _0789_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__or2_1
X_2019_ _1225_ _1245_ _1288_ VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_49_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3068_ net212 net205 VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__or2_1
XFILLER_0_9_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2370_ net233 VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__inv_2
XFILLER_0_19_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2706_ net225 net223 VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__nand2_1
X_2499_ _1753_ _1719_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__and2b_1
X_2637_ _0190_ _0232_ VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__xor2_2
X_2568_ _0110_ _0112_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1870_ net229 _1140_ VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_43_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3540_ clknet_3_0__leaf_clk _0024_ net182 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__dfrtp_1
X_2353_ _1611_ _1612_ VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__nand2_1
X_2422_ _1679_ _1682_ VGND VGND VPWR VPWR _1683_ sky130_fd_sc_hd__xnor2_4
X_3471_ net167 net286 _1023_ _1024_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__o22a_1
XFILLER_0_3_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2284_ _1538_ _1547_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_29_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1999_ net55 _1266_ _1267_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__or3_1
XFILLER_0_30_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1922_ _1168_ _1170_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2971_ _0503_ _0505_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__nor2_1
X_3523_ clknet_3_4__leaf_clk _0007_ net183 VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__dfrtp_1
X_1784_ net70 net4 net174 VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__mux2_1
X_1853_ _1122_ _1123_ net196 VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__mux2_2
XFILLER_0_24_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3385_ _0948_ _0942_ _0950_ _0951_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__a31o_1
X_2405_ _1651_ _1652_ VGND VGND VPWR VPWR _1666_ sky130_fd_sc_hd__and2b_1
X_2336_ _1580_ _1598_ VGND VGND VPWR VPWR _1599_ sky130_fd_sc_hd__xnor2_4
X_3454_ _1009_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__clkbuf_1
X_2198_ _1461_ _1463_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__xor2_2
X_2267_ _1529_ _1530_ net194 VGND VGND VPWR VPWR _1531_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold42 net79 VGND VGND VPWR VPWR net293 sky130_fd_sc_hd__dlygate4sd3_1
Xhold20 net152 VGND VGND VPWR VPWR net271 sky130_fd_sc_hd__dlygate4sd3_1
Xhold31 net150 VGND VGND VPWR VPWR net282 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 net119 VGND VGND VPWR VPWR net304 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_38_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3170_ _0750_ _0754_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__xnor2_1
X_2052_ _1318_ _1320_ VGND VGND VPWR VPWR _1321_ sky130_fd_sc_hd__xor2_1
X_2121_ _1254_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__clkbuf_4
X_1905_ _1172_ _1174_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__and2b_1
XFILLER_0_44_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2885_ net11 net13 _0336_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__or3_4
X_2954_ net210 _0490_ _0542_ _0494_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__o22a_1
XFILLER_0_8_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1767_ _1066_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__clkbuf_1
X_1836_ _1100_ _1106_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3506_ _0892_ _1053_ VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__nor2_1
X_3368_ net161 _0937_ net171 VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__mux2_1
X_2319_ net243 net235 VGND VGND VPWR VPWR _1582_ sky130_fd_sc_hd__and2_1
X_3437_ _0994_ _0995_ _0426_ _0382_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__o2bb2a_1
X_3299_ _0862_ _0875_ _0878_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__nand3_1
XFILLER_0_23_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput98 net98 VGND VGND VPWR VPWR a[9] sky130_fd_sc_hd__clkbuf_4
Xoutput76 net76 VGND VGND VPWR VPWR a[18] sky130_fd_sc_hd__clkbuf_4
Xoutput87 net87 VGND VGND VPWR VPWR a[28] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2670_ _0262_ _0264_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2104_ _1318_ _1320_ VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__nand2_1
X_3153_ _0736_ _0737_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__xnor2_1
X_3222_ _0804_ _0805_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__or2_1
X_2035_ _1223_ _1290_ VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__nor2_1
XFILLER_0_49_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3084_ _0667_ _0669_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__and2_1
X_2937_ _0522_ _0523_ _0526_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__a21bo_1
X_2868_ _0153_ _0402_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__and2_1
XFILLER_0_17_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1819_ _1092_ VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__clkbuf_1
X_2799_ net218 net214 VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_67_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer9 net261 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_39_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_48_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_57_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2722_ _0314_ _0315_ net236 VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_59_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2584_ _0144_ _0179_ _0180_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__and3_1
XFILLER_0_1_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2653_ net226 net218 VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__xor2_4
X_3136_ _0719_ _0721_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__xnor2_2
X_3205_ _0734_ _0787_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__nor2_1
X_3067_ net221 net217 VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__and2_1
X_2018_ _1242_ _1244_ VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__nor2_1
XFILLER_0_49_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2636_ _0223_ _0231_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__xnor2_4
X_2705_ _0296_ _0298_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__xor2_2
XFILLER_0_6_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2498_ _1712_ net273 _1755_ _1757_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__a22o_1
X_2567_ _0158_ _0163_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_69_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3119_ _0704_ _0659_ net219 VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_18_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2352_ _1569_ _1613_ _1614_ _1389_ VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__a211o_1
X_2283_ _1544_ _1546_ VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__xor2_4
X_2421_ _1459_ _1681_ VGND VGND VPWR VPWR _1682_ sky130_fd_sc_hd__xor2_4
X_3470_ _0725_ _1022_ net167 VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_24_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1998_ _1266_ _1267_ net55 VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3599_ clknet_3_3__leaf_clk _0083_ net181 VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__dfrtp_1
X_2619_ _0164_ _0166_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1921_ _1185_ _1191_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__or2_1
XFILLER_0_56_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1852_ net193 net197 VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__xor2_1
XFILLER_0_44_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2970_ _0553_ _0558_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3522_ clknet_3_4__leaf_clk _0006_ net189 VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__dfrtp_1
X_1783_ _1074_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__clkbuf_1
X_3453_ net306 _1008_ net166 VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2404_ _1663_ _1664_ VGND VGND VPWR VPWR _1665_ sky130_fd_sc_hd__and2_2
X_2266_ net192 net195 _1489_ VGND VGND VPWR VPWR _1530_ sky130_fd_sc_hd__and3_1
X_3384_ _1665_ _1707_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__and2b_1
X_2335_ _1595_ _1597_ VGND VGND VPWR VPWR _1598_ sky130_fd_sc_hd__xor2_4
X_2197_ _1404_ _1407_ _1405_ _1462_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_47_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold43 net74 VGND VGND VPWR VPWR net294 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 net143 VGND VGND VPWR VPWR net272 sky130_fd_sc_hd__dlygate4sd3_1
Xhold32 net113 VGND VGND VPWR VPWR net283 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 net88 VGND VGND VPWR VPWR net305 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2120_ _1384_ _1386_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__nand2_1
XFILLER_0_21_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2051_ _1276_ _1279_ _1277_ _1319_ VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_16_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1904_ _1172_ _1174_ VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__xnor2_1
X_1835_ _1102_ _1105_ VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_44_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2884_ _0436_ _0424_ _0473_ VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__and3_1
XFILLER_0_4_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2953_ net214 net213 _0491_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__a21oi_1
X_1766_ net92 net26 net170 VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__mux2_1
XFILLER_0_52_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3436_ _0977_ _0983_ _0375_ _0376_ _0982_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__o221ai_2
XFILLER_0_4_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3505_ _0886_ _1050_ _0884_ VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__a21oi_1
X_3367_ _1616_ _0936_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__xor2_1
X_2249_ _1424_ _1513_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__and2b_2
X_2318_ net192 net247 VGND VGND VPWR VPWR _1581_ sky130_fd_sc_hd__nand2_2
X_3298_ _0862_ _0875_ _0878_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_11_Left_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput99 net99 VGND VGND VPWR VPWR b[0] sky130_fd_sc_hd__clkbuf_4
Xoutput77 net77 VGND VGND VPWR VPWR a[19] sky130_fd_sc_hd__clkbuf_4
Xoutput88 net88 VGND VGND VPWR VPWR a[29] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_9_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2103_ _1361_ _1370_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__xnor2_1
X_3152_ _0590_ _0589_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__and2b_1
X_3221_ _0748_ _0781_ _0803_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__and3_1
X_3083_ _0667_ _0669_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__nor2_1
X_2034_ _1287_ _1289_ VGND VGND VPWR VPWR _1303_ sky130_fd_sc_hd__nor2_1
XFILLER_0_32_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2936_ _0524_ _0525_ VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__and2_1
X_2798_ net222 _0389_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__xnor2_2
X_1818_ net305 net22 net165 VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__mux2_1
X_2867_ _0455_ _0457_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_17_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3419_ _0333_ _0979_ net172 VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__o21a_1
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2652_ _0170_ _0218_ VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__or2b_1
X_2721_ net238 net234 _0260_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__and3_1
XFILLER_0_13_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2583_ _0145_ _0146_ _0178_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__nand3_2
X_3204_ _0734_ _0787_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__and2_1
X_2017_ _1270_ _1286_ VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__xnor2_4
X_3135_ _0679_ _0624_ _0720_ _0677_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__a31o_1
X_3066_ _0650_ _0652_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__xnor2_1
X_2919_ net46 _0508_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_45_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_172 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2635_ _0226_ _0230_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__and2_2
XFILLER_0_6_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2704_ net219 _0297_ net220 VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__mux2_1
X_2497_ _1255_ _1756_ VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__nor2_1
X_2566_ _0159_ _0162_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3049_ _0376_ _0427_ _0431_ _0383_ _0426_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__o32a_1
X_3118_ _0391_ _0656_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__nor2_1
XFILLER_0_33_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2420_ net241 _1630_ _1680_ VGND VGND VPWR VPWR _1681_ sky130_fd_sc_hd__a21o_1
XFILLER_0_9_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2351_ _1611_ _1612_ _1571_ VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__a21oi_1
X_2282_ _1492_ _1495_ _1493_ _1545_ VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__a2bb2o_2
XFILLER_0_19_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1997_ net203 net230 _1232_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__and3_1
XFILLER_0_27_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2549_ _0133_ _0135_ _0131_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__a21o_1
XFILLER_0_42_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3598_ clknet_3_3__leaf_clk _0082_ net181 VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__dfrtp_1
X_2618_ _0208_ _0213_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1920_ _1184_ _1189_ VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__xnor2_1
X_1851_ net193 VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__inv_2
XFILLER_0_21_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3521_ clknet_3_7__leaf_clk _0005_ net187 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__dfrtp_1
X_1782_ net69 net3 net170 VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__mux2_1
X_2403_ net2 _1608_ net3 VGND VGND VPWR VPWR _1664_ sky130_fd_sc_hd__o21ai_1
X_3383_ _1565_ _0949_ _1656_ _1657_ _1612_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__o221ai_1
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3452_ _0632_ _1007_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__xnor2_1
X_2196_ _1315_ _1364_ VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__nor2_1
X_2265_ _1278_ _1488_ VGND VGND VPWR VPWR _1529_ sky130_fd_sc_hd__and2_1
X_2334_ _1538_ _1547_ _1596_ VGND VGND VPWR VPWR _1597_ sky130_fd_sc_hd__a21boi_4
XFILLER_0_1_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold22 net101 VGND VGND VPWR VPWR net273 sky130_fd_sc_hd__dlygate4sd3_1
Xhold11 net149 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_15_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold33 net160 VGND VGND VPWR VPWR net284 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 net145 VGND VGND VPWR VPWR net306 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 net90 VGND VGND VPWR VPWR net295 sky130_fd_sc_hd__dlygate4sd3_1
X_2050_ _1236_ _1122_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__nor2_1
X_2952_ _0538_ _0540_ VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1765_ _1065_ VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__clkbuf_1
X_1903_ _1173_ _1149_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__xnor2_1
X_1834_ net197 _1103_ _1104_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_32_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2883_ _0436_ _0424_ _0473_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__a21oi_2
X_3366_ _1565_ _0935_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__nor2_1
X_3435_ _0382_ _0426_ _0338_ _0987_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__o2bb2a_1
X_3504_ _1712_ net271 _1051_ _1052_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__a22o_1
XFILLER_0_12_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2248_ _1421_ _1474_ _1475_ VGND VGND VPWR VPWR _1513_ sky130_fd_sc_hd__o21a_1
X_2179_ _1354_ _1419_ VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__nor2_1
X_2317_ _1578_ _1579_ VGND VGND VPWR VPWR _1580_ sky130_fd_sc_hd__and2_2
X_3297_ _0876_ _0877_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_35_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput89 net89 VGND VGND VPWR VPWR a[2] sky130_fd_sc_hd__clkbuf_4
Xoutput78 net78 VGND VGND VPWR VPWR a[1] sky130_fd_sc_hd__clkbuf_4
Xoutput67 net67 VGND VGND VPWR VPWR a[0] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_66_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3220_ _0748_ _0781_ _0803_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__a21oi_1
X_2033_ _1300_ _1301_ VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__and2_1
X_2102_ _1367_ _1369_ VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__xor2_2
X_3151_ _0734_ _0735_ VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__nand2_1
X_3082_ _0608_ _0613_ _0668_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_57_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2935_ net14 _0476_ VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2797_ net220 net213 VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__xor2_2
X_2866_ _0399_ _0404_ _0456_ VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__a21boi_2
X_1817_ _1091_ VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3349_ net157 _0922_ net175 VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__mux2_1
X_3418_ _0333_ _0979_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2582_ _0145_ _0146_ _0178_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__a21o_2
X_2651_ _0217_ _0214_ VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__or2b_1
X_2720_ _1687_ _0259_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__and2_1
XFILLER_0_1_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3203_ _0785_ _0786_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__or2_1
X_2016_ _1283_ _1285_ VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__xnor2_4
X_3134_ _0648_ _0619_ _0675_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__o21ai_2
X_3065_ _0491_ _0651_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__xor2_1
XFILLER_0_64_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2918_ _0194_ _0452_ _0507_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__a21oi_2
X_2849_ net220 _0439_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_48_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2634_ _0133_ _0224_ _0225_ _1668_ _0229_ VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__o221a_1
X_2565_ _1589_ _0161_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__xor2_2
XFILLER_0_2_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2703_ net222 net219 VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__xnor2_2
X_2496_ _1716_ _1754_ VGND VGND VPWR VPWR _1756_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3117_ _0701_ _0702_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__xor2_1
X_3048_ _1255_ _0634_ _0635_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_45_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2350_ _1571_ _1611_ _1612_ VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__and3_1
X_2281_ _1405_ _1458_ VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1996_ _1229_ _1228_ _1230_ VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__and3_1
XFILLER_0_51_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2548_ _0127_ _0130_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__nand2_1
X_3597_ clknet_3_6__leaf_clk _0081_ net185 VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__dfrtp_1
X_2617_ _0211_ _0212_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__and2_1
X_2479_ _1729_ _1738_ VGND VGND VPWR VPWR _1739_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_18_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3520_ clknet_3_4__leaf_clk _0004_ net183 VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__dfrtp_1
X_1781_ _1073_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__clkbuf_1
X_1850_ net201 _1120_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_21_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2402_ net2 net3 _1608_ VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__or3_4
X_3382_ _1606_ _1607_ _1610_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__a21boi_1
X_2333_ _1544_ _1546_ VGND VGND VPWR VPWR _1596_ sky130_fd_sc_hd__nand2_1
X_3451_ _0575_ _1004_ _0572_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_24_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2264_ _1117_ _1484_ VGND VGND VPWR VPWR _1528_ sky130_fd_sc_hd__or2_1
X_2195_ _1457_ _1460_ VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__xor2_2
XFILLER_0_1_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1979_ net307 _1249_ VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__xor2_4
XFILLER_0_62_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold23 net99 VGND VGND VPWR VPWR net274 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 net104 VGND VGND VPWR VPWR net285 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_30_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold12 net117 VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 net81 VGND VGND VPWR VPWR net296 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_11_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1902_ _1145_ _1146_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_44_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2951_ net217 _0539_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1764_ net301 net23 net170 VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__mux2_1
X_1833_ net195 net197 VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__or2_1
X_2882_ _0470_ _0472_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3503_ _0886_ _1050_ net166 VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__o21a_1
X_3365_ _0934_ _0935_ net284 _1258_ VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__a2bb2o_1
X_2316_ net192 _1576_ _1577_ VGND VGND VPWR VPWR _1579_ sky130_fd_sc_hd__or3_1
X_3434_ _0283_ _0333_ _0377_ _0427_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__nor4b_1
X_3296_ _0537_ _0856_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__and2_1
X_2247_ _1333_ _1336_ _1382_ VGND VGND VPWR VPWR _1512_ sky130_fd_sc_hd__nand3_2
X_2178_ _1416_ _1418_ VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput68 net68 VGND VGND VPWR VPWR a[10] sky130_fd_sc_hd__clkbuf_4
Xoutput79 net79 VGND VGND VPWR VPWR a[20] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3150_ net215 net211 VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__or2_1
X_2032_ net26 _1261_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__nand2_1
X_2101_ _1314_ _1317_ _1315_ _1368_ VGND VGND VPWR VPWR _1369_ sky130_fd_sc_hd__a2bb2o_1
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3081_ _0607_ _0605_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__and2b_1
XFILLER_0_69_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2934_ net14 _0476_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__or2_4
X_2865_ _0393_ _0398_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__nand2_1
XFILLER_0_17_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2796_ _0339_ _0371_ _0384_ _0294_ _0387_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__o221a_1
XFILLER_0_25_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1816_ net87 net21 net165 VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__mux2_1
X_3348_ _1432_ _0921_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3417_ _0977_ _0978_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__or2_1
X_3279_ _0827_ _0860_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__xor2_1
XFILLER_0_67_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2650_ _0244_ VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__inv_2
X_2581_ _0149_ _0177_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3133_ _0717_ _0718_ VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__nor2_1
X_3202_ _0783_ _0784_ net206 VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__a21oi_1
X_2015_ _1233_ _1241_ _1284_ VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__a21bo_2
XFILLER_0_54_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3064_ net207 net205 VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__or2b_1
XFILLER_0_72_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2848_ net218 net210 VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__xor2_2
XFILLER_0_9_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2917_ net227 net224 _0453_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__and3_1
X_2779_ _0370_ _0371_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2702_ _0107_ _0295_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__xnor2_2
X_2495_ _1716_ _1754_ VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__or2_1
X_2633_ _0228_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__inv_2
X_2564_ net235 _0105_ _0160_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__a21o_1
XFILLER_0_10_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3116_ _0653_ _0658_ _0659_ _0652_ _0650_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__o32a_1
X_3047_ _1255_ net283 VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2280_ _1540_ _1543_ VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__xor2_4
XFILLER_0_19_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1995_ net307 _1249_ _1264_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__a21o_2
XFILLER_0_51_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2616_ net240 _0209_ _0210_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__or3_1
XFILLER_0_30_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2547_ _0142_ _0143_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__and2_2
X_3596_ clknet_3_6__leaf_clk _0080_ net185 VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__dfrtp_1
X_2478_ _1735_ _1737_ VGND VGND VPWR VPWR _1738_ sky130_fd_sc_hd__xor2_4
XFILLER_0_18_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1780_ net68 net2 net170 VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__mux2_1
XFILLER_0_12_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2401_ _1662_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__clkbuf_1
X_3381_ _1705_ _1706_ _1665_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__o21ai_1
X_2332_ _1585_ _1594_ VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__xnor2_4
X_3450_ _1006_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__clkbuf_1
X_2263_ _1512_ _1514_ _1515_ _1511_ VGND VGND VPWR VPWR _1527_ sky130_fd_sc_hd__a211o_1
X_2194_ _1458_ _1459_ net244 VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1978_ _1246_ _1248_ VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__xor2_4
XFILLER_0_30_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3579_ clknet_3_2__leaf_clk _0063_ net178 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__dfrtp_1
Xhold24 net129 VGND VGND VPWR VPWR net275 sky130_fd_sc_hd__dlygate4sd3_1
Xhold13 net134 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 net147 VGND VGND VPWR VPWR net286 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 net144 VGND VGND VPWR VPWR net297 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_61_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1901_ _1168_ _1170_ _1171_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__a21oi_1
X_1832_ net195 net199 VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__xor2_2
XFILLER_0_29_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2881_ _0471_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__inv_2
X_2950_ net215 net205 VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__xor2_1
XFILLER_0_17_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1763_ _1064_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_52_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3433_ _0482_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__inv_2
XFILLER_0_4_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3502_ _0886_ _1050_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__nand2_1
XFILLER_0_57_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3364_ _1567_ _0933_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__nor2_1
X_2246_ _1508_ _1510_ VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__xnor2_2
X_2315_ _1576_ _1577_ net192 VGND VGND VPWR VPWR _1578_ sky130_fd_sc_hd__o21ai_2
X_3295_ _0827_ _0860_ _0858_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__o21ai_2
X_2177_ _1423_ _1425_ _1421_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput69 net69 VGND VGND VPWR VPWR a[11] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2100_ _1236_ _1277_ VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3080_ _0663_ _0666_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__xnor2_1
X_2031_ net12 net1 net23 net26 VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__or4_4
XFILLER_0_57_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2795_ _0370_ VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__inv_2
X_2933_ _0521_ _0488_ _0489_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__nand3b_2
X_1815_ _1090_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__clkbuf_1
X_2864_ _0449_ _0454_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_40_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3416_ _0283_ _0974_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__and2b_1
XFILLER_0_7_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_15_Left_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3347_ _1384_ _0917_ _0920_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__o21ai_2
X_2229_ net243 net239 VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__xor2_4
X_3278_ _0858_ _0859_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__nand2_1
XFILLER_0_48_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2580_ _0102_ _0176_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_38_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3063_ net205 _0649_ _0588_ _0592_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__o22a_1
X_3201_ net206 _0783_ _0784_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__and3_1
X_3132_ _0670_ _0673_ _0716_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__nor3_1
XFILLER_0_70_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2014_ _1239_ _1240_ VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2778_ _0341_ _0342_ _0369_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__and3_1
X_2847_ _0361_ _0418_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__or2b_1
X_2916_ _0503_ _0505_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__xor2_1
XFILLER_0_13_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2632_ _0149_ _0177_ _0227_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__a21o_1
X_2701_ net224 net217 VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__xor2_2
X_2494_ _1719_ _1753_ VGND VGND VPWR VPWR _1754_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_49_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2563_ net233 net224 VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__and2_1
XFILLER_0_4_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3046_ _0632_ _0633_ VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3115_ _0693_ _0700_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__xor2_1
XFILLER_0_45_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_36_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_45_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_18_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_63_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_72_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1994_ _1246_ _1248_ VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3595_ clknet_3_6__leaf_clk _0079_ net185 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__dfrtp_1
X_2615_ _0209_ _0210_ net240 VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_2_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2546_ net5 net255 net6 VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__o21ai_1
X_2477_ _1685_ _1688_ _1686_ _1736_ VGND VGND VPWR VPWR _1737_ sky130_fd_sc_hd__a2bb2o_2
XFILLER_0_2_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3029_ _0614_ _0616_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__xor2_1
XFILLER_0_33_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout250 net34 VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__buf_4
XPHY_EDGE_ROW_3_Left_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2400_ net130 _1661_ net170 VGND VGND VPWR VPWR _1662_ sky130_fd_sc_hd__mux2_1
XFILLER_0_21_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2262_ _1508_ _1510_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__nand2_1
X_3380_ _0933_ _0946_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__or2_1
X_2331_ _1591_ _1593_ VGND VGND VPWR VPWR _1594_ sky130_fd_sc_hd__xor2_4
XFILLER_0_46_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2193_ net245 net241 VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__xor2_4
XFILLER_0_1_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1977_ _1134_ _1136_ _1247_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__a21boi_4
X_2529_ _1722_ _0126_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__xnor2_4
X_3578_ clknet_3_2__leaf_clk _0062_ net178 VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold14 net153 VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 net126 VGND VGND VPWR VPWR net276 sky130_fd_sc_hd__dlygate4sd3_1
Xhold36 net162 VGND VGND VPWR VPWR net287 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 net83 VGND VGND VPWR VPWR net298 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_38_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1900_ _1166_ _1167_ VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__nor2_1
X_1831_ net203 _1101_ VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2880_ _0437_ _0438_ _0469_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__and3_1
X_1762_ net78 net12 net170 VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__mux2_1
X_3363_ _1567_ _0933_ _1255_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__a21o_1
X_3432_ _0991_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_12_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3501_ _0849_ _0867_ _1039_ _1049_ VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__a31o_1
X_2176_ _1441_ VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__inv_2
X_2245_ _1395_ _1472_ _1509_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__a21o_1
X_2314_ net194 net249 _1537_ VGND VGND VPWR VPWR _1577_ sky130_fd_sc_hd__and3_1
X_3294_ _0810_ _0813_ _0843_ _0874_ _0842_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__a311o_1
XFILLER_0_7_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2030_ _1299_ VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__clkbuf_1
X_2932_ _0488_ _0489_ _0521_ VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__a21bo_2
XFILLER_0_40_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2794_ _0226_ _0230_ _0385_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1814_ net86 net20 net165 VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2863_ _0450_ _0453_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_68_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3346_ _1347_ _1383_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__or2_1
X_3415_ _0245_ _0282_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__nor2_1
X_2159_ _1423_ _1425_ VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__xor2_2
X_2228_ net239 VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__inv_2
X_3277_ _0791_ _0833_ _0857_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__nand3_1
XFILLER_0_31_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3200_ net212 net56 VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__nand2_1
XFILLER_0_1_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2013_ _1274_ _1282_ VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__xnor2_4
X_3062_ net210 net207 VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__nand2_1
X_3131_ _0670_ _0673_ _0716_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__o21a_1
XFILLER_0_57_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2915_ _0449_ _0454_ _0504_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__a21boi_2
X_2777_ _0341_ _0342_ _0369_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__a21oi_2
X_2846_ _0417_ _0414_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__or2b_1
X_3329_ net131 _0906_ net176 VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__mux2_1
XFILLER_0_51_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2631_ _0149_ _0177_ _0127_ _0130_ VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__o211a_1
X_2700_ _0280_ _0293_ _0278_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__a21o_1
X_2562_ net241 net238 VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__nand2_1
X_2493_ _1750_ _1752_ VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__xor2_4
XFILLER_0_4_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3045_ _0570_ _0568_ _0569_ _0578_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__a31oi_1
X_3114_ _0694_ _0699_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__xnor2_1
X_2829_ _0316_ _0368_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__or2b_1
XFILLER_0_51_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_7__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_7__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_1993_ _1261_ _1262_ VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__and2_1
XFILLER_0_51_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3594_ clknet_3_7__leaf_clk _0078_ net187 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__dfrtp_1
X_2545_ net5 net6 _1717_ VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__or3_4
X_2614_ net242 net238 _0162_ VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__and3_1
X_2476_ _1588_ _1632_ VGND VGND VPWR VPWR _1736_ sky130_fd_sc_hd__nor2_1
X_3028_ _0553_ _0558_ _0615_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__a21bo_1
Xfanout240 net39 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__clkbuf_4
Xfanout251 net33 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__buf_2
XFILLER_0_56_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2261_ _1524_ _1521_ _1519_ VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__o21a_1
X_2192_ net242 VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__inv_2
X_2330_ _1540_ _1543_ _1541_ _1592_ VGND VGND VPWR VPWR _1593_ sky130_fd_sc_hd__a2bb2o_2
XFILLER_0_1_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1976_ _1115_ _1133_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__nand2_1
X_2528_ _0123_ _0125_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__xor2_4
X_3577_ clknet_3_2__leaf_clk _0061_ net179 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__dfrtp_1
Xhold48 net73 VGND VGND VPWR VPWR net299 sky130_fd_sc_hd__dlygate4sd3_1
X_2459_ _1717_ _1718_ VGND VGND VPWR VPWR _1719_ sky130_fd_sc_hd__and2_2
Xhold15 net146 VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 net111 VGND VGND VPWR VPWR net277 sky130_fd_sc_hd__dlygate4sd3_1
Xhold37 net91 VGND VGND VPWR VPWR net288 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_46_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1761_ _1063_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__clkbuf_1
X_1830_ net193 net202 VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_52_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3500_ _1043_ _1047_ _1048_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__o21a_1
X_3362_ _1520_ _0929_ _0932_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__a21oi_2
X_2313_ _1316_ _1536_ VGND VGND VPWR VPWR _1576_ sky130_fd_sc_hd__and2_1
X_3431_ net140 _0990_ net167 VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__mux2_1
X_2175_ _1439_ _1440_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__and2_1
X_2244_ _1469_ _1471_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3293_ _0864_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__inv_2
X_1959_ net201 net209 VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__or2_1
XFILLER_0_43_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
X_2931_ _0517_ _0520_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__xor2_1
X_2793_ _0291_ _0384_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__or2_1
XFILLER_0_25_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1813_ _1089_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__clkbuf_1
X_2862_ _0194_ _0452_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__xor2_2
XFILLER_0_68_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3345_ _1712_ net281 _0918_ _0919_ VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__a22o_1
X_3414_ _0976_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_40_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3276_ _0791_ _0833_ _0857_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2158_ _1333_ _1336_ _1382_ _1424_ VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__a31o_1
X_2089_ net197 net202 VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__nand2_1
X_2227_ net247 _1491_ VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__xnor2_4
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3130_ _0714_ _0715_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2012_ _1280_ _1281_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__xor2_4
XFILLER_0_54_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3061_ _0614_ _0616_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__and2b_1
XFILLER_0_72_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2845_ _0419_ _0422_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__nand2_1
X_2914_ _0448_ _0444_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__or2b_1
X_2776_ _0316_ _0368_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__xor2_1
X_3328_ _1253_ _0905_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__xor2_1
X_3259_ _0804_ _0808_ _0841_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__nor3_1
XFILLER_0_48_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2630_ _1512_ _1514_ _1515_ _1670_ _0225_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__a2111o_1
X_2492_ _1702_ _1751_ VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__nand2_2
XFILLER_0_42_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2561_ _0155_ _0157_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__xor2_2
X_3113_ _0697_ _0698_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__nor2_1
X_3044_ _0630_ _0631_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__nor2_2
XFILLER_0_60_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2828_ _0367_ _0364_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__or2b_1
XFILLER_0_18_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2759_ net46 _0295_ _0351_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__a21o_1
XFILLER_0_59_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1992_ net12 net1 net23 VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_27_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3593_ clknet_3_6__leaf_clk _0077_ net186 VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__dfrtp_1
X_2544_ _0098_ _0137_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__and2_1
X_2613_ _1589_ _0161_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__and2_1
X_2475_ _1731_ _1734_ VGND VGND VPWR VPWR _1735_ sky130_fd_sc_hd__xor2_4
XFILLER_0_23_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3027_ _0550_ _0552_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__nand2_1
XFILLER_0_18_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout230 net44 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__buf_2
Xfanout241 net242 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__buf_8
XFILLER_0_64_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2260_ _1518_ VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__inv_2
X_2191_ net249 _1456_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__xnor2_2
X_1975_ _1225_ _1245_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_55_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2458_ net4 _1663_ VGND VGND VPWR VPWR _1718_ sky130_fd_sc_hd__nand2_1
X_2527_ _1724_ _1742_ _0124_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__a21oi_2
Xhold38 net116 VGND VGND VPWR VPWR net289 sky130_fd_sc_hd__dlygate4sd3_1
Xhold27 net109 VGND VGND VPWR VPWR net278 sky130_fd_sc_hd__dlygate4sd3_1
X_3576_ clknet_3_2__leaf_clk _0060_ net180 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__dfrtp_1
Xhold16 net154 VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_11_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2389_ _1647_ _1650_ VGND VGND VPWR VPWR _1651_ sky130_fd_sc_hd__and2b_1
Xhold49 net77 VGND VGND VPWR VPWR net300 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_61_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1760_ net67 net1 net170 VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3361_ _1517_ _1482_ VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__and2b_1
X_2312_ _1512_ _1514_ _1515_ _1574_ VGND VGND VPWR VPWR _1575_ sky130_fd_sc_hd__a211oi_2
X_3430_ _0427_ _0989_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__xor2_1
X_3292_ _0825_ _0849_ _0867_ _0871_ _0872_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__o311a_4
XPHY_EDGE_ROW_69_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2174_ net29 _1427_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__nand2_1
X_2243_ _1448_ _1507_ VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__xor2_2
X_1889_ net33 VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__inv_2
X_1958_ net201 net209 VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__nand2_2
XFILLER_0_43_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3559_ clknet_3_5__leaf_clk _0043_ net183 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2930_ _0518_ _0519_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__nand2_1
X_2861_ net222 _0389_ _0451_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__a21o_1
XFILLER_0_40_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3413_ net137 _0975_ net172 VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__mux2_1
X_2792_ _0328_ _0372_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1812_ net85 net19 net167 VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3344_ _1384_ _0917_ _1255_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__a21oi_1
X_2226_ net245 net237 VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__xor2_4
X_3275_ net211 _0855_ _0856_ net56 VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__a22oi_2
X_2157_ _1331_ _1380_ _1381_ VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__a21boi_1
X_2088_ _1354_ _1355_ VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__and2_1
XFILLER_0_48_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3060_ net17 _0627_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__xor2_1
X_2011_ net191 _1122_ _1117_ _1235_ _1238_ VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__o32ai_4
XFILLER_0_54_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2844_ _0238_ _0242_ _0434_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__a21oi_1
X_2913_ _0497_ _0502_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_53_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2775_ _0364_ _0367_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__xnor2_1
X_3327_ net1 _1214_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__nor2_1
X_2209_ _1444_ _1445_ _1473_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__o21ai_1
X_3189_ _0725_ _0727_ _0773_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__a21oi_1
X_3258_ _0839_ _0840_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2491_ _1668_ _1671_ _1704_ VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__a21o_1
X_2560_ _0106_ _0109_ _0107_ _0156_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_65_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3043_ _0629_ _0626_ VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__and2b_1
XFILLER_0_4_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3112_ _0655_ _0696_ _0442_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__a21oi_1
X_2827_ _0361_ _0418_ VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__xnor2_1
X_2758_ net225 net217 VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__and2_1
X_2689_ _0243_ _0283_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__and2_1
XFILLER_0_36_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_32_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1991_ net12 net1 net23 VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__or3_1
X_3592_ clknet_3_6__leaf_clk _0076_ net186 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_41_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2612_ _0205_ _0207_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_27_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2543_ _0139_ _0140_ net270 _1258_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__a2bb2o_1
X_2474_ _1732_ _1733_ net231 VGND VGND VPWR VPWR _1734_ sky130_fd_sc_hd__mux2_2
XPHY_EDGE_ROW_50_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3026_ _0608_ _0613_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_61_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout242 net38 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__clkbuf_4
Xfanout231 net43 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__buf_6
Xfanout220 net49 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__buf_4
XFILLER_0_52_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2190_ net247 net240 VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__xor2_2
X_1974_ _1242_ _1244_ VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__xor2_4
XFILLER_0_55_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3575_ clknet_3_3__leaf_clk _0059_ net180 VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_15_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2457_ net4 _1663_ VGND VGND VPWR VPWR _1717_ sky130_fd_sc_hd__or2_4
Xhold17 net103 VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__dlygate4sd3_1
X_2388_ _1648_ _1602_ _1649_ VGND VGND VPWR VPWR _1650_ sky130_fd_sc_hd__a21oi_1
X_2526_ _1739_ _1741_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__nor2_1
Xhold28 net141 VGND VGND VPWR VPWR net279 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_11_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold39 net151 VGND VGND VPWR VPWR net290 sky130_fd_sc_hd__dlygate4sd3_1
X_3009_ net215 net205 VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__and2_1
XFILLER_0_21_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3360_ _0931_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__clkbuf_1
X_2311_ _1511_ _1559_ VGND VGND VPWR VPWR _1574_ sky130_fd_sc_hd__or2_1
X_2242_ _1504_ _1506_ VGND VGND VPWR VPWR _1507_ sky130_fd_sc_hd__xnor2_2
X_3291_ _0847_ _0867_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__or2_1
X_2173_ net29 _1427_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__or2_4
X_1957_ net201 _1120_ _1227_ VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__a21o_2
XFILLER_0_7_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1888_ net60 net229 net251 VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__o21a_1
X_3558_ clknet_3_5__leaf_clk _0042_ net184 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__dfrtp_1
X_2509_ net226 VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__inv_2
XFILLER_0_11_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3489_ _0849_ _1039_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__nand2_1
XFILLER_0_22_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2791_ _0382_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__inv_2
X_2860_ net220 net213 VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__and2_1
X_1811_ _1088_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_68_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3412_ _0283_ _0974_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__xnor2_1
X_3343_ _1384_ _0917_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__or2_1
X_2225_ _1486_ _1489_ VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__xnor2_4
X_3274_ net206 _0784_ _0695_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__a21bo_1
X_2156_ _1421_ _1422_ VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__and2_2
X_2087_ net202 _1352_ _1353_ VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__or3_1
XFILLER_0_48_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_31_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2989_ _0531_ _0532_ _0576_ VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__o21a_1
XFILLER_0_16_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2010_ _1276_ _1279_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__xor2_4
X_2912_ _0498_ _0501_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_45_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2843_ _0427_ _0433_ _0377_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__or3b_1
X_2774_ _0365_ _0318_ _0366_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_5_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3326_ _0904_ VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_0_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2208_ _1444_ _1445_ _1473_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__nor3_1
X_2139_ net247 net243 VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__xor2_4
X_3188_ _0689_ _0722_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__and2b_1
X_3257_ _0798_ _0838_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__and2_1
XFILLER_0_8_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2490_ _1747_ _1749_ VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_10_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3042_ _0626_ _0629_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__and2b_1
XFILLER_0_4_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3111_ _0442_ _0655_ _0696_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__and3_1
X_2688_ _0245_ _0282_ VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__xnor2_2
X_2826_ _0414_ _0417_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__xnor2_1
X_2757_ net234 net228 VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3309_ net56 _0696_ _0876_ _0877_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_68_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1990_ _1215_ _1253_ _1259_ VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__a21o_1
XFILLER_0_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3591_ clknet_3_5__leaf_clk _0075_ net184 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__dfrtp_1
X_2542_ _0097_ _1756_ _0138_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__o21a_1
XFILLER_0_42_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2611_ _0158_ _0163_ _0206_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__a21boi_2
X_2473_ net233 net227 VGND VGND VPWR VPWR _1733_ sky130_fd_sc_hd__xor2_2
X_3025_ _0611_ _0612_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__and2_1
XFILLER_0_65_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2809_ net222 net214 VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__and2_1
Xfanout243 net244 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__buf_8
Xfanout232 net43 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__clkbuf_2
Xfanout210 net54 VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__buf_4
Xfanout221 net49 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_49_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1973_ _1126_ _1132_ _1243_ VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__a21boi_4
XPHY_EDGE_ROW_23_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2525_ _0104_ _0122_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__xnor2_4
X_3574_ clknet_3_3__leaf_clk _0058_ net180 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_23_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2456_ _1617_ _1658_ _1708_ _1713_ _1715_ VGND VGND VPWR VPWR _1716_ sky130_fd_sc_hd__a311o_1
Xhold18 net133 VGND VGND VPWR VPWR net269 sky130_fd_sc_hd__dlygate4sd3_1
X_2387_ _1599_ _1601_ VGND VGND VPWR VPWR _1649_ sky130_fd_sc_hd__nor2_1
Xhold29 net105 VGND VGND VPWR VPWR net280 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_19_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3008_ _0593_ _0595_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_46_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2172_ _1384_ _1386_ _1437_ VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__a21o_1
XFILLER_0_57_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2241_ _1450_ _1468_ _1505_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__a21oi_2
X_2310_ _1556_ _1558_ _1572_ VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__a21o_2
X_3290_ _0854_ _0866_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__nand2_1
X_1887_ _1138_ _1154_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__xnor2_1
X_1956_ net191 net200 VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__and2_1
XFILLER_0_43_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3557_ clknet_3_5__leaf_clk _0041_ net183 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__dfrtp_1
X_3488_ _1017_ _1034_ _1038_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__a21o_1
X_2508_ net235 _0105_ VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_11_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2439_ _1697_ _1699_ VGND VGND VPWR VPWR _1700_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_34_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2790_ net11 _0336_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__xor2_2
XFILLER_0_25_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1810_ net84 net18 net165 VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__mux2_1
XFILLER_0_68_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3342_ _1340_ _0913_ _0916_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__a21boi_2
X_3411_ _0933_ _0946_ _0969_ _0973_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__o31ai_4
XFILLER_0_40_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2155_ _1391_ _1392_ _1420_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__or3_1
X_2224_ _1278_ _1488_ VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__xor2_4
X_3273_ _0589_ _0784_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__nand2_1
X_2086_ _1352_ _1353_ net202 VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__o21ai_2
X_1939_ net229 net251 _1205_ _1206_ _1209_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__a41o_1
X_2988_ _0531_ _0532_ _0576_ net168 VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__o31ai_1
X_3609_ clknet_3_1__leaf_clk _0093_ net179 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_10_Left_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_66_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2911_ _0250_ _0500_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__xor2_1
XFILLER_0_60_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2842_ _0283_ _0333_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__nand2_1
X_2773_ _0310_ _0312_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3325_ net123 _0903_ net165 VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__mux2_4
X_3256_ _0798_ _0838_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__nor2_1
X_2069_ _1302_ _1337_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__or2_1
X_2207_ _1395_ _1472_ VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__xor2_1
X_2138_ net244 VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__inv_2
XFILLER_0_28_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3187_ _0770_ _0771_ VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__and2b_1
XFILLER_0_21_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3110_ _0690_ _0695_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__and2_1
X_3041_ _0627_ _0628_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__and2_1
XFILLER_0_45_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2825_ _0415_ _0363_ _0416_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_18_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2687_ _0279_ _0281_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__xnor2_2
X_2756_ _0347_ _0348_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__xor2_2
XFILLER_0_5_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3239_ _0682_ _0725_ _0770_ _0773_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__a211o_1
X_3308_ _0888_ VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_10_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3590_ clknet_3_5__leaf_clk _0074_ net183 VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__dfrtp_1
X_2541_ _0097_ _1756_ _0138_ net173 VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__o31ai_1
X_2610_ _0155_ _0157_ VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2472_ net227 VGND VGND VPWR VPWR _1732_ sky130_fd_sc_hd__inv_2
X_3024_ net223 _0609_ _0610_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__or3_1
X_2808_ net232 net226 VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__nand2_1
Xfanout200 net60 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__buf_6
XFILLER_0_41_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2739_ _0290_ _0332_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__xor2_4
Xfanout222 net48 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__buf_6
Xfanout211 net54 VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__clkbuf_2
Xfanout244 net37 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__clkbuf_4
Xfanout233 net42 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__buf_6
XFILLER_0_5_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_62_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1972_ _1119_ _1125_ VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__nand2_1
XFILLER_0_55_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2455_ _1614_ _1656_ _1659_ _1708_ _1714_ VGND VGND VPWR VPWR _1715_ sky130_fd_sc_hd__o311a_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3573_ clknet_3_6__leaf_clk _0057_ net186 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__dfrtp_1
X_2524_ _0119_ _0121_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_11_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold19 net102 VGND VGND VPWR VPWR net270 sky130_fd_sc_hd__dlygate4sd3_1
X_2386_ _1531_ VGND VGND VPWR VPWR _1648_ sky130_fd_sc_hd__inv_2
XFILLER_0_46_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3007_ net207 _0536_ _0594_ _0540_ VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__o22a_1
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_29_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2171_ _1346_ _1383_ _1429_ _1426_ VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__a22o_1
X_2240_ _1465_ _1467_ VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__nor2_1
XFILLER_0_20_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_38_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1886_ _1137_ _1156_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__xor2_1
X_1955_ net203 net230 VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__nand2_2
XFILLER_0_43_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3556_ clknet_3_5__leaf_clk _0040_ net183 VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_47_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2438_ _1624_ _1642_ _1698_ VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__a21oi_2
X_3487_ _1035_ _1036_ _1037_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__o21ai_1
X_2507_ net233 net224 VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__xor2_4
XFILLER_0_3_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2369_ net241 _1630_ VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_2_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_57_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3341_ _1337_ _1302_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__or2b_1
X_3410_ _0970_ _0971_ _0969_ _0952_ _0972_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__o221a_1
X_3272_ _0852_ _0853_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__and2_4
X_2085_ net199 net203 _1311_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__and3_1
X_2154_ _1391_ _1392_ _1420_ VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__o21ai_1
X_2223_ net249 _1456_ _1487_ VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__a21o_2
XFILLER_0_56_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2987_ _0572_ _0575_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1869_ net198 net209 VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__xor2_1
X_1938_ _1098_ _1130_ _1197_ _1208_ VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__and4_1
XFILLER_0_3_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3608_ clknet_3_2__leaf_clk _0092_ net179 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__dfrtp_1
X_3539_ clknet_3_0__leaf_clk _0023_ net182 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_13_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2841_ _0376_ _0427_ _0431_ _0383_ _0426_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__o32ai_2
X_2910_ net221 _0439_ _0499_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__a21oi_1
X_2772_ _0310_ _0312_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__nand2_1
X_2206_ _1469_ _1471_ VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__xor2_1
X_3324_ _0900_ _0902_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__xor2_1
X_3255_ _0836_ _0837_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__or2_1
X_2068_ _1333_ _1336_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__xor2_2
X_2137_ net191 _1403_ VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__xnor2_2
X_3186_ _0730_ _0769_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3040_ net15 _0524_ net16 VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_26_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2824_ _0355_ _0357_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__nor2_1
XFILLER_0_41_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2686_ _0223_ _0231_ _0280_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__o21a_1
X_2755_ net219 _0301_ _0296_ _0298_ VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_39_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3238_ _0726_ _0725_ _0772_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__and3_1
X_3307_ net120 _0887_ net165 VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__mux2_1
X_3169_ _0752_ _0753_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2540_ _0099_ _0137_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__xnor2_4
X_2471_ net237 _1730_ VGND VGND VPWR VPWR _1731_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_23_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3023_ _0609_ _0610_ net223 VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_58_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2738_ _0330_ _0331_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__nor2_2
X_2807_ _0393_ _0398_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__xor2_2
XFILLER_0_14_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout201 net59 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__buf_4
Xfanout245 net246 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__buf_8
Xfanout234 net42 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__clkbuf_2
X_2669_ _0199_ _0204_ _0263_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__a21boi_2
Xfanout212 net213 VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__buf_2
Xfanout223 net48 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_37_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3572_ clknet_3_7__leaf_clk _0056_ net188 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__dfrtp_1
X_1971_ _1233_ _1241_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_55_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2454_ _1654_ _1655_ _1618_ VGND VGND VPWR VPWR _1714_ sky130_fd_sc_hd__a21o_1
X_2385_ _1578_ _1646_ VGND VGND VPWR VPWR _1647_ sky130_fd_sc_hd__xor2_1
X_2523_ _1729_ _1738_ _0120_ VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__a21boi_4
XFILLER_0_11_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput1 alpha[0] VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__buf_6
X_3006_ net212 net210 _0537_ VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_14_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2170_ _1429_ _1426_ VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__or2_1
X_1954_ _1223_ _1224_ VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__and2_2
XFILLER_0_7_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1885_ _1138_ _1154_ _1155_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__a21oi_1
X_3555_ clknet_3_6__leaf_clk _0039_ net185 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__dfrtp_1
X_2506_ _0102_ _0103_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__nand2_2
X_2437_ _1639_ _1641_ VGND VGND VPWR VPWR _1698_ sky130_fd_sc_hd__nor2_1
X_2368_ net239 net231 VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__xor2_4
X_3486_ _0780_ _0815_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_198 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2299_ net30 _1439_ net31 VGND VGND VPWR VPWR _1563_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_2_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3340_ net175 _0914_ _0915_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__a21oi_1
X_2222_ net247 net240 VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__and2_1
X_3271_ net21 _0778_ net22 VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__o21ai_1
X_2084_ _1098_ _1310_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__nor2_1
X_2153_ _1354_ _1419_ VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__xor2_1
XFILLER_0_17_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1937_ net230 net251 _1207_ VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__a21oi_1
X_2986_ _0570_ _0573_ _0574_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__or3_2
X_1868_ net201 net204 VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3607_ clknet_3_3__leaf_clk _0091_ net181 VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_3_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1799_ _1082_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__clkbuf_1
X_3538_ clknet_3_0__leaf_clk _0022_ net182 VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_58_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3469_ _0725_ _1022_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_66_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2840_ _0287_ _0333_ _0375_ _0378_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__a211oi_2
X_2771_ _0358_ _0363_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2205_ _1397_ _1415_ _1470_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__a21oi_1
X_3185_ _0730_ _0769_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__nor2_1
X_3323_ net206 _0901_ VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_0_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3254_ _0794_ _0801_ _0835_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__and3_1
X_2067_ _1218_ _1251_ _1292_ _1334_ _1335_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__a311o_4
X_2136_ net249 net242 VGND VGND VPWR VPWR _1403_ sky130_fd_sc_hd__xor2_2
XFILLER_0_48_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2969_ _0556_ _0557_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__and2_1
XFILLER_0_12_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2823_ _0355_ _0357_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2754_ _0344_ _0346_ VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__xnor2_2
X_2685_ _0219_ _0222_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__nand2_1
X_3306_ _0873_ _0886_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__xor2_1
X_2119_ _1384_ _1386_ VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__or2_1
X_3237_ net167 net263 _0819_ _0820_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__o22a_1
X_3168_ net217 _0697_ _0751_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__or3_1
XFILLER_0_64_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3099_ net114 _0685_ net174 VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__mux2_1
XFILLER_0_32_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2470_ net235 net226 VGND VGND VPWR VPWR _1730_ sky130_fd_sc_hd__xor2_4
XFILLER_0_2_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3022_ net225 net221 _0548_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__and3_1
X_2737_ _0329_ _0292_ _0294_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__and3_1
XFILLER_0_33_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2668_ _0196_ _0198_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__nand2_1
X_2806_ net216 _0394_ _0344_ _0397_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__o22ai_4
Xfanout202 net59 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__clkbuf_4
Xfanout246 net36 VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__buf_4
Xfanout235 net41 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__buf_8
Xfanout213 net53 VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__clkbuf_8
Xfanout224 net225 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__buf_6
X_2599_ _0193_ _0194_ net224 VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__mux2_1
XFILLER_0_9_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1970_ _1239_ _1240_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__xor2_4
XFILLER_0_55_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2522_ _1735_ _1737_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3571_ clknet_3_1__leaf_clk _0055_ net180 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__dfrtp_1
X_2453_ _1665_ _1707_ VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__and2_1
X_2384_ _1643_ _1645_ VGND VGND VPWR VPWR _1646_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput2 alpha[10] VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__clkbuf_2
X_3005_ _0588_ _0592_ VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_61_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1884_ _1151_ _1153_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__and2_1
X_1953_ net230 _1221_ _1222_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__or3_1
XFILLER_0_22_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3554_ clknet_3_5__leaf_clk _0038_ net189 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_43_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2505_ net243 _0100_ _0101_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__or3_1
X_3485_ _0724_ _0817_ _1025_ _1031_ VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__a31oi_1
XFILLER_0_3_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2298_ net30 net31 _1439_ VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__or3_4
X_2436_ _1678_ _1696_ VGND VGND VPWR VPWR _1697_ sky130_fd_sc_hd__xnor2_2
X_2367_ _1625_ _1628_ VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2152_ _1416_ _1418_ VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__xnor2_1
X_2221_ net192 net195 VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__nand2_2
X_3270_ net21 net22 _0778_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__or3_4
X_2083_ _1127_ _1306_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__or2_1
X_1867_ net198 net209 net229 VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__o21a_1
X_1936_ net230 net251 net196 VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__o21ai_1
X_2985_ _0533_ _0522_ _0567_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__and3_1
Xinput60 beta[5] VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__buf_1
X_3606_ clknet_3_3__leaf_clk _0090_ net181 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__dfrtp_1
X_3468_ _1021_ _1019_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__or2_1
XFILLER_0_24_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3537_ clknet_3_0__leaf_clk _0021_ net182 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__dfrtp_1
X_1798_ net300 net11 net169 VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__mux2_1
X_3399_ _0186_ _0239_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__nand2_1
X_2419_ net239 net231 VGND VGND VPWR VPWR _1680_ sky130_fd_sc_hd__and2_1
XFILLER_0_30_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2770_ _0361_ _0362_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__and2_1
XFILLER_0_13_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3322_ net25 _0882_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__and2b_1
X_2204_ _1412_ _1414_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__nor2_1
X_2135_ _1398_ _1401_ VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__xnor2_1
X_3184_ _0767_ _0768_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__nand2_1
X_3253_ _0794_ _0801_ _0835_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__a21oi_1
X_2066_ _1265_ _1291_ VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__and2_1
XFILLER_0_63_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1919_ _1184_ _1189_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__nand2_1
X_2899_ _0436_ _0470_ _0471_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__a21o_1
XFILLER_0_8_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2968_ net225 _0554_ _0555_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__or3_1
XFILLER_0_54_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2684_ _0277_ _0278_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__nor2_1
X_2822_ _0408_ _0413_ VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__xnor2_1
X_2753_ net216 _0345_ net218 VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__mux2_1
X_3305_ _0884_ _0885_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__nor2_2
X_2118_ _1341_ _1338_ _1342_ _1385_ VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__a31o_1
XFILLER_0_55_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2049_ _1314_ _1317_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__xor2_1
XFILLER_0_49_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3098_ _0646_ _0684_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__xnor2_1
X_3236_ net252 _0818_ _1389_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__a21o_1
X_3167_ _0697_ _0751_ net217 VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_17_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3021_ _0297_ _0547_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__nor2_1
X_2805_ _0395_ _0396_ _0394_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_67_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2736_ _0292_ _0294_ _0329_ VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__a21oi_2
X_2667_ _0256_ _0261_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__xnor2_2
Xfanout203 net204 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__buf_4
Xfanout247 net248 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__buf_8
Xfanout236 net41 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout214 net52 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__buf_4
Xfanout225 net47 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__clkbuf_4
X_3219_ _0801_ _0802_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__nand2_1
X_2598_ net226 net222 VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__xor2_2
XFILLER_0_64_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_17_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2521_ _0113_ _0118_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__xnor2_4
X_3570_ clknet_3_1__leaf_clk _0054_ net180 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_11_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2383_ _1580_ _1598_ _1644_ VGND VGND VPWR VPWR _1645_ sky130_fd_sc_hd__a21oi_1
X_2452_ _1389_ VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput3 alpha[11] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3004_ _0589_ _0590_ _0591_ VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_46_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2719_ _0310_ _0312_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_10_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_2_Left_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1883_ _1151_ _1153_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__xor2_1
X_1952_ _1221_ _1222_ net230 VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_22_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3553_ clknet_3_7__leaf_clk _0037_ net187 VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_51_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2504_ _0100_ _0101_ net243 VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__o21ai_4
X_2435_ _1693_ _1695_ VGND VGND VPWR VPWR _1696_ sky130_fd_sc_hd__xor2_4
X_3484_ _0780_ _0815_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2297_ _1526_ _1527_ _1559_ VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__nand3_2
X_2366_ _1406_ _1627_ VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__xor2_4
XFILLER_0_59_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2082_ _1268_ _1329_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__nor2_1
X_2151_ _1356_ _1374_ _1417_ VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__a21oi_1
X_2220_ net195 _1484_ VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__xnor2_2
X_2984_ _0533_ _0522_ _0567_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_8_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput61 beta[6] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__buf_1
X_1866_ _1134_ _1136_ VGND VGND VPWR VPWR _1137_ sky130_fd_sc_hd__xnor2_1
X_1935_ net202 net204 VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3605_ clknet_3_3__leaf_clk _0089_ net181 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_31_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput50 beta[25] VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__buf_1
X_1797_ _1081_ VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_16_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3398_ _0962_ VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__clkbuf_1
X_2418_ net248 net243 VGND VGND VPWR VPWR _1679_ sky130_fd_sc_hd__nand2_2
X_3467_ _1020_ _0681_ VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3536_ clknet_3_0__leaf_clk _0020_ net182 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__dfrtp_1
X_2349_ _1610_ _1606_ _1607_ VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__nand3b_2
XFILLER_0_66_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3252_ _0833_ _0834_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__nand2_1
X_3321_ _0873_ _0886_ _0892_ _0898_ _0899_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__o311a_4
X_2065_ _1265_ _1291_ _1293_ _1250_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__o211a_1
X_2134_ _1123_ _1400_ VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__xor2_1
X_2203_ _1450_ _1468_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__xnor2_1
X_3183_ _0717_ _0732_ _0766_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__or3_2
XFILLER_0_60_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2967_ _0554_ _0555_ net225 VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__o21ai_2
X_1918_ net208 _1127_ net229 _1188_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__a31o_1
X_1849_ net191 net200 VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__xor2_4
XFILLER_0_44_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2898_ _0386_ _0388_ _0487_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__a21o_1
X_3519_ clknet_3_4__leaf_clk _0003_ net183 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_50_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2821_ _0411_ _0412_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__and2_1
XFILLER_0_53_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2683_ _0246_ _0247_ _0276_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__and3_1
XFILLER_0_26_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2752_ net221 net216 VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__xnor2_1
X_3235_ net252 _0818_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__nor2_1
X_3304_ _0883_ _0879_ _0880_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__and3_1
X_2117_ _1302_ _1337_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__and2_1
X_2048_ _1315_ _1316_ net250 VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__mux2_1
X_3097_ _0682_ _0683_ VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__or2_2
X_3166_ net50 net215 _0699_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__and3_1
XFILLER_0_12_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3020_ _0605_ _0607_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2804_ net218 net216 VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__nand2_1
XFILLER_0_14_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout204 net58 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__buf_4
X_2735_ _0328_ VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__inv_2
X_2666_ _0257_ _0260_ VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__xnor2_2
X_2597_ net222 VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__inv_2
Xfanout248 net35 VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__buf_4
Xfanout237 net40 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__buf_8
Xfanout226 net46 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__buf_6
X_3149_ net215 net211 VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__nand2_1
Xfanout215 net52 VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__buf_2
X_3218_ _0796_ _0800_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__or2_1
XFILLER_0_49_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2451_ _1711_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__clkbuf_1
X_2520_ _0114_ _0117_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__xnor2_4
Xinput4 alpha[12] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_1
X_2382_ _1595_ _1597_ VGND VGND VPWR VPWR _1644_ sky130_fd_sc_hd__nor2_1
X_3003_ net210 net205 VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__and2_1
XFILLER_0_46_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2718_ _0256_ _0261_ _0311_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_14_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2649_ net8 _0187_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__xor2_1
XFILLER_0_52_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1882_ _1152_ _1113_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__xnor2_1
X_1951_ net208 net33 _1131_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__and3_1
X_3552_ clknet_3_7__leaf_clk _0036_ net187 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_3_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2503_ net246 net241 _1728_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__and3_1
X_2434_ _1629_ _1638_ _1694_ VGND VGND VPWR VPWR _1695_ sky130_fd_sc_hd__a21oi_4
X_2365_ net243 _1586_ _1626_ VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__a21o_2
X_3483_ _0725_ _0816_ _0817_ _0684_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_11_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2296_ _1526_ _1527_ _1559_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput160 net160 VGND VGND VPWR VPWR c[7] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_33_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2081_ _1326_ _1328_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__nor2_1
X_2150_ _1371_ _1373_ VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__and2b_1
XFILLER_0_17_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1934_ _1097_ _1099_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__and2_1
X_2983_ _0568_ _0569_ _0571_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__a21o_1
Xinput62 beta[7] VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__buf_1
X_1865_ net251 _1135_ _1108_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__a21o_1
Xinput40 beta[16] VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__dlymetal6s2s_1
X_3604_ clknet_3_3__leaf_clk _0088_ net181 VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_3_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1796_ net76 net10 net169 VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__mux2_1
Xinput51 beta[26] VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__clkbuf_1
X_3535_ clknet_3_0__leaf_clk _0019_ net182 VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__dfrtp_1
X_3397_ net135 _0961_ net174 VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__mux2_1
X_2348_ _1606_ _1607_ _1610_ VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2417_ _1676_ _1677_ VGND VGND VPWR VPWR _1678_ sky130_fd_sc_hd__and2_2
X_3466_ _0647_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__inv_2
X_2279_ _1541_ _1542_ net239 VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__mux2_2
XFILLER_0_62_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_35_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_44_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2202_ _1465_ _1467_ VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__xor2_2
XFILLER_0_28_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3182_ _0717_ _0732_ _0766_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3251_ _0829_ _0832_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__or2_1
X_3320_ _0890_ _0891_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__nand2_1
X_2064_ _1331_ _1332_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__and2_2
X_2133_ net193 _1362_ _1399_ VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_53_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1917_ _1185_ _1186_ _1187_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__and3_1
XPHY_EDGE_ROW_62_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2897_ _0423_ _0470_ _0472_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__nand3_1
XFILLER_0_8_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2966_ _0498_ _0501_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__and2_1
XFILLER_0_71_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1779_ _1072_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__clkbuf_1
X_3518_ clknet_3_4__leaf_clk _0002_ net183 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__dfrtp_1
X_1848_ _1102_ _1104_ _1116_ _1118_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__a31o_2
XPHY_EDGE_ROW_71_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3449_ net297 _1005_ net169 VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__mux2_1
XFILLER_0_62_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2820_ net232 _0409_ _0410_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__or3_1
X_2751_ net224 _0343_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__xnor2_4
X_2682_ _0246_ _0247_ _0276_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3234_ _0817_ _0774_ _0770_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__o21ba_1
X_3303_ _0879_ _0880_ _0883_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__a21oi_1
X_3165_ _0748_ _0749_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__nand2_1
XFILLER_0_71_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2116_ _1347_ _1383_ VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__xnor2_2
X_2047_ net192 net247 VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__xor2_4
X_3096_ _0647_ _0681_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2949_ _0536_ _0537_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_17_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2734_ _0324_ _0327_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_26_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2803_ net218 net216 VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout238 net40 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__clkbuf_2
X_2665_ _1687_ _0259_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__xor2_2
Xfanout227 net228 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__clkbuf_8
Xfanout205 net206 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__buf_2
Xfanout216 net217 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__buf_4
X_2596_ net231 _0191_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_66_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout249 net250 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__buf_6
XFILLER_0_5_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3148_ net217 net212 VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__and2_1
X_3217_ _0796_ _0800_ VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3079_ _0664_ _0665_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__and2_1
XFILLER_0_32_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2450_ net100 _1710_ net171 VGND VGND VPWR VPWR _1711_ sky130_fd_sc_hd__mux2_1
X_2381_ _1624_ _1642_ VGND VGND VPWR VPWR _1643_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_23_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput5 alpha[13] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__clkbuf_2
X_3002_ net207 net205 net210 VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_72_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2717_ _0253_ _0255_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2648_ _0238_ _0242_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__nand2_1
X_2579_ _0173_ _0175_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_69_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1950_ _1129_ _1130_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__nor2_1
XFILLER_0_22_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3551_ clknet_3_7__leaf_clk _0035_ net188 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__dfrtp_1
X_1881_ _1100_ _1106_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__xnor2_1
X_2502_ _1494_ _1727_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__and2_1
XFILLER_0_22_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2433_ _1635_ _1637_ VGND VGND VPWR VPWR _1694_ sky130_fd_sc_hd__and2_1
X_2364_ net241 net233 VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__and2_1
X_3482_ net168 net262 _1032_ _1033_ VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__o22a_1
X_2295_ _1556_ _1558_ VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_47_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput161 net161 VGND VGND VPWR VPWR c[8] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_42_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput150 net150 VGND VGND VPWR VPWR c[27] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2080_ _1333_ _1336_ _1331_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__a21boi_4
XFILLER_0_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1933_ _1194_ _1195_ _1203_ VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_33_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2982_ _0570_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__inv_2
Xinput30 alpha[7] VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__clkbuf_2
X_1864_ net196 net204 VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__nand2_1
Xinput63 beta[8] VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__buf_1
Xinput41 beta[17] VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__buf_1
X_3534_ clknet_3_3__leaf_clk _0018_ net185 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__dfrtp_1
X_1795_ _1080_ VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__clkbuf_1
X_3465_ _1018_ _1019_ net266 _1712_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_3_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3603_ clknet_3_0__leaf_clk _0087_ net179 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__dfrtp_1
Xinput52 beta[27] VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__buf_1
X_2347_ _1608_ _1609_ VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__and2_1
X_3396_ _0183_ _0960_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__xnor2_1
X_2416_ net247 _1674_ _1675_ VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__or3_1
XFILLER_0_35_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2278_ net241 net237 VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__xor2_4
XFILLER_0_30_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2132_ net191 net244 VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__and2_1
X_2201_ _1402_ _1411_ _1466_ VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__a21boi_2
X_3250_ _0829_ _0832_ VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__nand2_1
X_3181_ _0764_ _0765_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__and2_1
X_2063_ _1303_ _1304_ _1330_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__or3_1
X_1916_ net204 _1130_ net208 VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__mux2_1
X_1847_ _1117_ net197 net199 VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__and3_1
XFILLER_0_56_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2896_ _0478_ _0474_ _0475_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__nor3_1
X_2965_ _0250_ _0500_ VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__nor2_1
X_1778_ net98 net32 net170 VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__mux2_1
XFILLER_0_69_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3517_ clknet_3_4__leaf_clk _0001_ net183 VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__dfrtp_1
X_3448_ _0576_ _1004_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3379_ _1567_ _1616_ _1658_ _1708_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__or4_2
XFILLER_0_35_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2681_ _0211_ _0275_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__xor2_1
X_2750_ net222 net214 VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__xor2_4
XFILLER_0_41_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3302_ _0881_ _0882_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__nand2_1
X_2115_ _1348_ _1382_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_55_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3095_ _0647_ _0681_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__and2_1
X_3233_ _0730_ _0769_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__xnor2_2
X_3164_ _0745_ _0747_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__nand2_1
X_2046_ net248 VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__inv_2
XFILLER_0_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2879_ _0437_ _0438_ _0469_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__a21o_1
X_2948_ net210 net207 VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__xor2_2
XFILLER_0_17_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2733_ _0325_ _0326_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__nand2_1
X_2802_ net220 net218 VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__nand2_1
X_2664_ net231 _0191_ _0258_ VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__a21o_1
Xfanout239 net240 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__buf_8
Xfanout228 net45 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__buf_4
XFILLER_0_5_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout217 net51 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__clkbuf_4
Xfanout206 net57 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__clkbuf_4
X_2595_ net228 net220 VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__xor2_2
X_3147_ _0679_ _0624_ _0720_ _0677_ _0731_ VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__a311oi_4
X_3216_ _0798_ _0799_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__and2_1
X_3078_ net221 _0599_ _0603_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__or3_1
X_2029_ net110 _1298_ net176 VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__mux2_1
XFILLER_0_64_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2380_ _1639_ _1641_ VGND VGND VPWR VPWR _1642_ sky130_fd_sc_hd__xor2_2
Xinput6 alpha[14] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_1
X_3001_ net207 net205 VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__or2_1
XFILLER_0_46_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2647_ _0239_ _0236_ _0240_ _0190_ _0241_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__a32oi_4
X_2716_ _0304_ _0309_ VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_14_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2578_ _0104_ _0122_ _0174_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__o21a_1
XFILLER_0_10_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_9_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1880_ _1147_ _1149_ _1150_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3550_ clknet_3_7__leaf_clk _0034_ net189 VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__dfrtp_1
X_2501_ _0098_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__inv_2
X_3481_ net252 _1027_ _1031_ net168 VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_24_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2294_ _1448_ _1507_ _1557_ VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__o21ai_2
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2363_ net249 net245 VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__nand2_2
X_2432_ _1683_ _1692_ VGND VGND VPWR VPWR _1693_ sky130_fd_sc_hd__xnor2_4
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput162 net162 VGND VGND VPWR VPWR c[9] sky130_fd_sc_hd__clkbuf_4
Xoutput140 net140 VGND VGND VPWR VPWR c[18] sky130_fd_sc_hd__clkbuf_4
Xoutput151 net151 VGND VGND VPWR VPWR c[28] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_69_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_6_Left_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput31 alpha[8] VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__buf_1
X_1932_ _1193_ _1201_ _1202_ _1192_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__or4b_1
XFILLER_0_68_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1863_ _1115_ _1133_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__xor2_2
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2981_ net15 _0524_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__xor2_2
X_3602_ clknet_3_0__leaf_clk _0086_ net182 VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__dfrtp_1
Xinput20 alpha[27] VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__buf_1
XFILLER_0_16_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput64 beta[9] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__buf_1
X_3533_ clknet_3_6__leaf_clk _0017_ net185 VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__dfrtp_1
X_2415_ _1674_ _1675_ net247 VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__o21ai_4
X_1794_ net292 net9 net172 VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__mux2_1
Xinput42 beta[18] VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__buf_1
X_3464_ _0684_ _1017_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput53 beta[28] VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__dlymetal6s2s_1
X_2346_ net32 _1562_ VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3395_ _0954_ _0958_ _0959_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__o21a_1
X_2277_ net237 VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__inv_2
XFILLER_0_28_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2062_ _1303_ _1304_ _1330_ VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__o21ai_1
X_2131_ net195 net199 VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__nand2_1
X_2200_ _1408_ _1410_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__nand2_1
XFILLER_0_28_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3180_ _0711_ _0714_ _0763_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__or3_1
X_2964_ _0550_ _0552_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__xor2_1
X_1777_ _1071_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__clkbuf_1
X_1915_ net202 net251 VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__or2_1
X_1846_ net195 VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__inv_2
XFILLER_0_44_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2895_ _1712_ net278 _0483_ _0485_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__a22o_1
XFILLER_0_29_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3516_ clknet_3_7__leaf_clk _0000_ net187 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_69_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3378_ _0945_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__clkbuf_1
X_3447_ _1003_ _1000_ _0527_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2329_ _1458_ _1493_ VGND VGND VPWR VPWR _1592_ sky130_fd_sc_hd__nor2_1
XFILLER_0_62_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_9_Left_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2680_ _0271_ _0274_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_26_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3232_ _0780_ _0815_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__xnor2_4
X_3301_ net24 _0852_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__or2_4
XFILLER_0_1_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2114_ _1380_ _1381_ VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__and2_2
X_2045_ net196 _1313_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__xnor2_1
X_3094_ _0678_ _0680_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__xor2_2
X_3163_ _0745_ _0747_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__or2_1
X_2947_ net212 net210 VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__nand2_1
XFILLER_0_17_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1829_ _1095_ net199 net201 _1097_ _1099_ VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__a32o_1
XFILLER_0_32_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2878_ _0411_ _0468_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__xor2_1
XFILLER_0_31_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2801_ _0390_ _0392_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__xnor2_2
X_2594_ _0189_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__buf_2
XFILLER_0_41_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2732_ _0211_ _0275_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__or2b_1
X_2663_ net228 net220 VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__and2_1
Xfanout229 net44 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__buf_4
Xfanout207 net56 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout218 net219 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__clkbuf_8
X_3215_ net215 _0797_ _0740_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__or3_1
X_2028_ _1260_ _1297_ VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_59_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3146_ _0719_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3077_ _0599_ _0603_ net221 VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_9_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_68_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_40_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput7 alpha[15] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__buf_1
XFILLER_0_52_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3000_ net215 _0587_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_52_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2646_ _0232_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__inv_2
X_2577_ _0119_ _0121_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__or2_1
X_2715_ _0305_ _0308_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_14_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3129_ _0664_ _0713_ VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2500_ net5 net254 VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__xor2_1
X_2431_ _1689_ _1691_ VGND VGND VPWR VPWR _1692_ sky130_fd_sc_hd__xor2_4
X_3480_ _1027_ _1031_ net252 VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__o21a_1
XFILLER_0_3_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2293_ _1504_ _1506_ VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__or2_1
X_2362_ _1622_ _1623_ VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_22_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput130 net130 VGND VGND VPWR VPWR b[9] sky130_fd_sc_hd__clkbuf_4
Xoutput163 net163 VGND VGND VPWR VPWR done sky130_fd_sc_hd__clkbuf_4
X_2629_ _0134_ _0224_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__or2_1
XFILLER_0_42_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput141 net141 VGND VGND VPWR VPWR c[19] sky130_fd_sc_hd__clkbuf_4
Xoutput152 net152 VGND VGND VPWR VPWR c[29] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_33_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2980_ _0533_ _0522_ _0567_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__nand3_1
Xinput32 alpha[9] VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__buf_1
X_1931_ _1185_ _1191_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__and2_1
X_1862_ _1126_ _1132_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__xor2_2
X_1793_ _1079_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__clkbuf_1
Xinput43 beta[19] VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__buf_1
X_3601_ clknet_3_1__leaf_clk _0085_ net180 VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput54 beta[29] VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__buf_1
Xinput10 alpha[18] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__dlymetal6s2s_1
Xinput21 alpha[28] VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__clkbuf_2
Xinput65 rstb VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__buf_1
X_3532_ clknet_3_7__leaf_clk _0016_ net188 VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__dfrtp_1
X_3394_ _0099_ _0137_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__nand2_1
X_2414_ net250 net245 _1628_ VGND VGND VPWR VPWR _1675_ sky130_fd_sc_hd__and3_1
X_3463_ _0684_ _1017_ net167 VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__o21ai_1
X_2345_ net32 _1562_ VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__or2_4
X_2276_ net245 _1539_ VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_62_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2061_ _1268_ _1329_ VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__xor2_1
X_2130_ _1395_ _1396_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__nor2_1
X_1914_ net202 net251 VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2963_ _0497_ _0502_ _0551_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__o21ai_1
X_1776_ net97 net31 net170 VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__mux2_1
X_1845_ net197 _1103_ VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2894_ _1255_ _0484_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_31_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3515_ _1061_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_8_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3377_ net132 _0944_ net171 VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__mux2_1
X_2328_ _1587_ _1590_ VGND VGND VPWR VPWR _1591_ sky130_fd_sc_hd__xor2_4
X_3446_ _0526_ _0522_ _0523_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__and3b_1
X_2259_ _1523_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_40_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3300_ net24 _0852_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__nand2_1
X_3162_ _0690_ _0691_ _0693_ _0746_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__o22a_1
X_3231_ _0813_ _0814_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__nand2_2
X_2113_ _1349_ _1350_ _1379_ VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__or3_1
X_2044_ net193 net246 VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__xor2_1
X_3093_ _0679_ _0624_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__nand2_1
XFILLER_0_71_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2877_ _0464_ _0467_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__xnor2_1
X_2946_ _0107_ _0508_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__or2_1
XFILLER_0_17_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1759_ _1062_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__clkbuf_1
X_1828_ net61 _1098_ net199 VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3429_ _0377_ _0984_ _0988_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_55_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2731_ _0274_ _0271_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__or2b_1
XFILLER_0_26_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2800_ net214 _0391_ net216 VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__mux2_1
X_2593_ _0187_ _0188_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__and2_1
XFILLER_0_41_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2662_ net238 net234 VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout208 net55 VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__buf_2
XFILLER_0_66_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3145_ net19 net256 VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_5_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout219 net50 VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__clkbuf_4
X_3214_ _0797_ _0740_ net215 VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__o21ai_1
X_2027_ _1263_ _1296_ VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3076_ _0661_ _0662_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__xnor2_1
X_2929_ _0411_ _0468_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__or2b_1
XFILLER_0_17_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput8 alpha[16] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_52_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2714_ _1733_ _0307_ VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__xor2_2
XFILLER_0_6_336 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2645_ _0097_ _0138_ _0181_ _0141_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__a211o_1
X_2576_ _0167_ _0172_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__xnor2_2
X_3128_ _0664_ _0713_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__nor2_1
XFILLER_0_37_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3059_ _0644_ _0645_ VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__nand2_2
XFILLER_0_45_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2361_ net249 _1620_ _1621_ VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__or3_1
X_2430_ _1631_ _1634_ _1632_ _1690_ VGND VGND VPWR VPWR _1691_ sky130_fd_sc_hd__a2bb2o_2
X_2292_ _1528_ _1555_ VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__xor2_2
XFILLER_0_63_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput131 net131 VGND VGND VPWR VPWR c[0] sky130_fd_sc_hd__clkbuf_4
Xoutput142 net142 VGND VGND VPWR VPWR c[1] sky130_fd_sc_hd__clkbuf_4
Xoutput153 net153 VGND VGND VPWR VPWR c[2] sky130_fd_sc_hd__clkbuf_4
X_2628_ _0131_ _0178_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__or2_1
X_2559_ _1686_ _1732_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__nor2_1
Xoutput120 net120 VGND VGND VPWR VPWR b[29] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_65_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1930_ net208 _1127_ _1188_ _1198_ _1200_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_33_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput33 beta[0] VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__buf_1
Xinput55 beta[2] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_2
Xinput44 beta[1] VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__clkbuf_1
Xinput66 start VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_2
X_1861_ _1110_ _1131_ VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__xnor2_4
X_3531_ clknet_3_7__leaf_clk _0015_ net187 VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__dfrtp_1
X_1792_ net294 net8 net172 VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__mux2_1
X_3600_ clknet_3_3__leaf_clk _0084_ net180 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput11 alpha[19] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_2
Xinput22 alpha[29] VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__buf_1
X_2344_ _1605_ _1573_ _1575_ VGND VGND VPWR VPWR _1607_ sky130_fd_sc_hd__or3_2
X_3393_ _0099_ _0137_ _1719_ _1753_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__a2bb2o_1
X_2413_ _1406_ _1627_ VGND VGND VPWR VPWR _1674_ sky130_fd_sc_hd__and2_1
X_3462_ _0974_ net164 _1011_ _1016_ VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__a31o_1
X_2275_ net243 net235 VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__xor2_4
XFILLER_0_62_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2060_ _1326_ _1328_ VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_71_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1913_ _1162_ _1183_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__xor2_1
XFILLER_0_56_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2893_ _0432_ _0435_ _0482_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__o21a_1
X_2962_ _0495_ _0496_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__nand2_1
X_1775_ _1070_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_69_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1844_ _1107_ _1113_ _1114_ VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__a21bo_1
X_3445_ _1712_ net272 _1001_ _1002_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__a22o_1
X_3514_ net291 _1060_ net165 VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3376_ _1708_ _0943_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__xnor2_1
X_2258_ net127 _1522_ net172 VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__mux2_1
X_2327_ _1588_ _1589_ net237 VGND VGND VPWR VPWR _1590_ sky130_fd_sc_hd__mux2_2
X_2189_ _1451_ _1454_ VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_58_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2112_ _1349_ _1350_ _1379_ VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__o21ai_1
X_3161_ _0700_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__inv_2
X_3230_ _0764_ _0767_ _0812_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__nand3_1
X_2043_ _1308_ _1311_ VGND VGND VPWR VPWR _1312_ sky130_fd_sc_hd__xnor2_1
X_3092_ _0618_ _0619_ _0621_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__or3_2
XFILLER_0_72_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1827_ net197 net202 VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_44_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2876_ _0465_ _0413_ _0466_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__a21oi_1
X_2945_ _0510_ _0513_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__and2_1
XFILLER_0_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1758_ net302 net174 VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3428_ _0338_ _0987_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__nor2_1
X_3359_ net159 _0930_ net176 VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2730_ _0268_ _0323_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__xor2_1
XFILLER_0_26_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2661_ _0253_ _0255_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__xor2_2
Xfanout209 net55 VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__clkbuf_4
X_2592_ net7 net257 VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3144_ _0729_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_5_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3213_ _0734_ _0735_ _0737_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__and3_1
X_3075_ _0596_ _0602_ _0603_ _0595_ _0593_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__o32a_1
X_2026_ _1292_ _1295_ VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_57_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2928_ _0467_ _0464_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__or2b_1
X_2859_ net227 net224 VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__nand2_1
XFILLER_0_63_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_11_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput9 alpha[17] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_1
X_2644_ _0179_ _0180_ _0144_ VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__a21o_1
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2713_ net227 _0248_ _0306_ VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__a21o_1
X_2575_ _0170_ _0171_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__and2_1
XFILLER_0_10_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3058_ _0238_ _0242_ _0434_ _0638_ VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__a211o_1
X_3127_ _0711_ _0712_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__or2_1
X_2009_ _1277_ _1278_ net191 VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__mux2_2
XFILLER_0_18_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2291_ _1552_ _1554_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__xnor2_2
X_2360_ _1620_ _1621_ net249 VGND VGND VPWR VPWR _1622_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_63_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput121 net121 VGND VGND VPWR VPWR b[2] sky130_fd_sc_hd__clkbuf_4
Xoutput132 net132 VGND VGND VPWR VPWR c[10] sky130_fd_sc_hd__clkbuf_4
Xoutput110 net110 VGND VGND VPWR VPWR b[1] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2627_ _0219_ _0222_ VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__xnor2_4
Xoutput143 net143 VGND VGND VPWR VPWR c[20] sky130_fd_sc_hd__buf_2
XFILLER_0_27_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2489_ _1622_ _1700_ _1748_ VGND VGND VPWR VPWR _1749_ sky130_fd_sc_hd__o21ai_4
X_2558_ _0151_ _0154_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__xor2_2
Xoutput154 net154 VGND VGND VPWR VPWR c[30] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1860_ _1129_ _1130_ VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__xor2_4
Xinput23 alpha[2] VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__buf_1
Xinput12 alpha[1] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_8
Xinput34 beta[10] VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__clkbuf_1
X_1791_ _1078_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_58_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3530_ clknet_3_6__leaf_clk _0014_ net185 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__dfrtp_1
X_3461_ _0992_ _0996_ _1010_ _1013_ _1015_ VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__a311o_1
Xinput45 beta[20] VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_3_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput56 beta[30] VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__clkbuf_2
X_3392_ net173 net264 _0956_ _0957_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__o22a_1
X_2343_ _1573_ _1575_ _1605_ VGND VGND VPWR VPWR _1606_ sky130_fd_sc_hd__o21ai_4
X_2274_ _1534_ _1537_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__xnor2_4
X_2412_ _1578_ _1646_ VGND VGND VPWR VPWR _1673_ sky130_fd_sc_hd__nor2_1
XFILLER_0_47_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1989_ _1216_ _1252_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__and2b_1
XFILLER_0_62_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1912_ _1165_ _1164_ VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__and2b_1
X_1843_ _1100_ _1106_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2892_ _0432_ _0435_ _0482_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__or3_1
X_2961_ _0544_ _0549_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__xor2_1
X_1774_ net96 net30 net170 VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__mux2_1
XFILLER_0_69_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3444_ _0529_ _1000_ net168 VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__o21a_1
X_3513_ _0902_ _1059_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__xor2_1
XFILLER_0_12_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3375_ _0941_ _0942_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__or2b_1
X_2257_ _1520_ _1521_ VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__xnor2_1
X_2326_ net239 net235 VGND VGND VPWR VPWR _1589_ sky130_fd_sc_hd__xor2_2
XFILLER_0_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2188_ _1237_ _1453_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__xor2_2
XFILLER_0_43_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2111_ _1351_ _1378_ VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__xor2_1
X_2042_ _1098_ _1310_ VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__xor2_1
X_3091_ _0676_ _0677_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__nor2_1
X_3160_ _0743_ _0744_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__or2_1
XFILLER_0_71_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1826_ net196 _1096_ VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_44_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2944_ _0517_ _0520_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__nand2_2
X_2875_ _0405_ _0407_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3358_ _1520_ _0929_ VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3427_ _0373_ _0374_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__nor2_1
X_2309_ _1556_ _1558_ _1508_ _1510_ VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__o211a_1
X_3289_ _0870_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_41_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2660_ _0192_ _0195_ _0193_ _0254_ VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_66_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2591_ net7 _0142_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__or2_4
X_3212_ _0794_ _0795_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__and2_1
X_2025_ _1218_ _1251_ _1294_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__a21oi_2
X_3143_ net115 _0728_ net173 VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__mux2_1
X_3074_ _0653_ _0660_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_28_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2927_ _0515_ _0516_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2789_ _0381_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1809_ _1087_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__clkbuf_1
X_2858_ _0444_ _0448_ VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_13_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_37_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2643_ _1716_ _0183_ _0237_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__nand3_2
X_2574_ net242 _0168_ _0169_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__or3_1
X_2712_ net226 net219 VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__and2_1
XFILLER_0_14_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2008_ net194 net249 VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__xor2_4
X_3057_ _0636_ _0638_ _0640_ _0643_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__o211a_1
XFILLER_0_26_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3126_ _0708_ _0710_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2290_ _1485_ _1503_ _1553_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_47_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput100 net100 VGND VGND VPWR VPWR b[10] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput133 net133 VGND VGND VPWR VPWR c[11] sky130_fd_sc_hd__buf_2
XFILLER_0_42_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2626_ _0220_ _0221_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__nand2_2
Xoutput111 net111 VGND VGND VPWR VPWR b[20] sky130_fd_sc_hd__clkbuf_4
X_2557_ _0152_ _0153_ net226 VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__mux2_1
XFILLER_0_2_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput155 net155 VGND VGND VPWR VPWR c[31] sky130_fd_sc_hd__clkbuf_4
Xoutput144 net144 VGND VGND VPWR VPWR c[21] sky130_fd_sc_hd__clkbuf_4
Xoutput122 net122 VGND VGND VPWR VPWR b[30] sky130_fd_sc_hd__buf_2
XFILLER_0_10_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2488_ _1697_ _1699_ VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__or2_1
X_3109_ net211 net206 VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__or2_1
XFILLER_0_33_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1790_ net299 net7 net174 VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_26_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput13 alpha[20] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_1
Xinput35 beta[11] VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__clkbuf_1
X_3391_ _0138_ _0955_ net173 VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__o21ai_1
X_2411_ _1643_ _1645_ VGND VGND VPWR VPWR _1672_ sky130_fd_sc_hd__nor2_1
X_3460_ _0572_ _0631_ _1014_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_24_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput46 beta[21] VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_3_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput57 beta[31] VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_1
Xinput24 alpha[30] VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__buf_1
X_2342_ _1603_ _1604_ VGND VGND VPWR VPWR _1605_ sky130_fd_sc_hd__xnor2_4
X_2273_ _1316_ _1536_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__xor2_4
X_1988_ _1256_ _1257_ net274 _1258_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_62_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3589_ clknet_3_5__leaf_clk _0073_ net183 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_30_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2609_ _0199_ _0204_ VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__xnor2_2
Xfanout190 net65 VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__buf_2
XFILLER_0_56_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2960_ _0545_ _0548_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_71_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1911_ _1177_ _1158_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__xnor2_1
X_1773_ _1069_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_69_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1842_ _1109_ _1112_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_44_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2891_ _0480_ _0481_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3374_ _1654_ _1655_ _1618_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__a21bo_1
X_3443_ _0529_ _1000_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__nand2_1
X_3512_ _0886_ _0892_ _1050_ _1058_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__a31o_1
X_2256_ _1436_ _1438_ _1478_ _1477_ _1441_ VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__a32o_1
X_2187_ net191 _1403_ _1452_ VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__a21o_1
X_2325_ net235 VGND VGND VPWR VPWR _1588_ sky130_fd_sc_hd__inv_2
XFILLER_0_19_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2041_ net198 _1275_ _1309_ VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__a21oi_2
X_2110_ _1375_ _1377_ VGND VGND VPWR VPWR _1378_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_55_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3090_ _0648_ _0619_ _0675_ VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__nor3_2
XFILLER_0_71_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2943_ _0526_ _0522_ _0523_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__and3_1
X_1825_ net209 net204 VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2874_ _0405_ _0407_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__nand2_1
XFILLER_0_20_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3357_ _1478_ _0925_ _0928_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__o21ai_2
X_2308_ _1564_ _1560_ _1561_ VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__nand3b_1
X_3426_ _0986_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_13_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2239_ _1485_ _1503_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__xnor2_2
X_3288_ net304 _0869_ net166 VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__mux2_1
XFILLER_0_63_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2590_ _0144_ _0179_ _0180_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__nand3_2
XFILLER_0_66_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3142_ _0725_ _0727_ VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__xor2_1
X_3211_ _0743_ _0793_ _0782_ VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__or3_1
X_2024_ _1293_ _1250_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__and2_1
X_3073_ _0658_ _0659_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__or2_1
XFILLER_0_45_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2926_ _0461_ _0514_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__and2_1
X_2857_ net214 _0396_ _0390_ _0447_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__o22a_1
XFILLER_0_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2788_ net107 _0380_ net172 VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__mux2_1
X_1808_ net298 net17 net165 VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__mux2_1
X_3409_ _0181_ _0182_ _0233_ _0958_ _0959_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__o2111ai_1
XFILLER_0_55_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2711_ net236 net232 VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2642_ _1754_ _0138_ _0236_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__and3_1
X_2573_ _0168_ _0169_ net242 VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_14_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3125_ _0708_ _0710_ VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__nor2_1
X_2007_ net250 VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__inv_2
X_3056_ _0572_ _0575_ _0641_ _0642_ _0632_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__a221o_1
XFILLER_0_26_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2909_ net218 net210 VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__and2_1
XFILLER_0_20_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_56_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_65_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput156 net156 VGND VGND VPWR VPWR c[3] sky130_fd_sc_hd__clkbuf_4
Xoutput134 net134 VGND VGND VPWR VPWR c[12] sky130_fd_sc_hd__clkbuf_4
Xoutput101 net101 VGND VGND VPWR VPWR b[11] sky130_fd_sc_hd__buf_2
X_2487_ _1676_ _1746_ VGND VGND VPWR VPWR _1747_ sky130_fd_sc_hd__xnor2_4
X_2625_ _0102_ _0176_ VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__or2b_1
Xoutput145 net145 VGND VGND VPWR VPWR c[22] sky130_fd_sc_hd__clkbuf_4
Xoutput112 net112 VGND VGND VPWR VPWR b[21] sky130_fd_sc_hd__clkbuf_4
Xoutput123 net123 VGND VGND VPWR VPWR b[31] sky130_fd_sc_hd__clkbuf_4
X_2556_ net227 net224 VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__xor2_2
XFILLER_0_49_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3108_ net219 net215 VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__nand2_1
X_3039_ net15 net16 _0524_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__or3_4
XFILLER_0_21_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_1_Left_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput36 beta[12] VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__clkbuf_1
Xinput25 alpha[31] VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__clkbuf_2
Xinput14 alpha[21] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_1
Xinput58 beta[3] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_1
X_3390_ _0138_ _0955_ VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__and2_1
X_2341_ _1117_ _1484_ _1555_ _1554_ _1552_ VGND VGND VPWR VPWR _1604_ sky130_fd_sc_hd__o32a_2
X_2410_ _1512_ _1514_ _1515_ _1670_ VGND VGND VPWR VPWR _1671_ sky130_fd_sc_hd__a211o_1
Xinput47 beta[22] VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__clkbuf_1
X_2272_ net247 _1491_ _1535_ VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__a21o_2
XFILLER_0_59_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1987_ _1255_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__clkbuf_4
X_3588_ clknet_3_5__leaf_clk _0072_ net190 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__dfrtp_1
X_2539_ _0131_ _0136_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_30_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2608_ _0200_ _0203_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_3_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout191 net64 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__buf_6
Xfanout180 net182 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__clkbuf_4
X_1910_ _1179_ _1180_ VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2890_ _0479_ _0474_ _0475_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__or3_1
X_1772_ net95 net29 net171 VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__mux2_1
XFILLER_0_71_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1841_ _1110_ _1111_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__nand2_1
XFILLER_0_37_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3511_ _0890_ _1056_ _1057_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_8_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3373_ _0940_ _0941_ net287 _1258_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__a2bb2o_1
X_2324_ net243 _1586_ VGND VGND VPWR VPWR _1587_ sky130_fd_sc_hd__xnor2_4
X_3442_ _0992_ _0997_ _0480_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__a21boi_2
X_2255_ _1518_ _1519_ VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__nand2_2
X_2186_ net250 net242 VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__and2_1
XFILLER_0_7_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2040_ net196 net248 VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__and2_1
XFILLER_0_71_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2942_ _0530_ _0531_ net277 _1258_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__a2bb2o_1
X_2873_ _0458_ _0463_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__xnor2_1
X_1824_ net61 VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__inv_2
XFILLER_0_40_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3356_ _1442_ _1477_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__or2_1
X_2307_ net171 _1568_ _1569_ _1570_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__a31o_1
X_2238_ _1500_ _1502_ VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__xor2_2
X_3425_ net139 _0985_ net167 VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__mux2_1
X_3287_ _0867_ _0868_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__xnor2_1
X_2169_ _1435_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_35_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3141_ _0646_ _0726_ _0682_ VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__a21o_1
XFILLER_0_5_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3210_ _0743_ _0782_ _0793_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__o21ai_1
X_2023_ _1219_ VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__inv_2
X_3072_ _0654_ _0657_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__and2_1
X_2925_ _0461_ _0514_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__nor2_1
X_1807_ _1086_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__clkbuf_1
X_2856_ _0445_ _0446_ _0396_ VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__a21boi_1
X_3408_ _0144_ _0964_ _0190_ _0232_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__a22oi_1
X_2787_ _0377_ _0379_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__xnor2_1
X_3339_ net175 net265 VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__nor2_1
XFILLER_0_63_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2710_ _0299_ _0303_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__xor2_2
X_2641_ _0233_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__inv_2
X_2572_ net244 net239 _0117_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__and3_1
X_3055_ _0526_ _0522_ _0523_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__nand3_1
X_3124_ _0663_ _0666_ _0709_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__a21oi_1
X_2006_ net198 _1275_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__xnor2_4
X_2839_ _0430_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__clkbuf_1
X_2908_ _0107_ _0193_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__nor2_1
Xwire1 _1220_ VGND VGND VPWR VPWR net307 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_22_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2624_ _0175_ _0173_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__or2b_1
Xoutput157 net157 VGND VGND VPWR VPWR c[4] sky130_fd_sc_hd__clkbuf_4
Xoutput135 net135 VGND VGND VPWR VPWR c[13] sky130_fd_sc_hd__clkbuf_4
Xoutput124 net124 VGND VGND VPWR VPWR b[3] sky130_fd_sc_hd__clkbuf_4
Xoutput102 net102 VGND VGND VPWR VPWR b[12] sky130_fd_sc_hd__buf_2
X_2486_ _1743_ _1745_ VGND VGND VPWR VPWR _1746_ sky130_fd_sc_hd__xor2_4
Xoutput146 net146 VGND VGND VPWR VPWR c[23] sky130_fd_sc_hd__clkbuf_4
X_2555_ net224 VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__inv_2
Xoutput113 net113 VGND VGND VPWR VPWR b[22] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_10_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3038_ _0624_ _0625_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__and2_1
X_3107_ _0690_ _0691_ _0692_ _0537_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_56_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput59 beta[4] VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__buf_1
Xinput26 alpha[3] VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__buf_1
Xinput37 beta[13] VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__clkbuf_1
Xinput15 alpha[22] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__clkbuf_2
Xinput48 beta[23] VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__buf_1
X_2340_ _1531_ _1602_ VGND VGND VPWR VPWR _1603_ sky130_fd_sc_hd__xnor2_4
X_2271_ net245 net237 VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__and2_1
X_1986_ _1215_ _1253_ VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3587_ clknet_3_5__leaf_clk _0071_ net189 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__dfrtp_1
X_2607_ _1633_ _0202_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__xor2_2
XFILLER_0_15_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2538_ _0133_ _0135_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__nand2_2
X_2469_ _1725_ _1728_ VGND VGND VPWR VPWR _1729_ sky130_fd_sc_hd__xnor2_4
Xfanout170 net66 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__buf_4
Xfanout192 net64 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__clkbuf_4
Xfanout181 net182 VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__clkbuf_2
Xclkbuf_3_4__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_4__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_1840_ net208 net251 VGND VGND VPWR VPWR _1111_ sky130_fd_sc_hd__or2_1
X_1771_ _1068_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__clkbuf_1
X_3441_ _0998_ _0999_ net279 _1712_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__a2bb2o_1
X_3510_ _0890_ _1056_ _0884_ VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__o21ba_1
X_3372_ _1611_ _0939_ _1658_ VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__a21oi_1
X_2254_ _1482_ _1517_ VGND VGND VPWR VPWR _1519_ sky130_fd_sc_hd__or2_1
X_2323_ net241 net233 VGND VGND VPWR VPWR _1586_ sky130_fd_sc_hd__xor2_4
X_2185_ net193 net198 VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__nand2_1
X_1969_ net194 _1117_ _1095_ _1121_ _1124_ VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__o32ai_4
XFILLER_0_53_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2941_ _0486_ _0484_ _0529_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__o21a_1
X_1823_ _1094_ VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__clkbuf_1
X_2872_ _0461_ _0462_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__and2_1
XFILLER_0_52_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3424_ _0377_ _0984_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__xor2_1
XFILLER_0_4_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3355_ _0927_ VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__clkbuf_1
X_2306_ _1389_ net128 VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__and2_1
X_2237_ _1455_ _1464_ _1501_ VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__a21boi_2
X_3286_ _0825_ _0849_ _0847_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__o21ai_1
X_2168_ net125 _1434_ net174 VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__mux2_1
X_2099_ _1363_ _1366_ VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__xor2_2
XFILLER_0_9_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3140_ _0684_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__inv_2
X_3071_ _0654_ _0657_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__nor2_1
X_2022_ _1265_ _1291_ VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__xor2_4
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2786_ _0335_ _0378_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__nor2_1
XFILLER_0_25_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2924_ _0510_ _0513_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__xnor2_1
X_1806_ net303 net16 net169 VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__mux2_1
X_2855_ net216 net214 VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__nand2_1
X_3338_ _1340_ _0913_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3407_ _0190_ _0232_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3269_ _0851_ VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_72_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2640_ _0234_ _0235_ net285 _1258_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__a2bb2o_1
X_2571_ _1542_ _0116_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__and2_1
XFILLER_0_22_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_10_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2005_ net196 net248 VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__xor2_4
X_3054_ _0527_ _0528_ _0486_ VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__a21bo_1
X_3123_ _0662_ _0661_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__and2b_1
X_2907_ _0495_ _0496_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__xnor2_1
X_2838_ net108 _0429_ net172 VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__mux2_1
X_2769_ net234 _0359_ _0360_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__or3_1
XFILLER_0_13_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput114 net114 VGND VGND VPWR VPWR b[23] sky130_fd_sc_hd__clkbuf_4
Xoutput125 net125 VGND VGND VPWR VPWR b[4] sky130_fd_sc_hd__buf_2
Xoutput103 net103 VGND VGND VPWR VPWR b[13] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_42_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2623_ _0170_ _0218_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__xnor2_4
X_2554_ net233 _0150_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_2_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput158 net158 VGND VGND VPWR VPWR c[5] sky130_fd_sc_hd__clkbuf_4
Xoutput147 net147 VGND VGND VPWR VPWR c[24] sky130_fd_sc_hd__clkbuf_4
Xoutput136 net136 VGND VGND VPWR VPWR c[14] sky130_fd_sc_hd__clkbuf_4
X_2485_ _1678_ _1696_ _1744_ VGND VGND VPWR VPWR _1745_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_10_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3037_ _0623_ _0581_ _0582_ _0584_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__nand4_1
X_3106_ _0491_ _0691_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__nor2_1
XFILLER_0_58_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput27 alpha[4] VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__clkbuf_2
Xinput38 beta[14] VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput16 alpha[23] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__buf_1
Xinput49 beta[24] VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__buf_1
X_2270_ net194 net249 VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__nand2_2
X_1985_ _1215_ _1253_ _1255_ VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__a21o_1
XFILLER_0_23_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3586_ clknet_3_7__leaf_clk _0070_ net188 VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__dfrtp_1
X_2537_ _1668_ _1671_ _0134_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__a21o_1
X_2606_ net233 _0150_ _0201_ VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__a21o_1
XFILLER_0_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2399_ _1658_ _1660_ VGND VGND VPWR VPWR _1661_ sky130_fd_sc_hd__xnor2_1
X_2468_ _1494_ _1727_ VGND VGND VPWR VPWR _1728_ sky130_fd_sc_hd__xor2_4
XFILLER_0_65_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout171 net66 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__clkbuf_2
Xfanout193 net63 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__buf_4
Xfanout182 net65 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__buf_4
X_1770_ net94 net28 net176 VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3371_ _1611_ _1658_ _0939_ _1389_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__a31o_1
X_3440_ _0992_ _0997_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__nor2_1
X_2253_ _1482_ _1517_ VGND VGND VPWR VPWR _1518_ sky130_fd_sc_hd__nand2_1
X_2184_ _1448_ _1449_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__and2_1
X_2322_ _1581_ _1584_ VGND VGND VPWR VPWR _1585_ sky130_fd_sc_hd__xnor2_4
X_1899_ _1159_ _1169_ VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__nor2_1
X_1968_ _1235_ _1238_ VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__xor2_4
XFILLER_0_47_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3569_ clknet_3_1__leaf_clk _0053_ net180 VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_26_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2940_ _0486_ _0484_ _0529_ net168 VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__o31ai_1
XFILLER_0_52_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1822_ net288 net25 net166 VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__mux2_1
X_2871_ net227 _0459_ _0460_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__or3_1
X_3354_ net158 _0926_ net175 VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__mux2_1
X_3423_ _0982_ _0979_ _0983_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__a21oi_1
X_2167_ _1432_ _1433_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__xnor2_1
X_2305_ _1525_ _1567_ VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__nand2_1
X_2236_ _1461_ _1463_ VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__nand2_1
X_3285_ _0854_ _0866_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_17_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2098_ _1364_ _1365_ net248 VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__mux2_1
XFILLER_0_0_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2021_ _1223_ _1290_ VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__xor2_4
X_3070_ _0391_ _0656_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__xor2_1
X_2923_ _0511_ _0463_ _0512_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__a21o_1
X_2785_ _0290_ _0332_ VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__and2_1
X_1805_ _1085_ VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__clkbuf_1
X_2854_ net216 net214 VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__or2_1
X_3337_ _1297_ _0909_ _0912_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__a21o_1
X_3406_ _0186_ _0239_ _0236_ _0138_ _1754_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_56_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2219_ _1237_ _1453_ _1483_ VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__a21oi_2
X_3268_ net118 _0850_ net167 VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__mux2_1
X_3199_ net212 net56 VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__or2_1
XFILLER_0_31_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2570_ _0164_ _0166_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_22_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3122_ _0703_ _0707_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__xnor2_1
X_2004_ _1229_ _1273_ VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__xnor2_4
X_3053_ _0571_ _0573_ _0574_ _0632_ _0639_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__o41a_1
XFILLER_0_45_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2906_ net213 _0446_ _0440_ _0443_ VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_9_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2837_ _0427_ _0428_ VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__xnor2_1
X_2699_ _0246_ _0247_ _0276_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__a21o_1
X_2768_ _0359_ _0360_ net234 VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_5_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput159 net159 VGND VGND VPWR VPWR c[6] sky130_fd_sc_hd__clkbuf_4
Xoutput148 net148 VGND VGND VPWR VPWR c[25] sky130_fd_sc_hd__clkbuf_4
Xoutput104 net104 VGND VGND VPWR VPWR b[14] sky130_fd_sc_hd__clkbuf_4
Xoutput126 net126 VGND VGND VPWR VPWR b[5] sky130_fd_sc_hd__buf_2
Xoutput115 net115 VGND VGND VPWR VPWR b[24] sky130_fd_sc_hd__buf_2
XFILLER_0_42_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2622_ _0214_ _0217_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__xnor2_2
Xoutput137 net137 VGND VGND VPWR VPWR c[15] sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_34_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2553_ net231 net222 VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__xor2_2
XFILLER_0_2_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2484_ _1693_ _1695_ VGND VGND VPWR VPWR _1744_ sky130_fd_sc_hd__nor2_1
X_3105_ net207 net206 VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__nand2_2
XPHY_EDGE_ROW_43_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3036_ _0581_ _0582_ _0584_ _0623_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__a31o_1
XFILLER_0_18_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_52_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_61_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput28 alpha[5] VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__buf_1
XPHY_EDGE_ROW_70_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput39 beta[15] VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_32_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput17 alpha[24] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_59_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1984_ _1254_ VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__clkbuf_4
X_3585_ clknet_3_7__leaf_clk _0069_ net188 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__dfrtp_1
X_2536_ _1750_ _1703_ _1702_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__nand3b_1
X_2467_ net239 _1684_ _1726_ VGND VGND VPWR VPWR _1727_ sky130_fd_sc_hd__a21o_1
X_2605_ net231 net222 VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__and2_1
X_2398_ _1617_ _1614_ _1659_ VGND VGND VPWR VPWR _1660_ sky130_fd_sc_hd__nor3_1
XFILLER_0_3_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3019_ _0544_ _0549_ _0606_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_46_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_5_Left_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout183 net184 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__clkbuf_4
Xfanout172 net177 VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__clkbuf_4
Xfanout194 net63 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__buf_4
XFILLER_0_52_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3370_ _1565_ _0935_ _1612_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_52_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2321_ _1365_ _1583_ VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__xor2_4
X_2252_ _1511_ _1516_ VGND VGND VPWR VPWR _1517_ sky130_fd_sc_hd__xnor2_1
X_2183_ net197 _1446_ _1447_ VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__or3_1
XFILLER_0_18_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1898_ net200 net229 net251 VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__a21oi_1
X_1967_ _1236_ _1237_ net193 VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__mux2_2
XFILLER_0_43_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2519_ _1542_ _0116_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__xor2_4
X_3568_ clknet_3_3__leaf_clk _0052_ net180 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_11_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3499_ _0854_ _0866_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__or2b_1
XFILLER_0_29_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2870_ _0459_ _0460_ net227 VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_37_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1821_ _1093_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__clkbuf_1
X_3353_ _1478_ _0925_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__xor2_1
X_2304_ _1525_ _1567_ VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3422_ _0330_ _0331_ _0290_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__o21a_1
X_3284_ _0864_ _0865_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__xnor2_4
X_2166_ _1346_ _1383_ _1388_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__a21bo_1
X_2235_ _1490_ _1499_ VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__xnor2_2
X_2097_ net249 net246 VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__xor2_4
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2999_ _0585_ _0586_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__nor2_1
XFILLER_0_31_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_8_Left_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2020_ _1287_ _1289_ VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_57_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2853_ _0440_ _0443_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__xor2_2
X_2922_ _0455_ _0457_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__nor2_1
X_2784_ _0375_ _0376_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__nor2_2
X_1804_ net296 net15 net169 VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__mux2_1
XFILLER_0_13_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3336_ _1296_ _1262_ _1261_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__and3b_1
X_3405_ _0968_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__clkbuf_1
X_3267_ _0825_ _0849_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__xor2_1
X_2149_ _1397_ _1415_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__xnor2_1
X_2218_ net193 net198 _1454_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__and3_1
X_3198_ net211 _0651_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__nor2_1
XFILLER_0_54_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3121_ _0705_ _0706_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__and2_1
X_2003_ _1143_ _1272_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__xor2_4
X_3052_ _0629_ _0626_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__nand2_1
X_2836_ _0376_ _0379_ _0375_ VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__o21bai_1
X_2905_ _0492_ _0494_ VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2698_ _0226_ _0230_ _0291_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__a21o_1
X_2767_ net236 net232 _0308_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__and3_1
X_3319_ _0883_ _0893_ _0892_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__or3_4
XFILLER_0_67_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xoutput138 net138 VGND VGND VPWR VPWR c[16] sky130_fd_sc_hd__clkbuf_4
Xoutput127 net127 VGND VGND VPWR VPWR b[6] sky130_fd_sc_hd__clkbuf_4
Xoutput105 net105 VGND VGND VPWR VPWR b[15] sky130_fd_sc_hd__clkbuf_4
X_2552_ _0147_ _0126_ _0148_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__a21o_1
X_2483_ _1724_ _1742_ VGND VGND VPWR VPWR _1743_ sky130_fd_sc_hd__xnor2_4
X_2621_ _0215_ _0172_ _0216_ VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__a21oi_2
Xoutput116 net116 VGND VGND VPWR VPWR b[25] sky130_fd_sc_hd__clkbuf_4
Xoutput149 net149 VGND VGND VPWR VPWR c[26] sky130_fd_sc_hd__clkbuf_4
X_3035_ _0622_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__inv_2
X_3104_ net212 net211 VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__or2_1
XFILLER_0_58_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2819_ _0409_ _0410_ net232 VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_49_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput18 alpha[25] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__buf_1
Xinput29 alpha[6] VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_59_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1983_ net177 VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__inv_2
X_2604_ net240 net236 VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_21_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3584_ clknet_3_7__leaf_clk _0068_ net187 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_61_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2535_ _1747_ _1749_ _0132_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__a21oi_2
X_2466_ net237 net228 VGND VGND VPWR VPWR _1726_ sky130_fd_sc_hd__and2_1
X_2397_ _1610_ _1606_ _1607_ VGND VGND VPWR VPWR _1659_ sky130_fd_sc_hd__and3_1
X_3018_ _0543_ _0541_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__and2b_1
XFILLER_0_65_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout184 net190 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__clkbuf_4
Xfanout195 net196 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__buf_4
Xfanout173 net177 VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_69_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2251_ _1512_ _1514_ _1515_ VGND VGND VPWR VPWR _1516_ sky130_fd_sc_hd__a21oi_1
X_2320_ net245 _1539_ _1582_ VGND VGND VPWR VPWR _1583_ sky130_fd_sc_hd__a21o_2
X_2182_ _1446_ _1447_ net197 VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_18_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1966_ net191 net196 VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__xor2_2
XFILLER_0_28_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1897_ _1166_ _1167_ VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__xor2_1
XFILLER_0_55_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3567_ clknet_3_6__leaf_clk _0051_ net185 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_59_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2449_ _1708_ _1709_ VGND VGND VPWR VPWR _1710_ sky130_fd_sc_hd__xnor2_1
X_2518_ net237 _1730_ _0115_ VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__a21o_2
X_3498_ _0866_ _0854_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__and2b_1
XFILLER_0_34_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1820_ net295 net24 net165 VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__mux2_1
X_3421_ _0290_ _0330_ _0331_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__or3_1
XFILLER_0_4_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3352_ _0924_ _0921_ _1430_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__a21oi_2
X_2303_ _1565_ _1566_ VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__or2_2
X_2234_ _1496_ _1498_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__xor2_4
X_3283_ _0810_ _0813_ _0843_ _0842_ VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__a31o_1
X_2165_ _1430_ _1431_ VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__nor2_1
X_2096_ net246 VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__inv_2
X_1949_ net208 _1160_ _1135_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__nor3_1
XFILLER_0_28_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2998_ net212 net205 VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2783_ _0373_ _0374_ _0338_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__o21a_2
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1803_ _1084_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__clkbuf_1
X_2852_ _0441_ _0442_ net214 VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__mux2_2
X_2921_ _0455_ _0457_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__nand2_1
X_3404_ net136 _0967_ net172 VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__mux2_1
XFILLER_0_25_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3335_ _0911_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__clkbuf_1
X_2217_ net30 _1439_ VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__xor2_1
XFILLER_0_56_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3197_ _0750_ _0754_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__or2b_1
X_3266_ _0847_ _0848_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__nand2_2
X_2079_ _1346_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__inv_2
X_2148_ _1412_ _1414_ VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__xor2_1
XFILLER_0_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3051_ _0572_ _0575_ _0632_ _0637_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__a211o_1
X_3120_ net219 _0704_ _0659_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__or3_1
X_2002_ net200 _1234_ _1271_ VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__a21o_2
XFILLER_0_42_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2835_ _0383_ _0426_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__xnor2_4
X_2766_ _1733_ _0307_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__and2_1
X_2904_ net218 _0493_ VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__xnor2_1
X_2697_ _0223_ _0279_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__or2b_1
XFILLER_0_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3318_ _0897_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__clkbuf_1
X_3249_ _0830_ _0831_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_36_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2620_ _0164_ _0166_ VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput106 net106 VGND VGND VPWR VPWR b[16] sky130_fd_sc_hd__clkbuf_4
Xoutput128 net128 VGND VGND VPWR VPWR b[7] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2551_ _0123_ _0125_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__nor2_1
X_2482_ _1739_ _1741_ VGND VGND VPWR VPWR _1742_ sky130_fd_sc_hd__xor2_4
Xoutput139 net139 VGND VGND VPWR VPWR c[17] sky130_fd_sc_hd__clkbuf_4
Xoutput117 net117 VGND VGND VPWR VPWR b[26] sky130_fd_sc_hd__buf_2
X_3034_ _0620_ _0621_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__xnor2_1
X_3103_ net256 _0688_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2749_ _0268_ _0323_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__or2b_1
X_2818_ net234 net228 _0353_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__and3_1
XFILLER_0_5_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput19 alpha[26] VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_32_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1982_ _1216_ _1252_ VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_59_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3583_ clknet_3_7__leaf_clk _0067_ net188 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__dfrtp_1
X_2534_ _1747_ _1749_ _1702_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__o21ba_1
X_2603_ _0196_ _0198_ VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__xor2_2
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2396_ _1656_ _1657_ VGND VGND VPWR VPWR _1658_ sky130_fd_sc_hd__nor2_2
X_2465_ net245 net241 VGND VGND VPWR VPWR _1725_ sky130_fd_sc_hd__nand2_2
XFILLER_0_64_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3017_ _0596_ _0604_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_65_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout174 net176 VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__clkbuf_4
Xfanout196 net62 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__clkbuf_8
Xfanout185 net190 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2250_ _1423_ _1476_ _1513_ VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__a21boi_4
XFILLER_0_20_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2181_ net195 net199 _1401_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__and3_1
X_1965_ net191 VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__inv_2
XFILLER_0_47_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1896_ _1141_ _1144_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__xnor2_1
X_3566_ clknet_3_6__leaf_clk _0050_ net185 VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_43_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2517_ net235 net226 VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__and2_1
X_3497_ _1046_ VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__clkbuf_1
X_2448_ _1657_ _1660_ _1656_ VGND VGND VPWR VPWR _1709_ sky130_fd_sc_hd__o21ba_1
X_2379_ _1585_ _1594_ _1640_ VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_11_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_49_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_58_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_67_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3351_ _1431_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__inv_2
XFILLER_0_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3420_ _0980_ _0981_ net172 net138 VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_20_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2164_ _1429_ _1426_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__and2b_1
X_2302_ _1564_ _1560_ _1561_ VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__and3_1
X_2233_ _1457_ _1460_ _1458_ _1497_ VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__a2bb2o_2
X_3282_ _0862_ _0863_ VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__and2_2
X_2095_ net193 _1362_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_24_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1948_ _1137_ _1156_ VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__or2_2
X_1879_ _1145_ _1146_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2997_ net212 net205 VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__nor2_1
X_3549_ clknet_3_5__leaf_clk _0033_ net189 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_34_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2920_ _0506_ _0509_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__xor2_1
X_2782_ _0338_ _0373_ _0374_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__nor3_2
XFILLER_0_25_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_1802_ net80 net14 net169 VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__mux2_1
X_2851_ net216 net213 VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__xor2_1
X_3334_ net142 _0910_ net175 VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__mux2_1
X_3403_ _0236_ _0966_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__xnor2_1
X_2216_ _1255_ _1479_ _1480_ _1481_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__o31ai_1
X_2147_ _1361_ _1370_ _1413_ VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__a21boi_1
X_3196_ _0778_ _0779_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__and2_4
X_3265_ _0826_ _0846_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__or2_1
XFILLER_0_15_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2078_ net27 net253 VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__xor2_2
XFILLER_0_48_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2001_ net250 net198 VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__and2_1
X_3050_ _0480_ _0481_ _0527_ _0528_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__a22o_1
X_2903_ net216 net207 VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__xor2_2
X_2696_ _0288_ _0289_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__and2_2
X_2834_ _0424_ _0425_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__nand2_4
X_2765_ _0355_ _0357_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3317_ net122 _0896_ net165 VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__mux2_1
XFILLER_0_68_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3248_ net213 _0784_ _0791_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__mux2_1
X_3179_ _0711_ _0714_ _0763_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_32_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput107 net107 VGND VGND VPWR VPWR b[17] sky130_fd_sc_hd__clkbuf_4
X_2550_ _1722_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__inv_2
XFILLER_0_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput129 net129 VGND VGND VPWR VPWR b[8] sky130_fd_sc_hd__clkbuf_4
X_2481_ _1683_ _1692_ _1740_ VGND VGND VPWR VPWR _1741_ sky130_fd_sc_hd__a21boi_4
Xoutput118 net118 VGND VGND VPWR VPWR b[27] sky130_fd_sc_hd__clkbuf_4
X_3102_ net17 _0627_ net18 VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__o21ai_1
X_3033_ _0107_ _0508_ _0562_ _0561_ _0559_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__o32a_1
XFILLER_0_18_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2679_ _0272_ _0213_ _0273_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__a21oi_1
X_2748_ _0322_ _0319_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__or2b_1
X_2817_ _0108_ _0352_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_30_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1981_ _1218_ _1251_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__xor2_4
XFILLER_0_55_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3582_ clknet_3_7__leaf_clk _0066_ net188 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__dfrtp_1
X_2533_ _0127_ _0130_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_23_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2602_ _0151_ _0154_ _0152_ _0197_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_2_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2395_ _1654_ _1655_ _1618_ VGND VGND VPWR VPWR _1657_ sky130_fd_sc_hd__a21oi_2
X_2464_ _1722_ _1723_ VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__and2_2
XFILLER_0_3_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3016_ _0602_ _0603_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__nor2_1
XFILLER_0_58_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout175 net176 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__clkbuf_2
Xfanout197 net198 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__clkbuf_4
Xfanout186 net190 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_52_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2180_ _1123_ _1400_ VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__and2_1
XFILLER_0_18_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1895_ _1162_ _1164_ _1165_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__a21oi_1
X_1964_ net200 _1234_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_43_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2447_ _1665_ _1707_ VGND VGND VPWR VPWR _1708_ sky130_fd_sc_hd__xor2_4
X_3565_ clknet_3_6__leaf_clk _0049_ net190 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__dfrtp_1
X_2516_ net244 net239 VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__nand2_2
XFILLER_0_11_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3496_ net290 _1045_ net166 VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__mux2_1
X_2378_ _1591_ _1593_ VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__and2_1
XFILLER_0_19_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3350_ _0923_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__clkbuf_1
X_2301_ _1560_ _1561_ _1564_ VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_40_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2163_ _1426_ _1429_ VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__and2b_1
X_2232_ _1364_ _1405_ VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__nor2_1
X_3281_ _0836_ _0839_ _0861_ VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__or3_1
X_2094_ net191 net244 VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__xor2_2
XFILLER_0_0_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1947_ _1179_ _1212_ _1217_ _1157_ VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__a22o_2
X_1878_ _1138_ _1148_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2996_ _0533_ _0565_ _0579_ _0489_ _0583_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__o221a_1
XFILLER_0_16_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3479_ _0767_ _0768_ _0730_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__a21oi_2
X_3548_ clknet_3_0__leaf_clk _0032_ net179 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_22_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2850_ net213 VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__inv_2
X_2781_ _0370_ _0371_ _0339_ _0340_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__o211a_1
XFILLER_0_31_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1801_ _1083_ VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_13_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3333_ _1297_ _0909_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__xor2_1
X_3402_ _0963_ _0960_ _0965_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__a21o_1
XFILLER_0_40_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3264_ _0826_ _0846_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__nand2_1
X_2077_ _1345_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__clkbuf_1
X_2215_ _1255_ net276 VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__nand2_1
X_2146_ _1367_ _1369_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__nand2_1
X_3195_ net20 _0777_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__nand2_1
X_2979_ _0533_ _0522_ _0567_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__a21o_1
XFILLER_0_8_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2000_ _1268_ _1269_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__and2_2
XFILLER_0_26_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2833_ _0423_ _0386_ _0388_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__nand3b_1
X_2902_ _0490_ _0491_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_53_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2695_ net8 _0187_ net9 VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__o21ai_1
X_2764_ _0304_ _0309_ _0356_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__a21boi_2
X_3247_ _0591_ _0695_ VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__and2b_1
X_3316_ _0892_ _0895_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__xor2_1
Xrebuffer10 _1717_ VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__clkbuf_1
X_2129_ net199 _1393_ _1394_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__nor3_1
X_3178_ _0761_ _0762_ VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput108 net108 VGND VGND VPWR VPWR b[18] sky130_fd_sc_hd__buf_2
X_2480_ _1689_ _1691_ VGND VGND VPWR VPWR _1740_ sky130_fd_sc_hd__nand2_1
XFILLER_0_23_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput119 net119 VGND VGND VPWR VPWR b[28] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_2_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3101_ net17 net18 _0627_ VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__or3_4
Xoutput90 net90 VGND VGND VPWR VPWR a[30] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3032_ _0618_ _0619_ VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__nor2_1
X_2816_ _0405_ _0407_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_41_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2747_ _0292_ _0294_ _0329_ VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__a21o_1
X_2678_ _0205_ _0207_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__nor2_1
XFILLER_0_1_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1980_ _1219_ _1250_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__xnor2_4
X_3581_ clknet_3_4__leaf_clk _0065_ net189 VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__dfrtp_1
X_2532_ _0128_ _1746_ _0129_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__a21o_2
X_2463_ net245 _1720_ _1721_ VGND VGND VPWR VPWR _1723_ sky130_fd_sc_hd__or3_1
Xrebuffer1 _0816_ VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__dlymetal6s2s_1
X_2601_ _1732_ _0107_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__nor2_1
X_2394_ _1618_ _1654_ _1655_ VGND VGND VPWR VPWR _1656_ sky130_fd_sc_hd__and3_1
XFILLER_0_3_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3015_ net223 net219 _0601_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__and3_1
XFILLER_0_61_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout165 net166 VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__clkbuf_4
Xfanout187 net189 VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__clkbuf_4
Xfanout198 net61 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__clkbuf_8
Xfanout176 net177 VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__buf_2
XFILLER_0_64_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_25_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1894_ net201 net209 net204 VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__and3b_1
X_1963_ net250 net198 VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__xor2_4
XFILLER_0_55_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_28_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2446_ _1705_ _1706_ VGND VGND VPWR VPWR _1707_ sky130_fd_sc_hd__nor2_2
X_3564_ clknet_3_6__leaf_clk _0048_ net185 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__dfrtp_1
X_2515_ _0110_ _0112_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__xor2_4
XFILLER_0_11_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3495_ _0867_ _1044_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__xor2_1
X_2377_ _1629_ _1638_ VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_61_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2300_ _1562_ _1563_ VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__nand2_1
X_2231_ _1492_ _1495_ VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__xor2_4
X_3280_ _0836_ _0839_ _0861_ VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__o21ai_1
X_2162_ _1427_ _1428_ VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__and2_1
X_2093_ _1357_ _1360_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_63_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2995_ _0534_ _0515_ _0563_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_0_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1946_ _1182_ _1196_ _1178_ VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__a21o_1
X_1877_ net198 net209 net229 VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__a21oi_1
X_3547_ clknet_3_2__leaf_clk _0031_ net178 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_3_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3478_ _1030_ VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__clkbuf_1
X_2429_ _1541_ _1588_ VGND VGND VPWR VPWR _1690_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1800_ net293 net13 net169 VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__mux2_1
XFILLER_0_15_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3401_ _0144_ _0964_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__and2_1
XFILLER_0_40_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2780_ _0339_ _0340_ _0372_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_31_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3332_ _1253_ _0905_ _0908_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__o21bai_1
X_2214_ _1436_ _1438_ _1478_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__a21oi_1
X_3194_ net20 _0777_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__or2_4
X_3263_ _0844_ _0845_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2076_ net121 _1344_ net174 VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__mux2_1
Xclkbuf_3_5__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_5__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_2145_ _1402_ _1411_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__xnor2_1
X_1929_ net208 net230 _1199_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__o21ai_1
X_2978_ _0566_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__inv_2
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_12_Left_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_26_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_26_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2832_ _0386_ _0388_ _0423_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__a21bo_1
X_2763_ _0299_ _0303_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__nand2_1
X_2901_ net213 net210 VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__xor2_4
X_2694_ net8 net9 _0187_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__or3_4
XFILLER_0_6_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer11 _1717_ VGND VGND VPWR VPWR net308 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_6_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3246_ _0827_ _0828_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__and2_1
X_3315_ _0873_ _0886_ _0894_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__o21ba_1
X_3177_ _0705_ _0760_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__and2_1
XFILLER_0_20_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2059_ _1270_ _1286_ _1327_ VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__a21oi_1
X_2128_ _1393_ _1394_ net199 VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__o21a_1
XFILLER_0_44_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput109 net109 VGND VGND VPWR VPWR b[19] sky130_fd_sc_hd__buf_2
X_3100_ _0686_ VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__clkbuf_1
X_3031_ _0556_ _0617_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__nor2_2
Xoutput91 net91 VGND VGND VPWR VPWR a[31] sky130_fd_sc_hd__clkbuf_4
Xoutput80 net80 VGND VGND VPWR VPWR a[21] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2746_ _0325_ _0326_ _0324_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__a21o_1
XFILLER_0_26_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2815_ _0349_ _0354_ _0406_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_5_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2677_ _0205_ _0207_ VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3229_ _0764_ _0767_ _0812_ VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__a21o_1
XFILLER_0_49_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer2 _1300_ VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__buf_1
XFILLER_0_23_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3580_ clknet_3_2__leaf_clk _0064_ net178 VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__dfrtp_1
X_2600_ _0192_ _0195_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__xor2_2
X_2393_ _1619_ _1606_ _1653_ VGND VGND VPWR VPWR _1655_ sky130_fd_sc_hd__nand3_2
X_2531_ _1743_ _1745_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__nor2_1
X_2462_ _1720_ _1721_ net245 VGND VGND VPWR VPWR _1722_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_2_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3014_ net223 net219 _0601_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_65_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2729_ _0319_ _0322_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__xnor2_1
Xfanout188 net189 VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__buf_2
Xfanout177 net66 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__clkbuf_2
Xfanout199 net200 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__clkbuf_4
Xfanout166 net169 VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Left_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1962_ _1226_ _1232_ VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__xnor2_4
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1893_ net209 net204 _1139_ _1163_ VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__a22o_1
XFILLER_0_55_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3563_ clknet_3_6__leaf_clk _0047_ net186 VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_43_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2445_ _1704_ _1668_ _1671_ VGND VGND VPWR VPWR _1706_ sky130_fd_sc_hd__and3_1
X_2376_ _1635_ _1637_ VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__xor2_4
X_2514_ _1731_ _1734_ _1732_ _0111_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__a2bb2o_2
X_3494_ _0849_ _1039_ _1043_ VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__a21o_1
XFILLER_0_19_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_27_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2230_ _1493_ _1494_ net241 VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__mux2_2
X_2161_ net27 _1300_ net28 VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__o21ai_1
X_2092_ _1103_ _1359_ VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__xor2_1
X_1945_ net12 net1 VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__xnor2_4
X_2994_ _0226_ _0230_ _0385_ _0580_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__a211o_1
XFILLER_0_28_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1876_ _1145_ _1146_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3546_ clknet_3_2__leaf_clk _0030_ net178 VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__dfrtp_1
X_2359_ net192 net247 _1584_ VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__and3_1
X_3477_ net148 _1029_ net167 VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__mux2_1
X_2428_ _1685_ _1688_ VGND VGND VPWR VPWR _1689_ sky130_fd_sc_hd__xor2_4
XFILLER_0_30_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3331_ _1216_ _1252_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__nor2_1
X_3400_ _0179_ _0180_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2213_ _1436_ _1438_ _1478_ VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__and3_1
X_2144_ _1408_ _1410_ VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__xor2_2
X_3193_ net19 _0687_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__or2_4
X_3262_ _0810_ _0813_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__nand2_1
XFILLER_0_72_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2075_ _1340_ _1343_ VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_1928_ net208 _1127_ net229 _1160_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__o211ai_1
X_1859_ net203 net229 VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_56_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2977_ _0564_ _0565_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__nor2_1
XFILLER_0_8_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3529_ clknet_3_7__leaf_clk _0013_ net187 VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_31_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2900_ net214 net213 VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__nand2_1
XFILLER_0_9_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2831_ _0419_ _0422_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__xor2_1
X_2762_ _0349_ _0354_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2693_ _0244_ _0282_ VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__and2_1
XFILLER_0_6_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3314_ _0883_ _0893_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__nor2_1
X_2127_ net197 net202 _1360_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__and3_1
X_3245_ net53 _0785_ _0789_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__or3_1
XFILLER_0_13_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3176_ _0705_ _0760_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__nor2_1
X_2058_ _1283_ _1285_ VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__and2b_1
XFILLER_0_8_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput70 net70 VGND VGND VPWR VPWR a[12] sky130_fd_sc_hd__buf_2
Xoutput92 net92 VGND VGND VPWR VPWR a[3] sky130_fd_sc_hd__clkbuf_4
X_3030_ _0556_ _0617_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__and2_1
Xoutput81 net81 VGND VGND VPWR VPWR a[22] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2745_ _0336_ _0337_ VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__nand2_1
X_2676_ _0265_ _0270_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__xnor2_1
X_2814_ _0347_ _0348_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3159_ _0741_ _0742_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__nor2_1
X_3228_ _0810_ _0811_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__nand2_1
XFILLER_0_64_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer3 net308 VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__clkbuf_1
X_2530_ _1676_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__inv_2
XFILLER_0_23_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2392_ _1619_ _1606_ _1653_ VGND VGND VPWR VPWR _1654_ sky130_fd_sc_hd__a21o_1
X_2461_ net248 net243 _1682_ VGND VGND VPWR VPWR _1721_ sky130_fd_sc_hd__and3_1
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3013_ _0599_ _0600_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__and2b_1
XFILLER_0_58_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2728_ _0320_ _0270_ _0321_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__a21oi_1
X_2659_ _0107_ _0152_ VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout189 net190 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__clkbuf_4
Xfanout167 net168 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__clkbuf_4
Xfanout178 net179 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_49_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1892_ net201 net204 VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__or2_1
X_1961_ _1228_ _1231_ VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_43_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3562_ clknet_3_6__leaf_clk _0046_ net186 VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_50_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2513_ _1632_ _1686_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3493_ _1042_ _0846_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__nor2_1
X_2444_ _1668_ _1671_ _1704_ VGND VGND VPWR VPWR _1705_ sky130_fd_sc_hd__a21oi_1
X_2375_ _1587_ _1590_ _1588_ _1636_ VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__a2bb2o_2
XFILLER_0_19_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2160_ net27 net28 _1300_ VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__or3_4
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2091_ net196 _1313_ _1358_ VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__a21o_1
X_1944_ _1214_ net1 VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__and2b_1
X_1875_ _1097_ _1099_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_43_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2993_ _0388_ _0580_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__or2_1
XFILLER_0_0_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3476_ _1027_ _1028_ VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__nor2_1
X_2427_ _1686_ _1687_ net233 VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__mux2_2
X_3545_ clknet_3_2__leaf_clk _0029_ net178 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__dfrtp_1
X_2289_ _1500_ _1502_ VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__nor2_1
X_2358_ _1365_ _1583_ VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__and2_1
XFILLER_0_66_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3330_ _0907_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_21_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2212_ _1442_ _1477_ VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__xnor2_2
X_2143_ _1363_ _1366_ _1364_ _1409_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__a2bb2o_1
X_3192_ _0776_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__clkbuf_1
X_3261_ _0842_ _0843_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__or2b_1
XFILLER_0_72_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2074_ _1341_ _1342_ VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_46_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1927_ _1187_ _1197_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__and2b_1
X_1858_ _1127_ _1101_ _1128_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__o21a_2
X_2976_ _0534_ _0515_ _0563_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__nor3_1
X_3528_ clknet_3_5__leaf_clk _0012_ net184 VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__dfrtp_1
X_1789_ _1077_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_55_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3459_ _0626_ _0629_ VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__or2b_1
XFILLER_0_12_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_64_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2830_ _0420_ _0421_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2692_ _0285_ _0286_ net280 _1258_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_38_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2761_ _0350_ _0353_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__xnor2_2
XANTENNA_1 net11 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_13_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3244_ _0785_ _0789_ net212 VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__o21ai_2
X_3313_ _0879_ _0880_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__nand2_1
X_2057_ _1307_ _1325_ VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__xnor2_1
X_2126_ _1103_ _1359_ VGND VGND VPWR VPWR _1393_ sky130_fd_sc_hd__and2_1
X_3175_ _0758_ _0759_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__or2_1
X_2959_ _0297_ _0547_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__xor2_1
XFILLER_0_44_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput93 net93 VGND VGND VPWR VPWR a[4] sky130_fd_sc_hd__clkbuf_4
Xoutput71 net71 VGND VGND VPWR VPWR a[13] sky130_fd_sc_hd__clkbuf_4
Xoutput82 net82 VGND VGND VPWR VPWR a[23] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2813_ _0399_ _0404_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_41_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2744_ net10 _0288_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__nand2_1
X_2675_ _0268_ _0269_ VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3227_ _0758_ _0761_ _0809_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__or3_1
X_2109_ _1307_ _1325_ _1376_ VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_49_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3089_ _0648_ _0619_ _0675_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__o21a_1
X_3158_ _0741_ _0742_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__and2_1
XFILLER_0_17_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xrebuffer4 net258 VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__clkbuf_1
X_2460_ _1459_ _1681_ VGND VGND VPWR VPWR _1720_ sky130_fd_sc_hd__and2_1
XFILLER_0_2_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2391_ _1651_ _1652_ VGND VGND VPWR VPWR _1653_ sky130_fd_sc_hd__or2b_1
X_3012_ _0345_ _0598_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__nand2_1
XFILLER_0_61_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2589_ _1712_ net268 _0184_ _0185_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__a22o_1
X_2727_ _0262_ _0264_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__nor2_1
X_2658_ _0249_ _0252_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_14_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout168 net169 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__clkbuf_2
Xfanout179 net182 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_52_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1891_ _1160_ _1161_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__xnor2_1
X_1960_ _1229_ _1230_ VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__nand2_2
XFILLER_0_55_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3561_ clknet_3_7__leaf_clk _0045_ net187 VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__dfrtp_1
X_2443_ _1702_ _1703_ VGND VGND VPWR VPWR _1704_ sky130_fd_sc_hd__nand2_1
X_2512_ _0106_ _0109_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__xor2_4
XFILLER_0_11_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3492_ _0826_ VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__inv_2
X_2374_ _1493_ _1541_ VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2090_ net193 net246 VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__and2_1
XFILLER_0_29_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2992_ _0487_ _0579_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__or2_1
XFILLER_0_28_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1943_ _1181_ _1213_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__xnor2_1
X_1874_ net200 _1139_ _1141_ _1144_ VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__o22a_1
XFILLER_0_28_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3475_ _0724_ _1026_ _0817_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__a21oi_1
X_2426_ net235 net231 VGND VGND VPWR VPWR _1687_ sky130_fd_sc_hd__xor2_2
XFILLER_0_24_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3544_ clknet_3_2__leaf_clk _0028_ net178 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__dfrtp_1
X_2357_ _1604_ _1603_ VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__or2b_1
X_2288_ _1533_ _1551_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_19_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3260_ _0804_ _0808_ _0841_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_72_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2073_ _1215_ _1253_ _1263_ _1296_ _1259_ VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__a221o_1
X_2211_ _1443_ _1476_ VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__xnor2_2
X_2142_ _1277_ _1315_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__nor2_1
X_3191_ net289 _0775_ net167 VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__mux2_1
XFILLER_0_56_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2975_ _0534_ _0515_ _0563_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__o21a_1
X_3527_ clknet_3_4__leaf_clk _0011_ net184 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__dfrtp_1
X_1926_ _1185_ _1186_ VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__nand2_1
X_1857_ net194 net202 VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__nand2_1
X_1788_ net72 net6 net174 VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__mux2_1
X_3389_ _1719_ _1753_ _0954_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__a21o_1
X_2409_ _1605_ _1669_ _1666_ VGND VGND VPWR VPWR _1670_ sky130_fd_sc_hd__nand3_1
X_3458_ _1012_ _0575_ _0572_ _0632_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__and4b_1
XFILLER_0_62_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_2 net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_2691_ _0243_ _0283_ VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__nor2_1
X_2760_ _0108_ _0352_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__xor2_2
XFILLER_0_67_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3312_ _0890_ _0891_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__xnor2_4
X_3243_ net21 _0778_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__xor2_2
X_2125_ _1351_ _1378_ VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__nor2_1
X_2056_ _1322_ _1324_ VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_16_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3174_ _0755_ _0757_ VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__nor2_1
X_1909_ _1157_ _1178_ VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2958_ net218 _0493_ _0546_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_8_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2889_ _0474_ _0475_ _0479_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_50_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput94 net94 VGND VGND VPWR VPWR a[5] sky130_fd_sc_hd__clkbuf_4
Xoutput72 net72 VGND VGND VPWR VPWR a[14] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_50_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput83 net83 VGND VGND VPWR VPWR a[24] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2743_ net10 _0288_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__or2_4
XFILLER_0_26_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2812_ _0400_ _0403_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_41_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2674_ net238 _0266_ _0267_ VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__or3_1
XFILLER_0_26_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3157_ net207 net211 net206 VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__mux2_1
X_3226_ _0758_ _0761_ _0809_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__o21ai_2
X_2039_ net199 net203 VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__nand2_1
X_2108_ _1322_ _1324_ VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__and2b_1
XFILLER_0_49_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3088_ _0673_ _0674_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__nor2_1
XFILLER_0_17_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer5 _0687_ VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_2_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2390_ _1650_ _1647_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__or2b_1
X_3011_ _0345_ _0598_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__nor2_1
XFILLER_0_64_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2726_ _0262_ _0264_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2588_ _0140_ _0183_ _0141_ net173 VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__o31a_1
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2657_ _0193_ _0250_ _0251_ VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__o21a_1
Xfanout169 net66 VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__buf_4
X_3209_ _0791_ _0792_ VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__and2_1
XFILLER_0_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_19_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1890_ net200 net229 VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__xor2_1
XFILLER_0_70_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3560_ clknet_3_7__leaf_clk _0044_ net187 VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_43_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2442_ _1672_ _1673_ _1701_ VGND VGND VPWR VPWR _1703_ sky130_fd_sc_hd__or3_1
X_2373_ _1631_ _1634_ VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__xor2_4
X_2511_ _0107_ _0108_ net227 VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__mux2_2
X_3491_ _1712_ net282 _1040_ _1041_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_42_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2709_ net221 _0300_ _0249_ _0302_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__o22ai_4
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_4_Left_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_1942_ _1182_ _1196_ _1212_ VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2991_ _0521_ _0566_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__nand2_1
X_1873_ _1142_ _1143_ net201 VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__mux2_1
XFILLER_0_24_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3543_ clknet_3_2__leaf_clk _0027_ net180 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_3_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3612_ clknet_3_0__leaf_clk _0096_ net178 VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_10_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2356_ net2 _1608_ VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__xor2_2
X_3474_ _0724_ _0817_ _1026_ VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__and3_1
X_2425_ net231 VGND VGND VPWR VPWR _1686_ sky130_fd_sc_hd__inv_2
XFILLER_0_3_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2287_ _1548_ _1550_ VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__xor2_4
XFILLER_0_59_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_65_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xwire164 _0993_ VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__clkbuf_1
X_2210_ _1474_ _1475_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__and2b_2
X_3190_ _0772_ _0774_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2072_ _1263_ _1296_ VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__or2_1
X_2141_ _1404_ _1407_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__xor2_2
X_1925_ _1194_ _1195_ VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__nor2_1
XFILLER_0_29_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2974_ _0535_ _0562_ VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3526_ clknet_3_4__leaf_clk _0010_ net184 VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__dfrtp_1
X_1856_ net203 VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__inv_2
X_1787_ _1076_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_24_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2408_ _1511_ _1559_ VGND VGND VPWR VPWR _1669_ sky130_fd_sc_hd__nor2_1
X_3388_ _0953_ _0954_ net269 _1712_ VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__a2bb2o_1
X_2339_ _1599_ _1601_ VGND VGND VPWR VPWR _1602_ sky130_fd_sc_hd__xor2_4
X_3457_ _0480_ _1003_ _0527_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__o21a_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold50 net89 VGND VGND VPWR VPWR net301 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2690_ _1254_ _0284_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__or2_1
XANTENNA_3 net112 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3311_ net25 _0882_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__xor2_4
XPHY_EDGE_ROW_7_Left_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2124_ _1375_ _1377_ VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__nor2_1
X_3242_ _0646_ _0816_ _0821_ _0824_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__a31oi_4
X_3173_ _0755_ _0757_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__and2_1
X_2055_ _1274_ _1282_ _1323_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__a21bo_1
X_1908_ _1157_ _1178_ VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__or2_1
X_1839_ net208 net251 VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__nand2_2
XFILLER_0_29_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2888_ _0478_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__inv_2
X_2957_ net217 net207 VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__and2_1
XFILLER_0_8_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3509_ _0891_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__inv_2
XFILLER_0_12_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput95 net95 VGND VGND VPWR VPWR a[6] sky130_fd_sc_hd__clkbuf_4
Xoutput73 net73 VGND VGND VPWR VPWR a[15] sky130_fd_sc_hd__clkbuf_4
Xoutput84 net84 VGND VGND VPWR VPWR a[25] sky130_fd_sc_hd__buf_2
XFILLER_0_58_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2742_ _0334_ _0335_ net106 _1258_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_26_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2811_ _0153_ _0402_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__xor2_2
XFILLER_0_41_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2673_ _0266_ _0267_ net238 VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_1_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2107_ _1356_ _1374_ VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__xnor2_1
X_3156_ _0739_ _0740_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__nor2_1
X_3225_ _0807_ _0808_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__nor2_1
X_3087_ _0611_ _0672_ VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__and2_1
X_2038_ net203 _1306_ VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer6 _0142_ VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_23_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3010_ net217 _0539_ _0597_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_58_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2725_ _0313_ _0318_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2656_ net222 net220 VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__or2_1
X_2587_ _0140_ _0141_ _0183_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__o21ai_1
X_3139_ _0723_ _0724_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__nand2b_2
X_3208_ _0691_ _0790_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__nand2_1
XFILLER_0_49_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2510_ net231 net226 VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__xor2_2
X_3490_ _0849_ _1039_ net166 VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__o21a_1
X_2441_ _1672_ _1673_ _1701_ VGND VGND VPWR VPWR _1702_ sky130_fd_sc_hd__o21ai_2
X_2372_ _1632_ _1633_ net235 VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__mux2_2
XFILLER_0_11_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_20_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2639_ _0186_ _0184_ _0233_ VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_42_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2708_ _0251_ _0301_ _0300_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_69_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1941_ _1182_ _1196_ _1204_ _1211_ VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__o22a_1
X_1872_ net200 net204 VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__xor2_4
X_2990_ _0577_ _0578_ net112 _1258_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_51_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3473_ _1019_ _1025_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__or2_1
XFILLER_0_24_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3611_ clknet_3_0__leaf_clk _0095_ net179 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__dfrtp_1
X_3542_ clknet_3_2__leaf_clk _0026_ net178 VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__dfrtp_1
X_2355_ _1615_ _1617_ net275 _1258_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__a2bb2o_1
X_2286_ _1490_ _1499_ _1549_ VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__a21boi_4
X_2424_ net239 _1684_ VGND VGND VPWR VPWR _1685_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_51_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2140_ _1405_ _1406_ net246 VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__mux2_1
XFILLER_0_72_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2071_ _1338_ _1339_ VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__nand2_1
X_1924_ _1159_ _1175_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__xnor2_1
X_1855_ _1119_ _1125_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__xor2_4
XFILLER_0_56_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2973_ _0559_ _0561_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__xnor2_1
X_3525_ clknet_3_5__leaf_clk _0009_ net184 VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__dfrtp_1
X_1786_ net71 net5 net172 VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__mux2_1
X_3456_ _0992_ _1010_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__and2_1
XFILLER_0_24_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2269_ _1531_ _1532_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__and2_2
X_3387_ _0947_ _0952_ _1754_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__a21oi_1
X_2407_ _1605_ _1573_ _1666_ _1667_ VGND VGND VPWR VPWR _1668_ sky130_fd_sc_hd__a31oi_4
X_2338_ _1533_ _1551_ _1600_ VGND VGND VPWR VPWR _1601_ sky130_fd_sc_hd__a21oi_4
XFILLER_0_62_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_33_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_42_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold40 net155 VGND VGND VPWR VPWR net291 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 net163 VGND VGND VPWR VPWR net302 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_51_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_4 net67 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XPHY_EDGE_ROW_60_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3310_ _0879_ _0889_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__nand2_4
X_2123_ net174 _1387_ _1388_ _1390_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__a31o_1
X_3241_ _0771_ _0816_ _0822_ _0780_ _0823_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__a32o_2
X_3172_ _0703_ _0707_ _0756_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__a21o_1
X_2054_ _1280_ _1281_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__nand2_1
XFILLER_0_16_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1907_ _1158_ _1177_ VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__and2b_1
X_1838_ net195 net203 _1108_ VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__a21o_1
XFILLER_0_44_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2887_ _0476_ _0477_ VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2956_ net225 net221 VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_1769_ _1067_ VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__clkbuf_1
X_3439_ _0992_ _0997_ _1389_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__a21o_1
XFILLER_0_4_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3508_ net166 net267 _1054_ _1055_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__o22a_1
XFILLER_0_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_12_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput96 net96 VGND VGND VPWR VPWR a[7] sky130_fd_sc_hd__clkbuf_4
Xoutput74 net74 VGND VGND VPWR VPWR a[16] sky130_fd_sc_hd__clkbuf_4
Xoutput85 net85 VGND VGND VPWR VPWR a[26] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2741_ _0287_ _0284_ _0333_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__o21a_1
X_2672_ net240 net236 _0203_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__and3_1
XFILLER_0_5_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2810_ net224 _0343_ _0401_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3224_ _0752_ _0806_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__nor2_1
.ends
