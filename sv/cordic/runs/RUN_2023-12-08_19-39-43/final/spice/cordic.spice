* NGSPICE file created from cordic.ext - technology: sky130A

.subckt sky130_fd_sc_hd__xnor2_1 A B VGND VNB VPB VPWR Y
X0 a_377_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.365 ps=1.73 w=1 l=0.15
X1 a_47_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.3 ps=2.6 w=1 l=0.15
X2 a_129_47# B a_47_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_285_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X4 Y a_47_47# a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_129_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0683 ps=0.86 w=0.65 l=0.15
X6 VPWR A a_47_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.365 pd=1.73 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR a_47_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.165 ps=1.33 w=1 l=0.15
X8 Y B a_377_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND C Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_8 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=2.89
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=2.89
.ends

.subckt sky130_fd_sc_hd__o21ai_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 Y A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.174 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.182 pd=1.92 as=0.174 ps=1.39 w=0.7 l=0.15
X2 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X3 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_4 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.05
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.05
.ends

.subckt sky130_fd_sc_hd__decap_6 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=1.97
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=1.97
.ends

.subckt sky130_fd_sc_hd__a31o_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.35 as=0.265 ps=2.53 w=1 l=0.15
X1 a_209_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.172 ps=1.35 w=1 l=0.15
X2 a_303_47# A2 a_209_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.104 ps=0.97 w=0.65 l=0.15
X3 a_209_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.112 ps=0.995 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.172 ps=1.83 w=0.65 l=0.15
X5 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.107 ps=0.98 w=0.65 l=0.15
X6 a_80_21# A1 a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X7 VPWR A2 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.16 ps=1.32 w=1 l=0.15
X8 a_80_21# B1 a_209_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X9 a_209_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__decap_3 VGND VNB VPB VPWR
X0 VPWR VGND VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.226 pd=2.26 as=0 ps=0 w=0.87 l=0.59
X1 VGND VPWR VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.62 as=0 ps=0 w=0.55 l=0.59
.ends

.subckt sky130_fd_sc_hd__clkbuf_1 A VGND VNB VPB VPWR X
X0 VPWR a_75_212# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 a_75_212# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 a_75_212# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND a_75_212# X VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 Y a_61_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.183 ps=1.24 w=0.65 l=0.15
X1 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_217_297# a_61_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_479_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X4 a_217_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X5 Y a_61_47# a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X6 VPWR A1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_61_47# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VGND A2 a_637_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_61_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A1 a_479_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0683 ps=0.86 w=0.65 l=0.15
X11 VGND B1_N a_61_47# VNB sky130_fd_pr__nfet_01v8 ad=0.183 pd=1.24 as=0.126 ps=1.44 w=0.42 l=0.15
X12 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X13 a_637_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_109_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 VPWR A1 a_382_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X1 a_297_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X2 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.327 pd=1.65 as=0.28 ps=2.56 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.327 ps=1.65 w=1 l=0.15
X6 a_382_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.195 ps=1.39 w=1 l=0.15
X7 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_1 A B VGND VNB VPB VPWR X
X0 VPWR B a_59_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 X a_59_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.475 pd=2.95 as=0.167 ps=1.39 w=1 l=0.15
X2 VGND B a_145_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_59_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X4 X a_59_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.112 ps=1.04 w=0.65 l=0.15
X5 a_145_75# A a_59_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_1 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_199_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0959 pd=0.945 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_113_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.147 ps=1.29 w=1 l=0.15
X2 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X3 VPWR A1 a_113_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.147 pd=1.29 as=0.14 ps=1.28 w=1 l=0.15
X4 a_113_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A2 a_199_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0959 ps=0.945 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__inv_2 A VGND VNB VPB VPWR Y
X0 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_4 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.42 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0703 pd=0.755 as=0.111 ps=1.37 w=0.42 l=0.15
X6 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.14 ps=1.28 w=1 l=0.15
X7 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0703 ps=0.755 w=0.42 l=0.15
X8 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.165 ps=1.33 w=1 l=0.15
X9 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_2 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.265 ps=2.53 w=1 l=0.15
X1 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.745 as=0.111 ps=1.37 w=0.42 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.162 ps=1.33 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_2 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.149 ps=1.33 w=1 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.149 pd=1.33 as=0.166 ps=1.8 w=0.64 l=0.15
X3 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.097 ps=0.975 w=0.65 l=0.15
X4 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_6 A VGND VNB VPB VPWR X
X0 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_161_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X2 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_161_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR a_161_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 X a_161_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_161_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A a_161_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 VGND a_161_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 a_161_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21o_1 A1 A2 B1 VGND VNB VPB VPWR X
X0 a_81_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.257 ps=1.44 w=0.65 l=0.15
X1 a_299_297# B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A1 a_299_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X6 a_299_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 a_384_47# A1 a_81_21# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_1 A B VGND VNB VPB VPWR X
X0 X a_35_297# a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.26 ps=2.52 w=1 l=0.15
X1 X B a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.25 pd=1.42 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_117_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 VPWR B a_285_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.25 ps=1.42 w=0.65 l=0.15
X7 a_285_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A a_117_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_285_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_2 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.172 ps=1.83 w=0.65 l=0.15
X2 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.105 ps=1.21 w=1 l=0.15
X3 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X5 a_326_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.127 ps=1.04 w=0.65 l=0.15
X6 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.635 pd=3.27 as=0.195 ps=1.39 w=1 l=0.15
X7 Y C1 a_326_47# VNB sky130_fd_pr__nfet_01v8 ad=0.393 pd=2.51 as=0.0683 ps=0.86 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfstp_1 CLK D SET_B VGND VNB VPB VPWR Q
X0 VGND a_652_21# a_586_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0882 pd=0.84 as=0.0671 ps=0.75 w=0.42 l=0.15
X1 a_956_413# a_476_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0483 pd=0.65 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 VPWR a_476_47# a_652_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_586_47# a_193_47# a_476_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0671 pd=0.75 as=0.072 ps=0.76 w=0.36 l=0.15
X4 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X5 a_476_47# a_27_47# a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.072 pd=0.76 as=0.0935 ps=0.965 w=0.36 l=0.15
X6 a_1056_47# a_476_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X7 a_381_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.125 pd=1.17 as=0.218 ps=2.2 w=0.84 l=0.15
X8 a_652_21# SET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0798 ps=0.8 w=0.42 l=0.15
X9 a_1224_47# a_27_47# a_1032_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X10 a_562_413# a_27_47# a_476_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0945 pd=0.87 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 VGND a_1032_413# a_1602_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X12 VPWR a_1182_261# a_1140_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X13 Q a_1602_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.149 ps=1.33 w=1 l=0.15
X14 a_1032_413# a_193_47# a_1056_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X15 a_476_47# a_193_47# a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.125 ps=1.17 w=0.42 l=0.15
X16 a_1296_47# a_1182_261# a_1224_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0483 pd=0.65 as=0.0441 ps=0.63 w=0.42 l=0.15
X17 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X18 VPWR a_652_21# a_562_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0798 pd=0.8 as=0.0945 ps=0.87 w=0.42 l=0.15
X19 VPWR SET_B a_1032_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.123 pd=1.17 as=0.109 ps=1.36 w=0.42 l=0.15
X20 a_1032_413# a_27_47# a_956_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0483 ps=0.65 w=0.42 l=0.15
X21 a_1182_261# a_1032_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.218 pd=2.2 as=0.123 ps=1.17 w=0.84 l=0.15
X22 Q a_1602_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X23 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X24 a_1140_413# a_193_47# a_1032_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0819 ps=0.81 w=0.42 l=0.15
X25 VPWR a_1032_413# a_1602_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.149 pd=1.33 as=0.166 ps=1.8 w=0.64 l=0.15
X26 a_796_47# SET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0882 ps=0.84 w=0.42 l=0.15
X27 a_381_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0935 pd=0.965 as=0.166 ps=1.8 w=0.64 l=0.15
X28 a_1182_261# a_1032_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.6 as=0.114 ps=1.01 w=0.54 l=0.15
X29 a_652_21# a_476_47# a_796_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X30 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X31 VGND SET_B a_1296_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1.01 as=0.0483 ps=0.65 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_1 A B VGND VNB VPB VPWR X
X0 VGND A a_68_297# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_68_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_68_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR A a_150_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 X a_68_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.34 pd=2.68 as=0.146 ps=1.34 w=1 l=0.15
X5 a_150_297# B a_68_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2b_1 A_N B VGND VNB VPB VPWR X
X0 VPWR B a_207_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.228 pd=1.74 as=0.0609 ps=0.71 w=0.42 l=0.15
X1 X a_207_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.228 ps=1.74 w=1 l=0.15
X2 a_297_47# a_27_413# a_207_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0504 pd=0.66 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_207_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.99 w=0.65 l=0.15
X4 a_207_413# a_27_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0609 pd=0.71 as=0.0714 ps=0.76 w=0.42 l=0.15
X5 VPWR A_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0714 pd=0.76 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VGND B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.99 as=0.0504 ps=0.66 w=0.42 l=0.15
X7 a_27_413# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_2 A B_N VGND VNB VPB VPWR X
X0 VPWR A a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_218_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.156 ps=1.16 w=0.42 l=0.15
X2 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.156 pd=1.16 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_300_297# a_27_53# a_218_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_218_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 VPWR a_218_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=2.62 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_218_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X7 VGND a_218_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 VGND A a_218_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_2 A B VGND VNB VPB VPWR Y
X0 a_27_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_560_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X2 VGND B a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0991 ps=0.955 w=0.65 l=0.15
X3 Y B a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y a_27_297# a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_474_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X7 VGND A a_560_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# B a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X10 a_27_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X12 a_474_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_560_47# a_27_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X14 VPWR A a_474_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X15 Y a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X16 VPWR a_27_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X17 a_560_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_2 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_470_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_470_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_470_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.106 ps=0.975 w=0.65 l=0.15
X6 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X8 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X10 a_470_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.162 ps=1.33 w=1 l=0.15
X11 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X12 VPWR B a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X13 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X16 X a_112_47# a_470_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 a_470_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X18 X B a_470_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_1 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X3 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X4 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X5 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.301 ps=2.66 w=1 l=0.15
X7 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X8 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X10 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X12 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X13 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X14 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X15 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X16 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X17 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X18 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X20 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X21 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X22 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.209 ps=2.02 w=0.65 l=0.15
X23 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X24 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X25 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X26 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X27 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
.ends

.subckt sky130_fd_sc_hd__o221a_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_240_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_51_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND A1 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_51_297# B2 a_245_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.412 pd=1.83 as=0.105 ps=1.21 w=1 l=0.15
X4 a_149_47# C1 a_51_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.201 ps=1.92 w=0.65 l=0.15
X5 a_240_47# B1 a_149_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0991 ps=0.955 w=0.65 l=0.15
X6 VPWR A1 a_512_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.105 ps=1.21 w=1 l=0.15
X7 X a_51_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.165 ps=1.33 w=1 l=0.15
X8 a_149_47# B2 a_240_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_245_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X10 VPWR C1 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.34 ps=2.68 w=1 l=0.15
X11 a_512_297# A2 a_51_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.412 ps=1.83 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311oi_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
X0 Y A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_641_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=1.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 a_109_297# B1 a_641_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X5 a_277_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR A3 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.17 w=0.65 l=0.15
X11 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.14 ps=1.28 w=1 l=0.15
X12 a_641_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X13 a_277_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0975 ps=0.95 w=0.65 l=0.15
X15 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 Y C1 a_641_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=1.52 w=1 l=0.15
X18 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X19 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.17 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_1 A0 A1 S VGND VNB VPB VPWR X
X0 VPWR a_505_21# a_535_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_505_21# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.0693 ps=0.75 w=0.42 l=0.15
X2 a_218_374# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0767 pd=0.785 as=0.158 ps=1.39 w=0.42 l=0.15
X3 VGND a_505_21# a_439_47# VNB sky130_fd_pr__nfet_01v8 ad=0.145 pd=1.11 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 a_76_199# A0 a_218_374# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.193 pd=1.34 as=0.0767 ps=0.785 w=0.42 l=0.15
X5 a_505_21# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.145 ps=1.11 w=0.42 l=0.15
X6 a_439_47# A0 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0997 ps=0.895 w=0.42 l=0.15
X7 a_535_374# A1 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.193 ps=1.34 w=0.42 l=0.15
X8 a_76_199# A1 a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0997 pd=0.895 as=0.0693 ps=0.75 w=0.42 l=0.15
X9 a_218_47# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.113 ps=1.04 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.158 pd=1.39 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.04 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32a_2 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_429_297# A2 a_345_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.215 pd=1.43 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND A2 a_345_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_345_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.14 ps=1.08 w=0.65 l=0.15
X5 a_345_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.305 ps=1.61 w=1 l=0.15
X6 a_629_297# B2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR B1 a_629_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.33 pd=2.66 as=0.19 ps=1.38 w=1 l=0.15
X8 a_79_21# B2 a_345_47# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_345_47# B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.214 pd=1.96 as=0.123 ps=1.03 w=0.65 l=0.15
X10 a_79_21# A3 a_429_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.215 ps=1.43 w=1 l=0.15
X11 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X12 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_345_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.198 ps=1.26 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2bb2a_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_206_369# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.146 ps=1.34 w=0.42 l=0.15
X1 a_206_369# A2_N a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 VGND B2 a_489_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 a_585_369# B2 a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0672 ps=0.74 w=0.42 l=0.15
X4 a_489_47# a_206_369# a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_489_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VPWR A2_N a_206_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.209 pd=1.35 as=0.129 ps=1.18 w=0.42 l=0.15
X7 a_76_199# a_206_369# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.74 as=0.209 ps=1.35 w=0.42 l=0.15
X8 a_205_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0662 pd=0.735 as=0.0986 ps=0.98 w=0.42 l=0.15
X9 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.26 ps=2.52 w=1 l=0.15
X10 VPWR B1 a_585_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0986 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd3_1 A VGND VNB VPB VPWR X
X0 VPWR A a_49_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VGND a_285_47# a_391_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.5
X2 X a_391_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VGND A a_49_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VPWR a_285_47# a_391_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.5
X5 a_285_47# a_49_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X6 a_285_47# a_49_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.5
X7 X a_391_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_4 A VGND VNB VPB VPWR X
X0 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22o_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.16 ps=1.32 w=1 l=0.15
X1 a_27_297# B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0747 ps=0.88 w=0.65 l=0.15
X2 VGND A2 a_373_47# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.114 ps=1 w=0.65 l=0.15
X3 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.155 ps=1.31 w=1 l=0.15
X4 a_27_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.253 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.253 ps=2.52 w=1 l=0.15
X6 a_373_47# A1 a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.169 ps=1.82 w=0.65 l=0.15
X7 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.101 ps=0.96 w=0.65 l=0.15
X8 a_109_297# B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X9 a_109_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0747 pd=0.88 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux4_1 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
X0 a_277_47# a_247_21# a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VGND S0 a_247_21# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_834_97# a_247_21# a_750_97# VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 VGND A3 a_668_97# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.108 ps=1.36 w=0.42 l=0.15
X4 a_1290_413# S1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_834_97# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 a_750_97# S0 a_757_363# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.108 ps=1.36 w=0.42 l=0.15
X7 a_27_47# S0 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0852 ps=0.925 w=0.42 l=0.15
X8 X a_1478_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
X9 VPWR A1 a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X10 VPWR S0 a_247_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.108 pd=1.36 as=0.108 ps=1.36 w=0.42 l=0.15
X11 X a_1478_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X12 a_193_47# A0 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X13 a_750_97# a_1290_413# a_1478_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.269 pd=2.12 as=0.0921 ps=0.99 w=0.42 l=0.15
X14 a_1478_413# S1 a_277_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0921 pd=0.99 as=0.109 ps=1.36 w=0.42 l=0.15
X15 a_1290_413# S1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X16 a_277_47# a_247_21# a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0852 pd=0.925 as=0.0567 ps=0.69 w=0.42 l=0.15
X17 a_750_97# S0 a_668_97# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X18 a_923_363# a_247_21# a_750_97# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0901 pd=0.995 as=0.0567 ps=0.69 w=0.42 l=0.15
X19 a_757_363# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X20 VPWR A3 a_923_363# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0901 ps=0.995 w=0.42 l=0.15
X21 a_277_47# a_1290_413# a_1478_413# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.151 ps=1.28 w=0.42 l=0.15
X22 a_193_413# A0 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X23 a_193_413# S0 a_277_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.108 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X24 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X25 a_1478_413# S1 a_750_97# VNB sky130_fd_pr__nfet_01v8 ad=0.151 pd=1.28 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_16 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X7 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X8 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X11 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=1.37 as=0.0588 ps=0.7 w=0.42 l=0.15
X18 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X20 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.138 ps=1.27 w=1 l=0.15
X21 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X22 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X23 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X25 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X26 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X27 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X28 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X29 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X30 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X31 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X32 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X33 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X34 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X35 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X36 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X37 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X38 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X39 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0578 ps=0.695 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_1 A B VGND VNB VPB VPWR Y
X0 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A a_113_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_113_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X3 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_1 A B C VGND VNB VPB VPWR X
X0 X a_29_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.148 ps=1.34 w=1 l=0.15
X1 a_111_297# C a_29_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X2 X a_29_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.102 ps=0.99 w=0.65 l=0.15
X3 a_183_297# B a_111_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 VPWR A a_183_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X5 a_29_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VGND C a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_29_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_4 A B VGND VNB VPB VPWR Y
X0 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X6 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X11 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_285_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0683 ps=0.86 w=0.65 l=0.15
X1 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=2.1 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A1 a_114_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0894 ps=0.925 w=0.65 l=0.15
X3 a_114_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0894 pd=0.925 as=0.185 ps=1.87 w=0.65 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X5 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.28 ps=2.56 w=1 l=0.15
X8 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X10 a_285_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.091 ps=0.93 w=0.65 l=0.15
X11 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31a_1 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 a_103_199# B1 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.201 pd=1.92 as=0.107 ps=0.98 w=0.65 l=0.15
X1 VPWR a_103_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.36 ps=2.72 w=1 l=0.15
X2 a_337_297# A2 a_253_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_103_199# A3 a_337_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.165 ps=1.33 w=1 l=0.15
X4 a_253_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.195 ps=1.39 w=1 l=0.15
X5 VPWR B1 a_103_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.345 pd=2.69 as=0.213 ps=1.42 w=1 l=0.15
X6 VGND a_103_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.234 ps=2.02 w=0.65 l=0.15
X7 a_253_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.127 ps=1.04 w=0.65 l=0.15
X8 a_253_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X9 VGND A2 a_253_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xnor2_4 A B VGND VNB VPB VPWR Y
X0 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X5 VGND A a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_820_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_902_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X17 Y a_38_297# a_902_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_38_47# B a_38_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_38_297# B a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X21 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X23 a_38_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_902_47# a_38_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y B a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_38_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VPWR A a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 VGND A a_38_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 a_820_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y a_38_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 a_902_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X36 a_38_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VPWR A a_820_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VPWR a_38_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X39 VPWR B a_38_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_4 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X3 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X4 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X5 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=2.61 as=0.135 ps=1.27 w=1 l=0.15
X7 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X8 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X9 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X12 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X14 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X15 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X16 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X17 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X18 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X19 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X20 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X21 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X22 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X23 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X24 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X25 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X28 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X29 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X30 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X31 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X32 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
X33 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2bb2o_1 A1_N A2_N B1 B2 VGND VNB VPB VPWR X
X0 a_226_47# A2_N a_226_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.0441 ps=0.63 w=0.42 l=0.15
X1 a_489_413# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_226_297# A1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.167 ps=1.43 w=0.42 l=0.15
X3 VPWR B2 a_489_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_489_413# a_226_47# a_76_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_76_199# a_226_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.139 ps=1.08 w=0.42 l=0.15
X6 VGND B1 a_556_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_556_47# B2 a_76_199# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VGND A2_N a_226_47# VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.08 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 a_226_47# A1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.12 ps=1.09 w=0.42 l=0.15
X10 VPWR a_76_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.43 as=0.26 ps=2.52 w=1 l=0.15
X11 VGND a_76_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.09 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211a_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VGND A1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
X1 a_510_47# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.143 ps=1.09 w=0.65 l=0.15
X2 a_79_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.175 ps=1.35 w=1 l=0.15
X3 VPWR B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.22 ps=1.44 w=1 l=0.15
X4 a_79_21# A2 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.22 pd=1.44 as=0.162 ps=1.33 w=1 l=0.15
X5 a_297_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X6 a_79_21# C1 a_510_47# VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.114 ps=1 w=0.65 l=0.15
X7 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X8 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
X9 a_215_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.106 ps=0.975 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32o_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_93_21# A1 a_346_47# VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.146 ps=1.1 w=0.65 l=0.15
X1 a_93_21# B1 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.185 ps=1.37 w=1 l=0.15
X2 a_584_47# B1 a_93_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.143 ps=1.09 w=0.65 l=0.15
X3 VPWR a_93_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.243 pd=1.49 as=0.33 ps=2.66 w=1 l=0.15
X4 VGND B2 a_584_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 a_256_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.167 ps=1.16 w=0.65 l=0.15
X6 a_250_297# B2 a_93_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X7 VGND a_93_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.167 pd=1.16 as=0.214 ps=1.96 w=0.65 l=0.15
X8 a_250_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.243 ps=1.49 w=1 l=0.15
X9 VPWR A2 a_250_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.225 pd=1.45 as=0.165 ps=1.33 w=1 l=0.15
X10 a_250_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.225 ps=1.45 w=1 l=0.15
X11 a_346_47# A2 a_256_47# VNB sky130_fd_pr__nfet_01v8 ad=0.146 pd=1.1 as=0.0975 ps=0.95 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22a_1 A1 A2 B1 B2 VGND VNB VPB VPWR X
X0 a_78_199# B1 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X1 VPWR A1 a_493_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X2 a_493_297# A2 a_78_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.235 ps=1.47 w=1 l=0.15
X3 VPWR a_78_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.373 pd=1.75 as=0.28 ps=2.56 w=1 l=0.15
X4 VGND A2 a_215_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X5 a_78_199# B2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.235 pd=1.47 as=0.117 ps=1.24 w=1 l=0.15
X6 a_215_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_215_47# B2 a_78_199# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_292_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.117 pd=1.24 as=0.373 ps=1.75 w=1 l=0.15
X9 VGND a_78_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_4 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.385 pd=1.77 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X9 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.385 ps=1.77 w=1 l=0.15
X14 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X15 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X21 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.208 pd=1.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X31 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ba_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_222_93# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X1 VPWR A1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.105 ps=1.21 w=1 l=0.15
X2 VGND a_79_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_222_93# B1_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.186 ps=1.41 w=0.42 l=0.15
X4 VGND A2 a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
X5 a_448_47# a_222_93# a_79_199# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_79_199# a_222_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.3 ps=2.6 w=1 l=0.15
X7 a_544_297# A2 a_79_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.165 ps=1.33 w=1 l=0.15
X8 a_448_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_79_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.186 pd=1.41 as=0.26 ps=2.52 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__buf_1 A VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.115 pd=1.08 as=0.205 ps=2.1 w=0.79 l=0.15
X1 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.56 as=0.0754 ps=0.81 w=0.52 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=2.1 as=0.115 ps=1.08 w=0.79 l=0.15
X3 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0754 pd=0.81 as=0.135 ps=1.56 w=0.52 l=0.15
.ends

.subckt sky130_fd_sc_hd__o2111a_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 a_676_297# A2 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.213 ps=1.42 w=1 l=0.15
X1 a_512_47# B1 a_409_47# VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.119 ps=1.01 w=0.65 l=0.15
X2 a_306_47# D1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.198 ps=1.91 w=0.65 l=0.15
X3 VGND A2 a_512_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.198 ps=1.26 w=0.65 l=0.15
X4 VPWR C1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.218 ps=1.43 w=1 l=0.15
X5 a_79_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.213 pd=1.42 as=0.305 ps=1.61 w=1 l=0.15
X6 VPWR A1 a_676_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.105 ps=1.21 w=1 l=0.15
X7 a_512_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_409_47# C1 a_306_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.119 ps=1.01 w=0.65 l=0.15
X9 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.382 pd=1.76 as=0.26 ps=2.52 w=1 l=0.15
X10 a_79_21# D1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.218 pd=1.43 as=0.382 ps=1.76 w=1 l=0.15
X11 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2b_1 A B_N VGND VNB VPB VPWR X
X0 a_219_297# a_27_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.157 ps=1.17 w=0.42 l=0.15
X1 VGND B_N a_27_53# VNB sky130_fd_pr__nfet_01v8 ad=0.157 pd=1.17 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_301_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 X a_219_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_301_297# a_27_53# a_219_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_219_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X6 a_27_53# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.118 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 VGND A a_219_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfrtp_2 CLK D RESET_B VGND VNB VPB VPWR Q
X0 a_1217_47# a_27_47# a_1108_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0669 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X1 a_805_47# a_761_289# a_639_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.14 ps=1.1 w=0.42 l=0.15
X2 VGND a_1283_21# Q VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_1108_47# a_193_47# a_761_289# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.0999 ps=0.985 w=0.36 l=0.15
X4 a_1283_21# a_1108_47# a_1462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.064 ps=0.725 w=0.42 l=0.15
X5 a_651_413# a_27_47# a_543_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.116 pd=0.97 as=0.0724 ps=0.765 w=0.42 l=0.15
X6 VPWR a_1283_21# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND RESET_B a_805_47# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.15 as=0.0441 ps=0.63 w=0.42 l=0.15
X8 Q a_1283_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.301 ps=2.66 w=1 l=0.15
X9 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X10 a_448_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0651 pd=0.73 as=0.109 ps=1.36 w=0.42 l=0.15
X11 a_761_289# a_543_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0999 pd=0.985 as=0.135 ps=1.15 w=0.64 l=0.15
X12 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X13 a_1108_47# a_27_47# a_761_289# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.129 ps=1.18 w=0.42 l=0.15
X14 a_543_47# a_27_47# a_448_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0594 pd=0.69 as=0.066 ps=0.745 w=0.36 l=0.15
X15 a_1462_47# RESET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.125 ps=1.01 w=0.42 l=0.15
X16 a_543_47# a_193_47# a_448_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0724 pd=0.765 as=0.0651 ps=0.73 w=0.42 l=0.15
X17 a_448_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.221 ps=1.89 w=0.42 l=0.15
X18 VPWR a_1283_21# a_1270_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0567 ps=0.69 w=0.42 l=0.15
X19 VPWR a_1108_47# a_1283_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X20 a_1270_413# a_193_47# a_1108_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0588 ps=0.7 w=0.42 l=0.15
X21 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X22 a_1283_21# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0819 ps=0.81 w=0.42 l=0.15
X23 VPWR a_761_289# a_651_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0703 pd=0.755 as=0.116 ps=0.97 w=0.42 l=0.15
X24 Q a_1283_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.209 ps=2.02 w=0.65 l=0.15
X25 a_639_47# a_193_47# a_543_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.1 as=0.0594 ps=0.69 w=0.36 l=0.15
X26 VGND a_1283_21# a_1217_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.01 as=0.0669 ps=0.75 w=0.42 l=0.15
X27 a_651_413# RESET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0703 ps=0.755 w=0.42 l=0.15
X28 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X29 a_761_289# a_543_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.129 pd=1.18 as=0.218 ps=2.2 w=0.84 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_1 A B C VGND VNB VPB VPWR X
X0 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X1 VPWR C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0662 ps=0.735 w=0.42 l=0.15
X2 a_181_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VGND C a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.132 pd=1.14 as=0.0441 ps=0.63 w=0.42 l=0.15
X4 a_27_47# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X6 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.132 ps=1.14 w=0.65 l=0.15
X7 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_2 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VGND A2 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.091 ps=0.93 w=0.65 l=0.15
X1 Y B1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.175 ps=1.35 w=1 l=0.15
X4 a_29_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y A2 a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND A1 a_29_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 a_112_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X8 a_112_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.14 ps=1.28 w=1 l=0.15
X9 a_29_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X11 a_29_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.127 ps=1.04 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_388_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.127 pd=1.25 as=0.153 ps=1.3 w=1 l=0.15
X1 a_105_352# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_297_47# a_105_352# Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.169 ps=1.82 w=0.65 l=0.15
X3 a_297_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A1 a_388_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.127 ps=1.25 w=1 l=0.15
X5 VGND A2 a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.101 ps=0.96 w=0.65 l=0.15
X6 VPWR B1_N a_105_352# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.178 pd=1.4 as=0.109 ps=1.36 w=0.42 l=0.15
X7 Y a_105_352# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.178 ps=1.4 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311ai_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
X0 a_39_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X2 VPWR A1 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X4 a_125_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0943 ps=0.94 w=0.65 l=0.15
X5 a_125_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_125_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_1163_47# B1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_39_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_1163_47# B1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A3 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VGND A1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND A3 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_39_297# A2 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A1 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_125_47# B1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X17 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 a_125_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X19 VGND A2 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_125_47# B1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 VGND A2 a_125_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 Y C1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 Y C1 a_1163_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X24 a_461_297# A2 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 Y A3 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X26 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 Y A3 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X29 a_125_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 VPWR A1 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X31 a_461_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 a_461_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X33 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 a_125_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X35 a_1163_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X36 a_1163_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X37 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X38 a_39_297# A2 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X39 a_461_297# A2 a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_2 A0 A1 S VGND VNB VPB VPWR X
X0 VPWR S a_591_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.0672 ps=0.85 w=0.64 l=0.15
X1 a_591_369# A0 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0672 pd=0.85 as=0.131 ps=1.05 w=0.64 l=0.15
X2 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.178 pd=1.41 as=0.135 ps=1.27 w=1 l=0.15
X3 a_79_21# A1 a_306_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.131 pd=1.05 as=0.229 ps=1.36 w=0.64 l=0.15
X4 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND S a_578_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0578 ps=0.695 w=0.42 l=0.15
X6 a_306_369# a_257_199# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.229 pd=1.36 as=0.178 ps=1.41 w=0.64 l=0.15
X7 a_79_21# A0 a_288_47# VNB sky130_fd_pr__nfet_01v8 ad=0.173 pd=1.25 as=0.0683 ps=0.745 w=0.42 l=0.15
X8 a_288_47# a_257_199# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.745 as=0.097 ps=0.975 w=0.42 l=0.15
X9 a_257_199# S VGND VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.38 as=0.0567 ps=0.69 w=0.42 l=0.15
X10 a_578_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.173 ps=1.25 w=0.42 l=0.15
X11 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X12 a_257_199# S VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.173 pd=1.82 as=0.0864 ps=0.91 w=0.64 l=0.15
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__xor2_4 A B VGND VNB VPB VPWR X
X0 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_806_47# B X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X B a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X13 VGND A a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_806_297# a_112_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.272 ps=2.56 w=1 l=0.15
X15 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_112_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X17 VGND A a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.275 ps=2.55 w=1 l=0.15
X19 a_806_297# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X21 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VGND B a_112_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 VPWR B a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X24 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_806_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 a_27_297# B a_112_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X28 VGND a_112_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.257 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X30 a_112_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 a_112_47# B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X32 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 X a_112_47# a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X35 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 a_806_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X38 X a_112_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 VPWR A a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux2_4 A0 A1 S VGND VNB VPB VPWR X
X0 a_204_297# A1 a_396_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.16 ps=1.32 w=1 l=0.15
X1 VPWR a_396_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_396_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR S a_314_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X4 a_204_297# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.162 ps=1.33 w=1 l=0.15
X5 a_396_47# A0 a_314_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.26 ps=2.52 w=1 l=0.15
X6 a_206_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.109 ps=0.985 w=0.65 l=0.15
X7 X a_396_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_396_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_396_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_490_47# A1 a_396_47# VNB sky130_fd_pr__nfet_01v8 ad=0.275 pd=1.5 as=0.104 ps=0.97 w=0.65 l=0.15
X11 VGND S a_490_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.275 ps=1.5 w=0.65 l=0.15
X12 VGND a_396_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_396_47# A0 a_206_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.26 ps=1.45 w=0.65 l=0.15
X14 VGND a_396_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VPWR S a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X16 X a_396_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X17 VGND S a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=0.985 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlymetal6s2s_1 A VGND VNB VPB VPWR X
X0 a_558_47# a_381_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X1 VGND X a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_841_47# a_664_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X3 VPWR A a_62_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A a_62_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_558_47# a_381_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X6 X a_62_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VPWR X a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_841_47# a_664_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X9 X a_62_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.097 ps=0.975 w=0.65 l=0.15
X10 VPWR a_558_47# a_664_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND a_558_47# a_664_47# VNB sky130_fd_pr__nfet_01v8 ad=0.097 pd=0.975 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21boi_1 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_300_297# a_27_413# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X1 VGND A2 a_384_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X2 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.111 pd=1.37 as=0.111 ps=1.37 w=0.42 l=0.15
X3 Y a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.143 pd=1.09 as=0.102 ps=0.99 w=0.65 l=0.15
X4 VPWR A1 a_300_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X5 a_384_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.143 ps=1.09 w=0.65 l=0.15
X6 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.111 ps=1.37 w=0.42 l=0.15
X7 a_300_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311a_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_585_47# B1 a_266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.119 ps=1.01 w=0.65 l=0.15
X1 VGND A2 a_266_47# VNB sky130_fd_pr__nfet_01v8 ad=0.137 pd=1.07 as=0.117 ps=1.01 w=0.65 l=0.15
X2 VPWR a_81_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.62 as=0.26 ps=2.52 w=1 l=0.15
X3 a_81_21# C1 a_585_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X4 VGND a_81_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.203 pd=1.27 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_266_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.312 ps=1.62 w=1 l=0.15
X6 a_368_297# A2 a_266_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.21 pd=1.42 as=0.18 ps=1.36 w=1 l=0.15
X7 a_266_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.137 ps=1.07 w=0.65 l=0.15
X8 a_266_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.203 ps=1.27 w=0.65 l=0.15
X9 a_81_21# A3 a_368_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.21 ps=1.42 w=1 l=0.15
X10 a_81_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.15 ps=1.3 w=1 l=0.15
X11 VPWR B1 a_81_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.138 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_4 A B C VGND VNB VPB VPWR X
X0 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.26 ps=1.45 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.4 ps=1.8 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.205 pd=1.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VPWR A a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.4 pd=1.8 as=0.135 ps=1.27 w=1 l=0.15
X5 a_193_297# B a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.36 pd=2.72 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 a_109_297# C a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND C a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_2 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR A2 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 a_277_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X2 a_79_21# B1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.32 pd=2.64 as=0.165 ps=1.33 w=1 l=0.15
X3 a_277_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_361_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_277_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.127 ps=1.04 w=0.65 l=0.15
X9 a_79_21# A1 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X11 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32ai_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 a_1224_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X1 VPWR A1 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.183 ps=1.37 w=1 l=0.15
X2 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_806_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.205 ps=1.28 w=0.65 l=0.15
X8 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.205 pd=1.28 as=0.14 ps=1.08 w=0.65 l=0.15
X10 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_806_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A3 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y A3 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X19 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.119 ps=1.01 w=0.65 l=0.15
X22 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X23 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0926 ps=0.935 w=0.65 l=0.15
X24 a_806_297# A2 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X25 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.142 ps=1.28 w=1 l=0.15
X28 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 a_1224_297# A2 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X31 a_1224_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.183 pd=1.37 as=0.135 ps=1.27 w=1 l=0.15
X32 a_806_297# A2 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X33 VPWR A1 a_1224_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X35 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X36 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X37 a_1224_297# A2 a_806_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X38 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X39 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211o_1 A1 A2 B1 C1 VGND VNB VPB VPWR X
X0 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.265 ps=2.53 w=1 l=0.15
X1 a_80_21# C1 a_472_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X2 VPWR A2 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VGND B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X4 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.26 pd=1.45 as=0.172 ps=1.83 w=0.65 l=0.15
X5 a_300_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.26 ps=1.45 w=0.65 l=0.15
X6 a_217_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_80_21# A1 a_300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 a_472_297# B1 a_217_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X9 a_80_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3_2 A B C VGND VNB VPB VPWR X
X0 VPWR a_30_53# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.315 pd=2.63 as=0.135 ps=1.27 w=1 l=0.15
X1 VGND a_30_53# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 X a_30_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X3 a_112_297# C a_30_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X4 X a_30_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 VGND A a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 a_30_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 VGND C a_30_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_184_297# B a_112_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X9 VPWR A a_184_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3_2 A B C VGND VNB VPB VPWR X
X0 VPWR a_29_311# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_29_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.151 ps=1.35 w=1 l=0.15
X2 VPWR A a_29_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND a_29_311# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 a_184_53# B a_112_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X5 VPWR C a_29_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.151 pd=1.35 as=0.0744 ps=0.815 w=0.42 l=0.15
X6 X a_29_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.13 ps=1.11 w=0.65 l=0.15
X7 a_112_53# A a_29_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_29_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X9 VGND C a_184_53# VNB sky130_fd_pr__nfet_01v8 ad=0.13 pd=1.11 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__clkbuf_8 A VGND VNB VPB VPWR X
X0 VPWR A a_110_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 a_110_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X5 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X7 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND A a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.38 as=0.0588 ps=0.7 w=0.42 l=0.15
X10 a_110_47# A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.111 ps=1.37 w=0.42 l=0.15
X11 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X14 VGND a_110_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X15 X a_110_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X16 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X17 VPWR a_110_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X18 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
X19 X a_110_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o31ai_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 a_281_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X1 a_281_297# A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.26 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X6 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.114 ps=1 w=0.65 l=0.15
X7 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X9 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.127 ps=1.04 w=0.65 l=0.15
X10 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.198 ps=1.26 w=0.65 l=0.15
X11 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.127 ps=1.04 w=0.65 l=0.15
X12 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 Y A3 a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.195 ps=1.39 w=1 l=0.15
X15 a_27_297# A2 a_281_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3_1 A B C VGND VNB VPB VPWR Y
X0 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X1 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X2 a_193_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 Y A a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X4 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X5 a_109_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and3b_1 A_N B C VGND VNB VPB VPWR X
X0 a_109_93# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.108 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_209_311# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.142 ps=1.34 w=1 l=0.15
X2 a_109_93# A_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_296_53# a_109_93# a_209_311# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.108 ps=1.36 w=0.42 l=0.15
X4 VPWR C a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.34 as=0.0744 ps=0.815 w=0.42 l=0.15
X5 a_368_53# B a_296_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0536 pd=0.675 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_209_311# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.122 ps=1.08 w=0.65 l=0.15
X7 a_209_311# B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0744 pd=0.815 as=0.0567 ps=0.69 w=0.42 l=0.15
X8 VPWR a_109_93# a_209_311# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.108 ps=1.36 w=0.42 l=0.15
X9 VGND C a_368_53# VNB sky130_fd_pr__nfet_01v8 ad=0.122 pd=1.08 as=0.0536 ps=0.675 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_2 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.117 ps=1.01 w=0.65 l=0.15
X1 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.41 pd=1.82 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.175 ps=1.35 w=1 l=0.15
X4 a_277_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0975 pd=0.95 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 a_27_47# A2 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.41 ps=1.82 w=1 l=0.15
X10 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.18 ps=1.36 w=1 l=0.15
X11 a_277_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.114 ps=1 w=0.65 l=0.15
X13 Y A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.0975 ps=0.95 w=0.65 l=0.15
X14 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2_4 A B VGND VNB VPB VPWR Y
X0 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 Y A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 Y A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND B a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_286_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X2 a_286_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X3 Y A2 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X4 VGND A1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.185 ps=1.87 w=0.65 l=0.15
X6 VGND A2 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X7 a_487_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# B1 a_286_47# VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR A1 a_487_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_27_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X13 a_487_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X14 a_286_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_197_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0798 pd=0.8 as=0.0609 ps=0.71 w=0.42 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.312 ps=1.68 w=1 l=0.15
X3 a_303_47# C a_197_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0798 ps=0.8 w=0.42 l=0.15
X4 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.68 as=0.0588 ps=0.7 w=0.42 l=0.15
X6 VGND D a_303_47# VNB sky130_fd_pr__nfet_01v8 ad=0.196 pd=1.33 as=0.0693 ps=0.75 w=0.42 l=0.15
X7 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X8 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.196 ps=1.33 w=0.65 l=0.15
X9 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0609 pd=0.71 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2_2 A B VGND VNB VPB VPWR Y
X0 Y B a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X5 VGND B Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X7 a_27_297# B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a41o_1 A1 A2 A3 A4 B1 VGND VNB VPB VPWR X
X0 a_465_47# A2 a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 VGND A4 a_561_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.107 ps=0.98 w=0.65 l=0.15
X2 VPWR A3 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X3 a_297_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X4 a_297_297# A4 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.165 ps=1.33 w=1 l=0.15
X5 VPWR A1 a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_381_47# A1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.184 ps=1.22 w=0.65 l=0.15
X7 a_297_297# B1 a_79_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X8 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X9 a_79_21# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.184 pd=1.22 as=0.161 ps=1.14 w=0.65 l=0.15
X10 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.161 pd=1.14 as=0.169 ps=1.82 w=0.65 l=0.15
X11 a_561_47# A3 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_1 A B C D VGND VNB VPB VPWR X
X0 a_27_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_27_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_277_297# B a_205_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VPWR A a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.102 ps=0.99 w=0.65 l=0.15
X5 a_205_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X6 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.148 ps=1.34 w=1 l=0.15
X7 VGND C a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0693 ps=0.75 w=0.42 l=0.15
X8 a_109_297# D a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X9 VGND A a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31o_4 A1 A2 A3 B1 VGND VNB VPB VPWR X
X0 VPWR a_277_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 X a_277_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_277_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.165 ps=1.33 w=1 l=0.15
X5 a_277_47# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X6 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND a_277_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND a_277_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_193_47# A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_361_47# A1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 X a_277_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VGND A3 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.107 ps=0.98 w=0.65 l=0.15
X15 X a_277_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.257 ps=1.44 w=0.65 l=0.15
X16 a_277_47# A1 a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 a_445_47# A2 a_361_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 VGND B1 a_277_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=1.44 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 a_27_297# B1 a_277_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X21 VPWR a_277_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.5 pd=3 as=0.135 ps=1.27 w=1 l=0.15
X22 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X23 a_277_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4bb_1 A_N B_N C D VGND VNB VPB VPWR X
X0 VPWR D a_343_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.172 pd=1.46 as=0.0777 ps=0.79 w=0.42 l=0.15
X1 a_223_47# B_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.139 pd=1.5 as=0.0588 ps=0.7 w=0.42 l=0.15
X2 a_515_93# a_223_47# a_429_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0588 ps=0.7 w=0.42 l=0.15
X3 a_223_47# B_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.134 pd=1.48 as=0.0588 ps=0.7 w=0.42 l=0.15
X4 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.168 ps=1.64 w=0.42 l=0.15
X5 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.168 ps=1.64 w=0.42 l=0.15
X6 X a_343_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.172 ps=1.46 w=1 l=0.15
X7 a_429_93# a_27_47# a_343_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0588 pd=0.7 as=0.118 ps=1.4 w=0.42 l=0.15
X8 VGND D a_615_93# VNB sky130_fd_pr__nfet_01v8 ad=0.126 pd=1.11 as=0.0777 ps=0.79 w=0.42 l=0.15
X9 a_343_93# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X10 a_343_93# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.122 ps=1.42 w=0.42 l=0.15
X11 a_615_93# C a_515_93# VNB sky130_fd_pr__nfet_01v8 ad=0.0777 pd=0.79 as=0.0735 ps=0.77 w=0.42 l=0.15
X12 X a_343_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.165 pd=1.82 as=0.126 ps=1.11 w=0.65 l=0.15
X13 VPWR a_223_47# a_343_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0735 pd=0.77 as=0.0588 ps=0.7 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o211ai_4 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_806_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X5 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X7 a_110_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VPWR A1 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X10 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_47# B1 a_1314_47# VNB sky130_fd_pr__nfet_01v8 ad=0.257 pd=2.09 as=0.104 ps=0.97 w=0.65 l=0.15
X12 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 VPWR C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.14 ps=1.28 w=1 l=0.15
X16 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X17 Y A2 a_110_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.0943 ps=0.94 w=0.65 l=0.15
X19 Y C1 a_978_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 Y C1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_27_47# B1 a_806_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_110_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X24 a_806_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.675 pd=3.35 as=0.135 ps=1.27 w=1 l=0.15
X26 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.091 ps=0.93 w=0.65 l=0.15
X27 a_978_47# B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.091 ps=0.93 w=0.65 l=0.15
X28 a_1314_47# C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X30 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X31 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__and2_2 A B VGND VNB VPB VPWR X
X0 X a_61_75# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.167 ps=1.39 w=1 l=0.15
X1 VPWR a_61_75# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.38 pd=2.76 as=0.195 ps=1.39 w=1 l=0.15
X2 VPWR B a_61_75# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.167 pd=1.39 as=0.0567 ps=0.69 w=0.42 l=0.15
X3 VGND B a_147_75# VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=1.04 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 X a_61_75# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.112 ps=1.04 w=0.65 l=0.15
X5 VGND a_61_75# X VNB sky130_fd_pr__nfet_01v8 ad=0.247 pd=2.06 as=0.127 ps=1.04 w=0.65 l=0.15
X6 a_61_75# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
X7 a_147_75# A a_61_75# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.118 ps=1.4 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4b_2 A_N B C D VGND VNB VPB VPWR X
X0 VPWR a_193_413# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.153 ps=1.3 w=1 l=0.15
X1 a_297_47# a_27_413# a_193_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_369_47# B a_297_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 X a_193_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0991 pd=0.955 as=0.104 ps=1 w=0.65 l=0.15
X4 VPWR D a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.143 pd=1.33 as=0.0662 ps=0.735 w=0.42 l=0.15
X5 VPWR A_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X6 VGND D a_469_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=1 as=0.0619 ps=0.715 w=0.42 l=0.15
X7 VGND a_193_413# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0991 ps=0.955 w=0.65 l=0.15
X8 VPWR B a_193_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.128 pd=1.03 as=0.0987 ps=0.89 w=0.42 l=0.15
X9 a_193_413# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0662 pd=0.735 as=0.128 ps=1.03 w=0.42 l=0.15
X10 X a_193_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.143 ps=1.33 w=1 l=0.15
X11 a_193_413# a_27_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0987 pd=0.89 as=0.0567 ps=0.69 w=0.42 l=0.15
X12 a_469_47# C a_369_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0619 pd=0.715 as=0.0735 ps=0.77 w=0.42 l=0.15
X13 a_27_413# A_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21bo_1 A1 A2 B1_N VGND VNB VPB VPWR X
X0 a_298_297# a_27_413# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.265 ps=2.53 w=1 l=0.15
X1 a_215_297# a_27_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.136 ps=1.1 w=0.65 l=0.15
X2 a_298_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.258 ps=1.45 w=0.65 l=0.15
X4 VPWR B1_N a_27_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X5 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.26 ps=2.52 w=1 l=0.15
X6 a_382_47# A1 a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 VGND B1_N a_27_413# VNB sky130_fd_pr__nfet_01v8 ad=0.136 pd=1.1 as=0.111 ps=1.37 w=0.42 l=0.15
X8 VPWR A1 a_298_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.135 ps=1.27 w=1 l=0.15
X9 VGND A2 a_382_47# VNB sky130_fd_pr__nfet_01v8 ad=0.258 pd=1.45 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a22oi_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X1 a_467_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_467_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 Y A1 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 a_109_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND A2 a_467_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 a_109_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311o_1 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_75_199# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.135 ps=1.07 w=0.65 l=0.15
X1 a_208_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.112 ps=0.995 w=0.65 l=0.15
X2 a_315_47# A2 a_208_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.17 as=0.125 ps=1.03 w=0.65 l=0.15
X3 VGND B1 a_75_199# VNB sky130_fd_pr__nfet_01v8 ad=0.135 pd=1.07 as=0.106 ps=0.975 w=0.65 l=0.15
X4 a_75_199# A1 a_315_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.17 w=0.65 l=0.15
X5 a_75_199# C1 a_544_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.207 ps=1.41 w=1 l=0.15
X6 a_544_297# B1 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.207 pd=1.41 as=0.162 ps=1.33 w=1 l=0.15
X7 VPWR a_75_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.142 pd=1.28 as=0.285 ps=2.57 w=1 l=0.15
X8 a_201_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.142 ps=1.28 w=1 l=0.15
X9 VPWR A2 a_201_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.165 ps=1.33 w=1 l=0.15
X10 a_201_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.305 ps=1.61 w=1 l=0.15
X11 VGND a_75_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.112 pd=0.995 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o311a_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 X a_91_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.32 ps=2.64 w=1 l=0.15
X1 a_91_21# C1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.15 ps=1.3 w=1 l=0.15
X2 a_360_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.137 ps=1.07 w=0.65 l=0.15
X3 VPWR B1 a_91_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.138 ps=1.27 w=1 l=0.15
X4 a_360_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.175 pd=1.35 as=0.312 ps=1.62 w=1 l=0.15
X5 VGND A2 a_360_47# VNB sky130_fd_pr__nfet_01v8 ad=0.137 pd=1.07 as=0.114 ps=1 w=0.65 l=0.15
X6 a_360_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1 as=0.203 ps=1.27 w=0.65 l=0.15
X7 VPWR a_91_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.312 pd=1.62 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND a_91_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.203 pd=1.27 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 X a_91_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.208 ps=1.94 w=0.65 l=0.15
X10 a_677_47# B1 a_360_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.119 ps=1.01 w=0.65 l=0.15
X11 a_460_297# A2 a_360_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.21 pd=1.42 as=0.175 ps=1.35 w=1 l=0.15
X12 a_91_21# C1 a_677_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X13 a_91_21# A3 a_460_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.27 as=0.21 ps=1.42 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32ai_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.219 pd=1.33 as=0.101 ps=0.96 w=0.65 l=0.15
X1 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.219 ps=1.33 w=0.65 l=0.15
X2 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=1.61 as=0.105 ps=1.21 w=1 l=0.15
X3 a_333_297# A3 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.245 pd=1.49 as=0.305 ps=1.61 w=1 l=0.15
X4 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.234 pd=2.02 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.106 ps=0.975 w=0.65 l=0.15
X6 VPWR A1 a_461_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X7 a_109_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.26 ps=2.52 w=1 l=0.15
X8 a_461_297# A2 a_333_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.245 ps=1.49 w=1 l=0.15
X9 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or3b_1 A B C_N VGND VNB VPB VPWR X
X0 a_109_93# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X1 a_215_53# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 VGND a_109_93# a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 VGND A a_215_53# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 VPWR A a_369_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_369_297# B a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 X a_215_53# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X7 a_297_297# a_109_93# a_215_53# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X8 a_109_93# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 X a_215_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.1 ps=0.985 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_2 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 VGND A2 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 VPWR A1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_37_297# B1 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_485_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_292_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VPWR A2 a_292_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X8 a_485_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X11 a_37_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X12 Y A1 a_485_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X13 Y C1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X14 a_292_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X15 a_292_297# B1 a_37_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a21oi_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X2 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.26 ps=2.52 w=1 l=0.15
X3 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_462_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X5 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X7 Y B1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X11 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.145 ps=1.29 w=1 l=0.15
X12 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X13 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X14 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X15 a_28_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X16 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 a_28_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X18 VGND A2 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 VPWR A2 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.155 ps=1.31 w=1 l=0.15
X20 a_28_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A1 a_462_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X22 a_462_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 VPWR A1 a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311oi_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR Y
X0 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_47# A2 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.159 ps=1.14 w=0.65 l=0.15
X3 a_1139_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.245 pd=1.49 as=0.135 ps=1.27 w=1 l=0.15
X4 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X5 VPWR A3 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_109_297# B1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_1139_297# B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X12 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X13 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_109_297# B1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X15 a_445_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X16 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 VPWR A3 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X18 VPWR A1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 a_1139_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X20 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X21 a_27_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 VGND C1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X23 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 Y C1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X27 a_1139_297# C1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X28 Y A1 a_445_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X30 Y B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.159 pd=1.14 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X32 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 a_109_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y C1 a_1139_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.245 ps=1.49 w=1 l=0.15
X35 a_445_47# A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X36 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X37 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X38 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X39 VGND A3 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311o_2 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 a_79_21# C1 a_635_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.21 ps=1.42 w=1 l=0.15
X1 VPWR A2 a_319_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.185 pd=1.37 as=0.17 ps=1.34 w=1 l=0.15
X2 VGND B1 a_79_21# VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.08 as=0.133 ps=1.06 w=0.65 l=0.15
X3 a_417_47# A2 a_319_47# VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.02 as=0.111 ps=0.99 w=0.65 l=0.15
X4 a_79_21# A1 a_417_47# VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.12 ps=1.02 w=0.65 l=0.15
X5 a_319_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.111 pd=0.99 as=0.156 ps=1.13 w=0.65 l=0.15
X6 VPWR a_79_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.24 pd=1.48 as=0.135 ps=1.27 w=1 l=0.15
X7 a_319_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.21 pd=1.42 as=0.185 ps=1.37 w=1 l=0.15
X8 VGND a_79_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.156 pd=1.13 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 a_319_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.17 pd=1.34 as=0.24 ps=1.48 w=1 l=0.15
X10 a_79_21# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.14 ps=1.08 w=0.65 l=0.15
X11 a_635_297# B1 a_319_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.21 pd=1.42 as=0.21 ps=1.42 w=1 l=0.15
X12 X a_79_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 X a_79_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_2 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_39_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X1 X a_39_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=1 w=0.65 l=0.15
X2 VPWR a_39_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_39_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.156 ps=1.36 w=1 l=0.15
X4 VGND a_39_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.156 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X6 VGND A a_39_297# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=1 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 a_39_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21ai_4 A1 A2 B1 VGND VNB VPB VPWR Y
X0 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X2 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X3 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.16 pd=1.32 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.104 pd=0.97 as=0.091 ps=0.93 w=0.65 l=0.15
X5 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X7 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X8 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 Y B1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X12 a_32_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X13 a_32_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X14 a_115_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.104 ps=0.97 w=0.65 l=0.15
X16 VPWR B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.14 ps=1.28 w=1 l=0.15
X17 a_32_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X18 VGND A2 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X19 Y B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.16 ps=1.32 w=1 l=0.15
X20 VPWR A1 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X21 Y A2 a_115_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X22 VGND A1 a_32_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X23 a_115_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21bai_2 A1 A2 B1_N VGND VNB VPB VPWR Y
X0 a_397_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 VPWR B1_N a_28_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X2 Y A2 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X3 VGND A2 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 VGND A1 a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_28_297# B1_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X6 Y a_28_297# a_229_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X7 VPWR a_28_297# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X8 a_397_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X9 a_229_47# a_28_297# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 Y a_28_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X11 a_229_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 a_229_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VPWR A1 a_397_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a2111o_1 A1 A2 B1 C1 D1 VGND VNB VPB VPWR X
X0 VGND A2 a_660_47# VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.0829 ps=0.905 w=0.65 l=0.15
X1 VGND C1 a_85_193# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.101 ps=0.96 w=0.65 l=0.15
X2 a_414_297# C1 a_334_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.18 pd=1.36 as=0.125 ps=1.25 w=1 l=0.15
X3 VGND a_85_193# X VNB sky130_fd_pr__nfet_01v8 ad=0.275 pd=1.5 as=0.214 ps=1.96 w=0.65 l=0.15
X4 a_334_297# D1 a_85_193# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.125 pd=1.25 as=0.385 ps=2.77 w=1 l=0.15
X5 a_516_297# B1 a_414_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=1.56 as=0.18 ps=1.36 w=1 l=0.15
X6 a_516_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.135 ps=1.27 w=1 l=0.15
X7 a_660_47# A1 a_85_193# VNB sky130_fd_pr__nfet_01v8 ad=0.0829 pd=0.905 as=0.185 ps=1.22 w=0.65 l=0.15
X8 a_85_193# D1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.275 ps=1.5 w=0.65 l=0.15
X9 VPWR A1 a_516_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=1.56 w=1 l=0.15
X10 a_85_193# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.22 as=0.117 ps=1.01 w=0.65 l=0.15
X11 VPWR a_85_193# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.29 ps=2.58 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a221o_1 A1 A2 B1 B2 C1 VGND VNB VPB VPWR X
X0 a_465_47# A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X1 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.157 ps=1.32 w=1 l=0.15
X2 a_109_297# B1 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X3 a_193_297# B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X4 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.102 ps=0.965 w=0.65 l=0.15
X5 a_205_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.107 ps=0.98 w=0.65 l=0.15
X6 VPWR A2 a_193_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.32 as=0.165 ps=1.33 w=1 l=0.15
X7 a_193_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.26 ps=2.52 w=1 l=0.15
X8 a_27_47# B1 a_205_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0683 ps=0.86 w=0.65 l=0.15
X9 a_109_297# C1 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X10 VGND C1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.169 ps=1.82 w=0.65 l=0.15
X11 VGND A2 a_465_47# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.965 as=0.107 ps=0.98 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2b_2 A B_N VGND VNB VPB VPWR Y
X0 Y a_251_21# a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y a_251_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X4 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.179 ps=1.85 w=0.65 l=0.15
X5 VGND a_251_21# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR A a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X7 VPWR B_N a_251_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X8 VGND B_N a_251_21# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_27_297# a_251_21# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__a32oi_4 A1 A2 A3 B1 B2 VGND VNB VPB VPWR Y
X0 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.395 pd=1.79 as=0.135 ps=1.27 w=1 l=0.15
X2 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X4 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.338 pd=1.67 as=0.135 ps=1.27 w=1 l=0.15
X5 a_1249_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X6 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X7 a_1249_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X11 a_27_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.252 pd=1.5 as=0.338 ps=1.67 w=1 l=0.15
X12 a_803_47# A2 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X14 a_27_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 VPWR A1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.145 ps=1.29 w=1 l=0.15
X16 a_803_47# A2 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X17 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X19 VPWR A3 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.395 ps=1.79 w=1 l=0.15
X20 Y A1 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X21 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X22 a_1249_47# A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.133 ps=1.06 w=0.65 l=0.15
X23 a_27_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X24 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X25 a_27_47# B2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X26 a_1249_47# A2 a_803_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X27 VPWR A2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.252 ps=1.5 w=1 l=0.15
X28 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.0878 ps=0.92 w=0.65 l=0.15
X29 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.145 pd=1.29 as=0.135 ps=1.27 w=1 l=0.15
X30 a_803_47# A1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X31 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X32 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X33 Y B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X34 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X35 a_27_297# B1 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X36 VGND A3 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X37 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X38 VGND A3 a_1249_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.0878 ps=0.92 w=0.65 l=0.15
X39 VGND B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a211oi_1 A1 A2 B1 C1 VGND VNB VPB VPWR Y
X0 a_56_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X1 VPWR A2 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 Y C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.101 ps=0.96 w=0.65 l=0.15
X3 a_139_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.266 ps=2.12 w=0.65 l=0.15
X4 a_311_297# B1 a_56_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.155 pd=1.31 as=0.14 ps=1.28 w=1 l=0.15
X5 Y C1 a_311_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.155 ps=1.31 w=1 l=0.15
X6 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.101 pd=0.96 as=0.091 ps=0.93 w=0.65 l=0.15
X7 Y A1 a_139_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__a311o_4 A1 A2 A3 B1 C1 VGND VNB VPB VPWR X
X0 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 a_277_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.325 ps=1.65 w=1 l=0.15
X2 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_861_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.211 ps=1.3 w=0.65 l=0.15
X4 a_27_297# B1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X5 a_1059_47# A2 a_861_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 a_1059_47# A1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_277_297# B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0943 ps=0.94 w=0.65 l=0.15
X9 a_27_297# C1 a_109_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 VGND a_109_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.211 pd=1.3 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VGND A3 a_861_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 VGND C1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X13 VGND B1 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X14 VPWR a_109_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X15 a_109_47# A1 a_1059_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X16 X a_109_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X17 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X18 a_109_47# B1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X19 X a_109_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0943 pd=0.94 as=0.0878 ps=0.92 w=0.65 l=0.15
X20 VPWR A3 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X21 VPWR A2 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.325 pd=1.65 as=0.135 ps=1.27 w=1 l=0.15
X22 a_109_47# C1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X23 VPWR A1 a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X24 a_277_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X25 a_277_297# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.165 ps=1.33 w=1 l=0.15
X26 a_109_47# C1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X27 a_861_47# A2 a_1059_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4b_1 A B C D_N VGND VNB VPB VPWR X
X0 X a_215_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.275 pd=2.55 as=0.148 ps=1.34 w=1 l=0.15
X1 a_109_53# D_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_215_297# a_109_53# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.064 pd=0.725 as=0.109 ps=1.36 w=0.42 l=0.15
X3 X a_215_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.102 ps=0.99 w=0.65 l=0.15
X4 a_392_297# C a_297_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0452 pd=0.635 as=0.0683 ps=0.745 w=0.42 l=0.15
X5 a_465_297# B a_392_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.064 pd=0.725 as=0.0452 ps=0.635 w=0.42 l=0.15
X6 a_215_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X7 VPWR A a_465_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.064 ps=0.725 w=0.42 l=0.15
X8 a_297_297# a_109_53# a_215_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0683 pd=0.745 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_109_53# D_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.109 ps=1.36 w=0.42 l=0.15
X10 VGND C a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.064 ps=0.725 w=0.42 l=0.15
X11 VGND A a_215_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o21a_4 A1 A2 B1 VGND VNB VPB VPWR X
X0 X a_80_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X1 a_475_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X2 X a_80_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X3 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.172 pd=1.83 as=0.091 ps=0.93 w=0.65 l=0.15
X4 a_762_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.31 ps=1.62 w=1 l=0.15
X5 a_475_47# B1 a_80_21# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.091 ps=0.93 w=0.65 l=0.15
X6 VGND A2 a_475_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X7 VGND a_80_21# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X8 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X9 X a_80_21# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X10 a_80_21# A2 a_762_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X11 a_80_21# B1 a_475_47# VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.172 ps=1.83 w=0.65 l=0.15
X12 a_80_21# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.15 ps=1.3 w=1 l=0.15
X13 a_475_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.117 ps=1.01 w=0.65 l=0.15
X14 X a_80_21# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X15 VPWR A1 a_934_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X16 a_934_297# A2 a_80_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X17 VPWR B1 a_80_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.31 pd=1.62 as=0.14 ps=1.28 w=1 l=0.15
X18 VPWR a_80_21# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.15 pd=1.3 as=0.14 ps=1.28 w=1 l=0.15
X19 VGND A1 a_475_47# VNB sky130_fd_pr__nfet_01v8 ad=0.117 pd=1.01 as=0.117 ps=1.01 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_2 A_N B C VGND VNB VPB VPWR Y
X0 a_408_47# B a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X1 a_408_47# a_27_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 Y a_27_47# a_408_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X3 VPWR A_N a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.176 pd=1.39 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND C a_218_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X6 a_218_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.12 ps=1.04 w=0.65 l=0.15
X7 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VPWR C Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X9 VPWR a_27_47# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X10 a_218_47# B a_408_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X11 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.176 ps=1.39 w=1 l=0.15
X12 Y a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X13 VGND A_N a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.12 pd=1.04 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__mux4_2 A0 A1 A2 A3 S0 S1 VGND VNB VPB VPWR X
X0 a_600_345# S1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X1 a_788_316# S1 a_288_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0578 pd=0.695 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A3 a_372_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.164 ps=1.33 w=0.64 l=0.15
X3 a_872_316# a_600_345# a_788_316# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0578 ps=0.695 w=0.42 l=0.15
X4 VPWR S0 a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X5 a_1279_413# S0 a_872_316# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=0.995 as=0.0567 ps=0.69 w=0.42 l=0.15
X6 VGND a_788_316# X VNB sky130_fd_pr__nfet_01v8 ad=0.221 pd=1.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_1060_369# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.138 pd=1.16 as=0.166 ps=1.8 w=0.64 l=0.15
X8 a_872_316# a_27_47# a_1060_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.138 ps=1.16 w=0.42 l=0.15
X9 a_1281_47# a_27_47# a_872_316# VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.072 ps=0.76 w=0.36 l=0.15
X10 a_193_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.066 pd=0.745 as=0.0567 ps=0.69 w=0.42 l=0.15
X11 a_1064_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0786 pd=0.805 as=0.109 ps=1.36 w=0.42 l=0.15
X12 a_872_316# S1 a_788_316# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.6 as=0.0729 ps=0.81 w=0.54 l=0.15
X13 a_872_316# S0 a_1064_47# VNB sky130_fd_pr__nfet_01v8 ad=0.072 pd=0.76 as=0.0786 ps=0.805 w=0.36 l=0.15
X14 X a_788_316# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.107 ps=1 w=0.65 l=0.15
X15 a_788_316# a_600_345# a_288_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0729 pd=0.81 as=0.14 ps=1.6 w=0.54 l=0.15
X16 a_372_413# a_27_47# a_288_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.164 pd=1.33 as=0.0567 ps=0.69 w=0.42 l=0.15
X17 VGND A3 a_397_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0819 pd=0.81 as=0.0671 ps=0.75 w=0.42 l=0.15
X18 a_600_345# S1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.113 pd=1.38 as=0.0819 ps=0.81 w=0.42 l=0.15
X19 a_193_369# A2 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0957 pd=0.965 as=0.0864 ps=0.91 w=0.64 l=0.15
X20 VPWR a_788_316# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.34 pd=2.68 as=0.135 ps=1.27 w=1 l=0.15
X21 a_288_47# S0 a_193_369# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0957 ps=0.965 w=0.42 l=0.15
X22 a_397_47# S0 a_288_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0671 pd=0.75 as=0.0711 ps=0.755 w=0.36 l=0.15
X23 VGND A0 a_1281_47# VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=1 as=0.066 ps=0.745 w=0.42 l=0.15
X24 a_288_47# a_27_47# a_193_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0711 pd=0.755 as=0.066 ps=0.745 w=0.36 l=0.15
X25 X a_788_316# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.154 ps=1.34 w=1 l=0.15
X26 VGND S0 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X27 VPWR A0 a_1279_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.154 pd=1.34 as=0.105 ps=0.995 w=0.64 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand2b_1 A_N B VGND VNB VPB VPWR Y
X0 VGND A_N a_27_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X1 Y a_27_93# a_206_47# VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_206_47# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X3 VPWR a_27_93# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.265 pd=2.53 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
X5 VPWR A_N a_27_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__or2_4 A B VGND VNB VPB VPWR X
X0 a_121_297# B a_35_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.28 ps=2.56 w=1 l=0.15
X1 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X2 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X4 X a_35_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR a_35_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 X a_35_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.177 ps=1.36 w=1 l=0.15
X7 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 VPWR A a_121_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.105 ps=1.21 w=1 l=0.15
X9 VGND a_35_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A a_35_297# VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_35_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_1 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.115 ps=1 w=0.65 l=0.15
X1 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.115 pd=1 as=0.0926 ps=0.935 w=0.65 l=0.15
X2 VPWR A1 a_307_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.105 ps=1.21 w=1 l=0.15
X3 a_307_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.233 ps=1.47 w=1 l=0.15
X4 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 Y B2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.233 pd=1.47 as=0.112 ps=1.23 w=1 l=0.15
X6 a_109_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.112 pd=1.23 as=0.26 ps=2.52 w=1 l=0.15
X7 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0926 pd=0.935 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor2b_1 A B_N VGND VNB VPB VPWR Y
X0 Y a_74_47# a_265_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.105 ps=1.21 w=1 l=0.15
X1 VPWR B_N a_74_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.157 pd=1.39 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_265_297# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.105 pd=1.21 as=0.157 ps=1.39 w=1 l=0.15
X3 Y A VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X4 VGND B_N a_74_47# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X5 VGND a_74_47# Y VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_4 A B C D VGND VNB VPB VPWR X
X0 VPWR A a_304_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X1 a_304_297# B a_220_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X2 VGND C a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X3 a_220_297# C a_114_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X4 a_32_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.169 ps=1.82 w=0.65 l=0.15
X5 a_32_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.135 ps=1.27 w=1 l=0.15
X7 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X8 VGND A a_32_297# VNB sky130_fd_pr__nfet_01v8 ad=0.123 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X9 VPWR a_32_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X10 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.123 ps=1.03 w=0.65 l=0.15
X11 X a_32_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X12 X a_32_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.19 ps=1.38 w=1 l=0.15
X13 a_114_297# D a_32_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.19 pd=1.38 as=0.26 ps=2.52 w=1 l=0.15
X14 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 VGND a_32_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.179 pd=1.85 as=0.0878 ps=0.92 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__nand3b_1 A_N B C VGND VNB VPB VPWR Y
X0 Y a_53_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.192 ps=1.38 w=1 l=0.15
X1 a_232_47# C VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.1 ps=0.985 w=0.65 l=0.15
X2 VPWR B Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.192 pd=1.38 as=0.135 ps=1.27 w=1 l=0.15
X3 VPWR A_N a_53_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.109 ps=1.36 w=0.42 l=0.15
X4 VGND A_N a_53_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X5 a_316_47# B a_232_47# VNB sky130_fd_pr__nfet_01v8 ad=0.125 pd=1.03 as=0.0878 ps=0.92 w=0.65 l=0.15
X6 Y a_53_93# a_316_47# VNB sky130_fd_pr__nfet_01v8 ad=0.182 pd=1.86 as=0.125 ps=1.03 w=0.65 l=0.15
X7 Y C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.146 ps=1.34 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__or4_2 A B C D VGND VNB VPB VPWR X
X0 a_27_297# B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X1 a_27_297# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X2 a_277_297# B a_205_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.0441 ps=0.63 w=0.42 l=0.15
X3 VPWR A a_277_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.148 pd=1.34 as=0.0693 ps=0.75 w=0.42 l=0.15
X4 X a_27_297# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.102 ps=0.99 w=0.65 l=0.15
X5 a_205_297# C a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0693 ps=0.75 w=0.42 l=0.15
X6 VPWR a_27_297# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.305 pd=2.61 as=0.135 ps=1.27 w=1 l=0.15
X7 VGND a_27_297# X VNB sky130_fd_pr__nfet_01v8 ad=0.198 pd=1.91 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 X a_27_297# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.148 ps=1.34 w=1 l=0.15
X9 VGND C a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.0693 ps=0.75 w=0.42 l=0.15
X10 a_109_297# D a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0693 pd=0.75 as=0.109 ps=1.36 w=0.42 l=0.15
X11 VGND A a_27_297# VNB sky130_fd_pr__nfet_01v8 ad=0.102 pd=0.99 as=0.0567 ps=0.69 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__and4_2 A B C D VGND VNB VPB VPWR X
X0 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.195 pd=1.9 as=0.107 ps=0.98 w=0.65 l=0.15
X1 VGND D a_304_47# VNB sky130_fd_pr__nfet_01v8 ad=0.175 pd=1.26 as=0.0693 ps=0.75 w=0.42 l=0.15
X2 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.28 ps=1.62 w=1 l=0.15
X3 a_198_47# B a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0798 pd=0.8 as=0.0619 ps=0.715 w=0.42 l=0.15
X4 a_27_47# C VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0588 pd=0.7 as=0.0777 ps=0.79 w=0.42 l=0.15
X5 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.3 pd=2.6 as=0.165 ps=1.33 w=1 l=0.15
X6 a_304_47# C a_198_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0693 pd=0.75 as=0.0798 ps=0.8 w=0.42 l=0.15
X7 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0746 pd=0.775 as=0.109 ps=1.36 w=0.42 l=0.15
X8 VPWR D a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=1.62 as=0.0588 ps=0.7 w=0.42 l=0.15
X9 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.175 ps=1.26 w=0.65 l=0.15
X10 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0777 pd=0.79 as=0.0746 ps=0.775 w=0.42 l=0.15
X11 a_109_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0619 pd=0.715 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__nor3b_1 A B C_N VGND VNB VPB VPWR Y
X0 VGND a_91_199# Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.221 ps=1.98 w=0.65 l=0.15
X1 Y B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 VPWR A a_245_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.146 pd=1.34 as=0.135 ps=1.27 w=1 l=0.15
X3 a_91_199# C_N VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.1 ps=0.985 w=0.42 l=0.15
X4 VGND A Y VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 a_245_297# B a_161_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_91_199# C_N VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.146 ps=1.34 w=0.42 l=0.15
X7 a_161_297# a_91_199# Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.32 ps=2.64 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__dfstp_2 CLK D SET_B VGND VNB VPB VPWR Q
X0 VGND a_652_21# a_586_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0882 pd=0.84 as=0.0671 ps=0.75 w=0.42 l=0.15
X1 a_956_413# a_476_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0567 ps=0.69 w=0.42 l=0.15
X2 a_1136_413# a_193_47# a_1028_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0441 pd=0.63 as=0.0819 ps=0.81 w=0.42 l=0.15
X3 VPWR a_476_47# a_652_21# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_586_47# a_193_47# a_476_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0671 pd=0.75 as=0.072 ps=0.76 w=0.36 l=0.15
X5 a_1228_47# a_27_47# a_1028_413# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0735 ps=0.77 w=0.42 l=0.15
X6 VPWR CLK a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0864 pd=0.91 as=0.166 ps=1.8 w=0.64 l=0.15
X7 a_476_47# a_27_47# a_381_47# VNB sky130_fd_pr__nfet_01v8 ad=0.072 pd=0.76 as=0.0935 ps=0.965 w=0.36 l=0.15
X8 a_1056_47# a_476_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.109 ps=1.36 w=0.42 l=0.15
X9 a_381_47# D VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.125 pd=1.17 as=0.218 ps=2.2 w=0.84 l=0.15
X10 a_652_21# SET_B VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.0798 ps=0.8 w=0.42 l=0.15
X11 VPWR a_1602_47# Q VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.135 ps=1.27 w=1 l=0.15
X12 a_562_413# a_27_47# a_476_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0945 pd=0.87 as=0.0567 ps=0.69 w=0.42 l=0.15
X13 VGND a_1028_413# a_1602_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X14 VGND a_1602_47# Q VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X15 Q a_1602_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X16 a_1028_413# a_193_47# a_1056_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0735 pd=0.77 as=0.0441 ps=0.63 w=0.42 l=0.15
X17 a_476_47# a_193_47# a_381_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.125 ps=1.17 w=0.42 l=0.15
X18 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X19 VPWR a_1028_413# a_1602_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X20 VPWR a_652_21# a_562_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0798 pd=0.8 as=0.0945 ps=0.87 w=0.42 l=0.15
X21 Q a_1602_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X22 a_1028_413# a_27_47# a_956_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0819 pd=0.81 as=0.0441 ps=0.63 w=0.42 l=0.15
X23 VPWR a_1178_261# a_1136_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X24 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.166 pd=1.8 as=0.0864 ps=0.91 w=0.64 l=0.15
X25 a_1178_261# a_1028_413# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.223 pd=2.21 as=0.121 ps=1.16 w=0.84 l=0.15
X26 a_796_47# SET_B VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0882 ps=0.84 w=0.42 l=0.15
X27 a_1300_47# a_1178_261# a_1228_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0441 pd=0.63 as=0.0441 ps=0.63 w=0.42 l=0.15
X28 a_381_47# D VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0935 pd=0.965 as=0.166 ps=1.8 w=0.64 l=0.15
X29 a_1178_261# a_1028_413# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.14 pd=1.6 as=0.114 ps=1.01 w=0.54 l=0.15
X30 a_652_21# a_476_47# a_796_47# VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0441 ps=0.63 w=0.42 l=0.15
X31 VPWR SET_B a_1028_413# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.121 pd=1.16 as=0.109 ps=1.36 w=0.42 l=0.15
X32 VGND CLK a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X33 VGND SET_B a_1300_47# VNB sky130_fd_pr__nfet_01v8 ad=0.114 pd=1.01 as=0.0441 ps=0.63 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__a31oi_1 A1 A2 A3 B1 VGND VNB VPB VPWR Y
X0 Y A1 a_181_47# VNB sky130_fd_pr__nfet_01v8 ad=0.106 pd=0.975 as=0.119 ps=1.01 w=0.65 l=0.15
X1 a_181_47# A2 a_109_47# VNB sky130_fd_pr__nfet_01v8 ad=0.119 pd=1.01 as=0.0683 ps=0.86 w=0.65 l=0.15
X2 VGND B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.176 pd=1.84 as=0.106 ps=0.975 w=0.65 l=0.15
X3 VPWR A2 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.153 pd=1.3 as=0.135 ps=1.27 w=1 l=0.15
X4 Y B1 a_109_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.27 pd=2.54 as=0.162 ps=1.33 w=1 l=0.15
X5 a_109_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.162 pd=1.33 as=0.153 ps=1.3 w=1 l=0.15
X6 a_109_297# A3 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.26 ps=2.52 w=1 l=0.15
X7 a_109_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.169 ps=1.82 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__diode_2 DIODE VGND VNB VPB VPWR
D0 VNB DIODE sky130_fd_pr__diode_pw2nd_05v5 pj=2.64e+06 area=4.347e+11
.ends

.subckt sky130_fd_sc_hd__and2_4 A B VGND VNB VPB VPWR X
X0 VPWR B a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.177 pd=1.36 as=0.14 ps=1.28 w=1 l=0.15
X1 a_27_47# A VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.265 ps=2.53 w=1 l=0.15
X2 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.138 ps=1.08 w=0.65 l=0.15
X3 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X4 VGND B a_110_47# VNB sky130_fd_pr__nfet_01v8 ad=0.138 pd=1.08 as=0.0683 ps=0.86 w=0.65 l=0.15
X5 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.14 ps=1.28 w=1 l=0.15
X6 a_110_47# A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0683 pd=0.86 as=0.172 ps=1.83 w=0.65 l=0.15
X7 VPWR a_27_47# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.285 pd=2.57 as=0.14 ps=1.28 w=1 l=0.15
X8 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.185 pd=1.87 as=0.091 ps=0.93 w=0.65 l=0.15
X9 VGND a_27_47# X VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
X10 X a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.14 pd=1.28 as=0.177 ps=1.36 w=1 l=0.15
X11 X a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.091 pd=0.93 as=0.091 ps=0.93 w=0.65 l=0.15
.ends

.subckt sky130_fd_sc_hd__dlygate4sd1_1 A VGND VNB VPB VPWR X
X0 X a_299_93# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.1 ps=0.985 w=0.65 l=0.15
X1 VPWR a_193_47# a_299_93# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.141 pd=1.33 as=0.109 ps=1.36 w=0.42 l=0.15
X2 VPWR A a_27_47# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
X3 a_193_47# a_27_47# VGND VNB sky130_fd_pr__nfet_01v8 ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X4 a_193_47# a_27_47# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.109 pd=1.36 as=0.0567 ps=0.69 w=0.42 l=0.15
X5 VGND a_193_47# a_299_93# VNB sky130_fd_pr__nfet_01v8 ad=0.1 pd=0.985 as=0.109 ps=1.36 w=0.42 l=0.15
X6 X a_299_93# VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.26 pd=2.52 as=0.141 ps=1.33 w=1 l=0.15
X7 VGND A a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0567 pd=0.69 as=0.109 ps=1.36 w=0.42 l=0.15
.ends

.subckt sky130_fd_sc_hd__o32a_1 A1 A2 A3 B1 B2 VGND VNB VPB VPWR X
X0 a_77_199# B2 a_227_47# VNB sky130_fd_pr__nfet_01v8 ad=0.133 pd=1.06 as=0.127 ps=1.04 w=0.65 l=0.15
X1 a_323_297# A2 a_227_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.165 ps=1.33 w=1 l=0.15
X2 a_227_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.165 pd=1.33 as=0.135 ps=1.27 w=1 l=0.15
X3 a_227_47# B1 a_77_199# VNB sky130_fd_pr__nfet_01v8 ad=0.189 pd=1.88 as=0.133 ps=1.06 w=0.65 l=0.15
X4 VGND a_77_199# X VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.169 ps=1.82 w=0.65 l=0.15
X5 VPWR B1 a_539_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.29 pd=2.58 as=0.205 ps=1.41 w=1 l=0.15
X6 a_227_47# A3 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.127 ps=1.04 w=0.65 l=0.15
X7 VPWR a_77_199# X VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.335 ps=2.67 w=1 l=0.15
X8 a_77_199# A3 a_323_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.195 pd=1.39 as=0.195 ps=1.39 w=1 l=0.15
X9 VGND A2 a_227_47# VNB sky130_fd_pr__nfet_01v8 ad=0.127 pd=1.04 as=0.107 ps=0.98 w=0.65 l=0.15
X10 a_227_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.107 pd=0.98 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 a_539_297# B2 a_77_199# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.205 pd=1.41 as=0.195 ps=1.39 w=1 l=0.15
.ends

.subckt sky130_fd_sc_hd__o22ai_2 A1 A2 B1 B2 VGND VNB VPB VPWR Y
X0 Y B2 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X1 Y B2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X2 a_27_297# B1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X3 a_475_297# A1 VPWR VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X4 a_27_47# A2 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X5 VPWR A1 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X6 a_27_47# A1 VGND VNB sky130_fd_pr__nfet_01v8 ad=0.169 pd=1.82 as=0.0878 ps=0.92 w=0.65 l=0.15
X7 a_27_47# B1 Y VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X8 Y B1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.182 ps=1.86 w=0.65 l=0.15
X9 a_27_47# B2 Y VNB sky130_fd_pr__nfet_01v8 ad=0.27 pd=1.48 as=0.0878 ps=0.92 w=0.65 l=0.15
X10 VGND A1 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.0878 ps=0.92 w=0.65 l=0.15
X11 VPWR B1 a_27_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X12 a_475_297# A2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.135 ps=1.27 w=1 l=0.15
X13 Y A2 a_475_297# VPB sky130_fd_pr__pfet_01v8_hvt ad=0.135 pd=1.27 as=0.28 ps=2.56 w=1 l=0.15
X14 a_27_297# B2 Y VPB sky130_fd_pr__pfet_01v8_hvt ad=0.28 pd=2.56 as=0.135 ps=1.27 w=1 l=0.15
X15 VGND A2 a_27_47# VNB sky130_fd_pr__nfet_01v8 ad=0.0878 pd=0.92 as=0.27 ps=1.48 w=0.65 l=0.15
.ends

.subckt cordic VGND VPWR clk cos[0] cos[10] cos[11] cos[12] cos[13] cos[14] cos[15]
+ cos[1] cos[2] cos[3] cos[4] cos[5] cos[6] cos[7] cos[8] cos[9] in_valid out_valid
+ ready rstb sin[0] sin[10] sin[11] sin[12] sin[13] sin[14] sin[15] sin[1] sin[2]
+ sin[3] sin[4] sin[5] sin[6] sin[7] sin[8] sin[9] theta[0] theta[10] theta[11] theta[12]
+ theta[13] theta[14] theta[15] theta[1] theta[2] theta[3] theta[4] theta[5] theta[6]
+ theta[7] theta[8] theta[9]
X_3155_ _2392_ _2395_ VGND VGND VPWR VPWR _2396_ sky130_fd_sc_hd__xnor2_1
X_3086_ _2296_ _2297_ _2327_ VGND VGND VPWR VPWR _2329_ sky130_fd_sc_hd__nor3_1
XFILLER_0_76_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3988_ _0772_ _0819_ VGND VGND VPWR VPWR _0820_ sky130_fd_sc_hd__xnor2_1
X_2939_ _2144_ _2145_ _2184_ VGND VGND VPWR VPWR _2185_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_72_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4609_ net173 net176 _1386_ gm0.iter\[4\] VGND VGND VPWR VPWR _1387_ sky130_fd_sc_hd__a31o_1
XFILLER_0_82_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer7 net213 VGND VGND VPWR VPWR net214 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4960_ _1738_ _1740_ VGND VGND VPWR VPWR _1741_ sky130_fd_sc_hd__xnor2_1
X_3911_ _0676_ _0698_ _0744_ VGND VGND VPWR VPWR _0745_ sky130_fd_sc_hd__a21boi_2
X_4891_ net89 _1669_ VGND VGND VPWR VPWR _1671_ sky130_fd_sc_hd__nor2_1
X_3842_ net139 _0235_ net146 VGND VGND VPWR VPWR _0677_ sky130_fd_sc_hd__o21a_1
XFILLER_0_46_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3773_ _0281_ _0300_ VGND VGND VPWR VPWR _0610_ sky130_fd_sc_hd__and2_1
XFILLER_0_42_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2724_ _1964_ _1969_ VGND VGND VPWR VPWR _1971_ sky130_fd_sc_hd__nor2_1
X_2655_ net105 _1900_ _1901_ VGND VGND VPWR VPWR _1902_ sky130_fd_sc_hd__a21oi_1
X_2586_ net90 net83 _1802_ VGND VGND VPWR VPWR _1833_ sky130_fd_sc_hd__a21oi_1
X_4325_ slte0.opA\[6\] VGND VGND VPWR VPWR _1125_ sky130_fd_sc_hd__inv_2
Xfanout138 vec\[0\]\[9\] VGND VGND VPWR VPWR net138 sky130_fd_sc_hd__clkbuf_4
Xfanout127 net128 VGND VGND VPWR VPWR net127 sky130_fd_sc_hd__clkbuf_2
Xfanout116 net117 VGND VGND VPWR VPWR net116 sky130_fd_sc_hd__buf_2
Xfanout105 net106 VGND VGND VPWR VPWR net105 sky130_fd_sc_hd__buf_6
X_4256_ net17 net18 net192 VGND VGND VPWR VPWR _1063_ sky130_fd_sc_hd__a21o_1
Xfanout149 vec\[0\]\[6\] VGND VGND VPWR VPWR net149 sky130_fd_sc_hd__buf_2
X_4187_ _0621_ _1006_ _1009_ VGND VGND VPWR VPWR _1011_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_38_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3207_ _2444_ _2445_ VGND VGND VPWR VPWR _2446_ sky130_fd_sc_hd__xor2_1
X_3138_ net63 _1820_ VGND VGND VPWR VPWR _2379_ sky130_fd_sc_hd__nand2_2
X_3069_ _2306_ _2311_ VGND VGND VPWR VPWR _2312_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_464 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4110_ _0936_ _0935_ _0906_ _0594_ VGND VGND VPWR VPWR _0938_ sky130_fd_sc_hd__o211ai_1
X_5090_ clknet_3_3__leaf_clk _0084_ net199 VGND VGND VPWR VPWR vec\[0\]\[10\] sky130_fd_sc_hd__dfstp_1
X_4041_ _0863_ _0870_ VGND VGND VPWR VPWR _0871_ sky130_fd_sc_hd__xnor2_1
X_4943_ _1430_ _1621_ VGND VGND VPWR VPWR _1723_ sky130_fd_sc_hd__or2_1
XFILLER_0_19_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4874_ _1649_ _1652_ VGND VGND VPWR VPWR _1653_ sky130_fd_sc_hd__xnor2_1
X_3825_ _0607_ _0605_ VGND VGND VPWR VPWR _0661_ sky130_fd_sc_hd__and2b_1
X_3756_ net113 net118 VGND VGND VPWR VPWR _0593_ sky130_fd_sc_hd__or2b_2
XFILLER_0_40_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2707_ net105 _1953_ net111 VGND VGND VPWR VPWR _1954_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_71_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3687_ net163 net165 VGND VGND VPWR VPWR _0525_ sky130_fd_sc_hd__and2b_1
X_2638_ _1851_ _1860_ VGND VGND VPWR VPWR _1885_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_2_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2569_ _1811_ _1815_ VGND VGND VPWR VPWR _1816_ sky130_fd_sc_hd__xnor2_2
X_4308_ slte0.opA\[9\] slte0.opB\[9\] VGND VGND VPWR VPWR _1108_ sky130_fd_sc_hd__and2b_1
X_4239_ net14 _1046_ net191 VGND VGND VPWR VPWR _1050_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_65_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Left_100 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3610_ _0339_ _0447_ VGND VGND VPWR VPWR _0448_ sky130_fd_sc_hd__xor2_1
X_4590_ net162 _1350_ VGND VGND VPWR VPWR _1370_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3541_ _0205_ _0378_ VGND VGND VPWR VPWR _0379_ sky130_fd_sc_hd__xor2_2
X_3472_ net142 net139 VGND VGND VPWR VPWR _0310_ sky130_fd_sc_hd__or2_1
X_5073_ clknet_3_1__leaf_clk _0067_ net196 VGND VGND VPWR VPWR slte0.opA\[11\] sky130_fd_sc_hd__dfrtp_1
X_4024_ _0824_ _0822_ _0853_ _0786_ _0854_ VGND VGND VPWR VPWR _0855_ sky130_fd_sc_hd__o221a_1
XFILLER_0_47_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4926_ _1706_ VGND VGND VPWR VPWR _1707_ sky130_fd_sc_hd__inv_2
XFILLER_0_19_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4857_ _1024_ _1634_ _1635_ VGND VGND VPWR VPWR _1636_ sky130_fd_sc_hd__o21a_1
XFILLER_0_15_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3808_ _0592_ _0593_ _0594_ _0595_ _0591_ VGND VGND VPWR VPWR _0644_ sky130_fd_sc_hd__a311oi_2
X_4788_ net152 net149 net184 VGND VGND VPWR VPWR _1564_ sky130_fd_sc_hd__mux2_1
XFILLER_0_70_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3739_ _0238_ _0242_ VGND VGND VPWR VPWR _0576_ sky130_fd_sc_hd__and2b_1
XFILLER_0_30_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_56_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2972_ _1874_ _2161_ VGND VGND VPWR VPWR _2217_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_8_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4711_ _1463_ _1479_ _1473_ VGND VGND VPWR VPWR _1489_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_29_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4642_ _0116_ _1083_ _1415_ _1417_ net172 VGND VGND VPWR VPWR _1418_ sky130_fd_sc_hd__o32a_2
X_4573_ _1015_ _1353_ net190 net162 VGND VGND VPWR VPWR _0076_ sky130_fd_sc_hd__o2bb2a_1
X_3524_ _0341_ _0340_ VGND VGND VPWR VPWR _0362_ sky130_fd_sc_hd__xnor2_1
X_3455_ _0271_ _0273_ VGND VGND VPWR VPWR _0293_ sky130_fd_sc_hd__xor2_1
X_3386_ net144 _0223_ VGND VGND VPWR VPWR _0224_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5056_ clknet_3_1__leaf_clk _0050_ net196 VGND VGND VPWR VPWR slte0.opB\[12\] sky130_fd_sc_hd__dfrtp_1
X_4007_ _0836_ _0837_ VGND VGND VPWR VPWR _0838_ sky130_fd_sc_hd__xnor2_1
X_4909_ net114 _1563_ _1219_ VGND VGND VPWR VPWR _1689_ sky130_fd_sc_hd__mux2_1
XFILLER_0_35_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold30 net51 VGND VGND VPWR VPWR net237 sky130_fd_sc_hd__dlygate4sd3_1
Xhold41 slte0.opB\[9\] VGND VGND VPWR VPWR net248 sky130_fd_sc_hd__dlygate4sd3_1
Xhold52 slte0.opA\[6\] VGND VGND VPWR VPWR net259 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_26_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_7_Left_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_41_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3240_ _2334_ _2448_ _2477_ VGND VGND VPWR VPWR _2478_ sky130_fd_sc_hd__o21a_1
X_3171_ _2406_ _2410_ VGND VGND VPWR VPWR _2411_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_83_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2955_ _2142_ VGND VGND VPWR VPWR _2201_ sky130_fd_sc_hd__buf_4
X_2886_ _2130_ _2131_ _2132_ VGND VGND VPWR VPWR _2133_ sky130_fd_sc_hd__a21oi_1
X_4625_ net172 _1025_ VGND VGND VPWR VPWR _1402_ sky130_fd_sc_hd__or2_1
XFILLER_0_44_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4556_ _1319_ _1337_ VGND VGND VPWR VPWR _1338_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3507_ _0344_ VGND VGND VPWR VPWR _0345_ sky130_fd_sc_hd__inv_2
XFILLER_0_12_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4487_ _1272_ _1274_ VGND VGND VPWR VPWR _1275_ sky130_fd_sc_hd__xnor2_1
X_3438_ _0260_ _0262_ VGND VGND VPWR VPWR _0276_ sky130_fd_sc_hd__xor2_1
X_3369_ _0205_ _0206_ VGND VGND VPWR VPWR _0207_ sky130_fd_sc_hd__xnor2_2
X_5108_ clknet_3_5__leaf_clk _0102_ net203 VGND VGND VPWR VPWR vec\[1\]\[10\] sky130_fd_sc_hd__dfrtp_1
X_5039_ clknet_3_2__leaf_clk _0033_ net195 VGND VGND VPWR VPWR net24 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput42 net42 VGND VGND VPWR VPWR sin[14] sky130_fd_sc_hd__clkbuf_4
Xoutput20 net20 VGND VGND VPWR VPWR cos[10] sky130_fd_sc_hd__clkbuf_4
Xoutput31 net31 VGND VGND VPWR VPWR cos[6] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2740_ net111 _1953_ _1986_ VGND VGND VPWR VPWR _1987_ sky130_fd_sc_hd__o21ai_1
X_2671_ _1895_ _1917_ VGND VGND VPWR VPWR _1918_ sky130_fd_sc_hd__and2_1
X_4410_ _1168_ slte0.opA\[5\] _1015_ _1205_ VGND VGND VPWR VPWR _0061_ sky130_fd_sc_hd__a22o_1
XFILLER_0_78_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4341_ slte0.opA\[17\] VGND VGND VPWR VPWR _1141_ sky130_fd_sc_hd__inv_2
X_4272_ net9 net6 _1072_ net192 VGND VGND VPWR VPWR _1076_ sky130_fd_sc_hd__a31o_1
X_3223_ _2460_ _2461_ VGND VGND VPWR VPWR _2462_ sky130_fd_sc_hd__xnor2_2
X_3154_ _2393_ _2352_ _2394_ VGND VGND VPWR VPWR _2395_ sky130_fd_sc_hd__a21oi_1
X_3085_ _2296_ _2297_ _2327_ VGND VGND VPWR VPWR _2328_ sky130_fd_sc_hd__o21a_1
XFILLER_0_49_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3987_ _0816_ _0818_ VGND VGND VPWR VPWR _0819_ sky130_fd_sc_hd__xor2_1
X_2938_ _1796_ _2183_ VGND VGND VPWR VPWR _2184_ sky130_fd_sc_hd__xor2_1
XFILLER_0_32_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2869_ _2115_ _2055_ VGND VGND VPWR VPWR _2116_ sky130_fd_sc_hd__xnor2_1
X_4608_ net177 net186 VGND VGND VPWR VPWR _1386_ sky130_fd_sc_hd__or2_1
X_4539_ net81 net77 net74 net72 net186 net177 VGND VGND VPWR VPWR _1321_ sky130_fd_sc_hd__mux4_1
Xclkbuf_3_6__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_6__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_2_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer8 _2089_ VGND VGND VPWR VPWR net215 sky130_fd_sc_hd__clkbuf_1
XPHY_EDGE_ROW_79_Left_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3910_ _0694_ _0697_ VGND VGND VPWR VPWR _0744_ sky130_fd_sc_hd__nand2_1
X_4890_ net89 _1669_ VGND VGND VPWR VPWR _1670_ sky130_fd_sc_hd__and2_1
X_3841_ _0674_ _0675_ VGND VGND VPWR VPWR _0676_ sky130_fd_sc_hd__and2_1
XFILLER_0_13_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3772_ _0580_ _0608_ VGND VGND VPWR VPWR _0609_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_6_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2723_ _1964_ _1969_ VGND VGND VPWR VPWR _1970_ sky130_fd_sc_hd__xor2_2
XFILLER_0_54_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_14_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2654_ net105 _1685_ VGND VGND VPWR VPWR _1901_ sky130_fd_sc_hd__nor2_1
X_2585_ _1816_ _1831_ VGND VGND VPWR VPWR _1832_ sky130_fd_sc_hd__xnor2_2
X_4324_ _1119_ _1121_ _1123_ VGND VGND VPWR VPWR _1124_ sky130_fd_sc_hd__a21o_1
XFILLER_0_1_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout128 vec\[0\]\[13\] VGND VGND VPWR VPWR net128 sky130_fd_sc_hd__buf_4
Xfanout117 vec\[0\]\[17\] VGND VGND VPWR VPWR net117 sky130_fd_sc_hd__clkbuf_2
Xfanout106 net107 VGND VGND VPWR VPWR net106 sky130_fd_sc_hd__buf_6
XFILLER_0_10_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4255_ _1062_ VGND VGND VPWR VPWR _0049_ sky130_fd_sc_hd__clkbuf_1
Xfanout139 vec\[0\]\[9\] VGND VGND VPWR VPWR net139 sky130_fd_sc_hd__clkbuf_4
X_3206_ net56 _2308_ VGND VGND VPWR VPWR _2445_ sky130_fd_sc_hd__nand2_1
X_4186_ _0621_ _1006_ _1009_ VGND VGND VPWR VPWR _1010_ sky130_fd_sc_hd__or3_1
X_3137_ _2371_ _2377_ VGND VGND VPWR VPWR _2378_ sky130_fd_sc_hd__xnor2_1
X_3068_ _2267_ _2271_ _2310_ VGND VGND VPWR VPWR _2311_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_77_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_13_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_51_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4040_ _0864_ _0869_ VGND VGND VPWR VPWR _0870_ sky130_fd_sc_hd__xnor2_1
X_4942_ _1712_ _1713_ VGND VGND VPWR VPWR _1722_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4873_ _1206_ _1651_ VGND VGND VPWR VPWR _1652_ sky130_fd_sc_hd__or2_1
XFILLER_0_74_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3824_ _0633_ _0659_ VGND VGND VPWR VPWR _0660_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_6_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3755_ net122 net112 VGND VGND VPWR VPWR _0592_ sky130_fd_sc_hd__nand2_2
XFILLER_0_61_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_42_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3686_ _0522_ _0523_ VGND VGND VPWR VPWR _0524_ sky130_fd_sc_hd__xor2_1
X_2706_ _1942_ _1952_ VGND VGND VPWR VPWR _1953_ sky130_fd_sc_hd__nor2_4
X_2637_ _1873_ _1882_ _1883_ VGND VGND VPWR VPWR _1884_ sky130_fd_sc_hd__a21oi_2
XPHY_EDGE_ROW_12_Right_12 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2568_ net83 _1812_ _1814_ VGND VGND VPWR VPWR _1815_ sky130_fd_sc_hd__o21a_1
X_4307_ slte0.opB\[8\] _1106_ VGND VGND VPWR VPWR _1107_ sky130_fd_sc_hd__and2_1
X_4238_ _1049_ VGND VGND VPWR VPWR _0045_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_4_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4169_ _0621_ _0982_ _0993_ _1522_ VGND VGND VPWR VPWR _0995_ sky130_fd_sc_hd__o31a_1
XPHY_EDGE_ROW_21_Right_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_395 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_30_Right_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_61_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3540_ net148 net144 VGND VGND VPWR VPWR _0378_ sky130_fd_sc_hd__nand2_2
XFILLER_0_12_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3471_ _0307_ _0308_ VGND VGND VPWR VPWR _0309_ sky130_fd_sc_hd__xnor2_4
X_5072_ clknet_3_1__leaf_clk _0066_ net196 VGND VGND VPWR VPWR slte0.opA\[10\] sky130_fd_sc_hd__dfrtp_4
X_4023_ _0792_ _0779_ _0820_ VGND VGND VPWR VPWR _0854_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_79_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4925_ _1703_ _1704_ VGND VGND VPWR VPWR _1706_ sky130_fd_sc_hd__nor2_1
X_4856_ _1087_ _1562_ _1566_ _2195_ _1193_ VGND VGND VPWR VPWR _1635_ sky130_fd_sc_hd__o221a_1
XFILLER_0_74_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3807_ _0308_ _0642_ VGND VGND VPWR VPWR _0643_ sky130_fd_sc_hd__xnor2_2
X_4787_ _1558_ _1562_ _1022_ VGND VGND VPWR VPWR _1563_ sky130_fd_sc_hd__mux2_1
X_3738_ _2199_ _0575_ _2201_ net262 VGND VGND VPWR VPWR _0019_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_70_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3669_ _0218_ _0497_ _0506_ VGND VGND VPWR VPWR _0507_ sky130_fd_sc_hd__a21o_1
XFILLER_0_61_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2971_ _2210_ _2215_ VGND VGND VPWR VPWR _2216_ sky130_fd_sc_hd__xnor2_2
X_4710_ _1463_ _1479_ _1487_ _1473_ VGND VGND VPWR VPWR _1488_ sky130_fd_sc_hd__o211a_1
X_4641_ _1324_ _1356_ _1416_ VGND VGND VPWR VPWR _1417_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_21_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4572_ _1351_ _1352_ VGND VGND VPWR VPWR _1353_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_52_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3523_ _0359_ _0360_ VGND VGND VPWR VPWR _0361_ sky130_fd_sc_hd__xor2_1
XFILLER_0_24_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3454_ _0288_ _0290_ _0291_ VGND VGND VPWR VPWR _0292_ sky130_fd_sc_hd__a21oi_1
X_3385_ net138 net136 VGND VGND VPWR VPWR _0223_ sky130_fd_sc_hd__nand2_1
X_5055_ clknet_3_0__leaf_clk _0049_ net194 VGND VGND VPWR VPWR slte0.opB\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4006_ _0800_ _0805_ _0804_ VGND VGND VPWR VPWR _0837_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_27_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4908_ _1295_ _1687_ _1688_ net85 _1431_ VGND VGND VPWR VPWR _0100_ sky130_fd_sc_hd__a32o_1
XPHY_EDGE_ROW_33_Left_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4839_ _1594_ _1598_ _1616_ VGND VGND VPWR VPWR _1618_ sky130_fd_sc_hd__or3_1
XFILLER_0_50_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_42_Left_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold31 net39 VGND VGND VPWR VPWR net238 sky130_fd_sc_hd__dlygate4sd3_1
Xhold20 net27 VGND VGND VPWR VPWR net227 sky130_fd_sc_hd__dlygate4sd3_1
Xhold53 net44 VGND VGND VPWR VPWR net260 sky130_fd_sc_hd__dlygate4sd3_1
Xhold42 net35 VGND VGND VPWR VPWR net249 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_85_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_51_Left_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_60_Left_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3170_ _2407_ _2409_ VGND VGND VPWR VPWR _2410_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_16_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2954_ net167 _2139_ _2192_ _2199_ VGND VGND VPWR VPWR _2200_ sky130_fd_sc_hd__a31o_1
X_2885_ _1957_ _1976_ VGND VGND VPWR VPWR _2132_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_6_Right_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4624_ net189 net152 _1492_ _1401_ VGND VGND VPWR VPWR _0079_ sky130_fd_sc_hd__o22a_1
X_4555_ _1335_ _1336_ VGND VGND VPWR VPWR _1337_ sky130_fd_sc_hd__nor2_1
X_3506_ _0329_ _0343_ VGND VGND VPWR VPWR _0344_ sky130_fd_sc_hd__or2_1
X_4486_ net183 _1273_ VGND VGND VPWR VPWR _1274_ sky130_fd_sc_hd__nor2_1
X_3437_ _0271_ _0273_ _0274_ VGND VGND VPWR VPWR _0275_ sky130_fd_sc_hd__a21oi_1
X_3368_ net156 net151 VGND VGND VPWR VPWR _0206_ sky130_fd_sc_hd__nand2_2
XFILLER_0_57_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5107_ clknet_3_5__leaf_clk _0101_ net203 VGND VGND VPWR VPWR vec\[1\]\[9\] sky130_fd_sc_hd__dfrtp_1
X_3299_ net56 net62 VGND VGND VPWR VPWR _0142_ sky130_fd_sc_hd__nor2_1
XFILLER_0_79_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5038_ clknet_3_2__leaf_clk _0032_ net195 VGND VGND VPWR VPWR net23 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_75_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput43 net43 VGND VGND VPWR VPWR sin[15] sky130_fd_sc_hd__clkbuf_4
Xoutput21 net21 VGND VGND VPWR VPWR cos[11] sky130_fd_sc_hd__clkbuf_4
Xoutput32 net32 VGND VGND VPWR VPWR cos[7] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_85_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_59_Right_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_352 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2670_ net91 net88 VGND VGND VPWR VPWR _1917_ sky130_fd_sc_hd__or2_1
X_4340_ _1101_ _1130_ _1137_ _1139_ VGND VGND VPWR VPWR _1140_ sky130_fd_sc_hd__a31oi_4
X_4271_ _1075_ VGND VGND VPWR VPWR _0052_ sky130_fd_sc_hd__clkbuf_1
X_3222_ _2389_ _2425_ _2424_ VGND VGND VPWR VPWR _2461_ sky130_fd_sc_hd__o21ba_1
X_3153_ _2344_ _2346_ VGND VGND VPWR VPWR _2394_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_68_Right_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3084_ _2254_ _2326_ VGND VGND VPWR VPWR _2327_ sky130_fd_sc_hd__xor2_1
XFILLER_0_11_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_77_Right_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3986_ _0769_ _0774_ _0817_ VGND VGND VPWR VPWR _0818_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_57_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2937_ _2180_ _2182_ VGND VGND VPWR VPWR _2183_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4607_ _1015_ _1385_ net189 net155 VGND VGND VPWR VPWR _0078_ sky130_fd_sc_hd__o2bb2a_1
X_2868_ _2043_ _2044_ VGND VGND VPWR VPWR _2115_ sky130_fd_sc_hd__nand2_1
X_2799_ net104 net99 VGND VGND VPWR VPWR _2046_ sky130_fd_sc_hd__nor2_1
X_4538_ net69 net66 net64 net61 net182 net177 VGND VGND VPWR VPWR _1320_ sky130_fd_sc_hd__mux4_1
XFILLER_0_7_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4469_ _1253_ _1258_ VGND VGND VPWR VPWR _1259_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_23_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer9 net101 VGND VGND VPWR VPWR net216 sky130_fd_sc_hd__buf_1
XFILLER_0_63_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3840_ net152 _0672_ _0673_ VGND VGND VPWR VPWR _0675_ sky130_fd_sc_hd__or3_1
X_3771_ _0605_ _0607_ VGND VGND VPWR VPWR _0608_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_54_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2722_ _1966_ _1967_ _1968_ VGND VGND VPWR VPWR _1969_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_14_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2653_ _1685_ _1899_ VGND VGND VPWR VPWR _1900_ sky130_fd_sc_hd__xnor2_2
X_2584_ _1823_ _1830_ VGND VGND VPWR VPWR _1831_ sky130_fd_sc_hd__xor2_2
XFILLER_0_1_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4323_ slte0.opB\[5\] _1122_ slte0.opB\[4\] _1120_ VGND VGND VPWR VPWR _1123_ sky130_fd_sc_hd__a22o_1
XFILLER_0_22_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout118 net120 VGND VGND VPWR VPWR net118 sky130_fd_sc_hd__clkbuf_4
Xfanout129 net131 VGND VGND VPWR VPWR net129 sky130_fd_sc_hd__clkbuf_4
Xfanout107 vec\[1\]\[2\] VGND VGND VPWR VPWR net107 sky130_fd_sc_hd__buf_6
X_4254_ slte0.opB\[11\] _1061_ _1031_ VGND VGND VPWR VPWR _1062_ sky130_fd_sc_hd__mux2_1
X_3205_ net70 _1825_ _2443_ VGND VGND VPWR VPWR _2444_ sky130_fd_sc_hd__o21ai_1
X_4185_ _1007_ _1008_ VGND VGND VPWR VPWR _1009_ sky130_fd_sc_hd__xnor2_1
X_3136_ _2373_ _2376_ VGND VGND VPWR VPWR _2377_ sky130_fd_sc_hd__xor2_1
X_3067_ _2307_ _2309_ net62 net56 net59 VGND VGND VPWR VPWR _2310_ sky130_fd_sc_hd__o2111a_1
X_3969_ _0688_ _0263_ _0797_ net117 VGND VGND VPWR VPWR _0801_ sky130_fd_sc_hd__o31a_1
XFILLER_0_45_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4941_ _1152_ net76 _1015_ _1721_ VGND VGND VPWR VPWR _0103_ sky130_fd_sc_hd__a22o_1
XFILLER_0_74_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4872_ _1637_ _1650_ VGND VGND VPWR VPWR _1651_ sky130_fd_sc_hd__nor2_1
X_3823_ _0655_ _0658_ VGND VGND VPWR VPWR _0659_ sky130_fd_sc_hd__xor2_2
X_3754_ net126 net125 VGND VGND VPWR VPWR _0591_ sky130_fd_sc_hd__xnor2_2
X_3685_ _0512_ _0505_ VGND VGND VPWR VPWR _0523_ sky130_fd_sc_hd__xnor2_1
X_2705_ net109 net103 VGND VGND VPWR VPWR _1952_ sky130_fd_sc_hd__nor2_1
X_2636_ _1880_ _1881_ VGND VGND VPWR VPWR _1883_ sky130_fd_sc_hd__and2b_1
XFILLER_0_2_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2567_ _1813_ _1812_ VGND VGND VPWR VPWR _1814_ sky130_fd_sc_hd__or2b_1
X_4306_ slte0.opA\[8\] VGND VGND VPWR VPWR _1106_ sky130_fd_sc_hd__inv_2
X_4237_ slte0.opB\[7\] _1048_ _1031_ VGND VGND VPWR VPWR _1049_ sky130_fd_sc_hd__mux2_1
X_4168_ _0621_ _0982_ _0993_ VGND VGND VPWR VPWR _0994_ sky130_fd_sc_hd__o21ai_1
X_3119_ _2254_ _2326_ _2360_ VGND VGND VPWR VPWR _2361_ sky130_fd_sc_hd__o21ba_1
X_4099_ _0926_ _0927_ net226 _2201_ VGND VGND VPWR VPWR _0028_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_77_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3470_ net135 net131 VGND VGND VPWR VPWR _0308_ sky130_fd_sc_hd__nand2_2
X_5071_ clknet_3_1__leaf_clk _0065_ net196 VGND VGND VPWR VPWR slte0.opA\[9\] sky130_fd_sc_hd__dfrtp_2
X_4022_ _0784_ _0823_ VGND VGND VPWR VPWR _0853_ sky130_fd_sc_hd__nand2_1
XFILLER_0_35_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4924_ net77 _1702_ VGND VGND VPWR VPWR _1704_ sky130_fd_sc_hd__and2b_1
XFILLER_0_19_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4855_ net115 _1388_ _1558_ _1023_ VGND VGND VPWR VPWR _1634_ sky130_fd_sc_hd__a22o_1
XFILLER_0_51_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3806_ _0307_ _0641_ VGND VGND VPWR VPWR _0642_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_34_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4786_ _1559_ _1561_ net178 VGND VGND VPWR VPWR _1562_ sky130_fd_sc_hd__mux2_1
X_3737_ _0376_ _0574_ VGND VGND VPWR VPWR _0575_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_55_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_366 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3668_ net153 net148 _0217_ VGND VGND VPWR VPWR _0506_ sky130_fd_sc_hd__and3_1
X_2619_ _1848_ _1864_ _1865_ VGND VGND VPWR VPWR _1866_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_2_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3599_ _0424_ _0435_ VGND VGND VPWR VPWR _0437_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2970_ _2212_ _2214_ VGND VGND VPWR VPWR _2215_ sky130_fd_sc_hd__xnor2_2
X_4640_ _1183_ _1355_ _1359_ _1462_ VGND VGND VPWR VPWR _1416_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_24_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4571_ _1319_ _1336_ _1335_ VGND VGND VPWR VPWR _1352_ sky130_fd_sc_hd__o21bai_1
X_3522_ _0306_ _0315_ VGND VGND VPWR VPWR _0360_ sky130_fd_sc_hd__xnor2_2
X_3453_ net132 vec\[0\]\[13\] _0286_ VGND VGND VPWR VPWR _0291_ sky130_fd_sc_hd__and3_1
X_3384_ net139 net137 _0221_ VGND VGND VPWR VPWR _0222_ sky130_fd_sc_hd__a21o_1
X_5054_ clknet_3_0__leaf_clk _0048_ net194 VGND VGND VPWR VPWR slte0.opB\[10\] sky130_fd_sc_hd__dfrtp_1
X_4005_ _0829_ _0835_ VGND VGND VPWR VPWR _0836_ sky130_fd_sc_hd__xor2_1
XFILLER_0_47_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4907_ _1655_ _1661_ _1670_ _1684_ _1683_ VGND VGND VPWR VPWR _1688_ sky130_fd_sc_hd__o311ai_4
XFILLER_0_62_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4838_ _1594_ _1598_ _1616_ VGND VGND VPWR VPWR _1617_ sky130_fd_sc_hd__o21ai_1
X_4769_ net120 net115 net182 VGND VGND VPWR VPWR _1545_ sky130_fd_sc_hd__mux2_2
Xhold32 net43 VGND VGND VPWR VPWR net239 sky130_fd_sc_hd__dlygate4sd3_1
Xhold21 net31 VGND VGND VPWR VPWR net228 sky130_fd_sc_hd__dlygate4sd3_1
Xhold54 net37 VGND VGND VPWR VPWR net261 sky130_fd_sc_hd__dlygate4sd3_1
Xhold43 slte0.opA\[15\] VGND VGND VPWR VPWR net250 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_42_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2953_ _2198_ VGND VGND VPWR VPWR _2199_ sky130_fd_sc_hd__buf_4
XFILLER_0_84_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2884_ _1992_ _2010_ VGND VGND VPWR VPWR _2131_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4623_ _1399_ _1400_ VGND VGND VPWR VPWR _1401_ sky130_fd_sc_hd__xnor2_1
X_4554_ net164 _1334_ VGND VGND VPWR VPWR _1336_ sky130_fd_sc_hd__nor2_1
X_3505_ _0333_ _0337_ _0342_ VGND VGND VPWR VPWR _0343_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_40_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4485_ net179 _1452_ VGND VGND VPWR VPWR _1273_ sky130_fd_sc_hd__nand2_2
X_3436_ net129 net125 _0269_ VGND VGND VPWR VPWR _0274_ sky130_fd_sc_hd__and3_1
X_3367_ net154 net148 VGND VGND VPWR VPWR _0205_ sky130_fd_sc_hd__xor2_4
X_5106_ clknet_3_5__leaf_clk _0100_ net203 VGND VGND VPWR VPWR vec\[1\]\[8\] sky130_fd_sc_hd__dfrtp_1
X_3298_ net70 _0140_ VGND VGND VPWR VPWR _0141_ sky130_fd_sc_hd__xor2_1
X_5037_ clknet_3_2__leaf_clk _0031_ net195 VGND VGND VPWR VPWR net22 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_75_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_16_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput22 net22 VGND VGND VPWR VPWR cos[12] sky130_fd_sc_hd__clkbuf_4
Xoutput33 net33 VGND VGND VPWR VPWR cos[8] sky130_fd_sc_hd__clkbuf_4
Xoutput44 net44 VGND VGND VPWR VPWR sin[1] sky130_fd_sc_hd__buf_2
XFILLER_0_37_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_58_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4270_ slte0.opB\[14\] _1074_ _2141_ VGND VGND VPWR VPWR _1075_ sky130_fd_sc_hd__mux2_1
X_3221_ _2441_ _2459_ VGND VGND VPWR VPWR _2460_ sky130_fd_sc_hd__xor2_2
X_3152_ _2344_ _2346_ VGND VGND VPWR VPWR _2393_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3083_ _2323_ _2325_ VGND VGND VPWR VPWR _2326_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_64_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3985_ _0766_ _0768_ VGND VGND VPWR VPWR _0817_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2936_ _1798_ _1867_ _2181_ VGND VGND VPWR VPWR _2182_ sky130_fd_sc_hd__a21oi_1
X_2867_ _2112_ _2085_ _2113_ VGND VGND VPWR VPWR _2114_ sky130_fd_sc_hd__o21ai_1
X_4606_ _1373_ _1384_ VGND VGND VPWR VPWR _1385_ sky130_fd_sc_hd__xnor2_1
X_2798_ _1983_ _2042_ VGND VGND VPWR VPWR _2045_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_7_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_40_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4537_ net165 _1315_ VGND VGND VPWR VPWR _1319_ sky130_fd_sc_hd__nor2_1
X_4468_ _1256_ _1257_ VGND VGND VPWR VPWR _1258_ sky130_fd_sc_hd__nand2_1
X_3419_ _0253_ _0256_ VGND VGND VPWR VPWR _0257_ sky130_fd_sc_hd__xor2_2
X_4399_ _1090_ _1194_ VGND VGND VPWR VPWR _1195_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_73_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3770_ _0244_ _0280_ _0606_ VGND VGND VPWR VPWR _0607_ sky130_fd_sc_hd__o21a_1
XFILLER_0_6_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2721_ net85 net79 _1813_ VGND VGND VPWR VPWR _1968_ sky130_fd_sc_hd__and3_1
XFILLER_0_54_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2652_ net105 net100 VGND VGND VPWR VPWR _1899_ sky130_fd_sc_hd__nand2_2
X_2583_ _1826_ _1828_ _1829_ VGND VGND VPWR VPWR _1830_ sky130_fd_sc_hd__a21o_1
XFILLER_0_22_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4322_ slte0.opA\[5\] VGND VGND VPWR VPWR _1122_ sky130_fd_sc_hd__inv_2
X_4253_ net18 _1060_ VGND VGND VPWR VPWR _1061_ sky130_fd_sc_hd__xnor2_1
Xfanout119 net120 VGND VGND VPWR VPWR net119 sky130_fd_sc_hd__clkbuf_4
Xfanout108 net109 VGND VGND VPWR VPWR net108 sky130_fd_sc_hd__buf_4
X_3204_ net68 _1826_ VGND VGND VPWR VPWR _2443_ sky130_fd_sc_hd__nand2_1
XFILLER_0_38_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4184_ _0684_ _0863_ _0727_ VGND VGND VPWR VPWR _1008_ sky130_fd_sc_hd__mux2_1
X_3135_ _1829_ _2374_ _2375_ VGND VGND VPWR VPWR _2376_ sky130_fd_sc_hd__o21ai_2
X_3066_ net62 _2220_ _2308_ VGND VGND VPWR VPWR _2309_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_49_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3968_ _0793_ _0799_ VGND VGND VPWR VPWR _0800_ sky130_fd_sc_hd__xnor2_1
X_2919_ net60 net63 net58 VGND VGND VPWR VPWR _2165_ sky130_fd_sc_hd__mux2_4
XFILLER_0_72_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3899_ net130 _0684_ VGND VGND VPWR VPWR _0733_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4940_ _1719_ _1720_ VGND VGND VPWR VPWR _1721_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_74_415 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4871_ _1620_ _1624_ VGND VGND VPWR VPWR _1650_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3822_ _0587_ _0656_ _0657_ VGND VGND VPWR VPWR _0658_ sky130_fd_sc_hd__a21o_1
X_3753_ _0347_ _0589_ VGND VGND VPWR VPWR _0590_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_40_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3684_ net163 net160 VGND VGND VPWR VPWR _0522_ sky130_fd_sc_hd__nand2_1
X_2704_ _1946_ _1950_ VGND VGND VPWR VPWR _1951_ sky130_fd_sc_hd__and2b_1
X_2635_ _1880_ _1881_ VGND VGND VPWR VPWR _1882_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_2_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4305_ slte0.opB\[11\] _1102_ VGND VGND VPWR VPWR _1105_ sky130_fd_sc_hd__or2_1
X_2566_ net82 net74 VGND VGND VPWR VPWR _1813_ sky130_fd_sc_hd__xor2_4
X_4236_ net14 _1047_ VGND VGND VPWR VPWR _1048_ sky130_fd_sc_hd__xnor2_1
X_4167_ _0991_ _0992_ VGND VGND VPWR VPWR _0993_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_4_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3118_ _2323_ _2325_ VGND VGND VPWR VPWR _2360_ sky130_fd_sc_hd__nor2_1
X_4098_ _0754_ _0925_ _0892_ _2198_ VGND VGND VPWR VPWR _0927_ sky130_fd_sc_hd__a31o_1
X_3049_ net167 _2291_ _2249_ _2199_ VGND VGND VPWR VPWR _2293_ sky130_fd_sc_hd__a31o_1
XFILLER_0_80_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout90 net92 VGND VGND VPWR VPWR net90 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_10_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5070_ clknet_3_1__leaf_clk _0064_ net196 VGND VGND VPWR VPWR slte0.opA\[8\] sky130_fd_sc_hd__dfrtp_1
X_4021_ _0848_ _0851_ VGND VGND VPWR VPWR _0852_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_19_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4923_ _1702_ net77 VGND VGND VPWR VPWR _1703_ sky130_fd_sc_hd__and2b_1
XFILLER_0_74_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4854_ _1152_ net101 _1015_ _1632_ VGND VGND VPWR VPWR _0096_ sky130_fd_sc_hd__a22o_1
X_3805_ net128 net125 VGND VGND VPWR VPWR _0641_ sky130_fd_sc_hd__nand2_1
X_4785_ net133 net131 net182 VGND VGND VPWR VPWR _1561_ sky130_fd_sc_hd__mux2_1
X_3736_ _0412_ _0413_ _0573_ VGND VGND VPWR VPWR _0574_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_27_194 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3667_ _0494_ _0503_ _0504_ VGND VGND VPWR VPWR _0505_ sky130_fd_sc_hd__o21a_1
X_2618_ _1862_ _1863_ VGND VGND VPWR VPWR _1865_ sky130_fd_sc_hd__or2_1
X_3598_ _0424_ _0435_ VGND VGND VPWR VPWR _0436_ sky130_fd_sc_hd__nand2_1
X_2549_ _1792_ _1795_ net106 VGND VGND VPWR VPWR _1796_ sky130_fd_sc_hd__o21ai_2
X_4219_ slte0.opB\[3\] _1034_ _1031_ VGND VGND VPWR VPWR _1035_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_278 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4570_ net162 _1350_ VGND VGND VPWR VPWR _1351_ sky130_fd_sc_hd__xor2_1
X_3521_ _0355_ _0357_ _0358_ VGND VGND VPWR VPWR _0359_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_12_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3452_ _0223_ _0289_ VGND VGND VPWR VPWR _0290_ sky130_fd_sc_hd__and2_1
X_3383_ net144 net138 VGND VGND VPWR VPWR _0221_ sky130_fd_sc_hd__xor2_4
X_5053_ clknet_3_0__leaf_clk _0047_ net193 VGND VGND VPWR VPWR slte0.opB\[9\] sky130_fd_sc_hd__dfrtp_1
X_4004_ _0830_ _0834_ VGND VGND VPWR VPWR _0835_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4906_ _1683_ _1686_ VGND VGND VPWR VPWR _1687_ sky130_fd_sc_hd__or2_1
X_4837_ _1614_ _1615_ VGND VGND VPWR VPWR _1616_ sky130_fd_sc_hd__and2_1
X_4768_ _1295_ _1543_ _1544_ net113 net266 VGND VGND VPWR VPWR _0091_ sky130_fd_sc_hd__a32o_1
X_4699_ _1475_ _1476_ VGND VGND VPWR VPWR _1477_ sky130_fd_sc_hd__xor2_1
XFILLER_0_30_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3719_ _0521_ _0524_ _0546_ _0550_ _0556_ VGND VGND VPWR VPWR _0557_ sky130_fd_sc_hd__o311a_1
XFILLER_0_43_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold22 net29 VGND VGND VPWR VPWR net229 sky130_fd_sc_hd__dlygate4sd3_1
Xhold55 net19 VGND VGND VPWR VPWR net262 sky130_fd_sc_hd__dlygate4sd3_1
Xhold44 net36 VGND VGND VPWR VPWR net251 sky130_fd_sc_hd__dlygate4sd3_1
Xhold33 net30 VGND VGND VPWR VPWR net240 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_78_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2952_ _1421_ net186 _2197_ VGND VGND VPWR VPWR _2198_ sky130_fd_sc_hd__or3_4
XFILLER_0_84_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2883_ _2009_ _1993_ VGND VGND VPWR VPWR _2130_ sky130_fd_sc_hd__or2b_1
XFILLER_0_44_226 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4622_ _1373_ _1384_ _1382_ VGND VGND VPWR VPWR _1400_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_4_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4553_ net164 _1334_ VGND VGND VPWR VPWR _1335_ sky130_fd_sc_hd__and2_1
XFILLER_0_52_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3504_ _0340_ _0341_ VGND VGND VPWR VPWR _0342_ sky130_fd_sc_hd__and2b_1
X_4484_ _1238_ VGND VGND VPWR VPWR _1272_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_12_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3435_ _0234_ _0272_ VGND VGND VPWR VPWR _0273_ sky130_fd_sc_hd__and2_1
XFILLER_0_12_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_40_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3366_ net150 net145 _0201_ _0203_ VGND VGND VPWR VPWR _0204_ sky130_fd_sc_hd__a31o_2
X_3297_ _2307_ _2270_ _2309_ net59 _0116_ VGND VGND VPWR VPWR _0140_ sky130_fd_sc_hd__o32ai_4
X_5105_ clknet_3_5__leaf_clk _0099_ net206 VGND VGND VPWR VPWR vec\[1\]\[7\] sky130_fd_sc_hd__dfrtp_1
X_5036_ clknet_3_2__leaf_clk _0030_ net198 VGND VGND VPWR VPWR net21 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_32_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_362 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput23 net23 VGND VGND VPWR VPWR cos[13] sky130_fd_sc_hd__clkbuf_4
Xoutput34 net34 VGND VGND VPWR VPWR cos[9] sky130_fd_sc_hd__clkbuf_4
Xoutput45 net45 VGND VGND VPWR VPWR sin[2] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_410 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3220_ _2455_ _2458_ VGND VGND VPWR VPWR _2459_ sky130_fd_sc_hd__xor2_2
X_3151_ _2386_ _2391_ VGND VGND VPWR VPWR _2392_ sky130_fd_sc_hd__xnor2_1
X_3082_ _2256_ _2280_ _2324_ VGND VGND VPWR VPWR _2325_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_27_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3984_ _0810_ _0815_ VGND VGND VPWR VPWR _0816_ sky130_fd_sc_hd__xnor2_1
X_2935_ _1847_ _1866_ VGND VGND VPWR VPWR _2181_ sky130_fd_sc_hd__and2_1
XFILLER_0_72_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2866_ _2082_ net208 VGND VGND VPWR VPWR _2113_ sky130_fd_sc_hd__nand2_1
XFILLER_0_32_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4605_ _1382_ _1383_ VGND VGND VPWR VPWR _1384_ sky130_fd_sc_hd__nand2_1
X_2797_ net102 _1983_ _2041_ net108 VGND VGND VPWR VPWR _2044_ sky130_fd_sc_hd__a211o_1
X_4536_ net189 _0329_ _1316_ _1318_ VGND VGND VPWR VPWR _0074_ sky130_fd_sc_hd__a31o_1
X_4467_ slte0.opA\[11\] _1254_ _1255_ VGND VGND VPWR VPWR _1257_ sky130_fd_sc_hd__or3_2
XFILLER_0_0_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3418_ _0254_ _0255_ VGND VGND VPWR VPWR _0256_ sky130_fd_sc_hd__xnor2_2
X_4398_ _1193_ _1462_ VGND VGND VPWR VPWR _1194_ sky130_fd_sc_hd__nand2_2
X_3349_ net247 _2248_ VGND VGND VPWR VPWR _0190_ sky130_fd_sc_hd__nand2_1
X_5019_ clknet_3_7__leaf_clk _0013_ net204 VGND VGND VPWR VPWR net38 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_51_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_39_Left_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_48_Left_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2720_ _1811_ _1813_ VGND VGND VPWR VPWR _1967_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_54_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_57_Left_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2651_ net218 net94 _1896_ _1897_ VGND VGND VPWR VPWR _1898_ sky130_fd_sc_hd__a31o_1
X_2582_ net68 net62 _1825_ VGND VGND VPWR VPWR _1829_ sky130_fd_sc_hd__and3_2
X_4321_ slte0.opB\[4\] _1120_ slte0.opB\[3\] _1115_ VGND VGND VPWR VPWR _1121_ sky130_fd_sc_hd__o22a_1
XFILLER_0_10_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4252_ net192 net17 _1057_ VGND VGND VPWR VPWR _1060_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_10_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout109 net110 VGND VGND VPWR VPWR net109 sky130_fd_sc_hd__buf_4
X_3203_ net65 _1835_ net71 VGND VGND VPWR VPWR _2442_ sky130_fd_sc_hd__o21a_1
X_4183_ _0996_ _1002_ _1000_ VGND VGND VPWR VPWR _1007_ sky130_fd_sc_hd__a21o_1
X_3134_ net68 net62 _1825_ VGND VGND VPWR VPWR _2375_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_66_Left_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3065_ net62 net59 VGND VGND VPWR VPWR _2308_ sky130_fd_sc_hd__or2b_1
XFILLER_0_77_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3967_ _0795_ _0798_ VGND VGND VPWR VPWR _0799_ sky130_fd_sc_hd__xor2_1
XFILLER_0_45_310 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_75_Left_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2918_ net60 net58 VGND VGND VPWR VPWR _2164_ sky130_fd_sc_hd__and2b_1
XFILLER_0_5_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3898_ net136 _0247_ net143 VGND VGND VPWR VPWR _0732_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_33_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2849_ _2091_ _2095_ VGND VGND VPWR VPWR _2096_ sky130_fd_sc_hd__xor2_1
X_4519_ _1295_ _1302_ _1303_ slte0.opA\[16\] net266 VGND VGND VPWR VPWR _0072_ sky130_fd_sc_hd__a32o_1
XPHY_EDGE_ROW_84_Left_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4870_ net116 _1402_ _1648_ _1296_ VGND VGND VPWR VPWR _1649_ sky130_fd_sc_hd__a22o_1
XFILLER_0_59_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3821_ _0601_ _0603_ VGND VGND VPWR VPWR _0657_ sky130_fd_sc_hd__nor2_1
XFILLER_0_15_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3752_ net136 _0251_ _0588_ VGND VGND VPWR VPWR _0589_ sky130_fd_sc_hd__o21a_1
XFILLER_0_54_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3683_ _0513_ _0520_ VGND VGND VPWR VPWR _0521_ sky130_fd_sc_hd__nor2_1
X_2703_ net102 net97 _1948_ _1949_ VGND VGND VPWR VPWR _1950_ sky130_fd_sc_hd__a31o_1
X_2634_ _1854_ _1856_ VGND VGND VPWR VPWR _1881_ sky130_fd_sc_hd__xor2_2
XFILLER_0_2_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2565_ net74 net72 VGND VGND VPWR VPWR _1812_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4304_ slte0.opB\[11\] _1102_ slte0.opB\[10\] _1103_ VGND VGND VPWR VPWR _1104_ sky130_fd_sc_hd__a22o_1
XFILLER_0_49_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4235_ net191 _1046_ VGND VGND VPWR VPWR _1047_ sky130_fd_sc_hd__nor2_1
X_4166_ _0970_ _0977_ VGND VGND VPWR VPWR _0992_ sky130_fd_sc_hd__or2_1
XFILLER_0_4_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3117_ _2357_ _2358_ VGND VGND VPWR VPWR _2359_ sky130_fd_sc_hd__nor2_1
X_4097_ _0754_ _0892_ _0925_ VGND VGND VPWR VPWR _0926_ sky130_fd_sc_hd__a21oi_1
X_3048_ net168 _2249_ _2291_ VGND VGND VPWR VPWR _2292_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_77_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4999_ _1295_ _1779_ _1780_ net61 _1431_ VGND VGND VPWR VPWR _0108_ sky130_fd_sc_hd__a32o_1
XFILLER_0_18_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout80 vec\[1\]\[10\] VGND VGND VPWR VPWR net80 sky130_fd_sc_hd__clkbuf_2
Xfanout91 net92 VGND VGND VPWR VPWR net91 sky130_fd_sc_hd__clkbuf_8
XFILLER_0_64_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4020_ _0772_ _0849_ _0850_ VGND VGND VPWR VPWR _0851_ sky130_fd_sc_hd__o21a_1
XFILLER_0_35_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4922_ _1699_ _1701_ VGND VGND VPWR VPWR _1702_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4853_ _1619_ _1631_ VGND VGND VPWR VPWR _1632_ sky130_fd_sc_hd__xor2_1
X_3804_ _0634_ _0639_ VGND VGND VPWR VPWR _0640_ sky130_fd_sc_hd__xnor2_2
X_4784_ net140 net135 net186 VGND VGND VPWR VPWR _1559_ sky130_fd_sc_hd__mux2_1
X_3735_ _0445_ _0570_ _0572_ _0413_ VGND VGND VPWR VPWR _0573_ sky130_fd_sc_hd__a211o_1
XFILLER_0_70_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3666_ _0498_ _0502_ VGND VGND VPWR VPWR _0504_ sky130_fd_sc_hd__or2_1
X_2617_ _1862_ _1863_ VGND VGND VPWR VPWR _1864_ sky130_fd_sc_hd__xnor2_2
X_3597_ _0426_ _0433_ _0434_ VGND VGND VPWR VPWR _0435_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_62_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2548_ _1793_ _1794_ VGND VGND VPWR VPWR _1795_ sky130_fd_sc_hd__and2b_1
X_4218_ net10 _1033_ VGND VGND VPWR VPWR _1034_ sky130_fd_sc_hd__xnor2_1
X_4149_ _0922_ _0894_ _0950_ _0975_ VGND VGND VPWR VPWR _0976_ sky130_fd_sc_hd__o31ai_2
XFILLER_0_65_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3520_ _0353_ _0354_ VGND VGND VPWR VPWR _0358_ sky130_fd_sc_hd__nand2_1
XFILLER_0_52_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3451_ net138 net136 VGND VGND VPWR VPWR _0289_ sky130_fd_sc_hd__or2_1
X_3382_ net154 _0218_ _0219_ VGND VGND VPWR VPWR _0220_ sky130_fd_sc_hd__a21o_1
XFILLER_0_20_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5052_ clknet_3_0__leaf_clk _0046_ net193 VGND VGND VPWR VPWR slte0.opB\[8\] sky130_fd_sc_hd__dfrtp_1
X_4003_ _0831_ _0833_ VGND VGND VPWR VPWR _0834_ sky130_fd_sc_hd__xor2_1
XFILLER_0_1_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4905_ _1655_ _1661_ _1670_ _1684_ VGND VGND VPWR VPWR _1686_ sky130_fd_sc_hd__o31a_1
X_4836_ net104 _1612_ VGND VGND VPWR VPWR _1615_ sky130_fd_sc_hd__or2_1
XFILLER_0_28_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4767_ _1535_ _1539_ _1542_ VGND VGND VPWR VPWR _1544_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_15_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4698_ net135 _1460_ _1463_ VGND VGND VPWR VPWR _1476_ sky130_fd_sc_hd__a21o_1
X_3718_ _0520_ _0551_ _0555_ VGND VGND VPWR VPWR _0556_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3649_ _0446_ _0419_ VGND VGND VPWR VPWR _0487_ sky130_fd_sc_hd__nor2_1
Xhold23 net32 VGND VGND VPWR VPWR net230 sky130_fd_sc_hd__dlygate4sd3_1
Xhold34 net47 VGND VGND VPWR VPWR net241 sky130_fd_sc_hd__dlygate4sd3_1
Xhold45 slte0.opB\[6\] VGND VGND VPWR VPWR net252 sky130_fd_sc_hd__dlygate4sd3_1
Xhold56 slte0.opA\[4\] VGND VGND VPWR VPWR net263 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_53_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_20_Left_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2951_ net172 _2196_ VGND VGND VPWR VPWR _2197_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4621_ _1396_ _1398_ VGND VGND VPWR VPWR _1399_ sky130_fd_sc_hd__nand2_1
X_2882_ _2124_ _2125_ _2127_ _2060_ _2128_ VGND VGND VPWR VPWR _2129_ sky130_fd_sc_hd__a32o_1
XFILLER_0_25_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4552_ _1332_ _1333_ VGND VGND VPWR VPWR _1334_ sky130_fd_sc_hd__xor2_1
X_3503_ _0333_ _0337_ VGND VGND VPWR VPWR _0341_ sky130_fd_sc_hd__xor2_1
X_4483_ _1262_ _1270_ VGND VGND VPWR VPWR _1271_ sky130_fd_sc_hd__and2b_1
X_3434_ net136 vec\[0\]\[11\] VGND VGND VPWR VPWR _0272_ sky130_fd_sc_hd__or2_1
X_3365_ net147 _0202_ VGND VGND VPWR VPWR _0203_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3296_ _0120_ _0123_ VGND VGND VPWR VPWR _0139_ sky130_fd_sc_hd__and2b_1
XFILLER_0_57_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5104_ clknet_3_5__leaf_clk _0098_ net206 VGND VGND VPWR VPWR vec\[1\]\[6\] sky130_fd_sc_hd__dfrtp_1
X_5035_ clknet_3_2__leaf_clk _0029_ net198 VGND VGND VPWR VPWR net20 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_11_Left_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4819_ _1580_ _1578_ _1596_ _1482_ VGND VGND VPWR VPWR _1597_ sky130_fd_sc_hd__a31o_1
XFILLER_0_31_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput24 net24 VGND VGND VPWR VPWR cos[14] sky130_fd_sc_hd__clkbuf_4
Xoutput46 net46 VGND VGND VPWR VPWR sin[3] sky130_fd_sc_hd__clkbuf_4
Xoutput35 net35 VGND VGND VPWR VPWR out_valid sky130_fd_sc_hd__buf_2
XPHY_EDGE_ROW_19_Right_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_330 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_1__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_1__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_22_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_28_Right_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3150_ _2389_ _2390_ VGND VGND VPWR VPWR _2391_ sky130_fd_sc_hd__and2_1
X_3081_ _2276_ _2279_ VGND VGND VPWR VPWR _2324_ sky130_fd_sc_hd__nand2_1
XFILLER_0_27_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_37_Right_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3983_ _0813_ _0814_ VGND VGND VPWR VPWR _0815_ sky130_fd_sc_hd__and2_1
XFILLER_0_57_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2934_ _2150_ _2179_ VGND VGND VPWR VPWR _2180_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_17_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2865_ _2082_ net208 VGND VGND VPWR VPWR _2112_ sky130_fd_sc_hd__nor2_1
XFILLER_0_72_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4604_ net155 _1381_ VGND VGND VPWR VPWR _1383_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_46_Right_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4535_ _2199_ _1317_ VGND VGND VPWR VPWR _1318_ sky130_fd_sc_hd__nand2_1
X_2796_ net108 _1983_ _2042_ VGND VGND VPWR VPWR _2043_ sky130_fd_sc_hd__nand3_1
XFILLER_0_4_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4466_ _1254_ _1255_ slte0.opA\[11\] VGND VGND VPWR VPWR _1256_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_68_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3417_ net122 net112 VGND VGND VPWR VPWR _0255_ sky130_fd_sc_hd__xor2_4
X_4397_ _1081_ VGND VGND VPWR VPWR _1193_ sky130_fd_sc_hd__buf_2
X_3348_ net169 _0187_ _0179_ _2198_ VGND VGND VPWR VPWR _0189_ sky130_fd_sc_hd__a31o_1
XFILLER_0_0_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3279_ _0121_ _0122_ VGND VGND VPWR VPWR _0123_ sky130_fd_sc_hd__and2_1
XPHY_EDGE_ROW_55_Right_55 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5018_ clknet_3_7__leaf_clk _0012_ net204 VGND VGND VPWR VPWR net52 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_82_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_64_Right_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_73_Right_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_82_Right_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2650_ net96 _1895_ VGND VGND VPWR VPWR _1897_ sky130_fd_sc_hd__nor2_1
XFILLER_0_81_196 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2581_ _1812_ _1827_ VGND VGND VPWR VPWR _1828_ sky130_fd_sc_hd__and2_1
X_4320_ slte0.opA\[4\] VGND VGND VPWR VPWR _1120_ sky130_fd_sc_hd__inv_2
XFILLER_0_22_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4251_ _1059_ VGND VGND VPWR VPWR _0048_ sky130_fd_sc_hd__clkbuf_1
X_3202_ net81 _2419_ VGND VGND VPWR VPWR _2441_ sky130_fd_sc_hd__nand2_1
X_4182_ _1003_ _0982_ _0993_ VGND VGND VPWR VPWR _1006_ sky130_fd_sc_hd__and3b_1
X_3133_ _2223_ VGND VGND VPWR VPWR _2374_ sky130_fd_sc_hd__inv_2
X_3064_ net66 VGND VGND VPWR VPWR _2307_ sky130_fd_sc_hd__inv_2
XFILLER_0_54_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3966_ _0796_ _0645_ _0797_ VGND VGND VPWR VPWR _0798_ sky130_fd_sc_hd__a21o_1
X_2917_ _2161_ _2162_ VGND VGND VPWR VPWR _2163_ sky130_fd_sc_hd__and2_1
XFILLER_0_72_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3897_ _0726_ _0730_ VGND VGND VPWR VPWR _0731_ sky130_fd_sc_hd__xnor2_2
X_2848_ _1900_ _2092_ _2093_ _2094_ VGND VGND VPWR VPWR _2095_ sky130_fd_sc_hd__a31oi_2
X_2779_ _2022_ _2024_ _2025_ VGND VGND VPWR VPWR _2026_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4518_ _1299_ _1301_ VGND VGND VPWR VPWR _1303_ sky130_fd_sc_hd__or2_1
X_4449_ slte0.opA\[9\] _1240_ VGND VGND VPWR VPWR _1241_ sky130_fd_sc_hd__nand2_2
XFILLER_0_0_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_59_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3820_ _0601_ _0603_ VGND VGND VPWR VPWR _0656_ sky130_fd_sc_hd__nand2_1
XFILLER_0_6_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3751_ net130 net128 _0348_ VGND VGND VPWR VPWR _0588_ sky130_fd_sc_hd__a21o_1
XFILLER_0_82_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2702_ net221 _1947_ VGND VGND VPWR VPWR _1949_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3682_ _0514_ _0519_ VGND VGND VPWR VPWR _0520_ sky130_fd_sc_hd__xor2_1
X_2633_ _1876_ _1878_ _1879_ VGND VGND VPWR VPWR _1880_ sky130_fd_sc_hd__a21oi_2
X_2564_ net86 net79 VGND VGND VPWR VPWR _1811_ sky130_fd_sc_hd__nand2_4
XFILLER_0_2_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4303_ slte0.opA\[10\] VGND VGND VPWR VPWR _1103_ sky130_fd_sc_hd__inv_2
XFILLER_0_10_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4234_ net9 net13 _1042_ VGND VGND VPWR VPWR _1046_ sky130_fd_sc_hd__and3_1
XFILLER_0_65_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4165_ _0989_ _0990_ VGND VGND VPWR VPWR _0991_ sky130_fd_sc_hd__and2b_1
X_3116_ _2300_ _2356_ VGND VGND VPWR VPWR _2358_ sky130_fd_sc_hd__and2_1
X_4096_ _0923_ _0924_ VGND VGND VPWR VPWR _0925_ sky130_fd_sc_hd__and2_1
X_3047_ _2288_ _2290_ VGND VGND VPWR VPWR _2291_ sky130_fd_sc_hd__xor2_1
XFILLER_0_77_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4998_ _1759_ _1777_ _1775_ _1768_ VGND VGND VPWR VPWR _1780_ sky130_fd_sc_hd__o211ai_2
X_3949_ _0743_ _0745_ VGND VGND VPWR VPWR _0782_ sky130_fd_sc_hd__or2_1
XFILLER_0_60_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout92 vec\[1\]\[7\] VGND VGND VPWR VPWR net92 sky130_fd_sc_hd__clkbuf_2
Xfanout81 net84 VGND VGND VPWR VPWR net81 sky130_fd_sc_hd__clkbuf_4
Xfanout70 vec\[1\]\[13\] VGND VGND VPWR VPWR net70 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_3_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4921_ _1678_ _1700_ _1206_ VGND VGND VPWR VPWR _1701_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_59_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4852_ _1629_ _1630_ VGND VGND VPWR VPWR _1631_ sky130_fd_sc_hd__nor2_1
XFILLER_0_74_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3803_ _0636_ _0638_ VGND VGND VPWR VPWR _0639_ sky130_fd_sc_hd__xnor2_2
X_4783_ _1556_ _1557_ net178 VGND VGND VPWR VPWR _1558_ sky130_fd_sc_hd__mux2_1
X_3734_ _0411_ _0571_ VGND VGND VPWR VPWR _0572_ sky130_fd_sc_hd__or2_1
XFILLER_0_55_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3665_ _0498_ _0502_ VGND VGND VPWR VPWR _0503_ sky130_fd_sc_hd__xnor2_1
X_2616_ _1834_ _1843_ VGND VGND VPWR VPWR _1863_ sky130_fd_sc_hd__xnor2_2
X_3596_ _0427_ _0432_ VGND VGND VPWR VPWR _0434_ sky130_fd_sc_hd__nand2_1
X_2547_ _1791_ _1786_ VGND VGND VPWR VPWR _1794_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_55_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4217_ net3 net9 net191 VGND VGND VPWR VPWR _1033_ sky130_fd_sc_hd__a21oi_1
X_4148_ _0922_ _0897_ _0950_ _0973_ _0974_ VGND VGND VPWR VPWR _0975_ sky130_fd_sc_hd__o311a_1
X_4079_ _0906_ _0907_ VGND VGND VPWR VPWR _0908_ sky130_fd_sc_hd__and2_1
XFILLER_0_38_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_38_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3450_ _0286_ _0287_ VGND VGND VPWR VPWR _0288_ sky130_fd_sc_hd__xnor2_2
X_3381_ net154 _0217_ VGND VGND VPWR VPWR _0219_ sky130_fd_sc_hd__nor2_1
X_5051_ clknet_3_0__leaf_clk _0045_ net193 VGND VGND VPWR VPWR slte0.opB\[7\] sky130_fd_sc_hd__dfrtp_1
X_4002_ _0832_ _0271_ net129 VGND VGND VPWR VPWR _0833_ sky130_fd_sc_hd__mux2_1
XFILLER_0_46_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4904_ _1671_ VGND VGND VPWR VPWR _1684_ sky130_fd_sc_hd__inv_2
XFILLER_0_62_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4835_ net104 _1612_ VGND VGND VPWR VPWR _1614_ sky130_fd_sc_hd__nand2_1
X_4766_ _1535_ _1539_ _1542_ VGND VGND VPWR VPWR _1543_ sky130_fd_sc_hd__or3_1
XFILLER_0_7_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3717_ _0209_ _0418_ _0553_ _0554_ VGND VGND VPWR VPWR _0555_ sky130_fd_sc_hd__and4_1
X_4697_ _1473_ _1474_ VGND VGND VPWR VPWR _1475_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3648_ _0455_ _0463_ VGND VGND VPWR VPWR _0486_ sky130_fd_sc_hd__xnor2_1
X_3579_ net159 net153 _0415_ _0416_ VGND VGND VPWR VPWR _0417_ sky130_fd_sc_hd__a31o_1
XFILLER_0_11_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xhold24 net48 VGND VGND VPWR VPWR net231 sky130_fd_sc_hd__dlygate4sd3_1
Xhold35 net23 VGND VGND VPWR VPWR net242 sky130_fd_sc_hd__dlygate4sd3_1
Xhold46 slte0.opA\[17\] VGND VGND VPWR VPWR net253 sky130_fd_sc_hd__dlygate4sd3_1
Xhold57 net28 VGND VGND VPWR VPWR net264 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_66_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2950_ net178 _2195_ VGND VGND VPWR VPWR _2196_ sky130_fd_sc_hd__nor2_2
X_2881_ net108 _1983_ _2042_ _2126_ _2059_ VGND VGND VPWR VPWR _2128_ sky130_fd_sc_hd__a41o_1
XFILLER_0_84_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4620_ _1397_ VGND VGND VPWR VPWR _1398_ sky130_fd_sc_hd__inv_2
X_4551_ slte0.opA\[16\] _1140_ _1316_ _1141_ VGND VGND VPWR VPWR _1333_ sky130_fd_sc_hd__o211a_1
XFILLER_0_52_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4482_ _1098_ _1268_ _1270_ net257 net266 VGND VGND VPWR VPWR _0068_ sky130_fd_sc_hd__a32o_1
X_3502_ net156 _0339_ net164 VGND VGND VPWR VPWR _0340_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_40_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3433_ _0269_ _0270_ VGND VGND VPWR VPWR _0271_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_40_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3364_ net142 net139 VGND VGND VPWR VPWR _0202_ sky130_fd_sc_hd__nand2_1
X_5103_ clknet_3_6__leaf_clk _0097_ net206 VGND VGND VPWR VPWR vec\[1\]\[5\] sky130_fd_sc_hd__dfrtp_1
X_3295_ _2435_ _2493_ _2494_ _0130_ VGND VGND VPWR VPWR _0138_ sky130_fd_sc_hd__or4_1
X_5034_ clknet_3_3__leaf_clk _0028_ net198 VGND VGND VPWR VPWR net34 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_18_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_79_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4818_ _1594_ _1595_ VGND VGND VPWR VPWR _1596_ sky130_fd_sc_hd__or2_1
X_4749_ _1509_ _1513_ _1525_ _1014_ VGND VGND VPWR VPWR _1527_ sky130_fd_sc_hd__o31a_1
Xoutput25 net25 VGND VGND VPWR VPWR cos[15] sky130_fd_sc_hd__clkbuf_4
Xoutput47 net47 VGND VGND VPWR VPWR sin[4] sky130_fd_sc_hd__buf_2
Xoutput36 net36 VGND VGND VPWR VPWR ready sky130_fd_sc_hd__clkbuf_4
XFILLER_0_39_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3080_ _2302_ _2322_ VGND VGND VPWR VPWR _2323_ sky130_fd_sc_hd__xnor2_1
X_3982_ net143 _0811_ _0812_ VGND VGND VPWR VPWR _0814_ sky130_fd_sc_hd__or3_1
X_2933_ _2176_ _2178_ VGND VGND VPWR VPWR _2179_ sky130_fd_sc_hd__xor2_1
XFILLER_0_72_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_334 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2864_ net268 _2104_ _2109_ _2110_ VGND VGND VPWR VPWR _2111_ sky130_fd_sc_hd__a31o_1
XFILLER_0_4_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4603_ net155 _1381_ VGND VGND VPWR VPWR _1382_ sky130_fd_sc_hd__nand2_1
X_2795_ _1953_ _2041_ VGND VGND VPWR VPWR _2042_ sky130_fd_sc_hd__xor2_2
X_4534_ _1431_ _1315_ net165 VGND VGND VPWR VPWR _1317_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_13_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4465_ _1157_ _1195_ _1238_ VGND VGND VPWR VPWR _1255_ sky130_fd_sc_hd__o21a_1
XFILLER_0_0_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3416_ vec\[0\]\[14\] net119 VGND VGND VPWR VPWR _0254_ sky130_fd_sc_hd__nand2_2
X_4396_ _1186_ _1190_ VGND VGND VPWR VPWR _1192_ sky130_fd_sc_hd__nand2_1
X_3347_ net169 _0179_ _0187_ VGND VGND VPWR VPWR _0188_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_84_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5017_ clknet_3_7__leaf_clk _0011_ net204 VGND VGND VPWR VPWR net51 sky130_fd_sc_hd__dfrtp_1
X_3278_ net73 _2334_ _2474_ VGND VGND VPWR VPWR _0122_ sky130_fd_sc_hd__or3_1
XFILLER_0_75_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2580_ net74 net72 VGND VGND VPWR VPWR _1827_ sky130_fd_sc_hd__or2_1
X_4250_ slte0.opB\[10\] _1058_ _1031_ VGND VGND VPWR VPWR _1059_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3201_ _2369_ _2403_ _2439_ net167 VGND VGND VPWR VPWR _2440_ sky130_fd_sc_hd__o31a_1
X_4181_ net242 _2248_ _1005_ net265 VGND VGND VPWR VPWR _0032_ sky130_fd_sc_hd__a22o_1
X_3132_ _2372_ _1854_ net74 VGND VGND VPWR VPWR _2373_ sky130_fd_sc_hd__mux2_1
X_3063_ _2165_ _2305_ VGND VGND VPWR VPWR _2306_ sky130_fd_sc_hd__xor2_1
X_3965_ net126 net121 _0259_ VGND VGND VPWR VPWR _0797_ sky130_fd_sc_hd__a21oi_1
X_2916_ net70 net65 VGND VGND VPWR VPWR _2162_ sky130_fd_sc_hd__or2_1
XFILLER_0_72_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3896_ _0686_ _0690_ _0729_ VGND VGND VPWR VPWR _0730_ sky130_fd_sc_hd__a21oi_2
X_2847_ net105 net100 _1685_ VGND VGND VPWR VPWR _2094_ sky130_fd_sc_hd__and3_1
XFILLER_0_85_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2778_ net93 net87 _1787_ VGND VGND VPWR VPWR _2025_ sky130_fd_sc_hd__and3_1
XFILLER_0_13_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4517_ _1299_ _1301_ VGND VGND VPWR VPWR _1302_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4448_ _1238_ _1182_ _1239_ VGND VGND VPWR VPWR _1240_ sky130_fd_sc_hd__mux2_1
X_4379_ _1161_ _1167_ VGND VGND VPWR VPWR _1177_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3750_ _0585_ _0586_ VGND VGND VPWR VPWR _0587_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2701_ net213 _1947_ VGND VGND VPWR VPWR _1948_ sky130_fd_sc_hd__or2b_1
X_3681_ _0517_ _0518_ VGND VGND VPWR VPWR _0519_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_54_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2632_ net80 net73 _1874_ VGND VGND VPWR VPWR _1879_ sky130_fd_sc_hd__and3_1
X_2563_ _1799_ _1809_ VGND VGND VPWR VPWR _1810_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_2_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4302_ slte0.opA\[11\] VGND VGND VPWR VPWR _1102_ sky130_fd_sc_hd__inv_2
X_4233_ net252 _1442_ _1044_ _1045_ VGND VGND VPWR VPWR _0044_ sky130_fd_sc_hd__a22o_1
XFILLER_0_4_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4164_ _0962_ _0966_ _0988_ VGND VGND VPWR VPWR _0990_ sky130_fd_sc_hd__or3_1
X_3115_ _2300_ _2356_ VGND VGND VPWR VPWR _2357_ sky130_fd_sc_hd__nor2_1
X_4095_ _0922_ _0894_ _0897_ VGND VGND VPWR VPWR _0924_ sky130_fd_sc_hd__nand3_1
X_3046_ _2187_ _2191_ _2244_ _2289_ VGND VGND VPWR VPWR _2290_ sky130_fd_sc_hd__a31o_4
XFILLER_0_81_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4997_ _1775_ _1778_ VGND VGND VPWR VPWR _1779_ sky130_fd_sc_hd__or2_1
X_3948_ _0779_ _0780_ VGND VGND VPWR VPWR _0781_ sky130_fd_sc_hd__nor2_1
XFILLER_0_18_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3879_ net264 _2143_ _0713_ _1532_ VGND VGND VPWR VPWR _0022_ sky130_fd_sc_hd__a22o_1
XFILLER_0_33_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout60 net61 VGND VGND VPWR VPWR net60 sky130_fd_sc_hd__clkbuf_4
Xfanout82 net84 VGND VGND VPWR VPWR net82 sky130_fd_sc_hd__buf_2
Xfanout71 net73 VGND VGND VPWR VPWR net71 sky130_fd_sc_hd__buf_2
XFILLER_0_24_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_24_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout93 net94 VGND VGND VPWR VPWR net93 sky130_fd_sc_hd__buf_4
XFILLER_0_36_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4920_ _1677_ _1689_ VGND VGND VPWR VPWR _1700_ sky130_fd_sc_hd__or2_1
X_4851_ net217 _1627_ VGND VGND VPWR VPWR _1630_ sky130_fd_sc_hd__nor2_1
X_3802_ net144 _0430_ _0637_ VGND VGND VPWR VPWR _0638_ sky130_fd_sc_hd__a21o_1
XFILLER_0_51_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4782_ net123 net120 net182 VGND VGND VPWR VPWR _1557_ sky130_fd_sc_hd__mux2_1
XFILLER_0_55_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3733_ _0410_ _0405_ _0409_ VGND VGND VPWR VPWR _0571_ sky130_fd_sc_hd__and3_1
XFILLER_0_42_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3664_ _0207_ _0500_ _0501_ VGND VGND VPWR VPWR _0502_ sky130_fd_sc_hd__a21oi_1
X_2615_ _1851_ _1860_ _1861_ VGND VGND VPWR VPWR _1862_ sky130_fd_sc_hd__a21oi_2
X_3595_ _0427_ _0432_ VGND VGND VPWR VPWR _0433_ sky130_fd_sc_hd__xor2_2
X_2546_ net96 net214 net102 VGND VGND VPWR VPWR _1793_ sky130_fd_sc_hd__o21ai_2
X_4216_ _1032_ VGND VGND VPWR VPWR _0040_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4147_ _0947_ _0949_ VGND VGND VPWR VPWR _0974_ sky130_fd_sc_hd__nand2_1
X_4078_ _0645_ _0905_ VGND VGND VPWR VPWR _0907_ sky130_fd_sc_hd__nand2_1
X_3029_ _2226_ _2264_ _2272_ VGND VGND VPWR VPWR _2273_ sky130_fd_sc_hd__o21a_1
XFILLER_0_65_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3380_ _0216_ _0217_ VGND VGND VPWR VPWR _0218_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_20_384 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5050_ clknet_3_0__leaf_clk _0044_ net193 VGND VGND VPWR VPWR slte0.opB\[6\] sky130_fd_sc_hd__dfrtp_1
X_4001_ _0269_ VGND VGND VPWR VPWR _0832_ sky130_fd_sc_hd__inv_2
XFILLER_0_79_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_46_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4903_ _1681_ _1682_ VGND VGND VPWR VPWR _1683_ sky130_fd_sc_hd__and2_1
XFILLER_0_62_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4834_ _1609_ _1611_ VGND VGND VPWR VPWR _1612_ sky130_fd_sc_hd__xnor2_1
X_4765_ _1540_ _1541_ VGND VGND VPWR VPWR _1542_ sky130_fd_sc_hd__xnor2_1
X_3716_ net150 net142 net145 net153 VGND VGND VPWR VPWR _0554_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_55_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4696_ net132 _1471_ VGND VGND VPWR VPWR _1474_ sky130_fd_sc_hd__nand2_1
XFILLER_0_30_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_476 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3647_ _0477_ net211 _0484_ VGND VGND VPWR VPWR _0485_ sky130_fd_sc_hd__a21oi_1
X_3578_ net156 _0414_ VGND VGND VPWR VPWR _0416_ sky130_fd_sc_hd__nor2_1
X_2529_ net103 net96 VGND VGND VPWR VPWR _1685_ sky130_fd_sc_hd__xor2_4
Xhold36 net50 VGND VGND VPWR VPWR net243 sky130_fd_sc_hd__dlygate4sd3_1
Xhold25 net40 VGND VGND VPWR VPWR net232 sky130_fd_sc_hd__dlygate4sd3_1
Xhold47 slte0.opA\[2\] VGND VGND VPWR VPWR net254 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_78_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2880_ _2043_ _2126_ VGND VGND VPWR VPWR _2127_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_37_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4550_ _1193_ _1323_ _1330_ _1331_ VGND VGND VPWR VPWR _1332_ sky130_fd_sc_hd__a31o_1
XFILLER_0_12_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4481_ _1252_ _1266_ _1269_ _1257_ VGND VGND VPWR VPWR _1270_ sky130_fd_sc_hd__o211ai_4
X_3501_ _0334_ _0338_ VGND VGND VPWR VPWR _0339_ sky130_fd_sc_hd__and2_1
XFILLER_0_52_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3432_ net129 net125 VGND VGND VPWR VPWR _0270_ sky130_fd_sc_hd__nand2_2
X_3363_ net142 net139 _0200_ VGND VGND VPWR VPWR _0201_ sky130_fd_sc_hd__a21o_1
X_5102_ clknet_3_6__leaf_clk _0096_ net206 VGND VGND VPWR VPWR vec\[1\]\[4\] sky130_fd_sc_hd__dfrtp_1
X_3294_ _2493_ _2498_ _0130_ _0136_ VGND VGND VPWR VPWR _0137_ sky130_fd_sc_hd__o31a_1
X_5033_ clknet_3_2__leaf_clk _0027_ net198 VGND VGND VPWR VPWR net33 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_73_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4817_ net107 _1593_ VGND VGND VPWR VPWR _1595_ sky130_fd_sc_hd__nor2_1
XFILLER_0_16_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4748_ _1509_ _1513_ _1525_ VGND VGND VPWR VPWR _1526_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_43_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4679_ _1219_ _1341_ VGND VGND VPWR VPWR _1456_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_1_Right_1 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xoutput48 net48 VGND VGND VPWR VPWR sin[5] sky130_fd_sc_hd__clkbuf_4
Xoutput26 net26 VGND VGND VPWR VPWR cos[1] sky130_fd_sc_hd__clkbuf_4
Xoutput37 net37 VGND VGND VPWR VPWR sin[0] sky130_fd_sc_hd__buf_2
XFILLER_0_85_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_402 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3981_ _0811_ _0812_ net143 VGND VGND VPWR VPWR _0813_ sky130_fd_sc_hd__o21ai_2
X_2932_ _1810_ _1846_ _2177_ VGND VGND VPWR VPWR _2178_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_45_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2863_ _2092_ _2108_ _2107_ VGND VGND VPWR VPWR _2110_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_4_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4602_ _1379_ _1380_ VGND VGND VPWR VPWR _1381_ sky130_fd_sc_hd__nand2_1
X_2794_ net104 net99 VGND VGND VPWR VPWR _2041_ sky130_fd_sc_hd__and2_2
XFILLER_0_7_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4533_ _1315_ VGND VGND VPWR VPWR _1316_ sky130_fd_sc_hd__inv_2
XFILLER_0_13_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4464_ _1157_ _1229_ VGND VGND VPWR VPWR _1254_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3415_ _0251_ _0252_ VGND VGND VPWR VPWR _0253_ sky130_fd_sc_hd__and2_1
X_4395_ _1098_ _1189_ _1190_ net263 net266 VGND VGND VPWR VPWR _0060_ sky130_fd_sc_hd__a32o_1
XFILLER_0_40_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3346_ _0180_ _0186_ VGND VGND VPWR VPWR _0187_ sky130_fd_sc_hd__xor2_2
X_5016_ clknet_3_7__leaf_clk _0010_ net205 VGND VGND VPWR VPWR net50 sky130_fd_sc_hd__dfrtp_1
X_3277_ _2334_ _2474_ net73 VGND VGND VPWR VPWR _0121_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_30_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_17_Left_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_27_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_26_Left_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3200_ _2436_ VGND VGND VPWR VPWR _2439_ sky130_fd_sc_hd__inv_2
X_4180_ _1003_ _1004_ VGND VGND VPWR VPWR _1005_ sky130_fd_sc_hd__xnor2_1
X_3131_ _1852_ VGND VGND VPWR VPWR _2372_ sky130_fd_sc_hd__inv_2
X_3062_ _1836_ _2304_ VGND VGND VPWR VPWR _2305_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_77_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_35_Left_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3964_ _0258_ _0259_ VGND VGND VPWR VPWR _0796_ sky130_fd_sc_hd__or2b_1
XFILLER_0_45_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2915_ net69 net65 VGND VGND VPWR VPWR _2161_ sky130_fd_sc_hd__nand2_2
X_3895_ _0728_ net112 net118 net122 VGND VGND VPWR VPWR _0729_ sky130_fd_sc_hd__and4b_2
XFILLER_0_45_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2846_ vec\[1\]\[0\] net108 VGND VGND VPWR VPWR _2093_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_44_Left_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2777_ _2012_ _2023_ VGND VGND VPWR VPWR _2024_ sky130_fd_sc_hd__and2_1
XFILLER_0_13_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4516_ _1281_ _1288_ _1300_ _1291_ VGND VGND VPWR VPWR _1301_ sky130_fd_sc_hd__a31o_1
X_4447_ _1157_ _1220_ VGND VGND VPWR VPWR _1239_ sky130_fd_sc_hd__nor2_1
X_4378_ _1161_ _1167_ _1175_ VGND VGND VPWR VPWR _1176_ sky130_fd_sc_hd__a21bo_1
X_3329_ _0147_ _0162_ _0170_ VGND VGND VPWR VPWR _0171_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_76_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2700_ net93 net91 VGND VGND VPWR VPWR _1947_ sky130_fd_sc_hd__nand2_1
XFILLER_0_82_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3680_ _0477_ _0483_ VGND VGND VPWR VPWR _0518_ sky130_fd_sc_hd__xor2_1
XFILLER_0_2_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2631_ _1592_ _1877_ VGND VGND VPWR VPWR _1878_ sky130_fd_sc_hd__and2_1
X_2562_ _1804_ _1808_ VGND VGND VPWR VPWR _1809_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_10_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4301_ slte0.opB\[13\] _1099_ slte0.opB\[12\] _1100_ VGND VGND VPWR VPWR _1101_ sky130_fd_sc_hd__a22oi_2
XFILLER_0_49_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4232_ net191 net13 _1043_ _1031_ VGND VGND VPWR VPWR _1045_ sky130_fd_sc_hd__o31a_1
X_4163_ _0962_ _0966_ _0988_ VGND VGND VPWR VPWR _0989_ sky130_fd_sc_hd__o21a_1
XFILLER_0_4_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3114_ _2353_ _2355_ VGND VGND VPWR VPWR _2356_ sky130_fd_sc_hd__xnor2_1
X_4094_ _0894_ _0897_ _0922_ VGND VGND VPWR VPWR _0923_ sky130_fd_sc_hd__a21o_1
X_3045_ _2185_ _2242_ _2243_ VGND VGND VPWR VPWR _2289_ sky130_fd_sc_hd__a21boi_1
X_4996_ _1759_ _1777_ _1768_ VGND VGND VPWR VPWR _1778_ sky130_fd_sc_hd__o21a_1
X_3947_ _0719_ _0778_ VGND VGND VPWR VPWR _0780_ sky130_fd_sc_hd__and2_1
XFILLER_0_58_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3878_ _0710_ _0712_ VGND VGND VPWR VPWR _0713_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_18_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_251 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2829_ _1806_ _2047_ VGND VGND VPWR VPWR _2076_ sky130_fd_sc_hd__xor2_2
XFILLER_0_49_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout61 vec\[1\]\[16\] VGND VGND VPWR VPWR net61 sky130_fd_sc_hd__buf_2
Xfanout72 net73 VGND VGND VPWR VPWR net72 sky130_fd_sc_hd__clkbuf_4
Xfanout83 net84 VGND VGND VPWR VPWR net83 sky130_fd_sc_hd__buf_2
XFILLER_0_64_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout94 vec\[1\]\[6\] VGND VGND VPWR VPWR net94 sky130_fd_sc_hd__buf_4
XFILLER_0_10_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xclkbuf_3_7__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_7__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_51_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4850_ _1628_ VGND VGND VPWR VPWR _1629_ sky130_fd_sc_hd__inv_2
XFILLER_0_7_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3801_ net145 _0235_ VGND VGND VPWR VPWR _0637_ sky130_fd_sc_hd__nor2_1
XFILLER_0_27_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4781_ net127 net125 net182 VGND VGND VPWR VPWR _1556_ sky130_fd_sc_hd__mux2_1
XFILLER_0_27_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3732_ _0561_ _0565_ _0567_ _0568_ _0569_ VGND VGND VPWR VPWR _0570_ sky130_fd_sc_hd__a311o_1
X_3663_ net157 net151 _0205_ VGND VGND VPWR VPWR _0501_ sky130_fd_sc_hd__and3_1
XFILLER_0_70_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2614_ _1858_ _1859_ VGND VGND VPWR VPWR _1861_ sky130_fd_sc_hd__and2b_1
XFILLER_0_23_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3594_ _0414_ _0428_ _0430_ _0431_ VGND VGND VPWR VPWR _0432_ sky130_fd_sc_hd__a31o_1
XFILLER_0_50_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2545_ _1786_ _1791_ VGND VGND VPWR VPWR _1792_ sky130_fd_sc_hd__and2b_1
X_4215_ slte0.opB\[2\] _1030_ _1031_ VGND VGND VPWR VPWR _1032_ sky130_fd_sc_hd__mux2_1
X_4146_ _0947_ _0949_ _0920_ VGND VGND VPWR VPWR _0973_ sky130_fd_sc_hd__o21bai_1
X_4077_ _0645_ _0905_ VGND VGND VPWR VPWR _0906_ sky130_fd_sc_hd__or2_1
X_3028_ _2267_ _2271_ VGND VGND VPWR VPWR _2272_ sky130_fd_sc_hd__xor2_1
X_4979_ _1600_ _1194_ net114 _1517_ VGND VGND VPWR VPWR _1760_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_46_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4000_ net121 _0254_ _0687_ VGND VGND VPWR VPWR _0831_ sky130_fd_sc_hd__a21o_1
XFILLER_0_46_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4902_ net85 _1680_ VGND VGND VPWR VPWR _1682_ sky130_fd_sc_hd__or2_1
XFILLER_0_7_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4833_ _1179_ _1610_ VGND VGND VPWR VPWR _1611_ sky130_fd_sc_hd__or2b_1
XFILLER_0_28_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4764_ _1518_ _1519_ _1530_ _1272_ VGND VGND VPWR VPWR _1541_ sky130_fd_sc_hd__a31o_1
XFILLER_0_43_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_43_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3715_ net147 _0456_ _0552_ VGND VGND VPWR VPWR _0553_ sky130_fd_sc_hd__a21o_1
XFILLER_0_43_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4695_ net132 _1471_ VGND VGND VPWR VPWR _1473_ sky130_fd_sc_hd__or2_1
X_3646_ _0481_ _0482_ VGND VGND VPWR VPWR _0484_ sky130_fd_sc_hd__nor2_1
X_3577_ _0210_ _0414_ VGND VGND VPWR VPWR _0415_ sky130_fd_sc_hd__or2b_1
XFILLER_0_60_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2528_ _1613_ _1664_ VGND VGND VPWR VPWR _1675_ sky130_fd_sc_hd__and2_1
Xhold37 net46 VGND VGND VPWR VPWR net244 sky130_fd_sc_hd__dlygate4sd3_1
Xhold26 net22 VGND VGND VPWR VPWR net233 sky130_fd_sc_hd__dlygate4sd3_1
Xhold15 net25 VGND VGND VPWR VPWR net222 sky130_fd_sc_hd__dlygate4sd3_1
Xhold48 slte0.opA\[14\] VGND VGND VPWR VPWR net255 sky130_fd_sc_hd__dlygate4sd3_1
X_4129_ _0865_ _0728_ net126 VGND VGND VPWR VPWR _0956_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_16_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3500_ net159 net153 VGND VGND VPWR VPWR _0338_ sky130_fd_sc_hd__or2_1
X_4480_ _1264_ VGND VGND VPWR VPWR _1269_ sky130_fd_sc_hd__inv_2
XFILLER_0_12_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3431_ net126 net123 VGND VGND VPWR VPWR _0269_ sky130_fd_sc_hd__xor2_4
X_3362_ net147 net142 VGND VGND VPWR VPWR _0200_ sky130_fd_sc_hd__xor2_4
X_5101_ clknet_3_6__leaf_clk _0095_ net206 VGND VGND VPWR VPWR vec\[1\]\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_57_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3293_ _0127_ _0129_ _0135_ VGND VGND VPWR VPWR _0136_ sky130_fd_sc_hd__a21oi_1
X_5032_ clknet_3_2__leaf_clk _0026_ net200 VGND VGND VPWR VPWR net32 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4816_ net107 _1593_ VGND VGND VPWR VPWR _1594_ sky130_fd_sc_hd__and2_1
XFILLER_0_7_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_187 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4747_ _1523_ _1524_ VGND VGND VPWR VPWR _1525_ sky130_fd_sc_hd__or2_1
X_4678_ _1453_ _1454_ _1455_ VGND VGND VPWR VPWR _0083_ sky130_fd_sc_hd__o21a_1
X_3629_ _0465_ _0466_ VGND VGND VPWR VPWR _0467_ sky130_fd_sc_hd__xnor2_1
Xoutput49 net49 VGND VGND VPWR VPWR sin[6] sky130_fd_sc_hd__clkbuf_4
Xoutput38 net38 VGND VGND VPWR VPWR sin[10] sky130_fd_sc_hd__clkbuf_4
Xoutput27 net27 VGND VGND VPWR VPWR cos[2] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_66_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3980_ _0759_ _0764_ VGND VGND VPWR VPWR _0812_ sky130_fd_sc_hd__and2b_1
XFILLER_0_69_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2931_ _1832_ _1845_ VGND VGND VPWR VPWR _2177_ sky130_fd_sc_hd__or2_1
XFILLER_0_57_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_0_clk clk VGND VGND VPWR VPWR clknet_0_clk sky130_fd_sc_hd__clkbuf_16
X_4601_ _1363_ _1378_ _1374_ _1179_ VGND VGND VPWR VPWR _1380_ sky130_fd_sc_hd__a211o_1
X_2862_ _2107_ _2108_ _2092_ VGND VGND VPWR VPWR _2109_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_72_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2793_ _2018_ _2038_ _2039_ VGND VGND VPWR VPWR _2040_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_80_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4532_ _1081_ _0116_ _2196_ _1311_ _1314_ VGND VGND VPWR VPWR _1315_ sky130_fd_sc_hd__o311a_2
X_4463_ slte0.opA\[10\] _1248_ _1252_ VGND VGND VPWR VPWR _1253_ sky130_fd_sc_hd__a21o_1
XFILLER_0_40_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3414_ net130 net128 VGND VGND VPWR VPWR _0252_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_15_Right_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4394_ _1431_ VGND VGND VPWR VPWR _1191_ sky130_fd_sc_hd__buf_1
X_3345_ _0184_ _0185_ VGND VGND VPWR VPWR _0186_ sky130_fd_sc_hd__and2b_1
X_3276_ _0118_ _0119_ VGND VGND VPWR VPWR _0120_ sky130_fd_sc_hd__or2b_1
X_5015_ clknet_3_7__leaf_clk _0009_ net204 VGND VGND VPWR VPWR net49 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_84_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_24_Right_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_33_Right_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_42_Right_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_51_Right_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3130_ net73 _1874_ net78 VGND VGND VPWR VPWR _2371_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_38_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_60_Right_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3061_ _1835_ _2303_ VGND VGND VPWR VPWR _2304_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_77_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3963_ _0794_ _0288_ net132 VGND VGND VPWR VPWR _0795_ sky130_fd_sc_hd__mux2_1
X_3894_ net118 _0255_ _0727_ _0687_ net124 VGND VGND VPWR VPWR _0728_ sky130_fd_sc_hd__o221a_1
X_2914_ _1914_ _2159_ VGND VGND VPWR VPWR _2160_ sky130_fd_sc_hd__xnor2_2
X_2845_ vec\[1\]\[0\] net109 VGND VGND VPWR VPWR _2092_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4515_ _1131_ _1289_ VGND VGND VPWR VPWR _1300_ sky130_fd_sc_hd__or2_1
X_2776_ net99 net97 VGND VGND VPWR VPWR _2023_ sky130_fd_sc_hd__or2_1
XFILLER_0_79_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4446_ _1218_ VGND VGND VPWR VPWR _1238_ sky130_fd_sc_hd__buf_2
X_4377_ _1173_ _1174_ VGND VGND VPWR VPWR _1175_ sky130_fd_sc_hd__and2_1
X_3328_ _0168_ _0169_ VGND VGND VPWR VPWR _0170_ sky130_fd_sc_hd__or2_1
X_3259_ _2463_ _2495_ _2496_ VGND VGND VPWR VPWR _2497_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_68_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2630_ net87 net83 VGND VGND VPWR VPWR _1877_ sky130_fd_sc_hd__or2_1
XFILLER_0_49_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2561_ net97 _1571_ _1807_ VGND VGND VPWR VPWR _1808_ sky130_fd_sc_hd__o21a_1
XFILLER_0_2_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4300_ slte0.opA\[12\] VGND VGND VPWR VPWR _1100_ sky130_fd_sc_hd__inv_2
XFILLER_0_50_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4231_ net191 _1043_ net13 VGND VGND VPWR VPWR _1044_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_10_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4162_ _0986_ _0987_ VGND VGND VPWR VPWR _0988_ sky130_fd_sc_hd__nor2_1
X_3113_ _2302_ _2322_ _2354_ VGND VGND VPWR VPWR _2355_ sky130_fd_sc_hd__a21o_1
XFILLER_0_65_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4093_ _0920_ _0921_ VGND VGND VPWR VPWR _0922_ sky130_fd_sc_hd__nand2_1
X_3044_ _2286_ _2287_ VGND VGND VPWR VPWR _2288_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4995_ _1754_ _1767_ VGND VGND VPWR VPWR _1777_ sky130_fd_sc_hd__nand2_1
X_3946_ _0719_ _0778_ VGND VGND VPWR VPWR _0779_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3877_ _0711_ _0666_ _0626_ VGND VGND VPWR VPWR _0712_ sky130_fd_sc_hd__a21oi_1
X_2828_ _1766_ _2065_ _2074_ VGND VGND VPWR VPWR _2075_ sky130_fd_sc_hd__a21o_1
X_2759_ _1997_ _2004_ _2005_ VGND VGND VPWR VPWR _2006_ sky130_fd_sc_hd__a21boi_2
X_4429_ slte0.opA\[7\] _1222_ VGND VGND VPWR VPWR _1223_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout62 net63 VGND VGND VPWR VPWR net62 sky130_fd_sc_hd__buf_4
Xfanout73 vec\[1\]\[12\] VGND VGND VPWR VPWR net73 sky130_fd_sc_hd__buf_4
Xfanout95 vec\[1\]\[6\] VGND VGND VPWR VPWR net95 sky130_fd_sc_hd__buf_2
Xfanout84 vec\[1\]\[9\] VGND VGND VPWR VPWR net84 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_20_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_63_Left_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_72_Left_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3800_ net138 net134 _0588_ _0635_ VGND VGND VPWR VPWR _0636_ sky130_fd_sc_hd__a31o_1
X_4780_ _1152_ net111 _1015_ _1555_ VGND VGND VPWR VPWR _0092_ sky130_fd_sc_hd__a22o_1
XFILLER_0_55_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3731_ _0444_ _0440_ _0443_ VGND VGND VPWR VPWR _0569_ sky130_fd_sc_hd__and3_1
XFILLER_0_27_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3662_ _0494_ _0499_ VGND VGND VPWR VPWR _0500_ sky130_fd_sc_hd__nand2_1
X_2613_ _1858_ _1859_ VGND VGND VPWR VPWR _1860_ sky130_fd_sc_hd__xnor2_2
X_3593_ net145 net139 _0235_ VGND VGND VPWR VPWR _0431_ sky130_fd_sc_hd__and3_1
X_2544_ net93 net87 _1788_ _1790_ VGND VGND VPWR VPWR _1791_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_81_Left_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4214_ _2141_ VGND VGND VPWR VPWR _1031_ sky130_fd_sc_hd__clkbuf_4
X_4145_ _0970_ _0971_ VGND VGND VPWR VPWR _0972_ sky130_fd_sc_hd__or2_1
XFILLER_0_78_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4076_ _0901_ _0904_ VGND VGND VPWR VPWR _0905_ sky130_fd_sc_hd__xnor2_1
X_3027_ net60 _2268_ _2269_ _2270_ VGND VGND VPWR VPWR _2271_ sky130_fd_sc_hd__a31oi_2
XFILLER_0_46_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4978_ _1482_ _1758_ _1759_ _2307_ net188 VGND VGND VPWR VPWR _0106_ sky130_fd_sc_hd__o32ai_1
X_3929_ _0307_ VGND VGND VPWR VPWR _0762_ sky130_fd_sc_hd__inv_2
XFILLER_0_33_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_3_Left_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4901_ net85 _1680_ VGND VGND VPWR VPWR _1681_ sky130_fd_sc_hd__nand2_1
X_4832_ _1589_ _1590_ VGND VGND VPWR VPWR _1610_ sky130_fd_sc_hd__nand2_1
X_4763_ net55 net114 VGND VGND VPWR VPWR _1540_ sky130_fd_sc_hd__xnor2_2
X_3714_ net147 _0221_ VGND VGND VPWR VPWR _0552_ sky130_fd_sc_hd__nor2_1
X_4694_ _1469_ _1470_ VGND VGND VPWR VPWR _1471_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_55_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3645_ _0481_ _0482_ VGND VGND VPWR VPWR _0483_ sky130_fd_sc_hd__xor2_1
XFILLER_0_23_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3576_ net151 net147 VGND VGND VPWR VPWR _0414_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2527_ net102 _1644_ _1654_ VGND VGND VPWR VPWR _1664_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_53_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold27 net42 VGND VGND VPWR VPWR net234 sky130_fd_sc_hd__dlygate4sd3_1
Xhold38 net52 VGND VGND VPWR VPWR net245 sky130_fd_sc_hd__dlygate4sd3_1
Xhold16 net20 VGND VGND VPWR VPWR net223 sky130_fd_sc_hd__dlygate4sd3_1
Xhold49 slte0.opA\[1\] VGND VGND VPWR VPWR net256 sky130_fd_sc_hd__dlygate4sd3_1
X_4128_ _0939_ _0943_ VGND VGND VPWR VPWR _0955_ sky130_fd_sc_hd__or2b_1
X_4059_ _0886_ _0888_ VGND VGND VPWR VPWR _0889_ sky130_fd_sc_hd__xor2_1
XFILLER_0_19_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_283 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3430_ _0237_ _0267_ VGND VGND VPWR VPWR _0268_ sky130_fd_sc_hd__nor2_1
XFILLER_0_40_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3361_ net164 VGND VGND VPWR VPWR _0199_ sky130_fd_sc_hd__inv_2
X_5100_ clknet_3_6__leaf_clk _0094_ net206 VGND VGND VPWR VPWR vec\[1\]\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_57_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3292_ _2485_ _0128_ _0127_ _2490_ _2488_ VGND VGND VPWR VPWR _0135_ sky130_fd_sc_hd__o311a_1
X_5031_ clknet_3_2__leaf_clk _0025_ net198 VGND VGND VPWR VPWR net31 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4815_ _1589_ _1591_ VGND VGND VPWR VPWR _1593_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4746_ net123 _1521_ VGND VGND VPWR VPWR _1524_ sky130_fd_sc_hd__and2_1
X_4677_ net189 net140 VGND VGND VPWR VPWR _1455_ sky130_fd_sc_hd__or2_1
X_3628_ _0426_ _0433_ VGND VGND VPWR VPWR _0466_ sky130_fd_sc_hd__xnor2_1
Xoutput39 net39 VGND VGND VPWR VPWR sin[11] sky130_fd_sc_hd__clkbuf_4
Xoutput28 net28 VGND VGND VPWR VPWR cos[3] sky130_fd_sc_hd__buf_2
X_3559_ net141 net137 _0247_ VGND VGND VPWR VPWR _0397_ sky130_fd_sc_hd__and3_1
XFILLER_0_85_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_6_Left_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2930_ _2157_ _2175_ VGND VGND VPWR VPWR _2176_ sky130_fd_sc_hd__xor2_1
XFILLER_0_84_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4600_ _1179_ _1374_ _1378_ _1363_ VGND VGND VPWR VPWR _1379_ sky130_fd_sc_hd__o211ai_1
X_2861_ _2106_ _2105_ _2097_ VGND VGND VPWR VPWR _2108_ sky130_fd_sc_hd__and3_1
X_2792_ _2035_ _2037_ VGND VGND VPWR VPWR _2039_ sky130_fd_sc_hd__or2b_1
XFILLER_0_4_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4531_ _1081_ _1312_ _1313_ VGND VGND VPWR VPWR _1314_ sky130_fd_sc_hd__or3b_1
X_4462_ _1251_ _1252_ slte0.opA\[10\] _1168_ VGND VGND VPWR VPWR _0066_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_40_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3413_ net130 net128 VGND VGND VPWR VPWR _0251_ sky130_fd_sc_hd__nand2_1
XFILLER_0_68_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4393_ _1173_ _1176_ _1188_ VGND VGND VPWR VPWR _1190_ sky130_fd_sc_hd__a21o_1
X_3344_ _0181_ _0169_ _0183_ VGND VGND VPWR VPWR _0185_ sky130_fd_sc_hd__or3b_1
X_3275_ _0115_ _0117_ VGND VGND VPWR VPWR _0119_ sky130_fd_sc_hd__nand2_1
XFILLER_0_84_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5014_ clknet_3_7__leaf_clk _0008_ net205 VGND VGND VPWR VPWR net48 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_75_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_71_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4729_ _1481_ _1480_ VGND VGND VPWR VPWR _1506_ sky130_fd_sc_hd__nand2_1
XFILLER_0_16_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3060_ net64 net60 VGND VGND VPWR VPWR _2303_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3962_ _0286_ VGND VGND VPWR VPWR _0794_ sky130_fd_sc_hd__inv_2
XFILLER_0_57_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3893_ net118 net112 VGND VGND VPWR VPWR _0727_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_45_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2913_ net77 _1817_ _2158_ VGND VGND VPWR VPWR _2159_ sky130_fd_sc_hd__o21a_1
XFILLER_0_70_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2844_ _1644_ _2068_ VGND VGND VPWR VPWR _2091_ sky130_fd_sc_hd__xor2_2
XFILLER_0_13_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4514_ _1296_ _1141_ slte0.opA\[16\] _1298_ VGND VGND VPWR VPWR _1299_ sky130_fd_sc_hd__a31o_1
XFILLER_0_53_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2775_ _1849_ _1787_ VGND VGND VPWR VPWR _2022_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4445_ _1098_ _1236_ _1237_ net246 net266 VGND VGND VPWR VPWR _0064_ sky130_fd_sc_hd__a32o_1
X_4376_ slte0.opA\[3\] _1172_ VGND VGND VPWR VPWR _1174_ sky130_fd_sc_hd__or2_1
X_3327_ _0163_ _0167_ VGND VGND VPWR VPWR _0169_ sky130_fd_sc_hd__nor2_1
X_3258_ _2460_ _2461_ VGND VGND VPWR VPWR _2496_ sky130_fd_sc_hd__and2b_1
X_3189_ _2350_ _2396_ _2428_ VGND VGND VPWR VPWR _2429_ sky130_fd_sc_hd__o21a_1
XFILLER_0_48_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_51_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_27_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2560_ net97 _1806_ VGND VGND VPWR VPWR _1807_ sky130_fd_sc_hd__nand2_1
XFILLER_0_50_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4230_ net9 _1042_ VGND VGND VPWR VPWR _1043_ sky130_fd_sc_hd__and2_1
X_4161_ _0956_ _0985_ VGND VGND VPWR VPWR _0987_ sky130_fd_sc_hd__nor2_1
XFILLER_0_65_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3112_ _2320_ _2321_ VGND VGND VPWR VPWR _2354_ sky130_fd_sc_hd__nor2_1
X_4092_ _0898_ _0883_ _0919_ VGND VGND VPWR VPWR _0921_ sky130_fd_sc_hd__or3_1
X_3043_ _2250_ _2251_ _2285_ VGND VGND VPWR VPWR _2287_ sky130_fd_sc_hd__nor3_1
XFILLER_0_81_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4994_ net61 _1774_ VGND VGND VPWR VPWR _1775_ sky130_fd_sc_hd__xor2_1
X_3945_ _0775_ _0777_ VGND VGND VPWR VPWR _0778_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_18_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3876_ domain\[0\] domain\[1\] VGND VGND VPWR VPWR _0711_ sky130_fd_sc_hd__xor2_1
XFILLER_0_83_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2827_ net218 net94 _1756_ VGND VGND VPWR VPWR _2074_ sky130_fd_sc_hd__and3_1
XFILLER_0_60_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2758_ _1998_ _2003_ VGND VGND VPWR VPWR _2005_ sky130_fd_sc_hd__nand2_1
X_2689_ _1870_ _1890_ VGND VGND VPWR VPWR _1936_ sky130_fd_sc_hd__xnor2_2
X_4428_ _1218_ _1182_ _1221_ VGND VGND VPWR VPWR _1222_ sky130_fd_sc_hd__mux2_1
XFILLER_0_1_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4359_ _1025_ _1155_ _1156_ _1157_ VGND VGND VPWR VPWR _1158_ sky130_fd_sc_hd__a211o_1
XFILLER_0_76_292 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout63 net64 VGND VGND VPWR VPWR net63 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_64_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout74 vec\[1\]\[11\] VGND VGND VPWR VPWR net74 sky130_fd_sc_hd__buf_4
Xfanout96 net97 VGND VGND VPWR VPWR net96 sky130_fd_sc_hd__buf_6
Xfanout85 net88 VGND VGND VPWR VPWR net85 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_24_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3730_ _0562_ _0563_ _0564_ VGND VGND VPWR VPWR _0568_ sky130_fd_sc_hd__and3_1
X_3661_ net163 net159 VGND VGND VPWR VPWR _0499_ sky130_fd_sc_hd__or2b_1
X_2612_ _1837_ _1839_ VGND VGND VPWR VPWR _1859_ sky130_fd_sc_hd__xor2_2
X_3592_ _0429_ _0235_ VGND VGND VPWR VPWR _0430_ sky130_fd_sc_hd__xnor2_2
X_2543_ net92 _1789_ VGND VGND VPWR VPWR _1790_ sky130_fd_sc_hd__nor2_1
X_4213_ net3 _1029_ VGND VGND VPWR VPWR _1030_ sky130_fd_sc_hd__xnor2_1
X_4144_ _0967_ _0969_ VGND VGND VPWR VPWR _0971_ sky130_fd_sc_hd__nor2_1
X_4075_ _0255_ _0903_ VGND VGND VPWR VPWR _0904_ sky130_fd_sc_hd__xor2_1
X_3026_ net60 net219 VGND VGND VPWR VPWR _2270_ sky130_fd_sc_hd__nor2_2
XFILLER_0_46_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4977_ _1735_ _1748_ _1757_ _1744_ VGND VGND VPWR VPWR _1759_ sky130_fd_sc_hd__a211oi_2
XFILLER_0_18_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3928_ net129 net125 _0724_ _0760_ VGND VGND VPWR VPWR _0761_ sky130_fd_sc_hd__a31o_1
X_3859_ _0683_ _0693_ VGND VGND VPWR VPWR _0694_ sky130_fd_sc_hd__xor2_2
XFILLER_0_61_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4900_ _1677_ _1679_ VGND VGND VPWR VPWR _1680_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_62_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4831_ _1599_ _1608_ VGND VGND VPWR VPWR _1609_ sky130_fd_sc_hd__nand2_1
X_4762_ _1492_ _1538_ _1539_ _0688_ net188 VGND VGND VPWR VPWR _0090_ sky130_fd_sc_hd__o32ai_1
XFILLER_0_7_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4693_ _1456_ _1458_ _1238_ VGND VGND VPWR VPWR _1470_ sky130_fd_sc_hd__a21oi_1
X_3713_ net163 net160 _0523_ _0513_ VGND VGND VPWR VPWR _0551_ sky130_fd_sc_hd__a31o_1
X_3644_ _0456_ _0458_ VGND VGND VPWR VPWR _0482_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_70_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3575_ _0345_ _0371_ VGND VGND VPWR VPWR _0413_ sky130_fd_sc_hd__xnor2_1
X_2526_ net102 _1623_ VGND VGND VPWR VPWR _1654_ sky130_fd_sc_hd__nor2_1
Xhold28 net38 VGND VGND VPWR VPWR net235 sky130_fd_sc_hd__dlygate4sd3_1
Xhold17 net33 VGND VGND VPWR VPWR net224 sky130_fd_sc_hd__dlygate4sd3_1
XFILLER_0_46_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold39 slte0.opA\[8\] VGND VGND VPWR VPWR net246 sky130_fd_sc_hd__dlygate4sd3_1
X_4127_ net265 _0953_ _0954_ _2248_ net223 VGND VGND VPWR VPWR _0029_ sky130_fd_sc_hd__a32o_1
X_4058_ _0852_ _0857_ _0887_ VGND VGND VPWR VPWR _0888_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_78_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3009_ _2210_ _2215_ VGND VGND VPWR VPWR _2253_ sky130_fd_sc_hd__and2b_1
XFILLER_0_78_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_387 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3360_ net169 _1522_ _0198_ _2248_ net239 VGND VGND VPWR VPWR _0018_ sky130_fd_sc_hd__a32o_1
X_3291_ net235 _2143_ _0134_ _1532_ VGND VGND VPWR VPWR _0013_ sky130_fd_sc_hd__a22o_1
X_5030_ clknet_3_2__leaf_clk _0024_ net200 VGND VGND VPWR VPWR net30 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_73_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4814_ _1142_ _1590_ VGND VGND VPWR VPWR _1591_ sky130_fd_sc_hd__nor2_1
X_4745_ net123 _1521_ VGND VGND VPWR VPWR _1523_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4676_ _1437_ _1443_ _1451_ _1482_ VGND VGND VPWR VPWR _1454_ sky130_fd_sc_hd__a31o_1
XFILLER_0_43_254 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3627_ _0455_ _0463_ _0464_ VGND VGND VPWR VPWR _0465_ sky130_fd_sc_hd__a21bo_1
Xoutput29 net29 VGND VGND VPWR VPWR cos[4] sky130_fd_sc_hd__clkbuf_4
X_3558_ _0245_ _0247_ VGND VGND VPWR VPWR _0396_ sky130_fd_sc_hd__xnor2_4
X_2509_ net172 _1462_ _1472_ _1421_ VGND VGND VPWR VPWR _1482_ sky130_fd_sc_hd__a31o_4
X_3489_ _0302_ _0326_ VGND VGND VPWR VPWR _0327_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_39_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2860_ _2105_ _2097_ _2106_ VGND VGND VPWR VPWR _2107_ sky130_fd_sc_hd__a21oi_4
X_2791_ _2035_ _2037_ VGND VGND VPWR VPWR _2038_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4530_ net61 net55 net182 VGND VGND VPWR VPWR _1313_ sky130_fd_sc_hd__mux2_1
XFILLER_0_68_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4461_ _1232_ _1237_ _1241_ _1242_ _1249_ VGND VGND VPWR VPWR _1252_ sky130_fd_sc_hd__a311oi_4
X_3412_ _0245_ _0249_ VGND VGND VPWR VPWR _0250_ sky130_fd_sc_hd__xnor2_1
X_4392_ _1173_ _1176_ _1188_ VGND VGND VPWR VPWR _1189_ sky130_fd_sc_hd__nand3_1
X_3343_ _0181_ _0169_ _0183_ VGND VGND VPWR VPWR _0184_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_0_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3274_ _0115_ _0117_ VGND VGND VPWR VPWR _0118_ sky130_fd_sc_hd__nor2_1
X_5013_ clknet_3_7__leaf_clk _0007_ net205 VGND VGND VPWR VPWR net47 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_5_Right_5 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_346 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2989_ _2172_ _2174_ VGND VGND VPWR VPWR _2234_ sky130_fd_sc_hd__nor2_1
XFILLER_0_16_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4728_ net54 _1194_ _1504_ VGND VGND VPWR VPWR _1505_ sky130_fd_sc_hd__a21o_1
X_4659_ _1434_ _1435_ VGND VGND VPWR VPWR _1436_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3961_ net129 _0307_ net135 VGND VGND VPWR VPWR _0793_ sky130_fd_sc_hd__o21ai_1
X_2912_ net72 net69 _1915_ VGND VGND VPWR VPWR _2158_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3892_ _0722_ _0725_ VGND VGND VPWR VPWR _0726_ sky130_fd_sc_hd__xor2_2
XFILLER_0_45_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2843_ _2088_ net215 VGND VGND VPWR VPWR _2090_ sky130_fd_sc_hd__xnor2_1
X_2774_ _1942_ _2013_ VGND VGND VPWR VPWR _2021_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_79_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4513_ net170 _1272_ _1297_ VGND VGND VPWR VPWR _1298_ sky130_fd_sc_hd__o21a_1
XFILLER_0_53_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4444_ _1216_ _1213_ _1223_ _1225_ _1234_ VGND VGND VPWR VPWR _1237_ sky130_fd_sc_hd__a311o_2
X_4375_ slte0.opA\[3\] _1172_ VGND VGND VPWR VPWR _1173_ sky130_fd_sc_hd__nand2_1
X_3326_ _0163_ _0167_ VGND VGND VPWR VPWR _0168_ sky130_fd_sc_hd__and2_1
X_3257_ _2461_ _2460_ VGND VGND VPWR VPWR _2495_ sky130_fd_sc_hd__or2b_1
X_3188_ _2392_ _2395_ VGND VGND VPWR VPWR _2428_ sky130_fd_sc_hd__or2_1
XFILLER_0_76_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4160_ _0956_ _0985_ VGND VGND VPWR VPWR _0986_ sky130_fd_sc_hd__and2_1
X_3111_ _2347_ _2352_ VGND VGND VPWR VPWR _2353_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4091_ _0898_ _0883_ _0919_ VGND VGND VPWR VPWR _0920_ sky130_fd_sc_hd__o21ai_1
X_3042_ _2250_ _2251_ _2285_ VGND VGND VPWR VPWR _2286_ sky130_fd_sc_hd__o21a_1
XFILLER_0_81_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4993_ _1772_ _1773_ VGND VGND VPWR VPWR _1774_ sky130_fd_sc_hd__xnor2_1
X_3944_ _0721_ _0742_ _0776_ VGND VGND VPWR VPWR _0777_ sky130_fd_sc_hd__a21o_1
XFILLER_0_58_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3875_ _0708_ _0709_ VGND VGND VPWR VPWR _0710_ sky130_fd_sc_hd__and2_1
X_2826_ _2062_ _2071_ _2072_ VGND VGND VPWR VPWR _2073_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_26_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2757_ _1998_ _2003_ VGND VGND VPWR VPWR _2004_ sky130_fd_sc_hd__xor2_1
XFILLER_0_76_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2688_ _1913_ _1933_ _1934_ VGND VGND VPWR VPWR _1935_ sky130_fd_sc_hd__a21oi_2
X_4427_ _1146_ _1220_ VGND VGND VPWR VPWR _1221_ sky130_fd_sc_hd__nor2_1
X_4358_ net175 _1472_ _1083_ VGND VGND VPWR VPWR _1157_ sky130_fd_sc_hd__and3_2
X_3309_ _0124_ _0125_ _0151_ VGND VGND VPWR VPWR _0152_ sky130_fd_sc_hd__a21bo_1
X_4289_ _1017_ net184 VGND VGND VPWR VPWR _1090_ sky130_fd_sc_hd__nand2_2
XFILLER_0_68_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout64 vec\[1\]\[15\] VGND VGND VPWR VPWR net64 sky130_fd_sc_hd__buf_4
Xfanout75 net76 VGND VGND VPWR VPWR net75 sky130_fd_sc_hd__buf_2
XFILLER_0_64_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout86 net88 VGND VGND VPWR VPWR net86 sky130_fd_sc_hd__clkbuf_2
Xfanout97 vec\[1\]\[5\] VGND VGND VPWR VPWR net97 sky130_fd_sc_hd__buf_4
XFILLER_0_17_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3660_ _0218_ _0497_ VGND VGND VPWR VPWR _0498_ sky130_fd_sc_hd__xnor2_1
X_2611_ _1854_ _1856_ _1857_ VGND VGND VPWR VPWR _1858_ sky130_fd_sc_hd__a21oi_2
X_3591_ net145 net139 VGND VGND VPWR VPWR _0429_ sky130_fd_sc_hd__nand2_1
XFILLER_0_42_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2542_ net84 net79 VGND VGND VPWR VPWR _1789_ sky130_fd_sc_hd__nand2_1
XFILLER_0_2_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4212_ net9 net191 VGND VGND VPWR VPWR _1029_ sky130_fd_sc_hd__nor2_1
XFILLER_0_76_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4143_ _0967_ _0969_ VGND VGND VPWR VPWR _0970_ sky130_fd_sc_hd__and2_1
X_4074_ _0902_ _0593_ VGND VGND VPWR VPWR _0903_ sky130_fd_sc_hd__nand2_1
X_3025_ net57 net65 VGND VGND VPWR VPWR _2269_ sky130_fd_sc_hd__nand2_1
XFILLER_0_25_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4976_ _1744_ _1749_ _1757_ VGND VGND VPWR VPWR _1758_ sky130_fd_sc_hd__o21a_1
X_3927_ net126 _0723_ VGND VGND VPWR VPWR _0760_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3858_ _0691_ _0692_ VGND VGND VPWR VPWR _0693_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_14_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3789_ _0575_ _0619_ VGND VGND VPWR VPWR _0625_ sky130_fd_sc_hd__and2_1
X_2809_ _2053_ _2054_ VGND VGND VPWR VPWR _2056_ sky130_fd_sc_hd__and2b_1
XFILLER_0_21_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_52_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4830_ net174 _1604_ _1607_ VGND VGND VPWR VPWR _1608_ sky130_fd_sc_hd__a21o_1
XFILLER_0_7_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4761_ _1523_ _1529_ _1537_ VGND VGND VPWR VPWR _1539_ sky130_fd_sc_hd__nor3_1
XFILLER_0_28_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4692_ _1219_ _1358_ _1468_ VGND VGND VPWR VPWR _1469_ sky130_fd_sc_hd__a21bo_1
X_3712_ _0548_ _0549_ VGND VGND VPWR VPWR _0550_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3643_ _0240_ _0479_ _0480_ VGND VGND VPWR VPWR _0481_ sky130_fd_sc_hd__a21boi_1
X_3574_ _0411_ VGND VGND VPWR VPWR _0412_ sky130_fd_sc_hd__inv_2
X_2525_ _1623_ _1633_ VGND VGND VPWR VPWR _1644_ sky130_fd_sc_hd__xnor2_4
Xhold29 net49 VGND VGND VPWR VPWR net236 sky130_fd_sc_hd__dlygate4sd3_1
Xhold18 net21 VGND VGND VPWR VPWR net225 sky130_fd_sc_hd__dlygate4sd3_1
X_4126_ _0621_ _0928_ _0952_ VGND VGND VPWR VPWR _0954_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_39_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4057_ _0851_ _0848_ VGND VGND VPWR VPWR _0887_ sky130_fd_sc_hd__or2b_1
XFILLER_0_36_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3008_ _2214_ _2212_ VGND VGND VPWR VPWR _2252_ sky130_fd_sc_hd__and2b_1
X_4959_ _1272_ _1739_ VGND VGND VPWR VPWR _1740_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3290_ _0111_ _0133_ VGND VGND VPWR VPWR _0134_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_57_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_69_Left_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4813_ _1554_ _1574_ VGND VGND VPWR VPWR _1590_ sky130_fd_sc_hd__and2_1
XFILLER_0_7_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4744_ _1518_ _1520_ VGND VGND VPWR VPWR _1521_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_78_Left_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_22_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4675_ _1437_ _1443_ _1451_ VGND VGND VPWR VPWR _1453_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_43_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3626_ _0460_ _0462_ VGND VGND VPWR VPWR _0464_ sky130_fd_sc_hd__nand2_1
X_3557_ _0378_ _0394_ VGND VGND VPWR VPWR _0395_ sky130_fd_sc_hd__and2_1
Xoutput19 net19 VGND VGND VPWR VPWR cos[0] sky130_fd_sc_hd__buf_2
X_2508_ net179 net184 VGND VGND VPWR VPWR _1472_ sky130_fd_sc_hd__nor2_2
XFILLER_0_11_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3488_ _0303_ _0324_ _0325_ VGND VGND VPWR VPWR _0326_ sky130_fd_sc_hd__a21oi_1
X_4109_ _0594_ _0906_ _0935_ _0936_ VGND VGND VPWR VPWR _0937_ sky130_fd_sc_hd__a211o_1
X_5089_ clknet_3_3__leaf_clk _0083_ net199 VGND VGND VPWR VPWR vec\[0\]\[9\] sky130_fd_sc_hd__dfstp_1
XFILLER_0_19_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2790_ _1994_ _2036_ VGND VGND VPWR VPWR _2037_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_80_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4460_ _1249_ _1250_ _1482_ VGND VGND VPWR VPWR _1251_ sky130_fd_sc_hd__a21o_1
X_3411_ net138 _0246_ _0248_ VGND VGND VPWR VPWR _0249_ sky130_fd_sc_hd__o21a_1
X_4391_ _1186_ _1187_ VGND VGND VPWR VPWR _1188_ sky130_fd_sc_hd__nand2_1
X_3342_ _2379_ net63 _0182_ VGND VGND VPWR VPWR _0183_ sky130_fd_sc_hd__mux2_1
XFILLER_0_68_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3273_ net59 _2476_ _0116_ VGND VGND VPWR VPWR _0117_ sky130_fd_sc_hd__a21o_1
X_5012_ clknet_3_7__leaf_clk _0006_ net205 VGND VGND VPWR VPWR net46 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_84_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2988_ _2216_ _2232_ VGND VGND VPWR VPWR _2233_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_8_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4727_ _1296_ _1462_ _1339_ VGND VGND VPWR VPWR _1504_ sky130_fd_sc_hd__and3_1
XFILLER_0_31_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4658_ _1418_ _1419_ _1206_ VGND VGND VPWR VPWR _1435_ sky130_fd_sc_hd__a21oi_1
X_3609_ net153 net150 VGND VGND VPWR VPWR _0447_ sky130_fd_sc_hd__nand2_1
X_4589_ _1367_ _1368_ VGND VGND VPWR VPWR _1369_ sky130_fd_sc_hd__nand2_1
XFILLER_0_66_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_11_Right_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_20_Right_20 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_59 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3960_ _0775_ _0777_ VGND VGND VPWR VPWR _0792_ sky130_fd_sc_hd__and2_1
XFILLER_0_9_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2911_ _2155_ _2156_ VGND VGND VPWR VPWR _2157_ sky130_fd_sc_hd__or2_1
X_3891_ _0270_ _0724_ VGND VGND VPWR VPWR _0725_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_57_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2842_ _2079_ _2073_ VGND VGND VPWR VPWR _2089_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_79_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2773_ _2018_ _2019_ VGND VGND VPWR VPWR _2020_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4512_ slte0.opA\[16\] VGND VGND VPWR VPWR _1297_ sky130_fd_sc_hd__inv_2
X_4443_ _1234_ _1235_ VGND VGND VPWR VPWR _1236_ sky130_fd_sc_hd__nand2_1
XFILLER_0_0_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4374_ _1170_ _1171_ VGND VGND VPWR VPWR _1172_ sky130_fd_sc_hd__xnor2_1
X_3325_ _0164_ _0166_ VGND VGND VPWR VPWR _0167_ sky130_fd_sc_hd__xnor2_1
X_3256_ _2430_ _2462_ VGND VGND VPWR VPWR _2494_ sky130_fd_sc_hd__nand2_1
X_3187_ _2389_ _2426_ VGND VGND VPWR VPWR _2427_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_8_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_27_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3110_ _2350_ _2351_ VGND VGND VPWR VPWR _2352_ sky130_fd_sc_hd__and2_1
XFILLER_0_65_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4090_ _0899_ _0918_ VGND VGND VPWR VPWR _0919_ sky130_fd_sc_hd__xor2_1
X_3041_ _2207_ _2284_ VGND VGND VPWR VPWR _2285_ sky130_fd_sc_hd__xor2_1
X_4992_ _1272_ _1763_ VGND VGND VPWR VPWR _1773_ sky130_fd_sc_hd__or2b_1
X_3943_ _0739_ _0741_ VGND VGND VPWR VPWR _0776_ sky130_fd_sc_hd__nor2_1
X_3874_ _0707_ _0670_ _0671_ VGND VGND VPWR VPWR _0709_ sky130_fd_sc_hd__nand3_1
Xclkbuf_3_2__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_2__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_2825_ _2066_ _2070_ VGND VGND VPWR VPWR _2072_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2756_ _1988_ _1999_ _2001_ _2002_ VGND VGND VPWR VPWR _2003_ sky130_fd_sc_hd__a31o_1
X_2687_ _1931_ _1932_ VGND VGND VPWR VPWR _1934_ sky130_fd_sc_hd__and2b_1
XFILLER_0_30_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4426_ _1219_ _1084_ _1195_ VGND VGND VPWR VPWR _1220_ sky130_fd_sc_hd__a21o_1
X_4357_ net175 _1088_ VGND VGND VPWR VPWR _1156_ sky130_fd_sc_hd__nor2_1
X_3308_ _0112_ _0126_ VGND VGND VPWR VPWR _0151_ sky130_fd_sc_hd__or2b_1
X_4288_ _1087_ _1088_ VGND VGND VPWR VPWR _1089_ sky130_fd_sc_hd__nor2_1
X_3239_ _2374_ _2476_ VGND VGND VPWR VPWR _2477_ sky130_fd_sc_hd__xnor2_1
Xfanout54 net55 VGND VGND VPWR VPWR net54 sky130_fd_sc_hd__clkbuf_4
Xfanout65 net67 VGND VGND VPWR VPWR net65 sky130_fd_sc_hd__buf_4
XFILLER_0_24_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout98 vec\[1\]\[5\] VGND VGND VPWR VPWR net98 sky130_fd_sc_hd__buf_2
Xfanout76 vec\[1\]\[11\] VGND VGND VPWR VPWR net76 sky130_fd_sc_hd__buf_4
Xfanout87 net88 VGND VGND VPWR VPWR net87 sky130_fd_sc_hd__clkbuf_8
XPHY_EDGE_ROW_23_Left_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_28 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_32_Left_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_41_Left_127 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2610_ net75 net70 _1852_ VGND VGND VPWR VPWR _1857_ sky130_fd_sc_hd__and3_1
X_3590_ net150 net147 VGND VGND VPWR VPWR _0428_ sky130_fd_sc_hd__or2_1
X_2541_ net84 net79 _1787_ VGND VGND VPWR VPWR _1788_ sky130_fd_sc_hd__a21o_1
X_4211_ net170 _1026_ _1028_ VGND VGND VPWR VPWR _0039_ sky130_fd_sc_hd__o21a_1
XFILLER_0_76_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4142_ _0944_ _0945_ _0968_ VGND VGND VPWR VPWR _0969_ sky130_fd_sc_hd__a21bo_1
X_4073_ net124 net118 VGND VGND VPWR VPWR _0902_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_50_Left_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3024_ net57 net63 VGND VGND VPWR VPWR _2268_ sky130_fd_sc_hd__or2_2
X_4975_ _1754_ _1755_ VGND VGND VPWR VPWR _1757_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3926_ net134 _0348_ net140 VGND VGND VPWR VPWR _0759_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_46_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3857_ _0643_ _0649_ _0648_ VGND VGND VPWR VPWR _0692_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_41_92 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3788_ net265 _0622_ _0623_ _0624_ VGND VGND VPWR VPWR _0020_ sky130_fd_sc_hd__a31o_1
X_2808_ _2053_ _2054_ VGND VGND VPWR VPWR _2055_ sky130_fd_sc_hd__xnor2_1
X_2739_ _1981_ _1984_ _1985_ VGND VGND VPWR VPWR _1986_ sky130_fd_sc_hd__or3_1
XFILLER_0_14_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4409_ _1192_ _1204_ VGND VGND VPWR VPWR _1205_ sky130_fd_sc_hd__xor2_1
Xfanout200 net201 VGND VGND VPWR VPWR net200 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_423 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4760_ _1523_ _1529_ _1537_ VGND VGND VPWR VPWR _1538_ sky130_fd_sc_hd__o21a_1
X_4691_ net54 _1467_ VGND VGND VPWR VPWR _1468_ sky130_fd_sc_hd__nand2_1
X_3711_ _0490_ _0491_ VGND VGND VPWR VPWR _0549_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_55_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3642_ net150 net145 _0200_ VGND VGND VPWR VPWR _0480_ sky130_fd_sc_hd__nand3_1
XFILLER_0_55_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3573_ _0405_ _0409_ _0410_ VGND VGND VPWR VPWR _0411_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_49_Right_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2524_ net102 net96 VGND VGND VPWR VPWR _1633_ sky130_fd_sc_hd__nand2_2
XFILLER_0_11_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xhold19 net34 VGND VGND VPWR VPWR net226 sky130_fd_sc_hd__dlygate4sd3_1
X_4125_ _0621_ _0928_ _0952_ VGND VGND VPWR VPWR _0953_ sky130_fd_sc_hd__or3_1
X_4056_ _0884_ _0885_ VGND VGND VPWR VPWR _0886_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_58_Right_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3007_ _2148_ _2240_ VGND VGND VPWR VPWR _2251_ sky130_fd_sc_hd__nor2_1
XFILLER_0_19_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4958_ _1723_ _1722_ VGND VGND VPWR VPWR _1739_ sky130_fd_sc_hd__and2_1
X_3909_ _0721_ _0742_ VGND VGND VPWR VPWR _0743_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_46_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4889_ _1666_ _1668_ VGND VGND VPWR VPWR _1669_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_67_Right_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_76_Right_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_85_Right_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_52_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4812_ net172 _1588_ _1573_ VGND VGND VPWR VPWR _1589_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_16_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4743_ _1272_ _1519_ VGND VGND VPWR VPWR _1520_ sky130_fd_sc_hd__or2_1
XFILLER_0_83_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4674_ _1449_ _1450_ VGND VGND VPWR VPWR _1451_ sky130_fd_sc_hd__nor2_1
X_3625_ _0460_ _0462_ VGND VGND VPWR VPWR _0463_ sky130_fd_sc_hd__xor2_1
XFILLER_0_43_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3556_ net148 net144 VGND VGND VPWR VPWR _0394_ sky130_fd_sc_hd__or2_1
X_2507_ _1452_ VGND VGND VPWR VPWR _1462_ sky130_fd_sc_hd__buf_2
X_3487_ _0321_ _0323_ VGND VGND VPWR VPWR _0325_ sky130_fd_sc_hd__and2_1
XFILLER_0_51_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4108_ net112 _0934_ VGND VGND VPWR VPWR _0936_ sky130_fd_sc_hd__and2_1
X_5088_ clknet_3_3__leaf_clk _0082_ net199 VGND VGND VPWR VPWR vec\[0\]\[8\] sky130_fd_sc_hd__dfstp_1
X_4039_ _0866_ _0868_ VGND VGND VPWR VPWR _0869_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_2_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3410_ _0247_ _0246_ VGND VGND VPWR VPWR _0248_ sky130_fd_sc_hd__or2b_1
XFILLER_0_21_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4390_ slte0.opA\[4\] _1185_ VGND VGND VPWR VPWR _1187_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3341_ net65 net59 net56 VGND VGND VPWR VPWR _0182_ sky130_fd_sc_hd__o21a_1
XFILLER_0_21_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3272_ net58 VGND VGND VPWR VPWR _0116_ sky130_fd_sc_hd__inv_2
XFILLER_0_84_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5011_ clknet_3_7__leaf_clk _0005_ net205 VGND VGND VPWR VPWR net45 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_16_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2987_ _2229_ _2231_ VGND VGND VPWR VPWR _2232_ sky130_fd_sc_hd__xnor2_2
X_4726_ _1499_ _1497_ VGND VGND VPWR VPWR _1503_ sky130_fd_sc_hd__nand2_1
X_4657_ net54 _1430_ _1432_ _1433_ VGND VGND VPWR VPWR _1434_ sky130_fd_sc_hd__a31o_1
X_3608_ net157 VGND VGND VPWR VPWR _0446_ sky130_fd_sc_hd__inv_2
X_4588_ net158 _1366_ VGND VGND VPWR VPWR _1368_ sky130_fd_sc_hd__or2_1
X_3539_ _0361_ _0362_ VGND VGND VPWR VPWR _0377_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_79_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2910_ _2151_ _2154_ VGND VGND VPWR VPWR _2156_ sky130_fd_sc_hd__and2_1
XFILLER_0_85_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3890_ _0269_ _0723_ VGND VGND VPWR VPWR _0724_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_45_318 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2841_ net108 net105 VGND VGND VPWR VPWR _2088_ sky130_fd_sc_hd__nand2_1
X_2772_ _2015_ _2017_ VGND VGND VPWR VPWR _2019_ sky130_fd_sc_hd__nor2_1
X_4511_ _1193_ VGND VGND VPWR VPWR _1296_ sky130_fd_sc_hd__buf_2
X_4442_ _1216_ _1213_ _1223_ _1225_ VGND VGND VPWR VPWR _1235_ sky130_fd_sc_hd__a31o_1
XFILLER_0_21_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4373_ _1153_ _1159_ _1142_ VGND VGND VPWR VPWR _1171_ sky130_fd_sc_hd__a21o_1
X_3324_ net65 _0165_ VGND VGND VPWR VPWR _0166_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3255_ _2491_ _2492_ VGND VGND VPWR VPWR _2493_ sky130_fd_sc_hd__or2_2
X_3186_ _2424_ _2425_ VGND VGND VPWR VPWR _2426_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4709_ _1486_ VGND VGND VPWR VPWR _1487_ sky130_fd_sc_hd__inv_2
XFILLER_0_44_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_2_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3040_ _2281_ _2283_ VGND VGND VPWR VPWR _2284_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_81_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4991_ _1545_ net114 _1517_ VGND VGND VPWR VPWR _1772_ sky130_fd_sc_hd__mux2_1
XFILLER_0_81_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3942_ _0769_ _0774_ VGND VGND VPWR VPWR _0775_ sky130_fd_sc_hd__xor2_1
X_3873_ _0670_ _0671_ _0707_ VGND VGND VPWR VPWR _0708_ sky130_fd_sc_hd__a21o_1
XFILLER_0_73_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2824_ _2066_ _2070_ VGND VGND VPWR VPWR _2071_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2755_ net91 net83 _1801_ VGND VGND VPWR VPWR _2002_ sky130_fd_sc_hd__and3_1
X_2686_ _1931_ _1932_ VGND VGND VPWR VPWR _1933_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_1_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4425_ _1083_ VGND VGND VPWR VPWR _1219_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_1_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4356_ net170 _1090_ VGND VGND VPWR VPWR _1155_ sky130_fd_sc_hd__nor2_1
X_3307_ _0121_ _0149_ VGND VGND VPWR VPWR _0150_ sky130_fd_sc_hd__xnor2_1
X_4287_ _1017_ net171 net183 VGND VGND VPWR VPWR _1088_ sky130_fd_sc_hd__or3b_1
X_3238_ _2474_ _2475_ VGND VGND VPWR VPWR _2476_ sky130_fd_sc_hd__or2_1
X_3169_ net71 _1837_ _2408_ VGND VGND VPWR VPWR _2409_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_49_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_487 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout55 vec\[1\]\[17\] VGND VGND VPWR VPWR net55 sky130_fd_sc_hd__clkbuf_4
Xfanout99 net100 VGND VGND VPWR VPWR net99 sky130_fd_sc_hd__buf_6
Xfanout77 net78 VGND VGND VPWR VPWR net77 sky130_fd_sc_hd__buf_2
Xfanout88 vec\[1\]\[8\] VGND VGND VPWR VPWR net88 sky130_fd_sc_hd__buf_2
Xfanout66 vec\[1\]\[14\] VGND VGND VPWR VPWR net66 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_32_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2540_ net91 net84 VGND VGND VPWR VPWR _1787_ sky130_fd_sc_hd__xor2_4
XFILLER_0_50_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4210_ net170 _1026_ _1522_ VGND VGND VPWR VPWR _1028_ sky130_fd_sc_hd__a21oi_1
X_4141_ _0929_ _0946_ VGND VGND VPWR VPWR _0968_ sky130_fd_sc_hd__or2b_1
X_4072_ _0796_ _0867_ VGND VGND VPWR VPWR _0901_ sky130_fd_sc_hd__and2_1
X_3023_ _1853_ _2266_ VGND VGND VPWR VPWR _2267_ sky130_fd_sc_hd__xnor2_1
X_4974_ net66 _1753_ VGND VGND VPWR VPWR _1755_ sky130_fd_sc_hd__or2_1
X_3925_ _0260_ _0757_ VGND VGND VPWR VPWR _0758_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_73_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3856_ _0686_ _0690_ VGND VGND VPWR VPWR _0691_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_41_60 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3787_ net26 _2142_ VGND VGND VPWR VPWR _0624_ sky130_fd_sc_hd__and2_1
XFILLER_0_26_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2807_ _2021_ _2029_ VGND VGND VPWR VPWR _2054_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_14_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2738_ _1983_ _1953_ VGND VGND VPWR VPWR _1985_ sky130_fd_sc_hd__nor2_1
X_4408_ _1202_ _1203_ VGND VGND VPWR VPWR _1204_ sky130_fd_sc_hd__nor2_1
X_2669_ _1914_ _1915_ VGND VGND VPWR VPWR _1916_ sky130_fd_sc_hd__xnor2_4
Xfanout201 net2 VGND VGND VPWR VPWR net201 sky130_fd_sc_hd__buf_2
X_4339_ _1138_ _1101_ _1133_ _1134_ VGND VGND VPWR VPWR _1139_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_69_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_24_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3710_ _0514_ _0519_ _0547_ VGND VGND VPWR VPWR _0548_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_55_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4690_ net177 net175 _1430_ VGND VGND VPWR VPWR _1467_ sky130_fd_sc_hd__a21o_1
X_3641_ _0475_ _0478_ VGND VGND VPWR VPWR _0479_ sky130_fd_sc_hd__nor2_1
XFILLER_0_70_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3572_ _0346_ _0367_ VGND VGND VPWR VPWR _0410_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_51_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2523_ net99 net94 VGND VGND VPWR VPWR _1623_ sky130_fd_sc_hd__xor2_4
X_4124_ _0950_ _0951_ VGND VGND VPWR VPWR _0952_ sky130_fd_sc_hd__xor2_2
Xinput1 in_valid VGND VGND VPWR VPWR net1 sky130_fd_sc_hd__clkbuf_2
X_4055_ _0813_ _0847_ _0845_ VGND VGND VPWR VPWR _0885_ sky130_fd_sc_hd__o21a_1
XFILLER_0_78_335 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3006_ _2237_ _2239_ VGND VGND VPWR VPWR _2250_ sky130_fd_sc_hd__nor2_1
XFILLER_0_46_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4957_ _1737_ VGND VGND VPWR VPWR _1738_ sky130_fd_sc_hd__inv_2
X_3908_ _0739_ _0741_ VGND VGND VPWR VPWR _0742_ sky130_fd_sc_hd__xor2_2
X_4888_ _1667_ _1651_ _1206_ VGND VGND VPWR VPWR _1668_ sky130_fd_sc_hd__a21o_1
X_3839_ _0672_ _0673_ net152 VGND VGND VPWR VPWR _0674_ sky130_fd_sc_hd__o21ai_4
XFILLER_0_6_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_33_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4811_ _1584_ _1587_ _1024_ VGND VGND VPWR VPWR _1588_ sky130_fd_sc_hd__mux2_1
XFILLER_0_68_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_28_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4742_ _1493_ _1506_ _1504_ VGND VGND VPWR VPWR _1519_ sky130_fd_sc_hd__nor3_1
XFILLER_0_83_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4673_ net140 _1447_ VGND VGND VPWR VPWR _1450_ sky130_fd_sc_hd__nor2_2
X_3624_ _0461_ _0430_ VGND VGND VPWR VPWR _0462_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3555_ _0349_ _0351_ VGND VGND VPWR VPWR _0393_ sky130_fd_sc_hd__xnor2_2
X_3486_ _0321_ _0323_ VGND VGND VPWR VPWR _0324_ sky130_fd_sc_hd__xor2_1
X_2506_ net174 net176 VGND VGND VPWR VPWR _1452_ sky130_fd_sc_hd__nor2_2
XFILLER_0_44_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4107_ net112 _0934_ VGND VGND VPWR VPWR _0935_ sky130_fd_sc_hd__nor2_1
X_5087_ clknet_3_3__leaf_clk _0081_ net199 VGND VGND VPWR VPWR vec\[0\]\[7\] sky130_fd_sc_hd__dfstp_1
XFILLER_0_2_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4038_ net126 _0259_ _0867_ VGND VGND VPWR VPWR _0868_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_78_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3340_ _0164_ _0166_ VGND VGND VPWR VPWR _0181_ sky130_fd_sc_hd__nor2_1
X_5010_ clknet_3_7__leaf_clk _0004_ net204 VGND VGND VPWR VPWR net44 sky130_fd_sc_hd__dfrtp_1
X_3271_ net56 _0114_ VGND VGND VPWR VPWR _0115_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_17_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_338 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2986_ _2160_ _2171_ _2230_ VGND VGND VPWR VPWR _2231_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_83_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4725_ _1098_ _1501_ _1502_ VGND VGND VPWR VPWR _0087_ sky130_fd_sc_hd__a21oi_1
X_4656_ net174 _1415_ _1313_ _1307_ _1083_ VGND VGND VPWR VPWR _1433_ sky130_fd_sc_hd__a32o_1
XFILLER_0_3_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3607_ _0440_ _0443_ _0444_ VGND VGND VPWR VPWR _0445_ sky130_fd_sc_hd__a21o_1
X_4587_ net158 _1366_ VGND VGND VPWR VPWR _1367_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3538_ _0374_ _0375_ VGND VGND VPWR VPWR _0376_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_10_Left_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3469_ net133 net128 VGND VGND VPWR VPWR _0307_ sky130_fd_sc_hd__xor2_4
XFILLER_0_39_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2840_ _2080_ _2086_ VGND VGND VPWR VPWR _2087_ sky130_fd_sc_hd__or2_1
XFILLER_0_38_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2771_ _2015_ _2017_ VGND VGND VPWR VPWR _2018_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4510_ _1014_ VGND VGND VPWR VPWR _1295_ sky130_fd_sc_hd__buf_4
XFILLER_0_79_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4441_ _1232_ _1233_ VGND VGND VPWR VPWR _1234_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_9_Right_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4372_ _1018_ _1023_ _1169_ net183 VGND VGND VPWR VPWR _1170_ sky130_fd_sc_hd__a211oi_2
X_3323_ _0142_ _2220_ VGND VGND VPWR VPWR _0165_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3254_ _2488_ _2490_ VGND VGND VPWR VPWR _2492_ sky130_fd_sc_hd__nor2_1
XFILLER_0_28_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3185_ _2421_ _2423_ VGND VGND VPWR VPWR _2425_ sky130_fd_sc_hd__nor2_1
XFILLER_0_76_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2969_ net89 _2001_ _2213_ VGND VGND VPWR VPWR _2214_ sky130_fd_sc_hd__a21o_1
X_4708_ net129 _1485_ VGND VGND VPWR VPWR _1486_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_4_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4639_ _1018_ _1023_ _1296_ VGND VGND VPWR VPWR _1415_ sky130_fd_sc_hd__and3_1
XFILLER_0_67_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4990_ _1152_ net64 _1015_ _1771_ VGND VGND VPWR VPWR _0107_ sky130_fd_sc_hd__a22o_1
XFILLER_0_85_241 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3941_ _0772_ _0773_ VGND VGND VPWR VPWR _0774_ sky130_fd_sc_hd__and2_1
XFILLER_0_58_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3872_ _0703_ _0706_ VGND VGND VPWR VPWR _0707_ sky130_fd_sc_hd__xnor2_1
X_2823_ _1644_ _2068_ _2069_ VGND VGND VPWR VPWR _2070_ sky130_fd_sc_hd__a21oi_1
X_2754_ _2000_ _1801_ VGND VGND VPWR VPWR _2001_ sky130_fd_sc_hd__xnor2_2
X_2685_ _1871_ _1886_ VGND VGND VPWR VPWR _1932_ sky130_fd_sc_hd__xor2_1
X_4424_ _1206_ VGND VGND VPWR VPWR _1218_ sky130_fd_sc_hd__clkbuf_4
X_4355_ _1142_ _1153_ VGND VGND VPWR VPWR _1154_ sky130_fd_sc_hd__nor2_1
X_3306_ _0147_ _0148_ VGND VGND VPWR VPWR _0149_ sky130_fd_sc_hd__and2_1
X_4286_ _1086_ VGND VGND VPWR VPWR _1087_ sky130_fd_sc_hd__clkbuf_4
X_3237_ _2471_ _2443_ _2473_ VGND VGND VPWR VPWR _2475_ sky130_fd_sc_hd__and3_1
X_3168_ net71 _1835_ VGND VGND VPWR VPWR _2408_ sky130_fd_sc_hd__nor2_1
X_3099_ _2340_ _1876_ net77 VGND VGND VPWR VPWR _2341_ sky130_fd_sc_hd__mux2_1
XFILLER_0_49_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout56 net57 VGND VGND VPWR VPWR net56 sky130_fd_sc_hd__buf_4
XFILLER_0_64_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout89 net92 VGND VGND VPWR VPWR net89 sky130_fd_sc_hd__buf_2
Xfanout78 net80 VGND VGND VPWR VPWR net78 sky130_fd_sc_hd__clkbuf_4
Xfanout67 vec\[1\]\[14\] VGND VGND VPWR VPWR net67 sky130_fd_sc_hd__buf_2
XFILLER_0_51_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_44_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4140_ _0965_ _0966_ VGND VGND VPWR VPWR _0967_ sky130_fd_sc_hd__nor2_1
X_4071_ _0592_ _0870_ VGND VGND VPWR VPWR _0900_ sky130_fd_sc_hd__nor2_1
X_3022_ _1852_ _2265_ VGND VGND VPWR VPWR _2266_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_25_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4973_ net66 _1753_ VGND VGND VPWR VPWR _1754_ sky130_fd_sc_hd__nand2_1
X_3924_ _0722_ _0725_ _0756_ VGND VGND VPWR VPWR _0757_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_46_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_73_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3855_ net119 _0255_ _0689_ VGND VGND VPWR VPWR _0690_ sky130_fd_sc_hd__o21a_1
XFILLER_0_46_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3786_ _0575_ _0621_ _0619_ VGND VGND VPWR VPWR _0623_ sky130_fd_sc_hd__o21ai_1
X_2806_ _2045_ _2051_ _2052_ VGND VGND VPWR VPWR _2053_ sky130_fd_sc_hd__o21bai_2
X_2737_ _1983_ _1953_ VGND VGND VPWR VPWR _1984_ sky130_fd_sc_hd__and2_1
XFILLER_0_74_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2668_ net78 net72 VGND VGND VPWR VPWR _1915_ sky130_fd_sc_hd__xor2_4
X_4407_ slte0.opA\[5\] _1200_ VGND VGND VPWR VPWR _1203_ sky130_fd_sc_hd__nor2_1
X_2599_ _1832_ _1845_ VGND VGND VPWR VPWR _1846_ sky130_fd_sc_hd__xnor2_2
Xfanout202 net203 VGND VGND VPWR VPWR net202 sky130_fd_sc_hd__clkbuf_4
X_4338_ slte0.opB\[13\] _1099_ _1136_ VGND VGND VPWR VPWR _1138_ sky130_fd_sc_hd__o21ai_1
X_4269_ net6 _1073_ VGND VGND VPWR VPWR _1074_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_1_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3640_ net158 net155 VGND VGND VPWR VPWR _0478_ sky130_fd_sc_hd__nor2_1
X_3571_ _0407_ _0408_ VGND VGND VPWR VPWR _0409_ sky130_fd_sc_hd__nand2_1
XFILLER_0_11_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2522_ net97 net91 _1581_ _1602_ VGND VGND VPWR VPWR _1613_ sky130_fd_sc_hd__a31o_1
X_4123_ _0920_ _0923_ VGND VGND VPWR VPWR _0951_ sky130_fd_sc_hd__nand2_1
X_4054_ _0882_ _0883_ VGND VGND VPWR VPWR _0884_ sky130_fd_sc_hd__nor2_1
Xinput2 rstb VGND VGND VPWR VPWR net2 sky130_fd_sc_hd__buf_1
X_3005_ _2202_ _2245_ VGND VGND VPWR VPWR _2249_ sky130_fd_sc_hd__or2_1
XFILLER_0_36_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_46_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4956_ net114 _1194_ _1634_ _1219_ VGND VGND VPWR VPWR _1737_ sky130_fd_sc_hd__a22o_1
XFILLER_0_52_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3907_ _0683_ _0693_ _0740_ VGND VGND VPWR VPWR _0741_ sky130_fd_sc_hd__o21a_1
XFILLER_0_34_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4887_ _1649_ VGND VGND VPWR VPWR _1667_ sky130_fd_sc_hd__inv_2
X_3838_ _0634_ _0639_ VGND VGND VPWR VPWR _0673_ sky130_fd_sc_hd__and2b_1
XFILLER_0_61_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3769_ _0266_ _0279_ VGND VGND VPWR VPWR _0606_ sky130_fd_sc_hd__or2_1
XFILLER_0_42_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_29_Left_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_38_Left_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4810_ _1585_ _1586_ _1022_ VGND VGND VPWR VPWR _1587_ sky130_fd_sc_hd__mux2_1
X_4741_ net55 _1517_ _1194_ _1355_ VGND VGND VPWR VPWR _1518_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_22_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4672_ _1448_ VGND VGND VPWR VPWR _1449_ sky130_fd_sc_hd__inv_2
X_3623_ _0414_ _0428_ VGND VGND VPWR VPWR _0461_ sky130_fd_sc_hd__nand2_1
X_3554_ _0206_ _0379_ VGND VGND VPWR VPWR _0392_ sky130_fd_sc_hd__xnor2_2
X_3485_ _0282_ _0322_ VGND VGND VPWR VPWR _0323_ sky130_fd_sc_hd__xnor2_1
X_2505_ _1431_ net1 VGND VGND VPWR VPWR _1442_ sky130_fd_sc_hd__nand2_4
XPHY_EDGE_ROW_47_Left_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4106_ _0728_ _0933_ VGND VGND VPWR VPWR _0934_ sky130_fd_sc_hd__nor2_1
X_5086_ clknet_3_3__leaf_clk _0080_ net199 VGND VGND VPWR VPWR vec\[0\]\[6\] sky130_fd_sc_hd__dfstp_1
X_4037_ net126 _0260_ VGND VGND VPWR VPWR _0867_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_56_Left_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4939_ _1703_ _1708_ VGND VGND VPWR VPWR _1720_ sky130_fd_sc_hd__and2b_1
XFILLER_0_62_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_372 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_65_Left_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_74_Left_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3270_ _0113_ _2309_ VGND VGND VPWR VPWR _0114_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_0_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2985_ _2168_ _2170_ VGND VGND VPWR VPWR _2230_ sky130_fd_sc_hd__and2b_1
X_4724_ net188 net127 VGND VGND VPWR VPWR _1502_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_71_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4655_ net177 net176 net170 VGND VGND VPWR VPWR _1432_ sky130_fd_sc_hd__or3_1
X_3606_ _0407_ _0408_ VGND VGND VPWR VPWR _0444_ sky130_fd_sc_hd__xnor2_1
X_4586_ _1364_ _1365_ VGND VGND VPWR VPWR _1366_ sky130_fd_sc_hd__xnor2_1
X_3537_ _0328_ _0373_ VGND VGND VPWR VPWR _0375_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3468_ _0239_ _0305_ VGND VGND VPWR VPWR _0306_ sky130_fd_sc_hd__xnor2_2
X_3399_ net144 net138 _0236_ VGND VGND VPWR VPWR _0237_ sky130_fd_sc_hd__and3_1
XFILLER_0_79_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5069_ clknet_3_0__leaf_clk _0063_ net194 VGND VGND VPWR VPWR slte0.opA\[7\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_39_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_504 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_85_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2770_ _1983_ _2016_ VGND VGND VPWR VPWR _2017_ sky130_fd_sc_hd__nor2_1
XFILLER_0_53_342 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4440_ _1106_ _1231_ VGND VGND VPWR VPWR _1233_ sky130_fd_sc_hd__nand2_1
X_4371_ net177 net173 net175 net171 VGND VGND VPWR VPWR _1169_ sky130_fd_sc_hd__a31o_1
X_3322_ _0141_ _0144_ _2310_ VGND VGND VPWR VPWR _0164_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3253_ _2488_ _2490_ VGND VGND VPWR VPWR _2491_ sky130_fd_sc_hd__and2_1
X_3184_ _2421_ _2423_ VGND VGND VPWR VPWR _2424_ sky130_fd_sc_hd__and2_1
XFILLER_0_76_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_76_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2968_ net89 _1801_ VGND VGND VPWR VPWR _2213_ sky130_fd_sc_hd__nor2_1
XFILLER_0_71_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4707_ _1483_ _1484_ VGND VGND VPWR VPWR _1485_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2899_ _1736_ _1893_ VGND VGND VPWR VPWR _2145_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4638_ net189 net149 _1492_ _1414_ VGND VGND VPWR VPWR _0080_ sky130_fd_sc_hd__o22a_1
XFILLER_0_69_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4569_ _1347_ _1349_ VGND VGND VPWR VPWR _1350_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_82_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3940_ net146 _0770_ _0771_ VGND VGND VPWR VPWR _0773_ sky130_fd_sc_hd__or3_1
XFILLER_0_85_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3871_ _0704_ _0705_ VGND VGND VPWR VPWR _0706_ sky130_fd_sc_hd__or2_1
XFILLER_0_18_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_38_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2822_ net102 net96 _1623_ VGND VGND VPWR VPWR _2069_ sky130_fd_sc_hd__and3_1
X_2753_ net89 net83 VGND VGND VPWR VPWR _2000_ sky130_fd_sc_hd__nand2_1
XFILLER_0_81_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2684_ _1928_ _1929_ _1930_ VGND VGND VPWR VPWR _1931_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_30_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4423_ _1216_ _1213_ VGND VGND VPWR VPWR _1217_ sky130_fd_sc_hd__nand2_1
X_4354_ _1095_ _1147_ VGND VGND VPWR VPWR _1153_ sky130_fd_sc_hd__nor2_1
XFILLER_0_39_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3305_ _0118_ _0139_ _0146_ VGND VGND VPWR VPWR _0148_ sky130_fd_sc_hd__or3_1
XFILLER_0_1_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4285_ net173 net175 VGND VGND VPWR VPWR _1086_ sky130_fd_sc_hd__or2b_1
X_3236_ _2471_ _2443_ _2473_ VGND VGND VPWR VPWR _2474_ sky130_fd_sc_hd__a21oi_1
X_3167_ _2379_ _2268_ VGND VGND VPWR VPWR _2407_ sky130_fd_sc_hd__nand2_1
X_3098_ _1874_ VGND VGND VPWR VPWR _2340_ sky130_fd_sc_hd__inv_2
Xfanout57 net58 VGND VGND VPWR VPWR net57 sky130_fd_sc_hd__clkbuf_2
Xfanout79 net80 VGND VGND VPWR VPWR net79 sky130_fd_sc_hd__buf_4
Xfanout68 net70 VGND VGND VPWR VPWR net68 sky130_fd_sc_hd__buf_4
XFILLER_0_32_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_63_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4070_ net137 _0876_ VGND VGND VPWR VPWR _0899_ sky130_fd_sc_hd__nand2_1
X_3021_ net67 net63 VGND VGND VPWR VPWR _2265_ sky130_fd_sc_hd__nand2_1
X_4972_ _1751_ _1752_ VGND VGND VPWR VPWR _1753_ sky130_fd_sc_hd__xnor2_1
X_3923_ net121 _0645_ VGND VGND VPWR VPWR _0756_ sky130_fd_sc_hd__nor2_1
XFILLER_0_58_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3854_ net124 net117 _0687_ _0688_ VGND VGND VPWR VPWR _0689_ sky130_fd_sc_hd__a211o_1
XFILLER_0_46_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2805_ _2049_ _2050_ VGND VGND VPWR VPWR _2052_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3785_ _0575_ _0619_ _0621_ VGND VGND VPWR VPWR _0622_ sky130_fd_sc_hd__or3_1
X_2736_ _1982_ VGND VGND VPWR VPWR _1983_ sky130_fd_sc_hd__buf_2
X_2667_ net82 net75 VGND VGND VPWR VPWR _1914_ sky130_fd_sc_hd__nand2_2
XFILLER_0_67_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4406_ _1201_ VGND VGND VPWR VPWR _1202_ sky130_fd_sc_hd__inv_2
X_2598_ _1834_ _1843_ _1844_ VGND VGND VPWR VPWR _1845_ sky130_fd_sc_hd__a21oi_2
Xfanout203 net207 VGND VGND VPWR VPWR net203 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4337_ slte0.opB\[13\] _1099_ slte0.opB\[12\] _1100_ _1136_ VGND VGND VPWR VPWR _1137_
+ sky130_fd_sc_hd__o221a_1
X_4268_ net9 _1072_ net192 VGND VGND VPWR VPWR _1073_ sky130_fd_sc_hd__a21oi_1
X_3219_ _2456_ _2457_ VGND VGND VPWR VPWR _2458_ sky130_fd_sc_hd__nand2_1
X_4199_ _1018_ _1016_ VGND VGND VPWR VPWR _1020_ sky130_fd_sc_hd__and2_1
XFILLER_0_49_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_223 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_245 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_32_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3570_ _0377_ _0404_ VGND VGND VPWR VPWR _0408_ sky130_fd_sc_hd__xor2_1
XFILLER_0_23_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2521_ net93 _1592_ VGND VGND VPWR VPWR _1602_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_18_Right_18 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4122_ _0947_ _0949_ VGND VGND VPWR VPWR _0950_ sky130_fd_sc_hd__xnor2_2
X_4053_ _0862_ _0881_ VGND VGND VPWR VPWR _0883_ sky130_fd_sc_hd__nor2_1
X_3004_ _1560_ _2246_ _2247_ _2248_ net258 VGND VGND VPWR VPWR _0005_ sky130_fd_sc_hd__a32o_1
Xinput3 theta[0] VGND VGND VPWR VPWR net3 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_36_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_27_Right_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4955_ _1295_ _1734_ _1735_ net71 _1431_ VGND VGND VPWR VPWR _0104_ sky130_fd_sc_hd__a32o_1
X_3906_ _0691_ _0692_ VGND VGND VPWR VPWR _0740_ sky130_fd_sc_hd__or2_1
XFILLER_0_19_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4886_ net114 _1430_ _1432_ _1665_ VGND VGND VPWR VPWR _1666_ sky130_fd_sc_hd__a31o_1
X_3837_ _0638_ _0636_ VGND VGND VPWR VPWR _0672_ sky130_fd_sc_hd__and2b_1
XFILLER_0_34_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3768_ _0587_ _0604_ VGND VGND VPWR VPWR _0605_ sky130_fd_sc_hd__xnor2_2
X_2719_ _1947_ _1965_ VGND VGND VPWR VPWR _1966_ sky130_fd_sc_hd__and2_1
X_3699_ _0525_ _0536_ VGND VGND VPWR VPWR _0537_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_36_Right_36 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_45_Right_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_54_Right_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_63_Right_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4740_ _1296_ _2196_ VGND VGND VPWR VPWR _1517_ sky130_fd_sc_hd__nand2_1
XFILLER_0_83_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4671_ net140 _1447_ VGND VGND VPWR VPWR _1448_ sky130_fd_sc_hd__nand2_2
X_3622_ _0456_ _0458_ _0459_ VGND VGND VPWR VPWR _0460_ sky130_fd_sc_hd__a21o_1
XPHY_EDGE_ROW_72_Right_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3553_ _0355_ _0357_ VGND VGND VPWR VPWR _0391_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3484_ _0296_ _0297_ VGND VGND VPWR VPWR _0322_ sky130_fd_sc_hd__xor2_1
X_2504_ _1421_ VGND VGND VPWR VPWR _1431_ sky130_fd_sc_hd__buf_4
X_4105_ _0930_ _0931_ _0932_ VGND VGND VPWR VPWR _0933_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_81_Right_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5085_ clknet_3_3__leaf_clk _0079_ net200 VGND VGND VPWR VPWR vec\[0\]\[5\] sky130_fd_sc_hd__dfstp_1
X_4036_ _0863_ _0865_ VGND VGND VPWR VPWR _0866_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4938_ _1717_ _1718_ VGND VGND VPWR VPWR _1719_ sky130_fd_sc_hd__nor2_1
XFILLER_0_34_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4869_ _1145_ _1582_ _1647_ VGND VGND VPWR VPWR _1648_ sky130_fd_sc_hd__a21o_1
XFILLER_0_30_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_65_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2984_ _2218_ _2228_ VGND VGND VPWR VPWR _2229_ sky130_fd_sc_hd__xnor2_4
X_4723_ _1498_ _1500_ VGND VGND VPWR VPWR _1501_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_71_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4654_ net173 net171 VGND VGND VPWR VPWR _1430_ sky130_fd_sc_hd__or2_2
XFILLER_0_12_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3605_ _0441_ _0442_ VGND VGND VPWR VPWR _0443_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4585_ _1347_ _1348_ _1142_ VGND VGND VPWR VPWR _1365_ sky130_fd_sc_hd__a21o_1
X_3536_ _0328_ _0373_ VGND VGND VPWR VPWR _0374_ sky130_fd_sc_hd__nor2_1
X_3467_ _0203_ _0201_ VGND VGND VPWR VPWR _0305_ sky130_fd_sc_hd__and2b_1
X_3398_ _0234_ _0235_ VGND VGND VPWR VPWR _0236_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5068_ clknet_3_1__leaf_clk _0062_ net194 VGND VGND VPWR VPWR slte0.opA\[6\] sky130_fd_sc_hd__dfrtp_1
X_4019_ _0816_ _0818_ VGND VGND VPWR VPWR _0850_ sky130_fd_sc_hd__or2_1
XFILLER_0_79_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_0_Right_0 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_7_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4370_ _1431_ VGND VGND VPWR VPWR _1168_ sky130_fd_sc_hd__clkbuf_4
X_3321_ net68 _0140_ VGND VGND VPWR VPWR _0163_ sky130_fd_sc_hd__nand2_1
X_3252_ _2441_ _2459_ _2489_ VGND VGND VPWR VPWR _2490_ sky130_fd_sc_hd__o21ai_1
X_3183_ _2386_ _2391_ _2422_ VGND VGND VPWR VPWR _2423_ sky130_fd_sc_hd__a21o_1
XFILLER_0_28_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_48_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_56_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2967_ net82 net74 _2158_ _2211_ VGND VGND VPWR VPWR _2212_ sky130_fd_sc_hd__a31o_1
X_2898_ _1868_ _1892_ VGND VGND VPWR VPWR _2144_ sky130_fd_sc_hd__nor2_1
X_4706_ _1468_ _1481_ _1480_ _1218_ VGND VGND VPWR VPWR _1484_ sky130_fd_sc_hd__a211o_1
XFILLER_0_44_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4637_ _1411_ _1413_ VGND VGND VPWR VPWR _1414_ sky130_fd_sc_hd__xnor2_1
X_4568_ _1142_ _1348_ VGND VGND VPWR VPWR _1349_ sky130_fd_sc_hd__or2_1
X_3519_ _0216_ _0356_ VGND VGND VPWR VPWR _0357_ sky130_fd_sc_hd__xnor2_1
X_4499_ _1270_ _1285_ _1277_ VGND VGND VPWR VPWR _1286_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3870_ _0578_ _0663_ VGND VGND VPWR VPWR _0705_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2821_ _2062_ _2067_ VGND VGND VPWR VPWR _2068_ sky130_fd_sc_hd__nand2_2
X_2752_ net96 net93 VGND VGND VPWR VPWR _1999_ sky130_fd_sc_hd__or2_1
XFILLER_0_30_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2683_ _1926_ _1927_ VGND VGND VPWR VPWR _1930_ sky130_fd_sc_hd__nor2_1
X_4422_ _1210_ VGND VGND VPWR VPWR _1216_ sky130_fd_sc_hd__inv_2
XFILLER_0_53_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4353_ _1098_ _1150_ _1151_ net256 _1152_ VGND VGND VPWR VPWR _0057_ sky130_fd_sc_hd__a32o_1
X_3304_ _0118_ _0139_ _0146_ VGND VGND VPWR VPWR _0147_ sky130_fd_sc_hd__o21ai_1
X_4284_ net175 _1083_ _1084_ VGND VGND VPWR VPWR _1085_ sky130_fd_sc_hd__and3_1
X_3235_ net220 _2472_ VGND VGND VPWR VPWR _2473_ sky130_fd_sc_hd__xnor2_1
X_3166_ net68 _1852_ net76 VGND VGND VPWR VPWR _2406_ sky130_fd_sc_hd__o21a_1
X_3097_ net71 net66 _2304_ _2338_ VGND VGND VPWR VPWR _2339_ sky130_fd_sc_hd__a31o_1
XFILLER_0_49_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_479 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3999_ net128 _0286_ net132 VGND VGND VPWR VPWR _0830_ sky130_fd_sc_hd__o21a_1
XFILLER_0_57_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout58 vec\[1\]\[17\] VGND VGND VPWR VPWR net58 sky130_fd_sc_hd__clkbuf_2
Xfanout69 net70 VGND VGND VPWR VPWR net69 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_72_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_184 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3020_ _2226_ _2227_ _2218_ VGND VGND VPWR VPWR _2264_ sky130_fd_sc_hd__and3b_1
X_4971_ _1738_ _1739_ _1238_ VGND VGND VPWR VPWR _1752_ sky130_fd_sc_hd__a21oi_1
X_3922_ net53 _0751_ VGND VGND VPWR VPWR _0755_ sky130_fd_sc_hd__nand2_1
X_3853_ net118 VGND VGND VPWR VPWR _0688_ sky130_fd_sc_hd__inv_2
XFILLER_0_73_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2804_ _2049_ _2050_ VGND VGND VPWR VPWR _2051_ sky130_fd_sc_hd__xnor2_2
X_3784_ _0620_ VGND VGND VPWR VPWR _0621_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_26_173 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2735_ net111 net105 VGND VGND VPWR VPWR _1982_ sky130_fd_sc_hd__and2_1
XFILLER_0_54_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2666_ _1911_ _1912_ VGND VGND VPWR VPWR _1913_ sky130_fd_sc_hd__nor2_1
X_4405_ slte0.opA\[5\] _1200_ VGND VGND VPWR VPWR _1201_ sky130_fd_sc_hd__nand2_1
Xfanout204 net207 VGND VGND VPWR VPWR net204 sky130_fd_sc_hd__buf_4
X_2597_ _1841_ _1842_ VGND VGND VPWR VPWR _1844_ sky130_fd_sc_hd__and2b_1
X_4336_ _1133_ _1134_ _1135_ VGND VGND VPWR VPWR _1136_ sky130_fd_sc_hd__and3b_1
X_4267_ net5 _1071_ VGND VGND VPWR VPWR _1072_ sky130_fd_sc_hd__and2_1
X_3218_ _2417_ _2420_ VGND VGND VPWR VPWR _2457_ sky130_fd_sc_hd__or2b_1
X_4198_ _1018_ _1016_ VGND VGND VPWR VPWR _1019_ sky130_fd_sc_hd__nor2_1
X_3149_ net85 _2387_ _2388_ VGND VGND VPWR VPWR _2390_ sky130_fd_sc_hd__or3_1
XFILLER_0_49_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2520_ net87 net83 VGND VGND VPWR VPWR _1592_ sky130_fd_sc_hd__nand2_1
XFILLER_0_51_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4121_ _0899_ _0918_ _0948_ VGND VGND VPWR VPWR _0949_ sky130_fd_sc_hd__o21bai_2
X_4052_ _0862_ _0881_ VGND VGND VPWR VPWR _0882_ sky130_fd_sc_hd__and2_1
Xinput4 theta[10] VGND VGND VPWR VPWR net4 sky130_fd_sc_hd__buf_1
X_3003_ _2142_ VGND VGND VPWR VPWR _2248_ sky130_fd_sc_hd__buf_4
X_4954_ _1708_ _1732_ _1731_ _1718_ VGND VGND VPWR VPWR _1735_ sky130_fd_sc_hd__a211o_1
X_3905_ _0731_ _0738_ VGND VGND VPWR VPWR _0739_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_19_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4885_ _1662_ _1663_ _1296_ VGND VGND VPWR VPWR _1665_ sky130_fd_sc_hd__o21a_1
X_3836_ _0573_ _0617_ _0665_ _0616_ _0374_ VGND VGND VPWR VPWR _0671_ sky130_fd_sc_hd__a2111o_1
X_3767_ _0601_ _0603_ VGND VGND VPWR VPWR _0604_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2718_ net94 net92 VGND VGND VPWR VPWR _1965_ sky130_fd_sc_hd__or2_1
XFILLER_0_42_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3698_ _0534_ _0533_ VGND VGND VPWR VPWR _0536_ sky130_fd_sc_hd__xnor2_1
X_2649_ _1756_ _1895_ VGND VGND VPWR VPWR _1896_ sky130_fd_sc_hd__or2b_1
X_4319_ slte0.opB\[3\] _1115_ _1116_ _1117_ _1118_ VGND VGND VPWR VPWR _1119_ sky130_fd_sc_hd__a221o_1
XFILLER_0_69_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_18_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4670_ _1444_ _1446_ VGND VGND VPWR VPWR _1447_ sky130_fd_sc_hd__xnor2_2
X_3621_ net147 net142 _0221_ VGND VGND VPWR VPWR _0459_ sky130_fd_sc_hd__and3_1
XFILLER_0_24_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3552_ _0386_ _0389_ VGND VGND VPWR VPWR _0390_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2503_ net189 VGND VGND VPWR VPWR _1421_ sky130_fd_sc_hd__inv_2
X_3483_ _0304_ _0319_ _0320_ VGND VGND VPWR VPWR _0321_ sky130_fd_sc_hd__o21ai_1
X_4104_ net118 _0255_ net124 VGND VGND VPWR VPWR _0932_ sky130_fd_sc_hd__o21a_1
XFILLER_0_47_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_5084_ clknet_3_3__leaf_clk _0078_ net200 VGND VGND VPWR VPWR vec\[0\]\[4\] sky130_fd_sc_hd__dfstp_1
X_4035_ _0688_ net113 VGND VGND VPWR VPWR _0865_ sky130_fd_sc_hd__and2_1
XFILLER_0_2_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4937_ net76 _1716_ VGND VGND VPWR VPWR _1718_ sky130_fd_sc_hd__nor2_1
XFILLER_0_74_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4868_ _1324_ _1583_ _1585_ _1462_ VGND VGND VPWR VPWR _1647_ sky130_fd_sc_hd__a22o_1
X_3819_ _0640_ _0654_ VGND VGND VPWR VPWR _0655_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_27_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4799_ _1574_ _1575_ VGND VGND VPWR VPWR _1576_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_474 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2983_ _2226_ _2227_ VGND VGND VPWR VPWR _2228_ sky130_fd_sc_hd__and2b_1
X_4722_ _1486_ _1489_ _1499_ VGND VGND VPWR VPWR _1500_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_83_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_56_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4653_ _1098_ _1428_ _1429_ VGND VGND VPWR VPWR _0081_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_71_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3604_ _0439_ _0438_ VGND VGND VPWR VPWR _0442_ sky130_fd_sc_hd__xnor2_1
X_4584_ _1193_ _1362_ _1363_ VGND VGND VPWR VPWR _1364_ sky130_fd_sc_hd__a21boi_1
X_3535_ _0345_ _0371_ _0372_ VGND VGND VPWR VPWR _0373_ sky130_fd_sc_hd__a21o_1
XFILLER_0_24_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3466_ _0212_ _0211_ VGND VGND VPWR VPWR _0304_ sky130_fd_sc_hd__xor2_2
XFILLER_0_58_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3397_ net142 net136 VGND VGND VPWR VPWR _0235_ sky130_fd_sc_hd__xor2_4
XFILLER_0_42_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5067_ clknet_3_1__leaf_clk _0061_ net196 VGND VGND VPWR VPWR slte0.opA\[5\] sky130_fd_sc_hd__dfrtp_2
XFILLER_0_74_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4018_ _0816_ _0818_ VGND VGND VPWR VPWR _0849_ sky130_fd_sc_hd__and2_1
XFILLER_0_79_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_54_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3320_ _0121_ _0149_ VGND VGND VPWR VPWR _0162_ sky130_fd_sc_hd__or2b_1
XFILLER_0_0_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3251_ _2455_ _2458_ VGND VGND VPWR VPWR _2489_ sky130_fd_sc_hd__or2b_1
X_3182_ _2383_ _2385_ VGND VGND VPWR VPWR _2422_ sky130_fd_sc_hd__nor2_1
XFILLER_0_76_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_8_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2966_ net77 _1817_ VGND VGND VPWR VPWR _2211_ sky130_fd_sc_hd__nor2_1
X_2897_ net265 _2139_ _2143_ net261 VGND VGND VPWR VPWR _0003_ sky130_fd_sc_hd__a22o_1
X_4705_ _1218_ _1480_ _1481_ _1468_ VGND VGND VPWR VPWR _1483_ sky130_fd_sc_hd__o211ai_1
X_4636_ _1397_ _1412_ VGND VGND VPWR VPWR _1413_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4567_ _1315_ _1332_ VGND VGND VPWR VPWR _1348_ sky130_fd_sc_hd__and2_1
X_3518_ net151 _0330_ _0331_ VGND VGND VPWR VPWR _0356_ sky130_fd_sc_hd__o21a_1
X_4498_ _1262_ _1276_ VGND VGND VPWR VPWR _1285_ sky130_fd_sc_hd__nor2_1
X_3449_ net132 net128 VGND VGND VPWR VPWR _0287_ sky130_fd_sc_hd__nand2_2
XFILLER_0_85_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_49_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2820_ net108 net106 VGND VGND VPWR VPWR _2067_ sky130_fd_sc_hd__or2b_1
X_2751_ _1966_ _1967_ VGND VGND VPWR VPWR _1998_ sky130_fd_sc_hd__xor2_2
X_2682_ _1909_ _1907_ VGND VGND VPWR VPWR _1929_ sky130_fd_sc_hd__xnor2_1
X_4421_ _1098_ _1213_ _1215_ net259 net266 VGND VGND VPWR VPWR _0062_ sky130_fd_sc_hd__a32o_1
XFILLER_0_41_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4352_ _1431_ VGND VGND VPWR VPWR _1152_ sky130_fd_sc_hd__buf_4
X_3303_ _0141_ _0145_ VGND VGND VPWR VPWR _0146_ sky130_fd_sc_hd__xnor2_1
X_4283_ net183 net178 VGND VGND VPWR VPWR _1084_ sky130_fd_sc_hd__and2b_1
X_3234_ net65 net56 net59 VGND VGND VPWR VPWR _2472_ sky130_fd_sc_hd__mux2_1
X_3165_ _2404_ _2405_ net236 _2201_ VGND VGND VPWR VPWR _0009_ sky130_fd_sc_hd__a2bb2o_1
X_3096_ net69 _2303_ VGND VGND VPWR VPWR _2338_ sky130_fd_sc_hd__nor2_1
XFILLER_0_76_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout59 net60 VGND VGND VPWR VPWR net59 sky130_fd_sc_hd__clkbuf_8
X_3998_ _0254_ _0727_ VGND VGND VPWR VPWR _0829_ sky130_fd_sc_hd__nand2_1
XFILLER_0_17_311 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2949_ _2194_ VGND VGND VPWR VPWR _2195_ sky130_fd_sc_hd__buf_2
XFILLER_0_44_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4619_ net152 _1395_ VGND VGND VPWR VPWR _1397_ sky130_fd_sc_hd__nor2_1
XFILLER_0_55_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4970_ net114 _1194_ _1750_ VGND VGND VPWR VPWR _1751_ sky130_fd_sc_hd__a21oi_1
X_3921_ _0711_ VGND VGND VPWR VPWR _0754_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_46_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3852_ net122 net112 VGND VGND VPWR VPWR _0687_ sky130_fd_sc_hd__nor2_2
XFILLER_0_26_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2803_ _2022_ _2024_ VGND VGND VPWR VPWR _2050_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_61_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3783_ domain\[0\] domain\[1\] VGND VGND VPWR VPWR _0620_ sky130_fd_sc_hd__xnor2_1
X_2734_ net111 VGND VGND VPWR VPWR _1981_ sky130_fd_sc_hd__inv_2
X_2665_ net111 _1903_ _1910_ VGND VGND VPWR VPWR _1912_ sky130_fd_sc_hd__nor3_1
X_2596_ _1841_ _1842_ VGND VGND VPWR VPWR _1843_ sky130_fd_sc_hd__xnor2_2
X_4404_ _1197_ _1199_ VGND VGND VPWR VPWR _1200_ sky130_fd_sc_hd__xnor2_1
Xfanout205 net207 VGND VGND VPWR VPWR net205 sky130_fd_sc_hd__clkbuf_2
X_4335_ slte0.opB\[14\] _1132_ VGND VGND VPWR VPWR _1135_ sky130_fd_sc_hd__or2_1
XFILLER_0_66_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4266_ net16 _1042_ _1053_ _1067_ VGND VGND VPWR VPWR _1071_ sky130_fd_sc_hd__and4_1
XFILLER_0_5_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3217_ _2414_ _2416_ VGND VGND VPWR VPWR _2456_ sky130_fd_sc_hd__or2b_1
X_4197_ _1017_ VGND VGND VPWR VPWR _1018_ sky130_fd_sc_hd__clkbuf_4
X_3148_ _2387_ _2388_ net85 VGND VGND VPWR VPWR _2389_ sky130_fd_sc_hd__o21ai_2
X_3079_ _2320_ _2321_ VGND VGND VPWR VPWR _2322_ sky130_fd_sc_hd__xor2_1
XFILLER_0_49_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_55_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_11_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_23_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4120_ _0915_ _0917_ VGND VGND VPWR VPWR _0948_ sky130_fd_sc_hd__and2b_1
X_4051_ _0878_ _0880_ VGND VGND VPWR VPWR _0881_ sky130_fd_sc_hd__xor2_1
X_3002_ net168 _2202_ _2245_ VGND VGND VPWR VPWR _2247_ sky130_fd_sc_hd__a21o_1
Xinput5 theta[11] VGND VGND VPWR VPWR net5 sky130_fd_sc_hd__buf_1
XFILLER_0_36_64 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_406 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4953_ _1731_ _1733_ VGND VGND VPWR VPWR _1734_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3904_ _0732_ _0737_ VGND VGND VPWR VPWR _0738_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_52_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4884_ _1324_ _1601_ _1605_ _1462_ VGND VGND VPWR VPWR _1663_ sky130_fd_sc_hd__a22o_1
XFILLER_0_52_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3835_ _0629_ _0664_ _0669_ VGND VGND VPWR VPWR _0670_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_61_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3766_ _0250_ _0265_ _0602_ VGND VGND VPWR VPWR _0603_ sky130_fd_sc_hd__a21boi_2
X_2717_ _1916_ _1918_ VGND VGND VPWR VPWR _1964_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_42_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3697_ _0533_ _0534_ VGND VGND VPWR VPWR _0535_ sky130_fd_sc_hd__or2b_1
X_2648_ net91 net88 VGND VGND VPWR VPWR _1895_ sky130_fd_sc_hd__nand2_1
X_2579_ _1824_ _1825_ VGND VGND VPWR VPWR _1826_ sky130_fd_sc_hd__xnor2_4
X_4318_ slte0.opA\[2\] slte0.opB\[2\] VGND VGND VPWR VPWR _1118_ sky130_fd_sc_hd__and2b_1
X_4249_ net17 _1057_ VGND VGND VPWR VPWR _1058_ sky130_fd_sc_hd__xor2_1
XFILLER_0_65_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_2_Left_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3620_ _0447_ _0457_ VGND VGND VPWR VPWR _0458_ sky130_fd_sc_hd__and2_1
X_3551_ net161 _0388_ net165 VGND VGND VPWR VPWR _0389_ sky130_fd_sc_hd__o21ai_1
X_3482_ _0317_ _0318_ VGND VGND VPWR VPWR _0320_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_16_Left_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4103_ _0687_ _0727_ VGND VGND VPWR VPWR _0931_ sky130_fd_sc_hd__or2_1
X_5083_ clknet_3_6__leaf_clk _0077_ net199 VGND VGND VPWR VPWR vec\[0\]\[3\] sky130_fd_sc_hd__dfstp_1
X_4034_ net124 _0269_ net129 VGND VGND VPWR VPWR _0864_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_63_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_25_Left_111 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4936_ net76 _1716_ VGND VGND VPWR VPWR _1717_ sky130_fd_sc_hd__and2_1
X_4867_ _1152_ net98 _1645_ _1646_ VGND VGND VPWR VPWR _0097_ sky130_fd_sc_hd__a22o_1
X_3818_ _0651_ _0653_ VGND VGND VPWR VPWR _0654_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_6_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4798_ _1142_ _1554_ VGND VGND VPWR VPWR _1575_ sky130_fd_sc_hd__nor2_1
XFILLER_0_15_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3749_ _0581_ _0584_ VGND VGND VPWR VPWR _0586_ sky130_fd_sc_hd__and2_1
XFILLER_0_30_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_34_Left_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_10_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_217 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2982_ _2221_ _2222_ _2225_ VGND VGND VPWR VPWR _2227_ sky130_fd_sc_hd__or3_1
XFILLER_0_8_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4721_ net129 _1485_ VGND VGND VPWR VPWR _1499_ sky130_fd_sc_hd__nand2_1
X_4652_ net189 net146 VGND VGND VPWR VPWR _1429_ sky130_fd_sc_hd__nor2_1
X_3603_ _0422_ _0417_ VGND VGND VPWR VPWR _0441_ sky130_fd_sc_hd__and2b_1
XFILLER_0_12_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4583_ net54 _1169_ VGND VGND VPWR VPWR _1363_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3534_ _0369_ _0370_ VGND VGND VPWR VPWR _0372_ sky130_fd_sc_hd__nor2_1
XFILLER_0_12_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3465_ net164 _0214_ VGND VGND VPWR VPWR _0303_ sky130_fd_sc_hd__xnor2_2
X_3396_ net136 vec\[0\]\[11\] VGND VGND VPWR VPWR _0234_ sky130_fd_sc_hd__nand2_1
X_5066_ clknet_3_1__leaf_clk _0060_ net196 VGND VGND VPWR VPWR slte0.opA\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_72 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4017_ _0813_ _0847_ VGND VGND VPWR VPWR _0848_ sky130_fd_sc_hd__xor2_2
XFILLER_0_79_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4919_ net114 _1584_ _1219_ VGND VGND VPWR VPWR _1699_ sky130_fd_sc_hd__mux2_1
XFILLER_0_47_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_494 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_375 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_5_Left_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3250_ _2468_ _2487_ VGND VGND VPWR VPWR _2488_ sky130_fd_sc_hd__xor2_1
XFILLER_0_28_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3181_ _2417_ _2420_ VGND VGND VPWR VPWR _2421_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_21_9 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_29_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4704_ _1219_ _1376_ VGND VGND VPWR VPWR _1481_ sky130_fd_sc_hd__nand2_1
X_2965_ net87 _1787_ net95 VGND VGND VPWR VPWR _2210_ sky130_fd_sc_hd__o21ai_2
X_2896_ _2142_ VGND VGND VPWR VPWR _2143_ sky130_fd_sc_hd__buf_4
XFILLER_0_60_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4635_ _1373_ _1384_ _1396_ _1382_ VGND VGND VPWR VPWR _1412_ sky130_fd_sc_hd__o211a_1
XFILLER_0_44_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4566_ _1193_ _1342_ _1346_ _1331_ VGND VGND VPWR VPWR _1347_ sky130_fd_sc_hd__a31o_1
XFILLER_0_12_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3517_ _0353_ _0354_ VGND VGND VPWR VPWR _0355_ sky130_fd_sc_hd__xor2_1
X_4497_ _1283_ VGND VGND VPWR VPWR _1284_ sky130_fd_sc_hd__inv_2
X_3448_ net130 vec\[0\]\[14\] VGND VGND VPWR VPWR _0286_ sky130_fd_sc_hd__xor2_4
X_3379_ net150 net144 VGND VGND VPWR VPWR _0217_ sky130_fd_sc_hd__xor2_4
XFILLER_0_85_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5049_ clknet_3_0__leaf_clk _0043_ net193 VGND VGND VPWR VPWR slte0.opB\[5\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_67_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclone11 net100 VGND VGND VPWR VPWR net218 sky130_fd_sc_hd__clkbuf_2
XFILLER_0_62_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2750_ _1899_ _1996_ VGND VGND VPWR VPWR _1997_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_81_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2681_ _1926_ _1927_ VGND VGND VPWR VPWR _1928_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4420_ _1212_ _1214_ VGND VGND VPWR VPWR _1215_ sky130_fd_sc_hd__nand2_1
X_4351_ _1096_ _1149_ VGND VGND VPWR VPWR _1151_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_42 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3302_ _2310_ _0144_ VGND VGND VPWR VPWR _0145_ sky130_fd_sc_hd__or2b_1
XFILLER_0_1_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4282_ net173 net171 VGND VGND VPWR VPWR _1083_ sky130_fd_sc_hd__nor2_2
X_3233_ _1829_ VGND VGND VPWR VPWR _2471_ sky130_fd_sc_hd__inv_2
X_3164_ net167 _2369_ _2403_ _2199_ VGND VGND VPWR VPWR _2405_ sky130_fd_sc_hd__a31o_1
X_3095_ net75 _1915_ net81 VGND VGND VPWR VPWR _2337_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_64_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3997_ _0827_ _0828_ net228 _2201_ VGND VGND VPWR VPWR _0025_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_29_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2948_ net173 net175 VGND VGND VPWR VPWR _2194_ sky130_fd_sc_hd__or2_1
X_4618_ net152 _1395_ VGND VGND VPWR VPWR _1396_ sky130_fd_sc_hd__nand2_1
XFILLER_0_44_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2879_ _2057_ _2058_ VGND VGND VPWR VPWR _2126_ sky130_fd_sc_hd__xor2_1
X_4549_ _1081_ net54 VGND VGND VPWR VPWR _1331_ sky130_fd_sc_hd__nor2_1
XFILLER_0_23_315 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_33 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3920_ net265 _0752_ _0753_ _2248_ net229 VGND VGND VPWR VPWR _0023_ sky130_fd_sc_hd__a32o_1
XFILLER_0_73_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3851_ _0287_ _0685_ VGND VGND VPWR VPWR _0686_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_39_470 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3782_ _0616_ _0618_ VGND VGND VPWR VPWR _0619_ sky130_fd_sc_hd__xnor2_2
X_2802_ _1806_ _2047_ _2048_ VGND VGND VPWR VPWR _2049_ sky130_fd_sc_hd__a21boi_1
X_2733_ _1911_ _1937_ VGND VGND VPWR VPWR _1980_ sky130_fd_sc_hd__xor2_2
XFILLER_0_26_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2664_ _1903_ _1910_ net111 VGND VGND VPWR VPWR _1911_ sky130_fd_sc_hd__o21a_1
X_2595_ _1826_ _1828_ VGND VGND VPWR VPWR _1842_ sky130_fd_sc_hd__xor2_2
X_4403_ _1157_ _1198_ VGND VGND VPWR VPWR _1199_ sky130_fd_sc_hd__nor2_1
X_4334_ slte0.opB\[15\] _1131_ VGND VGND VPWR VPWR _1134_ sky130_fd_sc_hd__or2_1
XFILLER_0_5_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout206 net207 VGND VGND VPWR VPWR net206 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_5_76 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4265_ _1070_ VGND VGND VPWR VPWR _0051_ sky130_fd_sc_hd__clkbuf_1
X_3216_ _2452_ _2454_ VGND VGND VPWR VPWR _2455_ sky130_fd_sc_hd__xnor2_2
X_4196_ net179 VGND VGND VPWR VPWR _1017_ sky130_fd_sc_hd__inv_2
X_3147_ _2337_ _2342_ VGND VGND VPWR VPWR _2388_ sky130_fd_sc_hd__and2b_1
XFILLER_0_82_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3078_ _2263_ _2274_ _2273_ VGND VGND VPWR VPWR _2321_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_64_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_454 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4050_ _0836_ _0837_ _0879_ VGND VGND VPWR VPWR _0880_ sky130_fd_sc_hd__o21ai_1
X_3001_ net167 _2202_ _2245_ VGND VGND VPWR VPWR _2246_ sky130_fd_sc_hd__nand3_1
Xinput6 theta[12] VGND VGND VPWR VPWR net6 sky130_fd_sc_hd__buf_1
X_4952_ _1708_ _1732_ _1718_ VGND VGND VPWR VPWR _1733_ sky130_fd_sc_hd__a21o_1
X_3903_ _0734_ _0736_ VGND VGND VPWR VPWR _0737_ sky130_fd_sc_hd__xnor2_1
X_4883_ _1183_ _1600_ VGND VGND VPWR VPWR _1662_ sky130_fd_sc_hd__nor2_1
XFILLER_0_52_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3834_ _0629_ _0664_ _0613_ _0615_ VGND VGND VPWR VPWR _0669_ sky130_fd_sc_hd__o211a_1
XFILLER_0_46_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3765_ _0257_ _0264_ VGND VGND VPWR VPWR _0602_ sky130_fd_sc_hd__nand2_1
X_3696_ _0207_ _0500_ VGND VGND VPWR VPWR _0534_ sky130_fd_sc_hd__xor2_1
X_2716_ _1633_ _1962_ VGND VGND VPWR VPWR _1963_ sky130_fd_sc_hd__xnor2_2
X_2647_ _1736_ _1893_ VGND VGND VPWR VPWR _1894_ sky130_fd_sc_hd__xor2_2
XFILLER_0_65_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2578_ net65 net59 VGND VGND VPWR VPWR _1825_ sky130_fd_sc_hd__xor2_4
X_4317_ slte0.opA\[1\] slte0.opA\[0\] VGND VGND VPWR VPWR _1117_ sky130_fd_sc_hd__nor2_1
X_4248_ net16 _1043_ _1053_ net192 VGND VGND VPWR VPWR _1057_ sky130_fd_sc_hd__a31o_1
X_4179_ _0982_ _0993_ _0621_ VGND VGND VPWR VPWR _1004_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_340 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_14_Right_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xclkbuf_3_3__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_3__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_52_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_20_115 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_23_Right_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_73_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_32_Right_32 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_83_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3550_ _0382_ _0387_ VGND VGND VPWR VPWR _0388_ sky130_fd_sc_hd__nor2_2
X_3481_ _0317_ _0318_ VGND VGND VPWR VPWR _0319_ sky130_fd_sc_hd__and2_1
XFILLER_0_11_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_41_Right_41 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4102_ net122 net118 net112 VGND VGND VPWR VPWR _0930_ sky130_fd_sc_hd__or3_1
X_5082_ clknet_3_6__leaf_clk _0076_ net206 VGND VGND VPWR VPWR vec\[0\]\[2\] sky130_fd_sc_hd__dfstp_1
X_4033_ net122 net112 VGND VGND VPWR VPWR _0863_ sky130_fd_sc_hd__and2_1
XFILLER_0_2_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_50_Right_50 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4935_ _1712_ _1714_ VGND VGND VPWR VPWR _1716_ sky130_fd_sc_hd__xnor2_1
X_4866_ _1640_ _1641_ _1643_ _1014_ VGND VGND VPWR VPWR _1646_ sky130_fd_sc_hd__o31a_1
X_3817_ _0590_ _0600_ _0652_ VGND VGND VPWR VPWR _0653_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_27_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4797_ gm0.iter\[4\] _1572_ _1573_ VGND VGND VPWR VPWR _1574_ sky130_fd_sc_hd__o21ai_1
X_3748_ _0581_ _0584_ VGND VGND VPWR VPWR _0585_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3679_ _0515_ _0511_ _0516_ VGND VGND VPWR VPWR _0517_ sky130_fd_sc_hd__o21a_1
XFILLER_0_69_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_68_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2981_ _2221_ _2222_ _2225_ VGND VGND VPWR VPWR _2226_ sky130_fd_sc_hd__o21a_1
X_4720_ _1496_ _1497_ VGND VGND VPWR VPWR _1498_ sky130_fd_sc_hd__and2_1
XFILLER_0_56_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4651_ _1425_ _1427_ VGND VGND VPWR VPWR _1428_ sky130_fd_sc_hd__xnor2_1
X_3602_ _0438_ _0439_ VGND VGND VPWR VPWR _0440_ sky130_fd_sc_hd__or2b_1
X_4582_ _1024_ _1358_ _1359_ _1087_ _1361_ VGND VGND VPWR VPWR _1362_ sky130_fd_sc_hd__o221a_1
X_3533_ _0369_ _0370_ VGND VGND VPWR VPWR _0371_ sky130_fd_sc_hd__xor2_1
X_3464_ _0232_ _0301_ VGND VGND VPWR VPWR _0302_ sky130_fd_sc_hd__xnor2_1
X_3395_ net148 _0217_ net154 VGND VGND VPWR VPWR _0233_ sky130_fd_sc_hd__o21a_1
XFILLER_0_58_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5065_ clknet_3_0__leaf_clk _0059_ net197 VGND VGND VPWR VPWR slte0.opA\[3\] sky130_fd_sc_hd__dfrtp_1
X_4016_ _0845_ _0846_ VGND VGND VPWR VPWR _0847_ sky130_fd_sc_hd__nand2_1
XFILLER_0_79_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4918_ _1697_ _1698_ net81 _1168_ VGND VGND VPWR VPWR _0101_ sky130_fd_sc_hd__a2bb2o_1
X_4849_ net217 _1627_ VGND VGND VPWR VPWR _1628_ sky130_fd_sc_hd__nand2_1
XFILLER_0_85_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3180_ net81 _2419_ VGND VGND VPWR VPWR _2420_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_53_Left_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_48_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2964_ _2207_ _2208_ VGND VGND VPWR VPWR _2209_ sky130_fd_sc_hd__and2_1
XFILLER_0_17_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4703_ _1469_ _1456_ _1458_ VGND VGND VPWR VPWR _1480_ sky130_fd_sc_hd__and3b_1
XFILLER_0_44_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2895_ _2141_ _1522_ VGND VGND VPWR VPWR _2142_ sky130_fd_sc_hd__nor2_2
XPHY_EDGE_ROW_62_Left_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_4_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4634_ _1409_ _1410_ VGND VGND VPWR VPWR _1411_ sky130_fd_sc_hd__nand2_1
XFILLER_0_12_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4565_ _1024_ _1345_ VGND VGND VPWR VPWR _1346_ sky130_fd_sc_hd__nand2_1
XFILLER_0_69_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3516_ _0309_ _0311_ VGND VGND VPWR VPWR _0354_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_4_Right_4 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4496_ _1281_ _1282_ VGND VGND VPWR VPWR _1283_ sky130_fd_sc_hd__and2_1
XFILLER_0_12_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3447_ _0283_ _0284_ VGND VGND VPWR VPWR _0285_ sky130_fd_sc_hd__xnor2_2
X_3378_ net154 net148 VGND VGND VPWR VPWR _0216_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_71_Left_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5048_ clknet_3_0__leaf_clk _0042_ net193 VGND VGND VPWR VPWR slte0.opB\[4\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_67_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_80_Left_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2680_ _1873_ _1882_ VGND VGND VPWR VPWR _1927_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_30_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_424 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4350_ _1096_ _1149_ VGND VGND VPWR VPWR _1150_ sky130_fd_sc_hd__or2_1
X_3301_ net59 _0142_ _0114_ net57 _0143_ VGND VGND VPWR VPWR _0144_ sky130_fd_sc_hd__a221o_1
XFILLER_0_1_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4281_ _1018_ net175 _1081_ net183 net173 VGND VGND VPWR VPWR _1082_ sky130_fd_sc_hd__o2111a_1
X_3232_ _2452_ _2454_ VGND VGND VPWR VPWR _2470_ sky130_fd_sc_hd__nand2_1
X_3163_ net167 _2369_ _2403_ VGND VGND VPWR VPWR _2404_ sky130_fd_sc_hd__a21oi_1
X_3094_ _1826_ _2335_ VGND VGND VPWR VPWR _2336_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_12_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3996_ _0754_ _0791_ _0826_ _2199_ VGND VGND VPWR VPWR _0828_ sky130_fd_sc_hd__a31o_1
XFILLER_0_57_482 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2947_ net167 _2139_ _2192_ VGND VGND VPWR VPWR _2193_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_44_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4617_ _1392_ _1394_ VGND VGND VPWR VPWR _1395_ sky130_fd_sc_hd__xor2_1
X_2878_ _2114_ _2116_ VGND VGND VPWR VPWR _2125_ sky130_fd_sc_hd__or2_1
X_4548_ _1324_ _1325_ _1329_ VGND VGND VPWR VPWR _1330_ sky130_fd_sc_hd__a21oi_1
X_4479_ _1264_ _1267_ VGND VGND VPWR VPWR _1268_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_79_Right_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3850_ _0286_ _0684_ VGND VGND VPWR VPWR _0685_ sky130_fd_sc_hd__xnor2_2
X_3781_ _0573_ _0617_ _0374_ VGND VGND VPWR VPWR _0618_ sky130_fd_sc_hd__a21o_1
X_2801_ net97 net91 _1571_ VGND VGND VPWR VPWR _2048_ sky130_fd_sc_hd__nand3_1
X_2732_ _1941_ _1978_ VGND VGND VPWR VPWR _1979_ sky130_fd_sc_hd__and2b_1
XFILLER_0_26_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2663_ _1907_ _1909_ VGND VGND VPWR VPWR _1910_ sky130_fd_sc_hd__and2b_1
X_2594_ _1837_ _1839_ _1840_ VGND VGND VPWR VPWR _1841_ sky130_fd_sc_hd__a21oi_2
X_4402_ net178 _1023_ _1144_ _1146_ VGND VGND VPWR VPWR _1198_ sky130_fd_sc_hd__a31o_1
XFILLER_0_5_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4333_ slte0.opB\[15\] _1131_ slte0.opB\[14\] _1132_ VGND VGND VPWR VPWR _1133_ sky130_fd_sc_hd__a22o_1
X_4264_ slte0.opB\[13\] _1069_ _2141_ VGND VGND VPWR VPWR _1070_ sky130_fd_sc_hd__mux2_1
Xfanout207 net2 VGND VGND VPWR VPWR net207 sky130_fd_sc_hd__buf_2
X_3215_ net78 _2453_ VGND VGND VPWR VPWR _2454_ sky130_fd_sc_hd__xnor2_2
X_4195_ net183 _1015_ _1016_ VGND VGND VPWR VPWR _0035_ sky130_fd_sc_hd__o21a_1
X_3146_ _2341_ _2339_ VGND VGND VPWR VPWR _2387_ sky130_fd_sc_hd__and2b_1
X_3077_ _2312_ _2319_ VGND VGND VPWR VPWR _2320_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_49_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_17_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3979_ _0763_ _0761_ VGND VGND VPWR VPWR _0811_ sky130_fd_sc_hd__and2b_1
XFILLER_0_45_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_179 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_190 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3000_ _2203_ _2244_ VGND VGND VPWR VPWR _2245_ sky130_fd_sc_hd__xnor2_1
Xinput7 theta[13] VGND VGND VPWR VPWR net7 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_36_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4951_ net76 _1716_ _1703_ VGND VGND VPWR VPWR _1732_ sky130_fd_sc_hd__a21oi_1
X_3902_ _0735_ _0349_ net140 VGND VGND VPWR VPWR _0736_ sky130_fd_sc_hd__mux2_1
X_4882_ _1660_ _1661_ net95 _1168_ VGND VGND VPWR VPWR _0098_ sky130_fd_sc_hd__a2bb2o_1
X_3833_ net265 _0667_ _0668_ _2248_ net227 VGND VGND VPWR VPWR _0021_ sky130_fd_sc_hd__a32o_1
XFILLER_0_14_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3764_ _0590_ _0600_ VGND VGND VPWR VPWR _0601_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_42_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3695_ _0335_ _0527_ _0532_ VGND VGND VPWR VPWR _0533_ sky130_fd_sc_hd__a21oi_1
X_2715_ net221 _1947_ _1948_ VGND VGND VPWR VPWR _1962_ sky130_fd_sc_hd__o21a_1
X_2646_ _1868_ _1892_ VGND VGND VPWR VPWR _1893_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_42_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2577_ net68 net62 VGND VGND VPWR VPWR _1824_ sky130_fd_sc_hd__nand2_2
XFILLER_0_58_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4316_ slte0.opB\[2\] slte0.opA\[2\] VGND VGND VPWR VPWR _1116_ sky130_fd_sc_hd__or2b_1
X_4247_ net248 _1442_ _1055_ _1056_ VGND VGND VPWR VPWR _0047_ sky130_fd_sc_hd__a22o_1
X_4178_ _0996_ _1002_ VGND VGND VPWR VPWR _1003_ sky130_fd_sc_hd__xor2_1
X_3129_ _2353_ _2355_ VGND VGND VPWR VPWR _2370_ sky130_fd_sc_hd__and2_1
XFILLER_0_37_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3480_ _0285_ _0294_ VGND VGND VPWR VPWR _0318_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4101_ net132 _0913_ VGND VGND VPWR VPWR _0929_ sky130_fd_sc_hd__nand2_1
X_5081_ clknet_3_6__leaf_clk _0075_ net199 VGND VGND VPWR VPWR vec\[0\]\[1\] sky130_fd_sc_hd__dfstp_1
XFILLER_0_47_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4032_ _0840_ net140 VGND VGND VPWR VPWR _0862_ sky130_fd_sc_hd__or2b_1
XFILLER_0_2_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4934_ _1238_ _1713_ VGND VGND VPWR VPWR _1714_ sky130_fd_sc_hd__or2b_1
XFILLER_0_59_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4865_ _1640_ _1641_ _1643_ VGND VGND VPWR VPWR _1645_ sky130_fd_sc_hd__o21ai_1
X_3816_ _0597_ _0599_ VGND VGND VPWR VPWR _0652_ sky130_fd_sc_hd__nand2_1
X_4796_ _1193_ net116 VGND VGND VPWR VPWR _1573_ sky130_fd_sc_hd__or2_1
XFILLER_0_15_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3747_ _0553_ _0583_ VGND VGND VPWR VPWR _0584_ sky130_fd_sc_hd__xor2_1
XFILLER_0_15_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3678_ _0507_ _0508_ VGND VGND VPWR VPWR _0516_ sky130_fd_sc_hd__nand2_1
X_2629_ _1874_ _1875_ VGND VGND VPWR VPWR _1876_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_69_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_18_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2980_ _2223_ _2224_ VGND VGND VPWR VPWR _2225_ sky130_fd_sc_hd__xnor2_1
X_4650_ _1409_ _1426_ VGND VGND VPWR VPWR _1427_ sky130_fd_sc_hd__nand2_1
Xinput10 theta[1] VGND VGND VPWR VPWR net10 sky130_fd_sc_hd__buf_1
X_3601_ _0390_ _0402_ VGND VGND VPWR VPWR _0439_ sky130_fd_sc_hd__xor2_1
XFILLER_0_3_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4581_ _1312_ _1326_ _1360_ _1273_ VGND VGND VPWR VPWR _1361_ sky130_fd_sc_hd__o22a_1
X_3532_ _0303_ _0324_ VGND VGND VPWR VPWR _0370_ sky130_fd_sc_hd__xnor2_1
X_3463_ _0281_ _0300_ VGND VGND VPWR VPWR _0301_ sky130_fd_sc_hd__xor2_1
XFILLER_0_58_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3394_ _0230_ _0231_ VGND VGND VPWR VPWR _0232_ sky130_fd_sc_hd__and2_1
X_5064_ clknet_3_0__leaf_clk _0058_ net194 VGND VGND VPWR VPWR slte0.opA\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_74_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4015_ _0842_ _0844_ VGND VGND VPWR VPWR _0846_ sky130_fd_sc_hd__or2_1
XFILLER_0_79_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_119 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4917_ _1681_ _1688_ _1696_ VGND VGND VPWR VPWR _1698_ sky130_fd_sc_hd__a21oi_1
X_4848_ _1625_ _1626_ VGND VGND VPWR VPWR _1627_ sky130_fd_sc_hd__nor2_1
XFILLER_0_62_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4779_ net111 _1554_ VGND VGND VPWR VPWR _1555_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_70_391 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_79_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2963_ net101 _2206_ _2155_ VGND VGND VPWR VPWR _2208_ sky130_fd_sc_hd__or3_1
XFILLER_0_84_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4702_ net135 _1460_ _1471_ net133 VGND VGND VPWR VPWR _1479_ sky130_fd_sc_hd__a22o_1
X_2894_ _2140_ VGND VGND VPWR VPWR _2141_ sky130_fd_sc_hd__clkbuf_4
X_4633_ net149 _1408_ VGND VGND VPWR VPWR _1410_ sky130_fd_sc_hd__or2_1
X_4564_ _1343_ _1344_ _1022_ VGND VGND VPWR VPWR _1345_ sky130_fd_sc_hd__mux2_1
XFILLER_0_4_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3515_ _0349_ _0351_ _0352_ VGND VGND VPWR VPWR _0353_ sky130_fd_sc_hd__a21o_1
X_4495_ slte0.opA\[14\] _1280_ VGND VGND VPWR VPWR _1282_ sky130_fd_sc_hd__or2_1
X_3446_ _0224_ _0222_ VGND VGND VPWR VPWR _0284_ sky130_fd_sc_hd__and2b_1
X_3377_ _0199_ _0214_ VGND VGND VPWR VPWR _0215_ sky130_fd_sc_hd__or2_2
XFILLER_0_40_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5047_ clknet_3_0__leaf_clk _0041_ net193 VGND VGND VPWR VPWR slte0.opB\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_50_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_30_24 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3300_ net56 net62 VGND VGND VPWR VPWR _0143_ sky130_fd_sc_hd__and2_1
XFILLER_0_39_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4280_ net170 VGND VGND VPWR VPWR _1081_ sky130_fd_sc_hd__inv_2
X_3231_ _2451_ _2450_ VGND VGND VPWR VPWR _2469_ sky130_fd_sc_hd__or2b_1
X_3162_ _2400_ _2402_ VGND VGND VPWR VPWR _2403_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_55_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3093_ _2165_ _2305_ _2334_ VGND VGND VPWR VPWR _2335_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_76_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_97 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3995_ _0754_ _0791_ _0826_ VGND VGND VPWR VPWR _0827_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_17_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2946_ _2187_ _2191_ VGND VGND VPWR VPWR _2192_ sky130_fd_sc_hd__xor2_2
X_2877_ _2087_ _2090_ _2111_ _2117_ _2123_ VGND VGND VPWR VPWR _2124_ sky130_fd_sc_hd__a311o_1
XFILLER_0_4_230 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4616_ _1179_ _1393_ VGND VGND VPWR VPWR _1394_ sky130_fd_sc_hd__or2b_1
XFILLER_0_44_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4547_ _1017_ _1326_ _1327_ _1328_ _1452_ VGND VGND VPWR VPWR _1329_ sky130_fd_sc_hd__o2111a_1
X_4478_ _1252_ _1266_ _1257_ VGND VGND VPWR VPWR _1267_ sky130_fd_sc_hd__o21ai_1
X_3429_ net144 net138 _0236_ VGND VGND VPWR VPWR _0267_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_63_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3780_ _0328_ _0373_ _0412_ _0413_ VGND VGND VPWR VPWR _0617_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_26_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2800_ _2041_ _2046_ VGND VGND VPWR VPWR _2047_ sky130_fd_sc_hd__nor2_2
X_2731_ _1957_ _1976_ _1977_ VGND VGND VPWR VPWR _1978_ sky130_fd_sc_hd__a21bo_1
X_2662_ _1903_ _1908_ VGND VGND VPWR VPWR _1909_ sky130_fd_sc_hd__nor2_1
X_4401_ _1179_ _1196_ VGND VGND VPWR VPWR _1197_ sky130_fd_sc_hd__nor2b_2
X_2593_ net71 net67 _1835_ VGND VGND VPWR VPWR _1840_ sky130_fd_sc_hd__and3_1
XFILLER_0_22_394 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4332_ slte0.opA\[14\] VGND VGND VPWR VPWR _1132_ sky130_fd_sc_hd__inv_2
X_4263_ net5 _1068_ VGND VGND VPWR VPWR _1069_ sky130_fd_sc_hd__xnor2_1
X_3214_ _2379_ _2268_ _2409_ _2410_ _2406_ VGND VGND VPWR VPWR _2453_ sky130_fd_sc_hd__a32oi_4
XFILLER_0_66_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4194_ net188 net183 VGND VGND VPWR VPWR _1016_ sky130_fd_sc_hd__nand2_1
X_3145_ _2383_ _2385_ VGND VGND VPWR VPWR _2386_ sky130_fd_sc_hd__xor2_1
X_3076_ _2313_ _2318_ VGND VGND VPWR VPWR _2319_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_49_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3978_ _0807_ _0809_ VGND VGND VPWR VPWR _0810_ sky130_fd_sc_hd__xor2_1
X_2929_ _2172_ _2174_ VGND VGND VPWR VPWR _2175_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_9_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_72_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_36_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput8 theta[14] VGND VGND VPWR VPWR net8 sky130_fd_sc_hd__buf_1
XFILLER_0_52_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4950_ _1730_ VGND VGND VPWR VPWR _1731_ sky130_fd_sc_hd__inv_2
X_3901_ _0348_ VGND VGND VPWR VPWR _0735_ sky130_fd_sc_hd__inv_2
XFILLER_0_52_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4881_ _1629_ _1642_ _1641_ _1657_ _1658_ VGND VGND VPWR VPWR _1661_ sky130_fd_sc_hd__o311a_2
X_3832_ _0626_ _0666_ VGND VGND VPWR VPWR _0668_ sky130_fd_sc_hd__or2_1
XFILLER_0_6_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_358 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3763_ _0597_ _0599_ VGND VGND VPWR VPWR _0600_ sky130_fd_sc_hd__xor2_2
XFILLER_0_54_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2714_ _1922_ _1924_ VGND VGND VPWR VPWR _1961_ sky130_fd_sc_hd__xor2_1
X_3694_ net159 net153 _0210_ VGND VGND VPWR VPWR _0532_ sky130_fd_sc_hd__and3_1
XFILLER_0_42_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2645_ _1870_ _1890_ _1891_ VGND VGND VPWR VPWR _1892_ sky130_fd_sc_hd__a21oi_2
X_2576_ _1819_ _1822_ VGND VGND VPWR VPWR _1823_ sky130_fd_sc_hd__xor2_2
X_4315_ slte0.opA\[3\] VGND VGND VPWR VPWR _1115_ sky130_fd_sc_hd__inv_2
X_4246_ net16 _1054_ _1031_ VGND VGND VPWR VPWR _1056_ sky130_fd_sc_hd__o21a_1
XFILLER_0_10_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4177_ _1000_ _1001_ VGND VGND VPWR VPWR _1002_ sky130_fd_sc_hd__and2b_1
X_3128_ _2294_ _2331_ _2366_ VGND VGND VPWR VPWR _2369_ sky130_fd_sc_hd__or3_4
X_3059_ _2300_ _2301_ VGND VGND VPWR VPWR _2302_ sky130_fd_sc_hd__and2_1
XFILLER_0_77_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_33_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_47_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4100_ _0925_ _0892_ VGND VGND VPWR VPWR _0928_ sky130_fd_sc_hd__nor2_1
X_5080_ clknet_3_6__leaf_clk _0074_ net206 VGND VGND VPWR VPWR vec\[0\]\[0\] sky130_fd_sc_hd__dfstp_1
X_4031_ _0791_ _0826_ _0858_ VGND VGND VPWR VPWR _0861_ sky130_fd_sc_hd__or3_1
XFILLER_0_63_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4933_ _1677_ _1678_ _1689_ _1699_ VGND VGND VPWR VPWR _1713_ sky130_fd_sc_hd__or4_1
X_4864_ _1629_ _1642_ VGND VGND VPWR VPWR _1643_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3815_ _0643_ _0650_ VGND VGND VPWR VPWR _0651_ sky130_fd_sc_hd__xor2_2
XFILLER_0_34_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4795_ net174 _1563_ _1566_ _1324_ _1570_ VGND VGND VPWR VPWR _1572_ sky130_fd_sc_hd__a221o_1
XFILLER_0_6_166 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3746_ net141 net136 _0248_ _0582_ VGND VGND VPWR VPWR _0583_ sky130_fd_sc_hd__a31o_1
XFILLER_0_12_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3677_ _0507_ _0508_ VGND VGND VPWR VPWR _0515_ sky130_fd_sc_hd__nor2_1
XFILLER_0_42_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2628_ net79 net73 VGND VGND VPWR VPWR _1875_ sky130_fd_sc_hd__nand2_2
XFILLER_0_30_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_10_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2559_ _1571_ _1805_ VGND VGND VPWR VPWR _1806_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_10_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4229_ net3 net10 net11 net12 VGND VGND VPWR VPWR _1042_ sky130_fd_sc_hd__and4_1
XFILLER_0_65_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput11 theta[2] VGND VGND VPWR VPWR net11 sky130_fd_sc_hd__buf_1
X_3600_ _0423_ _0436_ _0437_ VGND VGND VPWR VPWR _0438_ sky130_fd_sc_hd__a21oi_1
X_4580_ net98 net95 net185 VGND VGND VPWR VPWR _1360_ sky130_fd_sc_hd__mux2_1
XFILLER_0_3_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3531_ _0346_ _0367_ _0368_ VGND VGND VPWR VPWR _0369_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_24_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_3_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3462_ _0282_ _0298_ _0299_ VGND VGND VPWR VPWR _0300_ sky130_fd_sc_hd__o21ai_1
X_3393_ net161 _0226_ _0229_ VGND VGND VPWR VPWR _0231_ sky130_fd_sc_hd__or3_1
X_5063_ clknet_3_0__leaf_clk _0057_ net194 VGND VGND VPWR VPWR slte0.opA\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4014_ _0842_ _0844_ VGND VGND VPWR VPWR _0845_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4916_ _1681_ _1688_ _1696_ _1482_ VGND VGND VPWR VPWR _1697_ sky130_fd_sc_hd__a31o_1
XFILLER_0_74_175 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4847_ _1599_ _1624_ _1620_ _1179_ VGND VGND VPWR VPWR _1626_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_62_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_486 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4778_ net172 net116 _1312_ _1553_ VGND VGND VPWR VPWR _1554_ sky130_fd_sc_hd__a31oi_4
XFILLER_0_70_370 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3729_ _0493_ _0566_ _0473_ VGND VGND VPWR VPWR _0567_ sky130_fd_sc_hd__a21o_1
XFILLER_0_85_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_60_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2962_ _2206_ _2155_ net101 VGND VGND VPWR VPWR _2207_ sky130_fd_sc_hd__o21ai_2
X_4701_ _1098_ _1477_ _1478_ VGND VGND VPWR VPWR _0085_ sky130_fd_sc_hd__a21oi_1
X_2893_ _1421_ net1 VGND VGND VPWR VPWR _2140_ sky130_fd_sc_hd__and2_1
X_4632_ net149 _1408_ VGND VGND VPWR VPWR _1409_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_186 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4563_ net107 net104 net216 net98 net185 net180 VGND VGND VPWR VPWR _1344_ sky130_fd_sc_hd__mux4_1
X_3514_ net138 net134 _0348_ VGND VGND VPWR VPWR _0352_ sky130_fd_sc_hd__and3_1
X_4494_ slte0.opA\[14\] _1280_ VGND VGND VPWR VPWR _1281_ sky130_fd_sc_hd__nand2_1
X_3445_ net147 net141 VGND VGND VPWR VPWR _0283_ sky130_fd_sc_hd__nand2_2
X_3376_ _0204_ _0209_ _0213_ VGND VGND VPWR VPWR _0214_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_85_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5115_ clknet_3_4__leaf_clk _0109_ net202 VGND VGND VPWR VPWR vec\[1\]\[17\] sky130_fd_sc_hd__dfrtp_1
X_5046_ clknet_3_0__leaf_clk _0040_ net193 VGND VGND VPWR VPWR slte0.opB\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_33_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_67_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclone14 net101 VGND VGND VPWR VPWR net221 sky130_fd_sc_hd__buf_4
XFILLER_0_62_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_9_Left_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_5_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_58 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3230_ _2453_ net78 VGND VGND VPWR VPWR _2468_ sky130_fd_sc_hd__or2b_1
X_3161_ _2362_ _2365_ _2401_ VGND VGND VPWR VPWR _2402_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_55_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3092_ net62 _2223_ VGND VGND VPWR VPWR _2334_ sky130_fd_sc_hd__nor2_2
XFILLER_0_71_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3994_ _0823_ _0825_ VGND VGND VPWR VPWR _0826_ sky130_fd_sc_hd__xor2_2
XFILLER_0_29_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2945_ _1940_ _2188_ _2137_ _2189_ _2190_ VGND VGND VPWR VPWR _2191_ sky130_fd_sc_hd__a311o_4
XFILLER_0_17_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2876_ _1664_ _2119_ _2121_ _2086_ _2122_ VGND VGND VPWR VPWR _2123_ sky130_fd_sc_hd__a32o_1
X_4615_ _1374_ _1378_ VGND VGND VPWR VPWR _1393_ sky130_fd_sc_hd__nand2_1
X_4546_ net180 net107 net185 VGND VGND VPWR VPWR _1328_ sky130_fd_sc_hd__or3b_1
X_4477_ _1265_ VGND VGND VPWR VPWR _1266_ sky130_fd_sc_hd__inv_2
X_3428_ _0250_ _0265_ VGND VGND VPWR VPWR _0266_ sky130_fd_sc_hd__xnor2_1
X_3359_ _0187_ _0179_ _0194_ VGND VGND VPWR VPWR _0198_ sky130_fd_sc_hd__or3_4
X_5029_ clknet_3_2__leaf_clk _0023_ net200 VGND VGND VPWR VPWR net29 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_75_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_50_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2730_ _1959_ _1975_ VGND VGND VPWR VPWR _1977_ sky130_fd_sc_hd__or2b_1
XFILLER_0_41_68 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2661_ _1898_ _1902_ VGND VGND VPWR VPWR _1908_ sky130_fd_sc_hd__nor2_1
X_4400_ _1181_ _1195_ VGND VGND VPWR VPWR _1196_ sky130_fd_sc_hd__or2_1
X_2592_ _1800_ _1838_ VGND VGND VPWR VPWR _1839_ sky130_fd_sc_hd__and2_1
X_4331_ slte0.opA\[15\] VGND VGND VPWR VPWR _1131_ sky130_fd_sc_hd__inv_2
X_4262_ net192 _1067_ _1057_ VGND VGND VPWR VPWR _1068_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_5_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3213_ _2450_ _2451_ VGND VGND VPWR VPWR _2452_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_5_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4193_ _1014_ VGND VGND VPWR VPWR _1015_ sky130_fd_sc_hd__buf_4
X_3144_ _2336_ _2343_ _2384_ VGND VGND VPWR VPWR _2385_ sky130_fd_sc_hd__a21oi_1
X_3075_ _2315_ _2317_ VGND VGND VPWR VPWR _2318_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_82_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_59_Left_145 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3977_ _0758_ _0765_ _0808_ VGND VGND VPWR VPWR _0809_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_57_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2928_ _1816_ _1831_ _2173_ VGND VGND VPWR VPWR _2174_ sky130_fd_sc_hd__a21boi_2
X_2859_ _2062_ _2071_ VGND VGND VPWR VPWR _2106_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_68_Left_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4529_ _1017_ _1452_ VGND VGND VPWR VPWR _1312_ sky130_fd_sc_hd__nand2_2
XPHY_EDGE_ROW_77_Left_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput9 theta[15] VGND VGND VPWR VPWR net9 sky130_fd_sc_hd__buf_2
X_3900_ net132 net128 _0685_ _0733_ VGND VGND VPWR VPWR _0734_ sky130_fd_sc_hd__a31o_1
XFILLER_0_52_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4880_ _1657_ _1659_ _1014_ VGND VGND VPWR VPWR _1660_ sky130_fd_sc_hd__o21ai_1
X_3831_ _0626_ _0666_ VGND VGND VPWR VPWR _0667_ sky130_fd_sc_hd__nand2_1
X_3762_ _0253_ _0256_ _0598_ VGND VGND VPWR VPWR _0599_ sky130_fd_sc_hd__a21o_1
XFILLER_0_27_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_39_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2713_ _1955_ _1954_ VGND VGND VPWR VPWR _1960_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_14_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3693_ _0383_ _0528_ _0529_ _0530_ VGND VGND VPWR VPWR _0531_ sky130_fd_sc_hd__or4b_1
X_2644_ _1888_ _1889_ VGND VGND VPWR VPWR _1891_ sky130_fd_sc_hd__and2_1
X_2575_ _1820_ _1821_ VGND VGND VPWR VPWR _1822_ sky130_fd_sc_hd__xnor2_2
X_4314_ _1107_ _1108_ _1111_ _1113_ VGND VGND VPWR VPWR _1114_ sky130_fd_sc_hd__and4bb_1
XFILLER_0_77_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4245_ net16 _1054_ VGND VGND VPWR VPWR _1055_ sky130_fd_sc_hd__nand2_1
X_4176_ _0997_ _0987_ _0999_ VGND VGND VPWR VPWR _1001_ sky130_fd_sc_hd__or3b_1
X_3127_ net231 _2143_ _2368_ _1532_ VGND VGND VPWR VPWR _0008_ sky130_fd_sc_hd__a22o_1
X_3058_ net95 _2298_ _2299_ VGND VGND VPWR VPWR _2301_ sky130_fd_sc_hd__or3_1
XFILLER_0_65_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_18_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_10_Right_10 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4030_ net230 _2143_ _0860_ _1532_ VGND VGND VPWR VPWR _0026_ sky130_fd_sc_hd__a22o_1
XFILLER_0_47_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4932_ _1430_ _1604_ _1711_ VGND VGND VPWR VPWR _1712_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_74_324 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4863_ _1614_ _1617_ _1631_ VGND VGND VPWR VPWR _1642_ sky130_fd_sc_hd__a21boi_1
X_3814_ _0648_ _0649_ VGND VGND VPWR VPWR _0650_ sky130_fd_sc_hd__nand2_1
X_4794_ net162 _1090_ _1568_ _1569_ _1452_ VGND VGND VPWR VPWR _1570_ sky130_fd_sc_hd__o2111a_1
X_3745_ net138 _0246_ VGND VGND VPWR VPWR _0582_ sky130_fd_sc_hd__nor2_1
XFILLER_0_15_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3676_ _0329_ _0495_ VGND VGND VPWR VPWR _0514_ sky130_fd_sc_hd__nand2_1
XFILLER_0_42_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2627_ net76 net70 VGND VGND VPWR VPWR _1874_ sky130_fd_sc_hd__xor2_4
XFILLER_0_63_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2558_ net97 net91 VGND VGND VPWR VPWR _1805_ sky130_fd_sc_hd__nand2_2
X_4228_ _1041_ VGND VGND VPWR VPWR _0043_ sky130_fd_sc_hd__clkbuf_1
X_4159_ _0983_ _0984_ VGND VGND VPWR VPWR _0985_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_65_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput12 theta[3] VGND VGND VPWR VPWR net12 sky130_fd_sc_hd__buf_1
X_3530_ _0364_ _0366_ VGND VGND VPWR VPWR _0368_ sky130_fd_sc_hd__and2b_1
XFILLER_0_24_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_24_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3461_ _0296_ _0297_ VGND VGND VPWR VPWR _0299_ sky130_fd_sc_hd__or2_1
XFILLER_0_58_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3392_ _0226_ _0229_ net161 VGND VGND VPWR VPWR _0230_ sky130_fd_sc_hd__o21ai_2
X_5062_ clknet_3_0__leaf_clk _0056_ net194 VGND VGND VPWR VPWR slte0.opA\[0\] sky130_fd_sc_hd__dfrtp_1
X_4013_ _0810_ _0815_ _0843_ VGND VGND VPWR VPWR _0844_ sky130_fd_sc_hd__a21o_1
XFILLER_0_79_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4915_ _1692_ _1694_ VGND VGND VPWR VPWR _1696_ sky130_fd_sc_hd__nand2_1
X_4846_ _1179_ _1620_ _1624_ _1599_ VGND VGND VPWR VPWR _1625_ sky130_fd_sc_hd__o211a_1
XFILLER_0_15_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4777_ net172 _2196_ _1545_ _1552_ VGND VGND VPWR VPWR _1553_ sky130_fd_sc_hd__a31o_1
X_3728_ _0488_ _0559_ VGND VGND VPWR VPWR _0566_ sky130_fd_sc_hd__nand2_1
X_3659_ _0495_ _0496_ VGND VGND VPWR VPWR _0497_ sky130_fd_sc_hd__and2_1
XFILLER_0_38_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_390 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_22_Left_108 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2961_ _2119_ _2153_ VGND VGND VPWR VPWR _2206_ sky130_fd_sc_hd__and2b_1
X_4700_ net189 net132 VGND VGND VPWR VPWR _1478_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2892_ _1940_ _2138_ VGND VGND VPWR VPWR _2139_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_71_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4631_ _1405_ _1407_ VGND VGND VPWR VPWR _1408_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_8_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4562_ net95 net89 net86 net82 net186 net180 VGND VGND VPWR VPWR _1343_ sky130_fd_sc_hd__mux4_1
XFILLER_0_69_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_213 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3513_ _0330_ _0350_ VGND VGND VPWR VPWR _0351_ sky130_fd_sc_hd__and2_1
X_4493_ _1238_ _1195_ _1182_ VGND VGND VPWR VPWR _1280_ sky130_fd_sc_hd__a21o_1
X_3444_ _0228_ _0227_ VGND VGND VPWR VPWR _0282_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_31_Left_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3375_ _0211_ _0212_ VGND VGND VPWR VPWR _0213_ sky130_fd_sc_hd__and2b_1
X_5114_ clknet_3_4__leaf_clk _0108_ net203 VGND VGND VPWR VPWR vec\[1\]\[16\] sky130_fd_sc_hd__dfrtp_1
X_5045_ clknet_3_4__leaf_clk _0039_ net202 VGND VGND VPWR VPWR gm0.iter\[4\] sky130_fd_sc_hd__dfrtp_2
XFILLER_0_26_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_40_Left_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4829_ _1087_ _1605_ _1606_ VGND VGND VPWR VPWR _1607_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_43_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_154 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_81_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_371 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3160_ _2361_ _2359_ VGND VGND VPWR VPWR _2401_ sky130_fd_sc_hd__and2b_1
X_3091_ _2332_ _2333_ net241 _2201_ VGND VGND VPWR VPWR _0007_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_71_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_8_Right_8 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3993_ _0784_ _0787_ _0824_ VGND VGND VPWR VPWR _0825_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_84_282 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2944_ _1894_ _1939_ VGND VGND VPWR VPWR _2190_ sky130_fd_sc_hd__and2_1
XFILLER_0_17_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2875_ net108 net105 _2089_ _2080_ VGND VGND VPWR VPWR _2122_ sky130_fd_sc_hd__a31o_1
XFILLER_0_72_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4614_ net54 _1387_ _1391_ VGND VGND VPWR VPWR _1392_ sky130_fd_sc_hd__a21o_1
X_4545_ net180 net185 net110 VGND VGND VPWR VPWR _1327_ sky130_fd_sc_hd__or3_1
X_4476_ slte0.opA\[10\] _1248_ _1256_ VGND VGND VPWR VPWR _1265_ sky130_fd_sc_hd__a21boi_1
X_3427_ _0257_ _0264_ VGND VGND VPWR VPWR _0265_ sky130_fd_sc_hd__xor2_2
XPHY_EDGE_ROW_39_Right_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3358_ _0195_ _0196_ _0197_ VGND VGND VPWR VPWR _0017_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_0_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3289_ _0130_ _0132_ VGND VGND VPWR VPWR _0133_ sky130_fd_sc_hd__xnor2_2
X_5028_ clknet_3_2__leaf_clk _0022_ net200 VGND VGND VPWR VPWR net28 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_48_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_48_Right_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_57_Right_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_66_Right_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2660_ net103 _1906_ net109 VGND VGND VPWR VPWR _1907_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_75_Right_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2591_ net79 net74 VGND VGND VPWR VPWR _1838_ sky130_fd_sc_hd__or2_1
X_4330_ _1104_ _1105_ _1114_ _1128_ _1129_ VGND VGND VPWR VPWR _1130_ sky130_fd_sc_hd__a221o_1
XFILLER_0_66_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4261_ net17 net18 net4 VGND VGND VPWR VPWR _1067_ sky130_fd_sc_hd__and3_1
X_3212_ _2310_ _2412_ VGND VGND VPWR VPWR _2451_ sky130_fd_sc_hd__nor2_1
XFILLER_0_66_88 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4192_ net186 _2197_ net190 VGND VGND VPWR VPWR _1014_ sky130_fd_sc_hd__o21a_4
X_3143_ _2335_ _1826_ VGND VGND VPWR VPWR _2384_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_84_Right_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3074_ _2316_ _1916_ net81 VGND VGND VPWR VPWR _2317_ sky130_fd_sc_hd__mux2_1
X_3976_ _0757_ _0260_ VGND VGND VPWR VPWR _0808_ sky130_fd_sc_hd__and2b_1
XFILLER_0_17_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2927_ net210 _1830_ VGND VGND VPWR VPWR _2173_ sky130_fd_sc_hd__nand2_1
XFILLER_0_45_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2858_ _2095_ _2091_ VGND VGND VPWR VPWR _2105_ sky130_fd_sc_hd__or2b_1
X_2789_ _1995_ _2006_ VGND VGND VPWR VPWR _2036_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_13_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_363 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4528_ _1024_ _1307_ _1310_ VGND VGND VPWR VPWR _1311_ sky130_fd_sc_hd__o21ai_1
X_4459_ _1232_ _1237_ _1241_ _1242_ VGND VGND VPWR VPWR _1250_ sky130_fd_sc_hd__a31o_1
XFILLER_0_40_182 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_51_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3830_ _0627_ _0665_ VGND VGND VPWR VPWR _0666_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_46_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3761_ vec\[0\]\[14\] net119 _0255_ VGND VGND VPWR VPWR _0598_ sky130_fd_sc_hd__and3_1
XFILLER_0_27_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2712_ _1958_ _1929_ VGND VGND VPWR VPWR _1959_ sky130_fd_sc_hd__xor2_1
X_3692_ _0334_ _0382_ _0338_ net166 VGND VGND VPWR VPWR _0530_ sky130_fd_sc_hd__a31o_1
XFILLER_0_54_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2643_ _1888_ _1889_ VGND VGND VPWR VPWR _1890_ sky130_fd_sc_hd__xor2_2
XFILLER_0_42_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2574_ net56 net62 VGND VGND VPWR VPWR _1821_ sky130_fd_sc_hd__xor2_2
XFILLER_0_50_480 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4313_ _1104_ _1112_ _1105_ VGND VGND VPWR VPWR _1113_ sky130_fd_sc_hd__and3b_1
XFILLER_0_22_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4244_ net9 _1042_ _1053_ net191 VGND VGND VPWR VPWR _1054_ sky130_fd_sc_hd__a31o_1
X_4175_ _0997_ _0987_ _0999_ VGND VGND VPWR VPWR _1000_ sky130_fd_sc_hd__o21ba_1
X_3126_ _2366_ _2367_ VGND VGND VPWR VPWR _2368_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3057_ _2298_ _2299_ net95 VGND VGND VPWR VPWR _2300_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_9_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3959_ _0788_ _0751_ net53 VGND VGND VPWR VPWR _0791_ sky130_fd_sc_hd__nand3b_2
XFILLER_0_18_455 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_24_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_285 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4931_ net114 _1467_ VGND VGND VPWR VPWR _1711_ sky130_fd_sc_hd__nand2_1
XFILLER_0_59_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4862_ net98 _1639_ VGND VGND VPWR VPWR _1641_ sky130_fd_sc_hd__and2_1
X_3813_ _0595_ _0644_ _0647_ VGND VGND VPWR VPWR _0649_ sky130_fd_sc_hd__or3_1
X_4793_ _0199_ _1472_ VGND VGND VPWR VPWR _1569_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_274 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3744_ _0480_ _0241_ VGND VGND VPWR VPWR _0581_ sky130_fd_sc_hd__and2_1
X_3675_ _0505_ _0512_ VGND VGND VPWR VPWR _0513_ sky130_fd_sc_hd__and2b_1
X_2626_ _1805_ _1872_ VGND VGND VPWR VPWR _1873_ sky130_fd_sc_hd__xnor2_2
X_2557_ net87 _1800_ _1803_ VGND VGND VPWR VPWR _1804_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_56_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4227_ slte0.opB\[5\] _1040_ _1031_ VGND VGND VPWR VPWR _1041_ sky130_fd_sc_hd__mux2_1
X_4158_ net124 _0931_ VGND VGND VPWR VPWR _0984_ sky130_fd_sc_hd__xor2_1
X_3109_ net90 _2348_ _2349_ VGND VGND VPWR VPWR _2351_ sky130_fd_sc_hd__or3_1
X_4089_ _0915_ _0917_ VGND VGND VPWR VPWR _0918_ sky130_fd_sc_hd__xor2_2
XFILLER_0_77_174 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xinput13 theta[4] VGND VGND VPWR VPWR net13 sky130_fd_sc_hd__buf_1
X_3460_ _0296_ _0297_ VGND VGND VPWR VPWR _0298_ sky130_fd_sc_hd__and2_1
X_3391_ _0227_ _0228_ VGND VGND VPWR VPWR _0229_ sky130_fd_sc_hd__and2b_1
XFILLER_0_58_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_5061_ clknet_3_0__leaf_clk _0055_ net193 VGND VGND VPWR VPWR domain\[1\] sky130_fd_sc_hd__dfrtp_4
XFILLER_0_74_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4012_ _0807_ _0809_ VGND VGND VPWR VPWR _0843_ sky130_fd_sc_hd__nor2_1
XFILLER_0_79_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4914_ _1693_ VGND VGND VPWR VPWR _1694_ sky130_fd_sc_hd__inv_2
XFILLER_0_7_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4845_ net174 _1621_ _1622_ VGND VGND VPWR VPWR _1624_ sky130_fd_sc_hd__a21bo_1
X_4776_ _1024_ _1548_ _1551_ VGND VGND VPWR VPWR _1552_ sky130_fd_sc_hd__o21a_1
XFILLER_0_62_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3727_ _0562_ _0563_ _0564_ VGND VGND VPWR VPWR _0565_ sky130_fd_sc_hd__a21o_1
X_3658_ net159 net157 VGND VGND VPWR VPWR _0496_ sky130_fd_sc_hd__or2_1
X_2609_ _1789_ _1855_ VGND VGND VPWR VPWR _1856_ sky130_fd_sc_hd__and2_1
X_3589_ _0395_ _0396_ VGND VGND VPWR VPWR _0427_ sky130_fd_sc_hd__xor2_2
XFILLER_0_85_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout190 state\[0\] VGND VGND VPWR VPWR net190 sky130_fd_sc_hd__buf_2
X_2960_ _1796_ _2183_ VGND VGND VPWR VPWR _2205_ sky130_fd_sc_hd__nor2_1
XFILLER_0_84_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2891_ _1979_ _1980_ _2137_ VGND VGND VPWR VPWR _2138_ sky130_fd_sc_hd__a21oi_1
X_4630_ _1179_ _1406_ VGND VGND VPWR VPWR _1407_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4561_ net174 _1341_ VGND VGND VPWR VPWR _1342_ sky130_fd_sc_hd__nand2_1
XFILLER_0_4_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3512_ net144 net141 VGND VGND VPWR VPWR _0350_ sky130_fd_sc_hd__or2_1
X_4492_ _1152_ slte0.opA\[13\] _1015_ _1279_ VGND VGND VPWR VPWR _0069_ sky130_fd_sc_hd__a22o_1
X_3443_ _0244_ _0280_ VGND VGND VPWR VPWR _0281_ sky130_fd_sc_hd__xor2_1
X_3374_ _0204_ _0209_ VGND VGND VPWR VPWR _0212_ sky130_fd_sc_hd__xor2_2
X_5113_ clknet_3_4__leaf_clk _0107_ net203 VGND VGND VPWR VPWR vec\[1\]\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_85_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5044_ clknet_3_4__leaf_clk _0038_ net202 VGND VGND VPWR VPWR gm0.iter\[3\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_75_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4828_ _1312_ _1567_ _1564_ _1273_ _1193_ VGND VGND VPWR VPWR _1606_ sky130_fd_sc_hd__o221a_1
XFILLER_0_28_380 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4759_ _1535_ _1536_ VGND VGND VPWR VPWR _1537_ sky130_fd_sc_hd__or2_1
XFILLER_0_50_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_39 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_103 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3090_ net167 _2294_ _2331_ _2199_ VGND VGND VPWR VPWR _2333_ sky130_fd_sc_hd__a31o_1
XFILLER_0_55_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3992_ _0781_ _0783_ VGND VGND VPWR VPWR _0824_ sky130_fd_sc_hd__nand2_1
X_2943_ _1894_ _1939_ _1979_ _1980_ VGND VGND VPWR VPWR _2189_ sky130_fd_sc_hd__o211a_1
XFILLER_0_44_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2874_ net218 net91 _1984_ _2120_ VGND VGND VPWR VPWR _2121_ sky130_fd_sc_hd__and4_1
XFILLER_0_4_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4613_ _1024_ _1389_ _1390_ VGND VGND VPWR VPWR _1391_ sky130_fd_sc_hd__o21a_1
X_4544_ net104 net216 net185 VGND VGND VPWR VPWR _1326_ sky130_fd_sc_hd__mux2_1
XFILLER_0_20_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4475_ _1262_ _1263_ VGND VGND VPWR VPWR _1264_ sky130_fd_sc_hd__or2_1
X_3426_ _0260_ _0262_ _0263_ VGND VGND VPWR VPWR _0264_ sky130_fd_sc_hd__a21o_1
X_3357_ net234 _2248_ VGND VGND VPWR VPWR _0197_ sky130_fd_sc_hd__nand2_1
XFILLER_0_29_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3288_ _0131_ _2499_ _2491_ VGND VGND VPWR VPWR _0132_ sky130_fd_sc_hd__a21o_1
X_5027_ clknet_3_2__leaf_clk _0021_ net198 VGND VGND VPWR VPWR net27 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_0_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_49 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_58_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_14_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2590_ _1835_ _1836_ VGND VGND VPWR VPWR _1837_ sky130_fd_sc_hd__xnor2_4
X_4260_ _1066_ VGND VGND VPWR VPWR _0050_ sky130_fd_sc_hd__clkbuf_1
X_3211_ _2448_ _2449_ VGND VGND VPWR VPWR _2450_ sky130_fd_sc_hd__and2b_1
XFILLER_0_66_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4191_ _1522_ _0754_ _1013_ _2248_ net222 VGND VGND VPWR VPWR _0034_ sky130_fd_sc_hd__a32o_1
X_3142_ _2378_ _2382_ VGND VGND VPWR VPWR _2383_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_82_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3073_ _1915_ VGND VGND VPWR VPWR _2316_ sky130_fd_sc_hd__inv_2
X_3975_ _0800_ _0806_ VGND VGND VPWR VPWR _0807_ sky130_fd_sc_hd__xor2_1
XFILLER_0_45_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2926_ _2160_ _2171_ VGND VGND VPWR VPWR _2172_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_57_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2857_ _1900_ _2098_ _2099_ _2100_ _2103_ VGND VGND VPWR VPWR _2104_ sky130_fd_sc_hd__o311a_1
XFILLER_0_32_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2788_ _2020_ _2033_ _2034_ VGND VGND VPWR VPWR _2035_ sky130_fd_sc_hd__a21oi_1
X_4527_ _2195_ _1308_ _1309_ _1087_ _1081_ VGND VGND VPWR VPWR _1310_ sky130_fd_sc_hd__o221a_1
X_4458_ slte0.opA\[10\] _1248_ VGND VGND VPWR VPWR _1249_ sky130_fd_sc_hd__xnor2_2
X_3409_ net139 net134 VGND VGND VPWR VPWR _0247_ sky130_fd_sc_hd__xor2_4
X_4389_ slte0.opA\[4\] _1185_ VGND VGND VPWR VPWR _1186_ sky130_fd_sc_hd__nand2_1
XFILLER_0_36_434 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_128 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3760_ _0591_ _0596_ VGND VGND VPWR VPWR _0597_ sky130_fd_sc_hd__xor2_2
X_2711_ _1926_ _1927_ VGND VGND VPWR VPWR _1958_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_54_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3691_ _0335_ _0527_ VGND VGND VPWR VPWR _0529_ sky130_fd_sc_hd__nor2_1
XFILLER_0_42_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2642_ _1848_ _1864_ VGND VGND VPWR VPWR _1889_ sky130_fd_sc_hd__xor2_2
XFILLER_0_2_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_77_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2573_ net65 net60 VGND VGND VPWR VPWR _1820_ sky130_fd_sc_hd__nand2_2
XFILLER_0_22_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4312_ slte0.opB\[10\] _1103_ VGND VGND VPWR VPWR _1112_ sky130_fd_sc_hd__or2_1
X_4243_ net13 net14 net15 VGND VGND VPWR VPWR _1053_ sky130_fd_sc_hd__and3_1
X_4174_ net122 _0802_ _0998_ VGND VGND VPWR VPWR _0999_ sky130_fd_sc_hd__mux2_1
X_3125_ _2294_ _2331_ net168 VGND VGND VPWR VPWR _2367_ sky130_fd_sc_hd__o21ai_1
X_3056_ _2257_ _2262_ VGND VGND VPWR VPWR _2299_ sky130_fd_sc_hd__and2b_1
XFILLER_0_77_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3958_ _0789_ _0790_ net240 _2201_ VGND VGND VPWR VPWR _0024_ sky130_fd_sc_hd__a2bb2o_1
X_3889_ net121 net119 VGND VGND VPWR VPWR _0723_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2909_ _2151_ _2154_ VGND VGND VPWR VPWR _2155_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_36_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4930_ _1152_ net77 _1708_ _1710_ VGND VGND VPWR VPWR _0102_ sky130_fd_sc_hd__a22o_1
X_4861_ net98 _1639_ VGND VGND VPWR VPWR _1640_ sky130_fd_sc_hd__nor2_1
X_3812_ _0595_ _0644_ _0647_ VGND VGND VPWR VPWR _0648_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_6_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4792_ _1017_ _1567_ VGND VGND VPWR VPWR _1568_ sky130_fd_sc_hd__or2_1
XFILLER_0_82_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3743_ _0578_ _0579_ VGND VGND VPWR VPWR _0580_ sky130_fd_sc_hd__and2_1
XFILLER_0_6_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3674_ _0509_ _0511_ VGND VGND VPWR VPWR _0512_ sky130_fd_sc_hd__xnor2_1
X_2625_ _1602_ _1581_ VGND VGND VPWR VPWR _1872_ sky130_fd_sc_hd__and2b_1
XFILLER_0_2_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_23_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2556_ net90 net83 _1802_ VGND VGND VPWR VPWR _1803_ sky130_fd_sc_hd__and3_1
XFILLER_0_10_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4226_ net12 _1039_ VGND VGND VPWR VPWR _1040_ sky130_fd_sc_hd__xor2_1
XFILLER_0_49_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4157_ _0958_ _0960_ _0729_ VGND VGND VPWR VPWR _0983_ sky130_fd_sc_hd__a21oi_1
X_3108_ _2348_ _2349_ net90 VGND VGND VPWR VPWR _2350_ sky130_fd_sc_hd__o21ai_2
X_4088_ _0874_ _0877_ _0916_ VGND VGND VPWR VPWR _0917_ sky130_fd_sc_hd__a21bo_1
X_3039_ _2209_ _2236_ _2282_ VGND VGND VPWR VPWR _2283_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_77_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput14 theta[5] VGND VGND VPWR VPWR net14 sky130_fd_sc_hd__buf_1
XFILLER_0_12_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3390_ _0225_ _0220_ VGND VGND VPWR VPWR _0228_ sky130_fd_sc_hd__xnor2_1
X_5060_ clknet_3_0__leaf_clk _0054_ net193 VGND VGND VPWR VPWR domain\[0\] sky130_fd_sc_hd__dfrtp_4
X_4011_ _0838_ _0841_ VGND VGND VPWR VPWR _0842_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_74_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4913_ net81 _1691_ VGND VGND VPWR VPWR _1693_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4844_ _1087_ _1547_ _1550_ _2195_ _1296_ VGND VGND VPWR VPWR _1622_ sky130_fd_sc_hd__o221a_1
XFILLER_0_74_167 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4775_ _2195_ _1549_ _1550_ _1087_ _1081_ VGND VGND VPWR VPWR _1551_ sky130_fd_sc_hd__o221a_1
XFILLER_0_7_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3726_ _0441_ _0442_ VGND VGND VPWR VPWR _0564_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_15_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3657_ net159 net156 VGND VGND VPWR VPWR _0495_ sky130_fd_sc_hd__nand2_1
X_2608_ net84 net80 VGND VGND VPWR VPWR _1855_ sky130_fd_sc_hd__or2_1
X_3588_ _0334_ _0425_ VGND VGND VPWR VPWR _0426_ sky130_fd_sc_hd__xnor2_2
X_2539_ net218 _1766_ _1776_ VGND VGND VPWR VPWR _1786_ sky130_fd_sc_hd__a21o_1
X_4209_ _1026_ _1027_ VGND VGND VPWR VPWR _0038_ sky130_fd_sc_hd__nor2_1
XFILLER_0_80_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_21_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout191 net8 VGND VGND VPWR VPWR net191 sky130_fd_sc_hd__buf_2
Xfanout180 net181 VGND VGND VPWR VPWR net180 sky130_fd_sc_hd__buf_2
XFILLER_0_84_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_326 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2890_ _1979_ _1980_ _2134_ _2136_ VGND VGND VPWR VPWR _2137_ sky130_fd_sc_hd__o211a_1
XFILLER_0_60_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4560_ _1339_ _1340_ _1022_ VGND VGND VPWR VPWR _1341_ sky130_fd_sc_hd__mux2_1
XFILLER_0_8_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3511_ _0347_ _0348_ VGND VGND VPWR VPWR _0349_ sky130_fd_sc_hd__xnor2_2
X_4491_ _1271_ _1278_ VGND VGND VPWR VPWR _1279_ sky130_fd_sc_hd__xnor2_1
X_3442_ _0266_ _0279_ VGND VGND VPWR VPWR _0280_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_12_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3373_ net153 _0210_ net159 VGND VGND VPWR VPWR _0211_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_85_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5112_ clknet_3_5__leaf_clk _0106_ net203 VGND VGND VPWR VPWR vec\[1\]\[14\] sky130_fd_sc_hd__dfrtp_1
X_5043_ clknet_3_4__leaf_clk _0037_ net202 VGND VGND VPWR VPWR gm0.iter\[2\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_75_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4827_ _1559_ _1565_ _1018_ VGND VGND VPWR VPWR _1605_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4758_ net120 _1534_ VGND VGND VPWR VPWR _1536_ sky130_fd_sc_hd__nor2_1
X_4689_ net189 net135 _1492_ _1466_ VGND VGND VPWR VPWR _0084_ sky130_fd_sc_hd__o22a_1
X_3709_ _0517_ _0518_ VGND VGND VPWR VPWR _0547_ sky130_fd_sc_hd__and2b_1
XFILLER_0_70_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_3_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_178 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_81_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3991_ _0821_ _0822_ VGND VGND VPWR VPWR _0823_ sky130_fd_sc_hd__nor2_1
X_2942_ _1979_ _1980_ VGND VGND VPWR VPWR _2188_ sky130_fd_sc_hd__nand2_1
XFILLER_0_71_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2873_ net96 net88 VGND VGND VPWR VPWR _2120_ sky130_fd_sc_hd__nor2_1
XFILLER_0_57_498 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_4_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4612_ _1087_ _1321_ _1325_ _2195_ _1193_ VGND VGND VPWR VPWR _1390_ sky130_fd_sc_hd__o221a_1
XFILLER_0_25_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4543_ net98 net95 net89 net86 net186 net180 VGND VGND VPWR VPWR _1325_ sky130_fd_sc_hd__mux4_1
X_4474_ _1196_ _1261_ slte0.opA\[12\] VGND VGND VPWR VPWR _1263_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3425_ net126 net121 _0259_ VGND VGND VPWR VPWR _0263_ sky130_fd_sc_hd__and3_1
X_3356_ _0191_ _0194_ _2198_ VGND VGND VPWR VPWR _0196_ sky130_fd_sc_hd__a21o_1
X_3287_ _2493_ VGND VGND VPWR VPWR _0131_ sky130_fd_sc_hd__inv_2
X_5026_ clknet_3_2__leaf_clk _0020_ net198 VGND VGND VPWR VPWR net26 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_31_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_207 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_1_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_34_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_22_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_5_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3210_ _2219_ _2447_ VGND VGND VPWR VPWR _2449_ sky130_fd_sc_hd__nand2_1
X_4190_ _1006_ _1009_ VGND VGND VPWR VPWR _1013_ sky130_fd_sc_hd__nand2_1
X_3141_ _2380_ _2381_ VGND VGND VPWR VPWR _2382_ sky130_fd_sc_hd__xor2_1
XPHY_EDGE_ROW_19_Left_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3072_ net75 net70 _2266_ _2314_ VGND VGND VPWR VPWR _2315_ sky130_fd_sc_hd__a31o_1
XFILLER_0_82_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3974_ _0804_ _0805_ VGND VGND VPWR VPWR _0806_ sky130_fd_sc_hd__or2b_1
X_2925_ _2168_ _2170_ VGND VGND VPWR VPWR _2171_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_17_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_28_Left_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2856_ _1944_ _2101_ _2102_ VGND VGND VPWR VPWR _2103_ sky130_fd_sc_hd__and3_1
XFILLER_0_72_287 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2787_ _2032_ _2031_ VGND VGND VPWR VPWR _2034_ sky130_fd_sc_hd__and2b_1
X_4526_ net101 net98 net95 net89 net185 net180 VGND VGND VPWR VPWR _1309_ sky130_fd_sc_hd__mux4_1
X_4457_ _1197_ _1247_ VGND VGND VPWR VPWR _1248_ sky130_fd_sc_hd__xnor2_2
X_3408_ net134 net130 VGND VGND VPWR VPWR _0246_ sky130_fd_sc_hd__nand2_1
X_4388_ _1182_ _1184_ VGND VGND VPWR VPWR _1185_ sky130_fd_sc_hd__xnor2_1
XPHY_EDGE_ROW_37_Left_123 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3339_ _0153_ _0156_ _0171_ _0172_ VGND VGND VPWR VPWR _0180_ sky130_fd_sc_hd__o31a_1
X_5009_ clknet_3_7__leaf_clk _0003_ net204 VGND VGND VPWR VPWR net37 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_46_Left_132 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_55_Left_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_59_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_64_Left_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2710_ _1951_ _1956_ VGND VGND VPWR VPWR _1957_ sky130_fd_sc_hd__or2_1
XFILLER_0_14_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3690_ _0335_ _0527_ VGND VGND VPWR VPWR _0528_ sky130_fd_sc_hd__and2_1
X_2641_ _1871_ _1886_ _1887_ VGND VGND VPWR VPWR _1888_ sky130_fd_sc_hd__o21ai_2
X_2572_ _1817_ _1818_ VGND VGND VPWR VPWR _1819_ sky130_fd_sc_hd__and2_1
X_4311_ slte0.opB\[8\] _1106_ slte0.opB\[7\] _1109_ _1110_ VGND VGND VPWR VPWR _1111_
+ sky130_fd_sc_hd__o221a_1
XFILLER_0_77_67 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4242_ _1052_ VGND VGND VPWR VPWR _0046_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_77_89 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4173_ net113 _0902_ VGND VGND VPWR VPWR _0998_ sky130_fd_sc_hd__nand2_1
X_3124_ _2362_ _2365_ VGND VGND VPWR VPWR _2366_ sky130_fd_sc_hd__xor2_1
X_3055_ _2261_ _2259_ VGND VGND VPWR VPWR _2298_ sky130_fd_sc_hd__and2b_1
X_3957_ _0754_ _0788_ _0755_ _2199_ VGND VGND VPWR VPWR _0790_ sky130_fd_sc_hd__a31o_1
X_2908_ _2119_ _2153_ VGND VGND VPWR VPWR _2154_ sky130_fd_sc_hd__xor2_1
X_3888_ _0592_ _0593_ VGND VGND VPWR VPWR _0722_ sky130_fd_sc_hd__nand2_1
XFILLER_0_26_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2839_ _2084_ _2085_ VGND VGND VPWR VPWR _2086_ sky130_fd_sc_hd__xnor2_1
X_4509_ _1293_ _1294_ net250 _1168_ VGND VGND VPWR VPWR _0071_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_41_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4860_ _1637_ _1638_ VGND VGND VPWR VPWR _1639_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_74_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_74_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3811_ _0645_ _0646_ VGND VGND VPWR VPWR _0647_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_27_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4791_ net158 net155 net184 VGND VGND VPWR VPWR _1567_ sky130_fd_sc_hd__mux2_1
X_3742_ net157 _0576_ _0577_ VGND VGND VPWR VPWR _0579_ sky130_fd_sc_hd__or3_1
XFILLER_0_12_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3673_ _0487_ _0510_ VGND VGND VPWR VPWR _0511_ sky130_fd_sc_hd__nor2_1
X_2624_ _1715_ _1695_ VGND VGND VPWR VPWR _1871_ sky130_fd_sc_hd__xor2_2
XFILLER_0_42_257 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2555_ _1800_ _1801_ VGND VGND VPWR VPWR _1802_ sky130_fd_sc_hd__xnor2_1
X_4225_ net191 net11 _1036_ VGND VGND VPWR VPWR _1039_ sky130_fd_sc_hd__o21a_1
X_4156_ _0925_ _0892_ _0952_ _0979_ VGND VGND VPWR VPWR _0982_ sky130_fd_sc_hd__and4bb_1
X_3107_ _2313_ _2318_ VGND VGND VPWR VPWR _2349_ sky130_fd_sc_hd__and2b_1
X_4087_ _0873_ _0871_ VGND VGND VPWR VPWR _0916_ sky130_fd_sc_hd__or2b_1
X_3038_ _2235_ _2233_ VGND VGND VPWR VPWR _2282_ sky130_fd_sc_hd__and2b_1
X_4989_ _1769_ _1770_ VGND VGND VPWR VPWR _1771_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_21_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xinput15 theta[6] VGND VGND VPWR VPWR net15 sky130_fd_sc_hd__buf_1
XFILLER_0_3_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_463 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4010_ net140 _0840_ VGND VGND VPWR VPWR _0841_ sky130_fd_sc_hd__xnor2_1
X_4912_ net81 _1691_ VGND VGND VPWR VPWR _1692_ sky130_fd_sc_hd__nand2_1
X_4843_ _1023_ _1546_ _1545_ _1375_ VGND VGND VPWR VPWR _1621_ sky130_fd_sc_hd__a22oi_2
X_4774_ net155 net152 net149 net146 net184 net179 VGND VGND VPWR VPWR _1550_ sky130_fd_sc_hd__mux4_2
XFILLER_0_43_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3725_ _0452_ net212 VGND VGND VPWR VPWR _0563_ sky130_fd_sc_hd__nand2_1
XFILLER_0_70_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3656_ net160 net163 VGND VGND VPWR VPWR _0494_ sky130_fd_sc_hd__nand2b_1
X_2607_ _1852_ _1853_ VGND VGND VPWR VPWR _1854_ sky130_fd_sc_hd__xnor2_4
XFILLER_0_23_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3587_ _0416_ _0415_ VGND VGND VPWR VPWR _0425_ sky130_fd_sc_hd__and2b_1
X_2538_ net221 _1756_ VGND VGND VPWR VPWR _1776_ sky130_fd_sc_hd__nor2_1
XFILLER_0_11_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4208_ net175 _1019_ net173 VGND VGND VPWR VPWR _1027_ sky130_fd_sc_hd__a21oi_1
X_4139_ _0941_ _0964_ VGND VGND VPWR VPWR _0966_ sky130_fd_sc_hd__nor2_1
XFILLER_0_78_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout192 net8 VGND VGND VPWR VPWR net192 sky130_fd_sc_hd__clkbuf_2
Xfanout181 gm0.iter\[1\] VGND VGND VPWR VPWR net181 sky130_fd_sc_hd__clkbuf_2
Xfanout170 net172 VGND VGND VPWR VPWR net170 sky130_fd_sc_hd__buf_2
Xclkbuf_3_4__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_4__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_60_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_105 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_382 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3510_ net137 net130 VGND VGND VPWR VPWR _0348_ sky130_fd_sc_hd__xor2_4
XFILLER_0_69_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4490_ _1276_ _1277_ VGND VGND VPWR VPWR _1278_ sky130_fd_sc_hd__nor2_1
X_3441_ _0268_ _0277_ _0278_ VGND VGND VPWR VPWR _0279_ sky130_fd_sc_hd__a21oi_1
X_3372_ net156 net151 VGND VGND VPWR VPWR _0210_ sky130_fd_sc_hd__xor2_4
X_5111_ clknet_3_4__leaf_clk _0105_ net202 VGND VGND VPWR VPWR vec\[1\]\[13\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_85_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5042_ clknet_3_4__leaf_clk _0036_ net202 VGND VGND VPWR VPWR gm0.iter\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4826_ _1600_ _1603_ _1022_ VGND VGND VPWR VPWR _1604_ sky130_fd_sc_hd__mux2_1
X_4757_ net120 _1534_ VGND VGND VPWR VPWR _1535_ sky130_fd_sc_hd__and2_1
X_4688_ _1463_ _1465_ VGND VGND VPWR VPWR _1466_ sky130_fd_sc_hd__and2b_1
X_3708_ _0531_ _0542_ _0544_ _0545_ VGND VGND VPWR VPWR _0546_ sky130_fd_sc_hd__o31a_1
X_3639_ _0419_ _0476_ VGND VGND VPWR VPWR _0477_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_66_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_503 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_69_260 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3990_ _0792_ _0779_ _0820_ VGND VGND VPWR VPWR _0822_ sky130_fd_sc_hd__nor3_1
XFILLER_0_29_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2941_ _2185_ _2186_ VGND VGND VPWR VPWR _2187_ sky130_fd_sc_hd__and2_1
XFILLER_0_29_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4611_ net55 _1388_ _1320_ _1023_ VGND VGND VPWR VPWR _1389_ sky130_fd_sc_hd__a22o_1
X_2872_ net93 _2022_ _2118_ VGND VGND VPWR VPWR _2119_ sky130_fd_sc_hd__a21o_1
XFILLER_0_72_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4542_ net174 _1022_ VGND VGND VPWR VPWR _1324_ sky130_fd_sc_hd__nor2_2
X_4473_ slte0.opA\[12\] _1196_ _1261_ VGND VGND VPWR VPWR _1262_ sky130_fd_sc_hd__and3_1
X_3424_ _0246_ _0261_ VGND VGND VPWR VPWR _0262_ sky130_fd_sc_hd__and2_1
X_3355_ _0191_ _0194_ VGND VGND VPWR VPWR _0195_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3286_ _0127_ _0129_ VGND VGND VPWR VPWR _0130_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_13_Left_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5025_ clknet_3_2__leaf_clk _0019_ net198 VGND VGND VPWR VPWR net19 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_24_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_17_Right_17 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4809_ net162 net158 net155 net152 net184 net179 VGND VGND VPWR VPWR _1586_ sky130_fd_sc_hd__mux4_1
XFILLER_0_16_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_322 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_26_Right_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_35_Right_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_44_Right_44 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3140_ _1826_ _2374_ VGND VGND VPWR VPWR _2381_ sky130_fd_sc_hd__nand2_1
X_3071_ net72 _2265_ VGND VGND VPWR VPWR _2314_ sky130_fd_sc_hd__nor2_1
XFILLER_0_15_84 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3973_ _0256_ _0801_ VGND VGND VPWR VPWR _0805_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_53_Right_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2924_ _1819_ _1822_ _2169_ VGND VGND VPWR VPWR _2170_ sky130_fd_sc_hd__a21o_1
X_2855_ _1899_ _1942_ _1904_ vec\[1\]\[0\] VGND VGND VPWR VPWR _2102_ sky130_fd_sc_hd__a31o_1
XFILLER_0_31_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4525_ net111 net110 net107 net104 net185 net180 VGND VGND VPWR VPWR _1308_ sky130_fd_sc_hd__mux4_1
XFILLER_0_53_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2786_ _2031_ _2032_ VGND VGND VPWR VPWR _2033_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_13_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4456_ net178 _1207_ _1092_ VGND VGND VPWR VPWR _1247_ sky130_fd_sc_hd__a21oi_1
XPHY_EDGE_ROW_62_Right_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3407_ net141 net136 VGND VGND VPWR VPWR _0245_ sky130_fd_sc_hd__nand2_2
X_4387_ _1025_ _1091_ _1088_ _1183_ VGND VGND VPWR VPWR _1184_ sky130_fd_sc_hd__o22a_1
X_3338_ _0161_ _0175_ VGND VGND VPWR VPWR _0179_ sky130_fd_sc_hd__or2_4
X_3269_ _2307_ _2270_ VGND VGND VPWR VPWR _0113_ sky130_fd_sc_hd__nor2_1
X_5008_ clknet_3_3__leaf_clk _0002_ net199 VGND VGND VPWR VPWR net35 sky130_fd_sc_hd__dfrtp_1
XPHY_EDGE_ROW_71_Right_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_36_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_63_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_80_Right_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2640_ _1884_ _1885_ VGND VGND VPWR VPWR _1887_ sky130_fd_sc_hd__or2_1
XFILLER_0_42_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2571_ net72 net69 VGND VGND VPWR VPWR _1818_ sky130_fd_sc_hd__or2_1
XFILLER_0_77_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4310_ slte0.opB\[9\] slte0.opA\[9\] VGND VGND VPWR VPWR _1110_ sky130_fd_sc_hd__or2b_1
XFILLER_0_10_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_303 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4241_ slte0.opB\[8\] _1051_ _1031_ VGND VGND VPWR VPWR _1052_ sky130_fd_sc_hd__mux2_1
X_4172_ _0983_ _0984_ VGND VGND VPWR VPWR _0997_ sky130_fd_sc_hd__nor2_1
X_3123_ _2290_ _2363_ _2364_ VGND VGND VPWR VPWR _2365_ sky130_fd_sc_hd__a21o_1
X_3054_ _2207_ _2284_ VGND VGND VPWR VPWR _2297_ sky130_fd_sc_hd__nor2_1
XFILLER_0_9_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3956_ _0754_ _0755_ _0788_ VGND VGND VPWR VPWR _0789_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_18_447 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_42_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2907_ net85 net79 _1814_ _2152_ VGND VGND VPWR VPWR _2153_ sky130_fd_sc_hd__a31o_1
X_3887_ _0719_ _0720_ VGND VGND VPWR VPWR _0721_ sky130_fd_sc_hd__and2_1
X_2838_ _1981_ _2063_ VGND VGND VPWR VPWR _2085_ sky130_fd_sc_hd__and2_1
XFILLER_0_60_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2769_ net111 net105 VGND VGND VPWR VPWR _2016_ sky130_fd_sc_hd__nor2_1
XFILLER_0_60_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4508_ _1281_ _1288_ _1292_ VGND VGND VPWR VPWR _1294_ sky130_fd_sc_hd__a21oi_1
X_4439_ _1106_ _1231_ VGND VGND VPWR VPWR _1232_ sky130_fd_sc_hd__or2_2
XFILLER_0_6_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_299 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3810_ vec\[0\]\[14\] net122 VGND VGND VPWR VPWR _0646_ sky130_fd_sc_hd__xor2_1
X_4790_ _1564_ _1565_ net179 VGND VGND VPWR VPWR _1566_ sky130_fd_sc_hd__mux2_1
X_3741_ _0576_ _0577_ net157 VGND VGND VPWR VPWR _0578_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_82_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_12_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3672_ _0419_ _0450_ _0495_ VGND VGND VPWR VPWR _0510_ sky130_fd_sc_hd__and3_1
X_2623_ _1736_ _1869_ VGND VGND VPWR VPWR _1870_ sky130_fd_sc_hd__and2_1
X_2554_ net87 net79 VGND VGND VPWR VPWR _1801_ sky130_fd_sc_hd__xor2_4
X_4224_ _1038_ VGND VGND VPWR VPWR _0042_ sky130_fd_sc_hd__clkbuf_1
X_4155_ net225 _2143_ _0981_ net265 VGND VGND VPWR VPWR _0030_ sky130_fd_sc_hd__a22o_1
X_3106_ _2317_ _2315_ VGND VGND VPWR VPWR _2348_ sky130_fd_sc_hd__and2b_1
XFILLER_0_37_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4086_ _0911_ _0914_ VGND VGND VPWR VPWR _0915_ sky130_fd_sc_hd__xnor2_2
X_3037_ _2256_ _2280_ VGND VGND VPWR VPWR _2281_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_77_199 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_328 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4988_ net66 _1753_ _1759_ VGND VGND VPWR VPWR _1770_ sky130_fd_sc_hd__a21o_1
XFILLER_0_80_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3939_ _0770_ _0771_ net146 VGND VGND VPWR VPWR _0772_ sky130_fd_sc_hd__o21ai_2
XPHY_EDGE_ROW_83_Left_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_14_450 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_1_Left_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xinput16 theta[7] VGND VGND VPWR VPWR net16 sky130_fd_sc_hd__buf_1
XFILLER_0_12_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4911_ _1689_ _1690_ VGND VGND VPWR VPWR _1691_ sky130_fd_sc_hd__xor2_1
X_4842_ _1609_ _1610_ VGND VGND VPWR VPWR _1620_ sky130_fd_sc_hd__nor2_1
X_4773_ net165 net164 net162 net158 net184 net179 VGND VGND VPWR VPWR _1549_ sky130_fd_sc_hd__mux4_1
XFILLER_0_55_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3724_ _0469_ _0471_ VGND VGND VPWR VPWR _0562_ sky130_fd_sc_hd__nand2_1
XFILLER_0_15_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3655_ _0474_ _0492_ VGND VGND VPWR VPWR _0493_ sky130_fd_sc_hd__or2b_1
X_2606_ net74 net69 VGND VGND VPWR VPWR _1853_ sky130_fd_sc_hd__nand2_2
XFILLER_0_2_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3586_ _0392_ _0399_ VGND VGND VPWR VPWR _0424_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_2_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2537_ _1746_ _1756_ VGND VGND VPWR VPWR _1766_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_54_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4207_ _1019_ _1025_ VGND VGND VPWR VPWR _1026_ sky130_fd_sc_hd__and2_1
X_4138_ _0941_ _0964_ VGND VGND VPWR VPWR _0965_ sky130_fd_sc_hd__and2_1
X_4069_ _0878_ _0880_ VGND VGND VPWR VPWR _0898_ sky130_fd_sc_hd__and2b_1
XFILLER_0_78_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_38_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_191 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xfanout160 net161 VGND VGND VPWR VPWR net160 sky130_fd_sc_hd__clkbuf_2
Xfanout171 net172 VGND VGND VPWR VPWR net171 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout182 net183 VGND VGND VPWR VPWR net182 sky130_fd_sc_hd__buf_4
Xfanout193 net195 VGND VGND VPWR VPWR net193 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_69_420 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3440_ _0275_ _0276_ VGND VGND VPWR VPWR _0278_ sky130_fd_sc_hd__and2b_1
XFILLER_0_52_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3371_ net156 _0207_ _0208_ VGND VGND VPWR VPWR _0209_ sky130_fd_sc_hd__a21oi_2
X_5110_ clknet_3_5__leaf_clk _0104_ net202 VGND VGND VPWR VPWR vec\[1\]\[12\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_85_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5041_ clknet_3_4__leaf_clk _0035_ net202 VGND VGND VPWR VPWR gm0.iter\[0\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_75_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_200 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4825_ _1601_ VGND VGND VPWR VPWR _1603_ sky130_fd_sc_hd__inv_2
XFILLER_0_47_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4756_ _1531_ _1533_ VGND VGND VPWR VPWR _1534_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_43_331 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4687_ _1464_ _1461_ VGND VGND VPWR VPWR _1465_ sky130_fd_sc_hd__nand2_1
X_3707_ _0541_ _0540_ _0539_ VGND VGND VPWR VPWR _0545_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_70_183 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3638_ _0388_ _0475_ VGND VGND VPWR VPWR _0476_ sky130_fd_sc_hd__xor2_1
X_3569_ _0380_ _0385_ _0406_ VGND VGND VPWR VPWR _0407_ sky130_fd_sc_hd__a21o_1
XFILLER_0_75_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2940_ _2144_ _2145_ _2184_ VGND VGND VPWR VPWR _2186_ sky130_fd_sc_hd__or3_1
XFILLER_0_84_242 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_4_Left_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2871_ net93 _1787_ VGND VGND VPWR VPWR _2118_ sky130_fd_sc_hd__nor2_1
X_4610_ _1022_ _1386_ VGND VGND VPWR VPWR _1388_ sky130_fd_sc_hd__nor2_1
X_4541_ net174 _1322_ VGND VGND VPWR VPWR _1323_ sky130_fd_sc_hd__nand2_1
XFILLER_0_52_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_63 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4472_ _1218_ _1260_ VGND VGND VPWR VPWR _1261_ sky130_fd_sc_hd__xnor2_1
X_3423_ net134 net130 VGND VGND VPWR VPWR _0261_ sky130_fd_sc_hd__or2_1
XFILLER_0_40_378 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3354_ _0192_ _0193_ VGND VGND VPWR VPWR _0194_ sky130_fd_sc_hd__xnor2_1
X_3285_ _2485_ _0128_ VGND VGND VPWR VPWR _0129_ sky130_fd_sc_hd__or2_1
XFILLER_0_29_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5024_ clknet_3_7__leaf_clk _0018_ net204 VGND VGND VPWR VPWR net43 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_75_220 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4808_ net149 net146 net143 net140 net184 net179 VGND VGND VPWR VPWR _1585_ sky130_fd_sc_hd__mux4_1
X_4739_ net188 net124 _1492_ _1516_ VGND VGND VPWR VPWR _0088_ sky130_fd_sc_hd__o22a_1
XFILLER_0_71_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_478 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_54_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_66_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3070_ net79 _1813_ net85 VGND VGND VPWR VPWR _2313_ sky130_fd_sc_hd__o21ai_2
X_3972_ _0801_ _0802_ _0803_ VGND VGND VPWR VPWR _0804_ sky130_fd_sc_hd__and3_1
X_2923_ net67 net60 _1821_ VGND VGND VPWR VPWR _2169_ sky130_fd_sc_hd__and3_1
X_2854_ _2098_ _2099_ _1900_ VGND VGND VPWR VPWR _2101_ sky130_fd_sc_hd__o21ai_1
X_2785_ _1997_ _2004_ VGND VGND VPWR VPWR _2032_ sky130_fd_sc_hd__xnor2_1
X_4524_ _1305_ _1306_ _1021_ VGND VGND VPWR VPWR _1307_ sky130_fd_sc_hd__mux2_1
X_4455_ _1245_ _1246_ slte0.opA\[9\] _1168_ VGND VGND VPWR VPWR _0065_ sky130_fd_sc_hd__a2bb2o_1
X_3406_ _0233_ _0243_ VGND VGND VPWR VPWR _0244_ sky130_fd_sc_hd__xnor2_1
X_4386_ net173 _1023_ VGND VGND VPWR VPWR _1183_ sky130_fd_sc_hd__nand2_1
X_3337_ net232 _2143_ _0178_ _1532_ VGND VGND VPWR VPWR _0015_ sky130_fd_sc_hd__a22o_1
X_3268_ net76 _2482_ VGND VGND VPWR VPWR _0112_ sky130_fd_sc_hd__nand2_1
X_3199_ net243 _2143_ _2438_ _1532_ VGND VGND VPWR VPWR _0010_ sky130_fd_sc_hd__a22o_1
X_5007_ clknet_3_2__leaf_clk _0001_ net198 VGND VGND VPWR VPWR net36 sky130_fd_sc_hd__dfstp_1
XFILLER_0_36_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_6_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_459 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2570_ net72 net69 VGND VGND VPWR VPWR _1817_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4240_ net15 _1050_ VGND VGND VPWR VPWR _1051_ sky130_fd_sc_hd__xnor2_1
X_4171_ _0970_ _0977_ _0989_ _0990_ VGND VGND VPWR VPWR _0996_ sky130_fd_sc_hd__o31a_1
X_3122_ _2286_ _2328_ _2329_ VGND VGND VPWR VPWR _2364_ sky130_fd_sc_hd__o21ba_1
X_3053_ _2281_ _2283_ VGND VGND VPWR VPWR _2296_ sky130_fd_sc_hd__nor2_1
XFILLER_0_77_348 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_9_136 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3955_ _0784_ _0787_ VGND VGND VPWR VPWR _0788_ sky130_fd_sc_hd__xor2_1
XFILLER_0_45_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2906_ net83 _1812_ VGND VGND VPWR VPWR _2152_ sky130_fd_sc_hd__nor2_1
X_3886_ net149 _0717_ _0718_ VGND VGND VPWR VPWR _0720_ sky130_fd_sc_hd__or3_1
XFILLER_0_60_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_84_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2837_ _2082_ _2083_ VGND VGND VPWR VPWR _2084_ sky130_fd_sc_hd__xor2_1
X_2768_ net106 _2012_ _2013_ _2014_ VGND VGND VPWR VPWR _2015_ sky130_fd_sc_hd__o22ai_1
XFILLER_0_13_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4507_ _1281_ _1288_ _1292_ _1482_ VGND VGND VPWR VPWR _1293_ sky130_fd_sc_hd__a31o_1
X_2699_ net110 _1943_ _1944_ _1945_ VGND VGND VPWR VPWR _1946_ sky130_fd_sc_hd__a31o_1
X_4438_ _1094_ _1229_ _1230_ VGND VGND VPWR VPWR _1231_ sky130_fd_sc_hd__o21a_1
X_4369_ _1098_ _1166_ _1167_ net254 _1152_ VGND VGND VPWR VPWR _0058_ sky130_fd_sc_hd__a32o_1
XFILLER_0_76_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_2_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3740_ _0233_ _0243_ VGND VGND VPWR VPWR _0577_ sky130_fd_sc_hd__and2_1
XFILLER_0_27_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_407 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3671_ _0507_ _0508_ VGND VGND VPWR VPWR _0509_ sky130_fd_sc_hd__xor2_1
X_2622_ net109 _1675_ _1725_ VGND VGND VPWR VPWR _1869_ sky130_fd_sc_hd__or3_1
XFILLER_0_23_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2553_ net79 net75 VGND VGND VPWR VPWR _1800_ sky130_fd_sc_hd__nand2_1
XFILLER_0_10_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4223_ slte0.opB\[4\] _1037_ _1031_ VGND VGND VPWR VPWR _1038_ sky130_fd_sc_hd__mux2_1
X_4154_ _0979_ _0980_ VGND VGND VPWR VPWR _0981_ sky130_fd_sc_hd__xnor2_1
X_3105_ _2344_ _2346_ VGND VGND VPWR VPWR _2347_ sky130_fd_sc_hd__xnor2_1
X_4085_ net132 _0913_ VGND VGND VPWR VPWR _0914_ sky130_fd_sc_hd__xor2_2
X_3036_ _2276_ _2279_ VGND VGND VPWR VPWR _2280_ sky130_fd_sc_hd__xor2_1
XFILLER_0_77_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4987_ _1767_ _1768_ VGND VGND VPWR VPWR _1769_ sky130_fd_sc_hd__nand2_1
XFILLER_0_73_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3938_ _0732_ _0737_ VGND VGND VPWR VPWR _0771_ sky130_fd_sc_hd__and2b_1
X_3869_ _0660_ _0662_ VGND VGND VPWR VPWR _0704_ sky130_fd_sc_hd__nor2_1
XFILLER_0_14_440 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_41_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_68_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput17 theta[8] VGND VGND VPWR VPWR net17 sky130_fd_sc_hd__buf_1
XFILLER_0_74_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4910_ _1676_ _1678_ _1238_ VGND VGND VPWR VPWR _1690_ sky130_fd_sc_hd__o21ba_1
X_4841_ _1614_ _1617_ VGND VGND VPWR VPWR _1619_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4772_ _1546_ _1547_ _1021_ VGND VGND VPWR VPWR _1548_ sky130_fd_sc_hd__mux2_1
X_3723_ _0473_ _0493_ _0557_ _0558_ _0560_ VGND VGND VPWR VPWR _0561_ sky130_fd_sc_hd__a2111o_1
X_3654_ _0485_ _0486_ _0490_ _0491_ VGND VGND VPWR VPWR _0492_ sky130_fd_sc_hd__a2bb2o_1
X_2605_ net73 net67 VGND VGND VPWR VPWR _1852_ sky130_fd_sc_hd__xor2_4
XFILLER_0_23_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3585_ _0417_ _0422_ VGND VGND VPWR VPWR _0423_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_11_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2536_ net97 net91 VGND VGND VPWR VPWR _1756_ sky130_fd_sc_hd__xor2_4
X_4206_ _1024_ _1022_ VGND VGND VPWR VPWR _1025_ sky130_fd_sc_hd__nor2_2
XFILLER_0_47_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4137_ _0962_ _0963_ VGND VGND VPWR VPWR _0964_ sky130_fd_sc_hd__or2_1
XFILLER_0_3_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_78_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4068_ _0887_ _0895_ _0896_ VGND VGND VPWR VPWR _0897_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3019_ _2257_ _2262_ VGND VGND VPWR VPWR _2263_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_65_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout150 net152 VGND VGND VPWR VPWR net150 sky130_fd_sc_hd__buf_4
Xfanout161 net162 VGND VGND VPWR VPWR net161 sky130_fd_sc_hd__buf_2
Xfanout172 gm0.iter\[4\] VGND VGND VPWR VPWR net172 sky130_fd_sc_hd__clkbuf_4
Xfanout183 net187 VGND VGND VPWR VPWR net183 sky130_fd_sc_hd__clkbuf_4
Xfanout194 net195 VGND VGND VPWR VPWR net194 sky130_fd_sc_hd__buf_2
XFILLER_0_44_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_69_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_56_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_4_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3370_ net156 _0205_ VGND VGND VPWR VPWR _0208_ sky130_fd_sc_hd__nor2_1
X_5040_ clknet_3_2__leaf_clk _0034_ net198 VGND VGND VPWR VPWR net25 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_229 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_62 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4824_ _1556_ _1561_ _1018_ VGND VGND VPWR VPWR _1601_ sky130_fd_sc_hd__mux2_1
XFILLER_0_7_256 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4755_ _1518_ _1519_ _1272_ VGND VGND VPWR VPWR _1533_ sky130_fd_sc_hd__a21oi_1
X_3706_ _0537_ _0543_ VGND VGND VPWR VPWR _0544_ sky130_fd_sc_hd__nand2_1
X_4686_ _1437_ _1443_ _1448_ _1450_ VGND VGND VPWR VPWR _1464_ sky130_fd_sc_hd__a31o_1
XFILLER_0_31_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_43_376 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3637_ net158 net153 VGND VGND VPWR VPWR _0475_ sky130_fd_sc_hd__and2_1
XFILLER_0_3_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3568_ _0389_ _0386_ VGND VGND VPWR VPWR _0406_ sky130_fd_sc_hd__and2b_1
X_2519_ net87 net83 _1571_ VGND VGND VPWR VPWR _1581_ sky130_fd_sc_hd__a21o_1
XFILLER_0_59_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3499_ net160 _0335_ _0336_ VGND VGND VPWR VPWR _0337_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_38_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_468 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2870_ _2114_ _2116_ VGND VGND VPWR VPWR _2117_ sky130_fd_sc_hd__and2_1
XFILLER_0_57_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_298 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_25_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4540_ _1320_ _1321_ _1021_ VGND VGND VPWR VPWR _1322_ sky130_fd_sc_hd__mux2_1
XFILLER_0_80_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4471_ net178 net183 _1462_ VGND VGND VPWR VPWR _1260_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3422_ _0258_ _0259_ VGND VGND VPWR VPWR _0260_ sky130_fd_sc_hd__xnor2_4
X_3353_ _2164_ _2165_ _2220_ _2265_ VGND VGND VPWR VPWR _0193_ sky130_fd_sc_hd__o22a_1
XFILLER_0_0_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3284_ _2468_ _2487_ VGND VGND VPWR VPWR _0128_ sky130_fd_sc_hd__nor2_1
X_5023_ clknet_3_7__leaf_clk _0017_ net204 VGND VGND VPWR VPWR net42 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_48_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_3_Right_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4807_ _1582_ _1583_ _1022_ VGND VGND VPWR VPWR _1584_ sky130_fd_sc_hd__mux2_1
XFILLER_0_63_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2999_ _2242_ _2243_ VGND VGND VPWR VPWR _2244_ sky130_fd_sc_hd__and2_1
X_4738_ _1513_ _1515_ VGND VGND VPWR VPWR _1516_ sky130_fd_sc_hd__nor2_1
X_4669_ _1433_ _1445_ _1218_ VGND VGND VPWR VPWR _1446_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_43_195 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_31_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_75 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3971_ net121 _0254_ VGND VGND VPWR VPWR _0803_ sky130_fd_sc_hd__or2_1
X_2922_ _2163_ _2167_ VGND VGND VPWR VPWR _2168_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_17_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2853_ _2098_ _2096_ VGND VGND VPWR VPWR _2100_ sky130_fd_sc_hd__or2b_1
XFILLER_0_72_279 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2784_ _2021_ _2029_ _2030_ VGND VGND VPWR VPWR _2031_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_13_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4523_ net85 net81 net77 net74 net187 net177 VGND VGND VPWR VPWR _1306_ sky130_fd_sc_hd__mux4_1
X_4454_ _1232_ _1237_ _1244_ VGND VGND VPWR VPWR _1246_ sky130_fd_sc_hd__a21oi_1
X_3405_ _0238_ _0242_ VGND VGND VPWR VPWR _0243_ sky130_fd_sc_hd__xnor2_1
X_4385_ _1179_ _1181_ VGND VGND VPWR VPWR _1182_ sky130_fd_sc_hd__nor2b_1
X_3336_ _0176_ _0177_ VGND VGND VPWR VPWR _0178_ sky130_fd_sc_hd__nor2_1
X_3267_ net169 _0110_ VGND VGND VPWR VPWR _0111_ sky130_fd_sc_hd__nand2_1
X_5006_ clknet_3_3__leaf_clk _0000_ net199 VGND VGND VPWR VPWR state\[0\] sky130_fd_sc_hd__dfrtp_1
X_3198_ _2436_ _2437_ VGND VGND VPWR VPWR _2438_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_48_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_351 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_15_Left_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_24_Left_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_39_265 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_496 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4170_ net233 _2248_ _0994_ _0995_ VGND VGND VPWR VPWR _0031_ sky130_fd_sc_hd__a22o_1
X_3121_ _2288_ _2330_ VGND VGND VPWR VPWR _2363_ sky130_fd_sc_hd__and2_1
X_3052_ _2288_ _2290_ _2286_ VGND VGND VPWR VPWR _2295_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_26_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_26_96 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3954_ _0708_ _0750_ _0786_ VGND VGND VPWR VPWR _0787_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_85_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3885_ _0717_ _0718_ net149 VGND VGND VPWR VPWR _0719_ sky130_fd_sc_hd__o21ai_1
X_2905_ _2048_ _1807_ VGND VGND VPWR VPWR _2151_ sky130_fd_sc_hd__and2_1
XFILLER_0_33_419 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2836_ _2045_ _2051_ VGND VGND VPWR VPWR _2083_ sky130_fd_sc_hd__xor2_2
XFILLER_0_13_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2767_ net109 net102 VGND VGND VPWR VPWR _2014_ sky130_fd_sc_hd__nand2_1
XFILLER_0_60_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_77_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4506_ _1290_ _1291_ VGND VGND VPWR VPWR _1292_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2698_ net109 _1906_ VGND VGND VPWR VPWR _1945_ sky130_fd_sc_hd__nor2_1
X_4437_ _1094_ _1195_ _1218_ VGND VGND VPWR VPWR _1230_ sky130_fd_sc_hd__o21ai_1
X_4368_ _1164_ _1151_ _1163_ VGND VGND VPWR VPWR _1167_ sky130_fd_sc_hd__a21bo_1
X_3319_ _2500_ _2467_ _0133_ _0158_ VGND VGND VPWR VPWR _0161_ sky130_fd_sc_hd__or4_4
X_4299_ slte0.opA\[13\] VGND VGND VPWR VPWR _1099_ sky130_fd_sc_hd__inv_2
XFILLER_0_51_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_327 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_27_202 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3670_ _0240_ _0479_ VGND VGND VPWR VPWR _0508_ sky130_fd_sc_hd__xor2_2
X_2621_ _1798_ _1867_ VGND VGND VPWR VPWR _1868_ sky130_fd_sc_hd__xnor2_2
X_2552_ net94 _1756_ net218 VGND VGND VPWR VPWR _1799_ sky130_fd_sc_hd__o21a_1
XFILLER_0_10_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4222_ net11 _1036_ VGND VGND VPWR VPWR _1037_ sky130_fd_sc_hd__xor2_1
X_4153_ _0928_ _0952_ _0621_ VGND VGND VPWR VPWR _0980_ sky130_fd_sc_hd__a21oi_1
X_3104_ _2312_ _2319_ _2345_ VGND VGND VPWR VPWR _2346_ sky130_fd_sc_hd__a21oi_2
X_4084_ _0864_ _0869_ _0912_ VGND VGND VPWR VPWR _0913_ sky130_fd_sc_hd__o21ai_2
X_3035_ _2216_ _2277_ _2278_ VGND VGND VPWR VPWR _2279_ sky130_fd_sc_hd__a21o_1
XFILLER_0_77_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_77_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4986_ net64 _1765_ VGND VGND VPWR VPWR _1768_ sky130_fd_sc_hd__or2_1
X_3937_ _0736_ _0734_ VGND VGND VPWR VPWR _0770_ sky130_fd_sc_hd__and2b_1
X_3868_ _0631_ _0702_ VGND VGND VPWR VPWR _0703_ sky130_fd_sc_hd__xor2_2
XFILLER_0_5_151 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3799_ net136 _0251_ VGND VGND VPWR VPWR _0635_ sky130_fd_sc_hd__nor2_1
X_2819_ _1766_ _2065_ VGND VGND VPWR VPWR _2066_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xinput18 theta[9] VGND VGND VPWR VPWR net18 sky130_fd_sc_hd__buf_1
XFILLER_0_24_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_59_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4840_ _1295_ _1617_ _1618_ net104 _1191_ VGND VGND VPWR VPWR _0095_ sky130_fd_sc_hd__a32o_1
XFILLER_0_74_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4771_ net143 net140 net135 net133 net184 net179 VGND VGND VPWR VPWR _1547_ sky130_fd_sc_hd__mux4_1
X_3722_ _0488_ _0559_ VGND VGND VPWR VPWR _0560_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_70_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3653_ _0485_ _0486_ VGND VGND VPWR VPWR _0491_ sky130_fd_sc_hd__xor2_1
X_2604_ _1849_ _1850_ VGND VGND VPWR VPWR _1851_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_70_399 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3584_ net165 _0388_ _0421_ VGND VGND VPWR VPWR _0422_ sky130_fd_sc_hd__o21ai_1
X_2535_ net100 net93 VGND VGND VPWR VPWR _1746_ sky130_fd_sc_hd__nand2_2
XFILLER_0_61_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4205_ net174 VGND VGND VPWR VPWR _1024_ sky130_fd_sc_hd__inv_2
X_4136_ _0937_ _0955_ _0961_ VGND VGND VPWR VPWR _0963_ sky130_fd_sc_hd__and3_1
X_4067_ _0882_ _0883_ _0885_ VGND VGND VPWR VPWR _0896_ sky130_fd_sc_hd__o21a_1
X_3018_ _2259_ _2261_ VGND VGND VPWR VPWR _2262_ sky130_fd_sc_hd__xnor2_1
Xwire53 _0714_ VGND VGND VPWR VPWR net53 sky130_fd_sc_hd__buf_1
XFILLER_0_78_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_500 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4969_ _1296_ _1462_ _1582_ VGND VGND VPWR VPWR _1750_ sky130_fd_sc_hd__and3_1
XFILLER_0_61_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xfanout140 vec\[0\]\[9\] VGND VGND VPWR VPWR net140 sky130_fd_sc_hd__clkbuf_4
Xfanout151 net152 VGND VGND VPWR VPWR net151 sky130_fd_sc_hd__clkbuf_4
Xfanout162 vec\[0\]\[2\] VGND VGND VPWR VPWR net162 sky130_fd_sc_hd__clkbuf_2
Xfanout173 gm0.iter\[3\] VGND VGND VPWR VPWR net173 sky130_fd_sc_hd__buf_2
Xfanout195 net201 VGND VGND VPWR VPWR net195 sky130_fd_sc_hd__buf_2
Xfanout184 net187 VGND VGND VPWR VPWR net184 sky130_fd_sc_hd__buf_4
XFILLER_0_44_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_444 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4823_ net115 _1084_ _1557_ _1018_ VGND VGND VPWR VPWR _1600_ sky130_fd_sc_hd__a22oi_2
X_4754_ net55 _1517_ _1530_ VGND VGND VPWR VPWR _1531_ sky130_fd_sc_hd__a21bo_1
X_3705_ _0525_ _0536_ VGND VGND VPWR VPWR _0543_ sky130_fd_sc_hd__or2_1
XFILLER_0_55_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4685_ _1437_ _1443_ _1448_ _1450_ _1461_ VGND VGND VPWR VPWR _1463_ sky130_fd_sc_hd__a311oi_4
X_3636_ _0454_ _0467_ VGND VGND VPWR VPWR _0474_ sky130_fd_sc_hd__xnor2_1
X_3567_ _0377_ _0404_ VGND VGND VPWR VPWR _0405_ sky130_fd_sc_hd__or2_1
XFILLER_0_11_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2518_ net93 net87 VGND VGND VPWR VPWR _1571_ sky130_fd_sc_hd__xor2_4
X_3498_ net160 _0210_ VGND VGND VPWR VPWR _0336_ sky130_fd_sc_hd__nor2_1
X_4119_ _0929_ _0946_ VGND VGND VPWR VPWR _0947_ sky130_fd_sc_hd__xnor2_2
X_5099_ clknet_3_6__leaf_clk _0093_ net206 VGND VGND VPWR VPWR vec\[1\]\[1\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_81_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_344 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_39_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_238 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4470_ _1152_ slte0.opA\[11\] _1015_ _1259_ VGND VGND VPWR VPWR _0067_ sky130_fd_sc_hd__a22o_1
X_3421_ net124 net119 VGND VGND VPWR VPWR _0259_ sky130_fd_sc_hd__xor2_4
X_3352_ _0180_ _0186_ _0184_ VGND VGND VPWR VPWR _0192_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_0_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3283_ _0112_ _0126_ VGND VGND VPWR VPWR _0127_ sky130_fd_sc_hd__xnor2_2
X_5022_ clknet_3_7__leaf_clk _0016_ net207 VGND VGND VPWR VPWR net41 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_45_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_414 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_75_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4806_ net135 net133 net131 net127 net186 net179 VGND VGND VPWR VPWR _1583_ sky130_fd_sc_hd__mux4_1
XFILLER_0_61_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2998_ _2204_ _2205_ _2241_ VGND VGND VPWR VPWR _2243_ sky130_fd_sc_hd__or3_1
XFILLER_0_56_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4737_ _1511_ _1514_ VGND VGND VPWR VPWR _1515_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4668_ _1418_ _1419_ VGND VGND VPWR VPWR _1445_ sky130_fd_sc_hd__nand2_1
X_3619_ net153 net150 VGND VGND VPWR VPWR _0457_ sky130_fd_sc_hd__or2_1
X_4599_ _1024_ _1376_ _1377_ VGND VGND VPWR VPWR _1378_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_54_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_81_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_13_Right_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3970_ net121 _0254_ VGND VGND VPWR VPWR _0802_ sky130_fd_sc_hd__nand2_1
X_2921_ _2164_ _2165_ _2166_ VGND VGND VPWR VPWR _2167_ sky130_fd_sc_hd__o21a_1
XFILLER_0_9_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2852_ _1981_ net108 VGND VGND VPWR VPWR _2099_ sky130_fd_sc_hd__and2_1
XFILLER_0_72_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_22_Right_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_31_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2783_ _2026_ _2028_ VGND VGND VPWR VPWR _2030_ sky130_fd_sc_hd__nand2_1
XFILLER_0_80_280 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4522_ net72 net69 net66 net64 net182 net177 VGND VGND VPWR VPWR _1305_ sky130_fd_sc_hd__mux4_1
X_4453_ _1232_ _1237_ _1244_ _1482_ VGND VGND VPWR VPWR _1245_ sky130_fd_sc_hd__a31o_1
X_3404_ net150 _0200_ _0241_ VGND VGND VPWR VPWR _0242_ sky130_fd_sc_hd__o21a_1
X_4384_ _1170_ _1180_ VGND VGND VPWR VPWR _1181_ sky130_fd_sc_hd__or2_1
X_3335_ net169 _0161_ _0175_ VGND VGND VPWR VPWR _0177_ sky130_fd_sc_hd__a21oi_1
X_3266_ _2500_ _2467_ VGND VGND VPWR VPWR _0110_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_31_Right_31 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5005_ _1784_ _1785_ net55 _1168_ VGND VGND VPWR VPWR _0109_ sky130_fd_sc_hd__a2bb2o_1
X_3197_ _2369_ _2403_ net167 VGND VGND VPWR VPWR _2437_ sky130_fd_sc_hd__o21a_1
XFILLER_0_72_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_222 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_40_Right_40 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_63_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_155 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_291 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3120_ _2359_ _2361_ VGND VGND VPWR VPWR _2362_ sky130_fd_sc_hd__xnor2_1
X_3051_ _2202_ _2245_ _2291_ VGND VGND VPWR VPWR _2294_ sky130_fd_sc_hd__or3_4
X_3953_ _0747_ _0749_ _0785_ VGND VGND VPWR VPWR _0786_ sky130_fd_sc_hd__a21oi_1
X_2904_ _2148_ _2149_ VGND VGND VPWR VPWR _2150_ sky130_fd_sc_hd__and2_1
X_3884_ _0677_ _0682_ VGND VGND VPWR VPWR _0718_ sky130_fd_sc_hd__and2_1
XFILLER_0_42_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_33_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2835_ _2077_ _2078_ _2081_ VGND VGND VPWR VPWR _2082_ sky130_fd_sc_hd__a21bo_1
XFILLER_0_60_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2766_ _1906_ _2012_ VGND VGND VPWR VPWR _2013_ sky130_fd_sc_hd__xor2_2
X_4505_ _1131_ _1289_ VGND VGND VPWR VPWR _1291_ sky130_fd_sc_hd__and2_1
X_2697_ _1942_ _1906_ VGND VGND VPWR VPWR _1944_ sky130_fd_sc_hd__or2_1
X_4436_ _1206_ _1181_ VGND VGND VPWR VPWR _1229_ sky130_fd_sc_hd__or2b_1
X_4367_ _1163_ _1165_ VGND VGND VPWR VPWR _1166_ sky130_fd_sc_hd__or2_1
X_3318_ net238 _2143_ _0160_ _1532_ VGND VGND VPWR VPWR _0014_ sky130_fd_sc_hd__a22o_1
XFILLER_0_6_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4298_ _1014_ VGND VGND VPWR VPWR _1098_ sky130_fd_sc_hd__clkbuf_4
X_3249_ _2485_ _2486_ VGND VGND VPWR VPWR _2487_ sky130_fd_sc_hd__or2_1
XFILLER_0_64_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_47_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_82_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2620_ _1847_ _1866_ VGND VGND VPWR VPWR _1867_ sky130_fd_sc_hd__xor2_2
XFILLER_0_12_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2551_ _1796_ _1797_ VGND VGND VPWR VPWR _1798_ sky130_fd_sc_hd__and2_1
XFILLER_0_23_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4221_ net3 net9 net10 net191 VGND VGND VPWR VPWR _1036_ sky130_fd_sc_hd__a31o_1
X_4152_ _0977_ _0978_ VGND VGND VPWR VPWR _0979_ sky130_fd_sc_hd__or2_1
X_3103_ _2311_ _2306_ VGND VGND VPWR VPWR _2345_ sky130_fd_sc_hd__and2b_1
X_4083_ _0866_ _0868_ VGND VGND VPWR VPWR _0912_ sky130_fd_sc_hd__or2_1
XFILLER_0_37_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3034_ _2229_ _2231_ VGND VGND VPWR VPWR _2278_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_43_Left_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_46_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4985_ net64 _1765_ VGND VGND VPWR VPWR _1767_ sky130_fd_sc_hd__nand2_1
XFILLER_0_53_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3936_ _0766_ _0768_ VGND VGND VPWR VPWR _0769_ sky130_fd_sc_hd__xor2_1
XFILLER_0_73_386 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3867_ _0699_ _0701_ VGND VGND VPWR VPWR _0702_ sky130_fd_sc_hd__xnor2_2
X_3798_ net141 _0221_ net147 VGND VGND VPWR VPWR _0634_ sky130_fd_sc_hd__o21ai_2
X_2818_ _2063_ _2064_ VGND VGND VPWR VPWR _2065_ sky130_fd_sc_hd__and2_1
XFILLER_0_5_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2749_ _1990_ _1989_ VGND VGND VPWR VPWR _1996_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_52_Left_138 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4419_ _1186_ _1190_ _1201_ _1203_ VGND VGND VPWR VPWR _1214_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_61_Left_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_491 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_70_Left_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_261 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_58_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4770_ net131 net127 net125 net123 net182 net178 VGND VGND VPWR VPWR _1546_ sky130_fd_sc_hd__mux4_2
XFILLER_0_23_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3721_ _0492_ _0474_ VGND VGND VPWR VPWR _0559_ sky130_fd_sc_hd__xnor2_1
X_3652_ net163 _0475_ _0487_ _0489_ VGND VGND VPWR VPWR _0490_ sky130_fd_sc_hd__o31a_1
X_3583_ _0329_ _0418_ _0420_ VGND VGND VPWR VPWR _0421_ sky130_fd_sc_hd__or3_1
X_2603_ _1790_ _1788_ VGND VGND VPWR VPWR _1850_ sky130_fd_sc_hd__and2b_1
X_2534_ _1675_ _1725_ net109 VGND VGND VPWR VPWR _1736_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_2_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4204_ _1023_ _1019_ VGND VGND VPWR VPWR _0037_ sky130_fd_sc_hd__xnor2_1
X_4135_ _0937_ _0955_ _0961_ VGND VGND VPWR VPWR _0962_ sky130_fd_sc_hd__a21oi_1
X_4066_ _0882_ _0883_ _0885_ VGND VGND VPWR VPWR _0895_ sky130_fd_sc_hd__or3_1
XFILLER_0_64_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_78_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3017_ net86 _1967_ _2260_ VGND VGND VPWR VPWR _2261_ sky130_fd_sc_hd__a21o_1
XFILLER_0_38_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4968_ _1735_ _1748_ VGND VGND VPWR VPWR _1749_ sky130_fd_sc_hd__and2_1
XFILLER_0_58_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3919_ _0715_ _0751_ VGND VGND VPWR VPWR _0753_ sky130_fd_sc_hd__nand2_1
X_4899_ _1206_ _1678_ VGND VGND VPWR VPWR _1679_ sky130_fd_sc_hd__or2b_1
Xfanout130 net131 VGND VGND VPWR VPWR net130 sky130_fd_sc_hd__buf_4
Xfanout141 net142 VGND VGND VPWR VPWR net141 sky130_fd_sc_hd__clkbuf_4
Xfanout152 vec\[0\]\[5\] VGND VGND VPWR VPWR net152 sky130_fd_sc_hd__clkbuf_4
Xfanout163 net164 VGND VGND VPWR VPWR net163 sky130_fd_sc_hd__buf_2
Xfanout174 gm0.iter\[3\] VGND VGND VPWR VPWR net174 sky130_fd_sc_hd__clkbuf_4
Xfanout196 net197 VGND VGND VPWR VPWR net196 sky130_fd_sc_hd__clkbuf_4
Xfanout185 net187 VGND VGND VPWR VPWR net185 sky130_fd_sc_hd__buf_2
XFILLER_0_69_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_84_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_69_Right_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_78_Right_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_426 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4822_ net116 _1169_ VGND VGND VPWR VPWR _1599_ sky130_fd_sc_hd__nand2_1
XFILLER_0_7_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4753_ net172 _1312_ _1313_ VGND VGND VPWR VPWR _1530_ sky130_fd_sc_hd__or3b_1
XFILLER_0_55_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_83_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_43_323 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3704_ _0539_ _0540_ _0541_ VGND VGND VPWR VPWR _0542_ sky130_fd_sc_hd__o21a_1
X_4684_ net135 _1460_ VGND VGND VPWR VPWR _1461_ sky130_fd_sc_hd__xnor2_2
X_3635_ _0452_ _0472_ VGND VGND VPWR VPWR _0473_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3566_ _0390_ _0402_ _0403_ VGND VGND VPWR VPWR _0404_ sky130_fd_sc_hd__a21oi_1
X_2517_ _1522_ VGND VGND VPWR VPWR _1560_ sky130_fd_sc_hd__clkbuf_2
X_3497_ _0210_ _0334_ VGND VGND VPWR VPWR _0335_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_52_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4118_ _0944_ _0945_ VGND VGND VPWR VPWR _0946_ sky130_fd_sc_hd__xor2_2
X_5098_ clknet_3_6__leaf_clk _0092_ net206 VGND VGND VPWR VPWR vec\[1\]\[0\] sky130_fd_sc_hd__dfrtp_2
X_4049_ _0838_ _0841_ VGND VGND VPWR VPWR _0879_ sky130_fd_sc_hd__or2b_1
XFILLER_0_78_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_404 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_19_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_297 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3420_ net126 net121 VGND VGND VPWR VPWR _0258_ sky130_fd_sc_hd__nand2_2
XFILLER_0_52_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3351_ _0161_ _0175_ _0187_ net169 VGND VGND VPWR VPWR _0191_ sky130_fd_sc_hd__o31a_1
XFILLER_0_0_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3282_ _0124_ _0125_ VGND VGND VPWR VPWR _0126_ sky130_fd_sc_hd__xor2_2
XFILLER_0_29_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5021_ clknet_3_6__leaf_clk _0015_ net204 VGND VGND VPWR VPWR net40 sky130_fd_sc_hd__dfrtp_1
XFILLER_0_75_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_201 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_0_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4805_ net125 net123 net120 net115 net182 net178 VGND VGND VPWR VPWR _1582_ sky130_fd_sc_hd__mux4_2
X_2997_ _2204_ _2205_ _2241_ VGND VGND VPWR VPWR _2242_ sky130_fd_sc_hd__o21ai_1
X_4736_ _1488_ _1503_ _1496_ VGND VGND VPWR VPWR _1514_ sky130_fd_sc_hd__o21a_1
XFILLER_0_71_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4667_ net54 _1322_ _1219_ VGND VGND VPWR VPWR _1444_ sky130_fd_sc_hd__mux2_1
X_3618_ _0283_ _0221_ VGND VGND VPWR VPWR _0456_ sky130_fd_sc_hd__xnor2_2
X_4598_ _1087_ _1306_ _1309_ _2195_ _1193_ VGND VGND VPWR VPWR _1377_ sky130_fd_sc_hd__o221a_1
X_3549_ net164 net156 VGND VGND VPWR VPWR _0387_ sky130_fd_sc_hd__nor2_1
XFILLER_0_81_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_54_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_81_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_8_Left_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_15_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2920_ net60 net63 net58 VGND VGND VPWR VPWR _2166_ sky130_fd_sc_hd__nand3b_1
XFILLER_0_45_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2851_ _1981_ net108 VGND VGND VPWR VPWR _2098_ sky130_fd_sc_hd__nor2_1
X_2782_ _2026_ _2028_ VGND VGND VPWR VPWR _2029_ sky130_fd_sc_hd__xor2_2
XFILLER_0_25_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4521_ _1295_ _1303_ _1304_ net253 net266 VGND VGND VPWR VPWR _0073_ sky130_fd_sc_hd__a32o_1
X_4452_ _1241_ _1243_ VGND VGND VPWR VPWR _1244_ sky130_fd_sc_hd__nand2_1
X_3403_ net150 _0240_ VGND VGND VPWR VPWR _0241_ sky130_fd_sc_hd__nand2_1
X_4383_ _1153_ _1159_ VGND VGND VPWR VPWR _1180_ sky130_fd_sc_hd__nand2_1
X_3334_ net169 _0161_ _0175_ VGND VGND VPWR VPWR _0176_ sky130_fd_sc_hd__and3_1
XFILLER_0_0_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3265_ _2501_ _2502_ net245 _2201_ VGND VGND VPWR VPWR _0012_ sky130_fd_sc_hd__a2bb2o_1
X_5004_ _1781_ _1780_ _1783_ VGND VGND VPWR VPWR _1785_ sky130_fd_sc_hd__a21oi_1
X_3196_ _2431_ _2435_ VGND VGND VPWR VPWR _2436_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_48_267 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_29_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4719_ net127 _1495_ VGND VGND VPWR VPWR _1497_ sky130_fd_sc_hd__nand2_1
XFILLER_0_39_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_204 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_54_237 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3050_ _2292_ _2293_ net244 _2201_ VGND VGND VPWR VPWR _0006_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_26_21 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_106 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3952_ _0704_ _0705_ _0747_ _0749_ _0703_ VGND VGND VPWR VPWR _0785_ sky130_fd_sc_hd__o221a_1
XFILLER_0_85_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2903_ net104 _2146_ _2147_ VGND VGND VPWR VPWR _2149_ sky130_fd_sc_hd__or3_1
XFILLER_0_18_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3883_ _0681_ _0679_ VGND VGND VPWR VPWR _0717_ sky130_fd_sc_hd__and2b_1
XFILLER_0_45_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2834_ _2075_ _2076_ VGND VGND VPWR VPWR _2081_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4504_ _1131_ _1289_ VGND VGND VPWR VPWR _1290_ sky130_fd_sc_hd__nor2_1
X_2765_ net99 net96 VGND VGND VPWR VPWR _2012_ sky130_fd_sc_hd__nand2_1
XFILLER_0_13_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2696_ _1942_ _1906_ VGND VGND VPWR VPWR _1943_ sky130_fd_sc_hd__nand2_1
X_4435_ _1168_ slte0.opA\[7\] _1227_ _1228_ VGND VGND VPWR VPWR _0063_ sky130_fd_sc_hd__a22o_1
X_4366_ _1164_ _1151_ VGND VGND VPWR VPWR _1165_ sky130_fd_sc_hd__nand2_1
X_3317_ _0158_ _0159_ VGND VGND VPWR VPWR _0160_ sky130_fd_sc_hd__xor2_1
X_4297_ net188 _1096_ _1097_ net265 VGND VGND VPWR VPWR _0056_ sky130_fd_sc_hd__a211oi_1
X_3248_ _2469_ _2470_ _2484_ VGND VGND VPWR VPWR _2486_ sky130_fd_sc_hd__and3_1
X_3179_ _2373_ _2376_ _2418_ VGND VGND VPWR VPWR _2419_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_8_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_484 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_270 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_63_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2550_ net107 _1792_ _1795_ VGND VGND VPWR VPWR _1797_ sky130_fd_sc_hd__or3_1
XFILLER_0_10_126 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4220_ _1035_ VGND VGND VPWR VPWR _0041_ sky130_fd_sc_hd__clkbuf_1
X_4151_ _0976_ _0972_ VGND VGND VPWR VPWR _0978_ sky130_fd_sc_hd__and2b_1
X_3102_ _2336_ _2343_ VGND VGND VPWR VPWR _2344_ sky130_fd_sc_hd__xnor2_2
X_4082_ _0909_ _0910_ VGND VGND VPWR VPWR _0911_ sky130_fd_sc_hd__and2b_1
X_3033_ _2229_ _2231_ VGND VGND VPWR VPWR _2277_ sky130_fd_sc_hd__nand2_1
XFILLER_0_77_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4984_ _1763_ _1764_ VGND VGND VPWR VPWR _1765_ sky130_fd_sc_hd__and2_1
X_3935_ _0731_ _0738_ _0767_ VGND VGND VPWR VPWR _0768_ sky130_fd_sc_hd__a21oi_1
X_3866_ _0633_ _0659_ _0700_ VGND VGND VPWR VPWR _0701_ sky130_fd_sc_hd__a21boi_2
XFILLER_0_61_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_82_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_432 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3797_ _0631_ _0632_ VGND VGND VPWR VPWR _0633_ sky130_fd_sc_hd__and2_1
X_2817_ net106 net102 VGND VGND VPWR VPWR _2064_ sky130_fd_sc_hd__or2_1
XFILLER_0_41_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2748_ _1963_ _1970_ VGND VGND VPWR VPWR _1995_ sky130_fd_sc_hd__xnor2_2
X_2679_ _1922_ _1924_ _1925_ VGND VGND VPWR VPWR _1926_ sky130_fd_sc_hd__a21oi_2
X_4418_ _1186_ _1190_ _1201_ _1203_ _1212_ VGND VGND VPWR VPWR _1213_ sky130_fd_sc_hd__a311o_1
X_4349_ slte0.opA\[1\] _1148_ VGND VGND VPWR VPWR _1149_ sky130_fd_sc_hd__xor2_1
XFILLER_0_68_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_76_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_7_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3720_ _0548_ _0549_ VGND VGND VPWR VPWR _0558_ sky130_fd_sc_hd__and2_1
XFILLER_0_55_332 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_15_218 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3651_ _0488_ VGND VGND VPWR VPWR _0489_ sky130_fd_sc_hd__inv_2
XFILLER_0_2_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3582_ _0382_ _0387_ _0419_ VGND VGND VPWR VPWR _0420_ sky130_fd_sc_hd__o21a_1
X_2602_ net93 net87 VGND VGND VPWR VPWR _1849_ sky130_fd_sc_hd__nand2_1
X_2533_ _1695_ _1715_ VGND VGND VPWR VPWR _1725_ sky130_fd_sc_hd__and2b_1
XFILLER_0_11_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4203_ _1022_ VGND VGND VPWR VPWR _1023_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_48_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4134_ _0958_ _0960_ VGND VGND VPWR VPWR _0961_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4065_ _0855_ _0856_ _0893_ VGND VGND VPWR VPWR _0894_ sky130_fd_sc_hd__a21o_1
XFILLER_0_3_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3016_ net86 _1813_ VGND VGND VPWR VPWR _2260_ sky130_fd_sc_hd__nor2_1
XFILLER_0_64_95 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4967_ _1728_ _1742_ VGND VGND VPWR VPWR _1748_ sky130_fd_sc_hd__and2_1
X_3918_ _0715_ _0751_ VGND VGND VPWR VPWR _0752_ sky130_fd_sc_hd__or2_1
X_4898_ _1637_ _1650_ _1649_ _1666_ VGND VGND VPWR VPWR _1678_ sky130_fd_sc_hd__or4_2
X_3849_ net124 net121 VGND VGND VPWR VPWR _0684_ sky130_fd_sc_hd__nand2_2
XFILLER_0_46_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout120 vec\[0\]\[16\] VGND VGND VPWR VPWR net120 sky130_fd_sc_hd__clkbuf_2
Xfanout131 vec\[0\]\[12\] VGND VGND VPWR VPWR net131 sky130_fd_sc_hd__buf_2
Xfanout142 net143 VGND VGND VPWR VPWR net142 sky130_fd_sc_hd__buf_4
Xfanout153 net154 VGND VGND VPWR VPWR net153 sky130_fd_sc_hd__clkbuf_4
Xfanout164 vec\[0\]\[1\] VGND VGND VPWR VPWR net164 sky130_fd_sc_hd__clkbuf_4
Xfanout197 net201 VGND VGND VPWR VPWR net197 sky130_fd_sc_hd__buf_4
Xfanout175 net176 VGND VGND VPWR VPWR net175 sky130_fd_sc_hd__buf_2
Xfanout186 net187 VGND VGND VPWR VPWR net186 sky130_fd_sc_hd__buf_4
XFILLER_0_69_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_84_405 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_54 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4821_ _1597_ _1598_ net107 _1168_ VGND VGND VPWR VPWR _0094_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_75_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4752_ _1509_ _1513_ _1524_ VGND VGND VPWR VPWR _1529_ sky130_fd_sc_hd__nor3_1
XFILLER_0_28_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4683_ _1457_ _1459_ VGND VGND VPWR VPWR _1460_ sky130_fd_sc_hd__xnor2_2
X_3703_ net166 net163 VGND VGND VPWR VPWR _0541_ sky130_fd_sc_hd__nand2_1
XFILLER_0_3_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3634_ _0469_ _0471_ VGND VGND VPWR VPWR _0472_ sky130_fd_sc_hd__xor2_1
XFILLER_0_43_368 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_176 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3565_ _0391_ _0401_ VGND VGND VPWR VPWR _0403_ sky130_fd_sc_hd__nor2_1
XFILLER_0_59_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2516_ net249 _1442_ _1532_ VGND VGND VPWR VPWR _0002_ sky130_fd_sc_hd__a21o_1
X_3496_ net159 net153 VGND VGND VPWR VPWR _0334_ sky130_fd_sc_hd__nand2_2
XFILLER_0_11_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_45_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4117_ _0910_ _0914_ _0909_ VGND VGND VPWR VPWR _0945_ sky130_fd_sc_hd__a21o_1
X_5097_ clknet_3_1__leaf_clk _0091_ net201 VGND VGND VPWR VPWR vec\[0\]\[17\] sky130_fd_sc_hd__dfrtp_1
X_4048_ _0874_ _0877_ VGND VGND VPWR VPWR _0878_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_427 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_66_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_460 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_354 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_74_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_276 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_65_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_25_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3350_ _0188_ _0189_ _0190_ VGND VGND VPWR VPWR _0016_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_0_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5020_ clknet_3_7__leaf_clk _0014_ net204 VGND VGND VPWR VPWR net39 sky130_fd_sc_hd__dfrtp_1
X_3281_ _2480_ _2483_ _2478_ VGND VGND VPWR VPWR _0125_ sky130_fd_sc_hd__a21o_1
XFILLER_0_17_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_30 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_75_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4804_ net110 _1576_ VGND VGND VPWR VPWR _1580_ sky130_fd_sc_hd__nand2_1
XFILLER_0_63_408 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2996_ _2148_ _2240_ VGND VGND VPWR VPWR _2241_ sky130_fd_sc_hd__xor2_1
X_4735_ _1488_ _1503_ _1511_ _1496_ VGND VGND VPWR VPWR _1513_ sky130_fd_sc_hd__o211a_1
XFILLER_0_71_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_16_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_43_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4666_ _1409_ _1426_ _1424_ _1439_ _1423_ VGND VGND VPWR VPWR _1443_ sky130_fd_sc_hd__a311o_2
X_3617_ _0382_ _0448_ VGND VGND VPWR VPWR _0455_ sky130_fd_sc_hd__xnor2_1
X_4597_ _1023_ _1305_ _1313_ _1375_ VGND VGND VPWR VPWR _1376_ sky130_fd_sc_hd__a22o_1
X_3548_ _0380_ _0385_ VGND VGND VPWR VPWR _0386_ sky130_fd_sc_hd__xor2_1
X_3479_ _0306_ _0315_ _0316_ VGND VGND VPWR VPWR _0317_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_39_438 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_66_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2850_ _1981_ net109 _2096_ VGND VGND VPWR VPWR _2097_ sky130_fd_sc_hd__or3_4
XFILLER_0_57_246 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_72_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2781_ _2027_ _2001_ VGND VGND VPWR VPWR _2028_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_13_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4520_ _1296_ _1297_ _1140_ slte0.opA\[17\] VGND VGND VPWR VPWR _1304_ sky130_fd_sc_hd__a31o_1
X_4451_ _1242_ VGND VGND VPWR VPWR _1243_ sky130_fd_sc_hd__inv_2
XFILLER_0_40_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3402_ _0200_ _0239_ VGND VGND VPWR VPWR _0240_ sky130_fd_sc_hd__xnor2_2
X_4382_ _1142_ VGND VGND VPWR VPWR _1179_ sky130_fd_sc_hd__clkbuf_4
X_3333_ _0173_ _0174_ VGND VGND VPWR VPWR _0175_ sky130_fd_sc_hd__xnor2_2
X_3264_ net167 _2500_ _2467_ _2199_ VGND VGND VPWR VPWR _2502_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_7_Right_7 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5003_ _1781_ _1780_ _1783_ _1482_ VGND VGND VPWR VPWR _1784_ sky130_fd_sc_hd__a31o_1
X_3195_ _2290_ _2363_ _2432_ _2434_ VGND VGND VPWR VPWR _2435_ sky130_fd_sc_hd__a31oi_4
XFILLER_0_48_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_343 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2979_ net65 net63 VGND VGND VPWR VPWR _2224_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4718_ net127 _1495_ VGND VGND VPWR VPWR _1496_ sky130_fd_sc_hd__or2_1
XFILLER_0_44_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4649_ _1397_ _1411_ _1412_ VGND VGND VPWR VPWR _1426_ sky130_fd_sc_hd__or3_1
XFILLER_0_12_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_35_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_50_488 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3951_ _0781_ _0783_ VGND VGND VPWR VPWR _0784_ sky130_fd_sc_hd__xor2_2
X_2902_ _2146_ _2147_ net104 VGND VGND VPWR VPWR _2148_ sky130_fd_sc_hd__o21ai_2
X_3882_ _0703_ _0706_ _0708_ VGND VGND VPWR VPWR _0716_ sky130_fd_sc_hd__a21bo_1
X_2833_ _2073_ _2079_ VGND VGND VPWR VPWR _2080_ sky130_fd_sc_hd__and2b_1
X_2764_ _1992_ _2010_ VGND VGND VPWR VPWR _2011_ sky130_fd_sc_hd__xor2_1
XFILLER_0_41_400 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4503_ _2196_ _1144_ _1272_ net170 VGND VGND VPWR VPWR _1289_ sky130_fd_sc_hd__o2bb2a_1
XFILLER_0_41_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2695_ net109 net103 VGND VGND VPWR VPWR _1942_ sky130_fd_sc_hd__and2_2
X_4434_ _1217_ _1226_ _1014_ VGND VGND VPWR VPWR _1228_ sky130_fd_sc_hd__o21a_1
X_4365_ slte0.opA\[1\] _1148_ VGND VGND VPWR VPWR _1164_ sky130_fd_sc_hd__nand2_1
X_3316_ _0110_ _0133_ net169 VGND VGND VPWR VPWR _0159_ sky130_fd_sc_hd__o21a_1
X_4296_ net188 _1095_ slte0.opA\[0\] VGND VGND VPWR VPWR _1097_ sky130_fd_sc_hd__a21oi_1
X_3247_ _2469_ _2470_ _2484_ VGND VGND VPWR VPWR _2485_ sky130_fd_sc_hd__a21oi_1
X_3178_ _2371_ _2377_ VGND VGND VPWR VPWR _2418_ sky130_fd_sc_hd__or2b_1
Xrebuffer10 net216 VGND VGND VPWR VPWR net217 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_341 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_51_219 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_32_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4150_ _0972_ _0976_ VGND VGND VPWR VPWR _0977_ sky130_fd_sc_hd__and2b_1
X_3101_ _2337_ _2342_ VGND VGND VPWR VPWR _2343_ sky130_fd_sc_hd__xnor2_2
X_4081_ _0756_ _0900_ _0908_ VGND VGND VPWR VPWR _0910_ sky130_fd_sc_hd__or3_1
X_3032_ _2263_ _2275_ VGND VGND VPWR VPWR _2276_ sky130_fd_sc_hd__xnor2_1
X_4983_ _1760_ _1762_ VGND VGND VPWR VPWR _1764_ sky130_fd_sc_hd__nand2_1
X_3934_ _0730_ _0726_ VGND VGND VPWR VPWR _0767_ sky130_fd_sc_hd__and2b_1
XFILLER_0_85_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3865_ _0655_ _0658_ VGND VGND VPWR VPWR _0700_ sky130_fd_sc_hd__nand2_1
XFILLER_0_5_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2816_ net106 net102 VGND VGND VPWR VPWR _2063_ sky130_fd_sc_hd__nand2_1
X_3796_ net154 _0630_ _0585_ VGND VGND VPWR VPWR _0632_ sky130_fd_sc_hd__or3_1
XFILLER_0_5_143 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_466 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2747_ _1991_ _1987_ VGND VGND VPWR VPWR _1994_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_75_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2678_ _1920_ _1921_ VGND VGND VPWR VPWR _1925_ sky130_fd_sc_hd__and2_1
XFILLER_0_14_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_41_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4417_ _1210_ _1211_ VGND VGND VPWR VPWR _1212_ sky130_fd_sc_hd__or2_1
XFILLER_0_1_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4348_ _1143_ _1147_ VGND VGND VPWR VPWR _1148_ sky130_fd_sc_hd__xnor2_1
X_4279_ _1080_ VGND VGND VPWR VPWR _0055_ sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_17_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_74_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3650_ net165 net163 net161 _0476_ VGND VGND VPWR VPWR _0488_ sky130_fd_sc_hd__and4_2
X_3581_ net165 net161 VGND VGND VPWR VPWR _0419_ sky130_fd_sc_hd__nand2_2
Xrebuffer1 _2083_ VGND VGND VPWR VPWR net208 sky130_fd_sc_hd__buf_1
X_2601_ _1794_ _1793_ VGND VGND VPWR VPWR _1848_ sky130_fd_sc_hd__xor2_2
X_2532_ _1675_ _1705_ VGND VGND VPWR VPWR _1715_ sky130_fd_sc_hd__nor2_1
XFILLER_0_23_252 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4202_ _1021_ VGND VGND VPWR VPWR _1022_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_48_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4133_ _0592_ _0959_ _0729_ VGND VGND VPWR VPWR _0960_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_3_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4064_ _0852_ _0886_ VGND VGND VPWR VPWR _0893_ sky130_fd_sc_hd__nand2_1
X_3015_ net80 net73 _2217_ _2258_ VGND VGND VPWR VPWR _2259_ sky130_fd_sc_hd__a31o_1
XFILLER_0_64_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_78_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4966_ _1295_ _1745_ _1747_ net68 _1431_ VGND VGND VPWR VPWR _0105_ sky130_fd_sc_hd__a32o_1
X_3917_ _0716_ _0750_ VGND VGND VPWR VPWR _0751_ sky130_fd_sc_hd__xor2_2
XFILLER_0_46_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4897_ net114 _1430_ _1432_ _1676_ VGND VGND VPWR VPWR _1677_ sky130_fd_sc_hd__a31o_1
X_3848_ _0677_ _0682_ VGND VGND VPWR VPWR _0683_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_61_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3779_ _0613_ _0615_ VGND VGND VPWR VPWR _0616_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_6_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xfanout121 net122 VGND VGND VPWR VPWR net121 sky130_fd_sc_hd__buf_2
Xfanout110 vec\[1\]\[1\] VGND VGND VPWR VPWR net110 sky130_fd_sc_hd__buf_4
Xfanout132 net134 VGND VGND VPWR VPWR net132 sky130_fd_sc_hd__buf_4
Xfanout143 vec\[0\]\[8\] VGND VGND VPWR VPWR net143 sky130_fd_sc_hd__clkbuf_4
Xfanout165 vec\[0\]\[0\] VGND VGND VPWR VPWR net165 sky130_fd_sc_hd__clkbuf_4
Xfanout154 net155 VGND VGND VPWR VPWR net154 sky130_fd_sc_hd__buf_4
Xfanout198 net200 VGND VGND VPWR VPWR net198 sky130_fd_sc_hd__clkbuf_4
Xfanout187 gm0.iter\[0\] VGND VGND VPWR VPWR net187 sky130_fd_sc_hd__clkbuf_4
Xfanout176 gm0.iter\[2\] VGND VGND VPWR VPWR net176 sky130_fd_sc_hd__buf_2
XFILLER_0_69_436 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_49_193 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_64_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4820_ _1580_ _1578_ _1596_ VGND VGND VPWR VPWR _1598_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_28_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4751_ _1526_ _1527_ _1528_ VGND VGND VPWR VPWR _0089_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_28_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_28_388 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4682_ _1218_ _1458_ VGND VGND VPWR VPWR _1459_ sky130_fd_sc_hd__nor2_1
X_3702_ _0538_ _0535_ _0537_ VGND VGND VPWR VPWR _0540_ sky130_fd_sc_hd__and3_1
XFILLER_0_55_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3633_ _0423_ _0470_ VGND VGND VPWR VPWR _0471_ sky130_fd_sc_hd__xnor2_1
X_3564_ _0391_ _0401_ VGND VGND VPWR VPWR _0402_ sky130_fd_sc_hd__xor2_1
XFILLER_0_11_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2515_ net251 _1442_ _1532_ VGND VGND VPWR VPWR _0001_ sky130_fd_sc_hd__a21o_1
X_3495_ net154 net148 _0331_ _0332_ VGND VGND VPWR VPWR _0333_ sky130_fd_sc_hd__a31o_1
XFILLER_0_75_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4116_ _0939_ _0943_ VGND VGND VPWR VPWR _0944_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_38_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5096_ clknet_3_0__leaf_clk _0090_ net201 VGND VGND VPWR VPWR vec\[0\]\[16\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_78_211 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4047_ net137 _0876_ VGND VGND VPWR VPWR _0877_ sky130_fd_sc_hd__xor2_1
XFILLER_0_81_409 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4949_ _1728_ _1729_ VGND VGND VPWR VPWR _1730_ sky130_fd_sc_hd__and2_1
XFILLER_0_19_377 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_314 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_49_Left_135 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_58_Left_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_67_Left_153 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_453 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_133 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3280_ _0120_ _0123_ VGND VGND VPWR VPWR _0124_ sky130_fd_sc_hd__xnor2_2
XPHY_EDGE_ROW_76_Left_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_85_Left_171 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_75_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4803_ _1295_ _1578_ _1579_ net110 net266 VGND VGND VPWR VPWR _0093_ sky130_fd_sc_hd__a32o_1
X_2995_ _2237_ _2239_ VGND VGND VPWR VPWR _2240_ sky130_fd_sc_hd__xnor2_2
X_4734_ _1509_ _1510_ VGND VGND VPWR VPWR _1511_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_306 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4665_ net189 net143 _1492_ _1441_ VGND VGND VPWR VPWR _0082_ sky130_fd_sc_hd__o22a_1
XFILLER_0_71_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_9_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3616_ _0452_ _0453_ VGND VGND VPWR VPWR _0454_ sky130_fd_sc_hd__nor2_1
X_4596_ net177 _1023_ VGND VGND VPWR VPWR _1375_ sky130_fd_sc_hd__nor2_1
X_3547_ net164 _0339_ _0383_ _0384_ VGND VGND VPWR VPWR _0385_ sky130_fd_sc_hd__o22a_1
X_3478_ _0313_ _0314_ VGND VGND VPWR VPWR _0316_ sky130_fd_sc_hd__and2b_1
X_5079_ clknet_3_1__leaf_clk _0073_ net202 VGND VGND VPWR VPWR slte0.opA\[17\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_66_247 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_19_163 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_22_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_30_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_383 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_57_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2780_ _1988_ _1999_ VGND VGND VPWR VPWR _2027_ sky130_fd_sc_hd__nand2_1
XFILLER_0_31_78 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4450_ slte0.opA\[9\] _1240_ VGND VGND VPWR VPWR _1242_ sky130_fd_sc_hd__nor2_2
X_4381_ _1168_ slte0.opA\[3\] _1176_ _1178_ VGND VGND VPWR VPWR _0059_ sky130_fd_sc_hd__a22o_1
X_3401_ net150 net145 VGND VGND VPWR VPWR _0239_ sky130_fd_sc_hd__nand2_2
X_3332_ _0153_ _0156_ VGND VGND VPWR VPWR _0174_ sky130_fd_sc_hd__nor2_1
XFILLER_0_0_266 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3263_ net169 _2467_ _2500_ VGND VGND VPWR VPWR _2501_ sky130_fd_sc_hd__a21oi_1
X_3194_ _2401_ _2433_ _2432_ _2364_ _2398_ VGND VGND VPWR VPWR _2434_ sky130_fd_sc_hd__a221o_1
X_5002_ _1540_ _1782_ VGND VGND VPWR VPWR _1783_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_76_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_85 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_48_214 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_5__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_5__leaf_clk sky130_fd_sc_hd__clkbuf_16
X_2978_ net56 net59 VGND VGND VPWR VPWR _2223_ sky130_fd_sc_hd__nand2_2
X_4717_ _1493_ _1494_ VGND VGND VPWR VPWR _1495_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_16_188 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4648_ _1423_ _1424_ VGND VGND VPWR VPWR _1425_ sky130_fd_sc_hd__and2b_1
Xfanout1 _1560_ VGND VGND VPWR VPWR net265 sky130_fd_sc_hd__buf_4
XFILLER_0_31_147 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4579_ net89 net85 net81 net77 net186 net180 VGND VGND VPWR VPWR _1359_ sky130_fd_sc_hd__mux4_2
XFILLER_0_79_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_39_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_58_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3950_ _0674_ _0746_ _0782_ VGND VGND VPWR VPWR _0783_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_42_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2901_ _1799_ _1809_ VGND VGND VPWR VPWR _2147_ sky130_fd_sc_hd__and2_1
X_3881_ _0620_ net53 VGND VGND VPWR VPWR _0715_ sky130_fd_sc_hd__or2_1
X_2832_ _2077_ _2078_ VGND VGND VPWR VPWR _2079_ sky130_fd_sc_hd__xor2_1
X_2763_ _1993_ _2009_ VGND VGND VPWR VPWR _2010_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_369 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4502_ _1098_ _1287_ _1288_ net255 net266 VGND VGND VPWR VPWR _0070_ sky130_fd_sc_hd__a32o_1
X_2694_ _1913_ _1933_ VGND VGND VPWR VPWR _1941_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_41_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_13_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_6_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4433_ _1217_ _1226_ VGND VGND VPWR VPWR _1227_ sky130_fd_sc_hd__nand2_1
X_4364_ _1161_ _1162_ VGND VGND VPWR VPWR _1163_ sky130_fd_sc_hd__and2_1
X_3315_ _0156_ _0157_ VGND VGND VPWR VPWR _0158_ sky130_fd_sc_hd__nor2_1
X_4295_ slte0.opA\[0\] _1095_ VGND VGND VPWR VPWR _1096_ sky130_fd_sc_hd__and2_1
X_3246_ _2480_ _2483_ VGND VGND VPWR VPWR _2484_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_83_51 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3177_ _2414_ _2416_ VGND VGND VPWR VPWR _2417_ sky130_fd_sc_hd__xor2_1
Xrebuffer11 _2179_ VGND VGND VPWR VPWR net267 sky130_fd_sc_hd__dlymetal6s2s_1
XFILLER_0_83_73 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_36_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_17_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_44_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_364 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_35_294 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_37_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3100_ _2339_ _2341_ VGND VGND VPWR VPWR _2342_ sky130_fd_sc_hd__xnor2_2
X_4080_ _0756_ _0900_ _0908_ VGND VGND VPWR VPWR _0909_ sky130_fd_sc_hd__o21a_1
X_3031_ _2273_ _2274_ VGND VGND VPWR VPWR _2275_ sky130_fd_sc_hd__or2b_1
XFILLER_0_37_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_53_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4982_ _1760_ _1762_ VGND VGND VPWR VPWR _1763_ sky130_fd_sc_hd__or2_1
XFILLER_0_53_87 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3933_ _0758_ _0765_ VGND VGND VPWR VPWR _0766_ sky130_fd_sc_hd__xnor2_1
X_3864_ _0676_ _0698_ VGND VGND VPWR VPWR _0699_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_73_367 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2815_ net106 net108 VGND VGND VPWR VPWR _2062_ sky130_fd_sc_hd__nand2b_1
X_3795_ _0630_ _0585_ net154 VGND VGND VPWR VPWR _0631_ sky130_fd_sc_hd__o21ai_4
X_2746_ _1960_ _1973_ VGND VGND VPWR VPWR _1993_ sky130_fd_sc_hd__xor2_1
XFILLER_0_5_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2677_ _1746_ _1923_ VGND VGND VPWR VPWR _1924_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_68_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4416_ slte0.opA\[6\] _1209_ VGND VGND VPWR VPWR _1211_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_21_Left_107 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4347_ _1025_ _1144_ _1146_ _1085_ _1092_ VGND VGND VPWR VPWR _1147_ sky130_fd_sc_hd__a2111o_1
X_4278_ net9 domain\[1\] _1442_ VGND VGND VPWR VPWR _1080_ sky130_fd_sc_hd__mux2_1
X_3229_ _2369_ _2403_ _2439_ _2465_ VGND VGND VPWR VPWR _2467_ sky130_fd_sc_hd__or4_4
XFILLER_0_64_301 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XPHY_EDGE_ROW_30_Left_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_483 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_109 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_82_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2600_ _1810_ _1846_ VGND VGND VPWR VPWR _1847_ sky130_fd_sc_hd__xor2_2
Xrebuffer2 _1960_ VGND VGND VPWR VPWR net209 sky130_fd_sc_hd__clkbuf_1
X_3580_ net166 net159 _0388_ VGND VGND VPWR VPWR _0418_ sky130_fd_sc_hd__and3_1
X_2531_ _1613_ _1664_ VGND VGND VPWR VPWR _1705_ sky130_fd_sc_hd__nor2_1
XFILLER_0_2_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4201_ net175 VGND VGND VPWR VPWR _1021_ sky130_fd_sc_hd__inv_2
X_4132_ net118 _0687_ _0936_ VGND VGND VPWR VPWR _0959_ sky130_fd_sc_hd__a21oi_1
X_4063_ _0791_ _0826_ _0858_ _0889_ VGND VGND VPWR VPWR _0892_ sky130_fd_sc_hd__or4_4
X_3014_ net75 _2161_ VGND VGND VPWR VPWR _2258_ sky130_fd_sc_hd__nor2_1
XFILLER_0_64_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4965_ _1743_ _1744_ _1728_ _1735_ VGND VGND VPWR VPWR _1747_ sky130_fd_sc_hd__o211ai_1
X_3916_ _0747_ _0749_ VGND VGND VPWR VPWR _0750_ sky130_fd_sc_hd__xnor2_2
X_4896_ net173 _1415_ _1545_ _1548_ _1083_ VGND VGND VPWR VPWR _1676_ sky130_fd_sc_hd__a32o_1
XFILLER_0_6_431 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3847_ _0679_ _0681_ VGND VGND VPWR VPWR _0682_ sky130_fd_sc_hd__xnor2_2
X_3778_ _0215_ _0327_ _0614_ VGND VGND VPWR VPWR _0615_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_61_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2729_ _1959_ _1975_ VGND VGND VPWR VPWR _1976_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_14_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_14_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout122 net123 VGND VGND VPWR VPWR net122 sky130_fd_sc_hd__buf_4
Xfanout111 vec\[1\]\[0\] VGND VGND VPWR VPWR net111 sky130_fd_sc_hd__clkbuf_4
Xfanout100 net101 VGND VGND VPWR VPWR net100 sky130_fd_sc_hd__buf_6
Xfanout133 net134 VGND VGND VPWR VPWR net133 sky130_fd_sc_hd__buf_2
Xfanout144 vec\[0\]\[7\] VGND VGND VPWR VPWR net144 sky130_fd_sc_hd__buf_4
Xfanout155 vec\[0\]\[4\] VGND VGND VPWR VPWR net155 sky130_fd_sc_hd__clkbuf_2
Xfanout188 net190 VGND VGND VPWR VPWR net188 sky130_fd_sc_hd__clkbuf_4
Xfanout199 net200 VGND VGND VPWR VPWR net199 sky130_fd_sc_hd__clkbuf_4
Xfanout166 vec\[0\]\[0\] VGND VGND VPWR VPWR net166 sky130_fd_sc_hd__dlymetal6s2s_1
Xfanout177 net181 VGND VGND VPWR VPWR net177 sky130_fd_sc_hd__clkbuf_4
XPHY_EDGE_ROW_29_Right_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_84_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_64_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_64_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_38_Right_38 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_19 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_47_Right_47 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_34_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_239 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4750_ net188 net122 VGND VGND VPWR VPWR _1528_ sky130_fd_sc_hd__nor2_1
XFILLER_0_50_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_56_Right_56 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4681_ _1434_ _1445_ _1444_ VGND VGND VPWR VPWR _1458_ sky130_fd_sc_hd__nor3_1
X_3701_ _0535_ _0537_ _0538_ VGND VGND VPWR VPWR _0539_ sky130_fd_sc_hd__a21oi_1
X_3632_ _0424_ _0435_ VGND VGND VPWR VPWR _0470_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_3_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3563_ _0392_ _0399_ _0400_ VGND VGND VPWR VPWR _0401_ sky130_fd_sc_hd__o21ba_1
X_2514_ _1522_ VGND VGND VPWR VPWR _1532_ sky130_fd_sc_hd__buf_4
XFILLER_0_3_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3494_ net151 _0330_ VGND VGND VPWR VPWR _0332_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_65_Right_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4115_ _0941_ _0942_ VGND VGND VPWR VPWR _0943_ sky130_fd_sc_hd__and2_1
X_5095_ clknet_3_1__leaf_clk _0089_ net197 VGND VGND VPWR VPWR vec\[0\]\[15\] sky130_fd_sc_hd__dfstp_1
X_4046_ _0831_ _0833_ _0875_ VGND VGND VPWR VPWR _0876_ sky130_fd_sc_hd__o21ai_1
XPHY_EDGE_ROW_74_Right_74 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_19_312 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_481 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4948_ net71 _1727_ VGND VGND VPWR VPWR _1729_ sky130_fd_sc_hd__or2_1
X_4879_ _1629_ _1642_ _1641_ _1658_ VGND VGND VPWR VPWR _1659_ sky130_fd_sc_hd__o31a_1
XFILLER_0_6_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_42_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_83_Right_83 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_212 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_57_418 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_289 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_209 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2994_ _2150_ net267 _2238_ VGND VGND VPWR VPWR _2239_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_28_120 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4802_ _1981_ _1554_ _1577_ VGND VGND VPWR VPWR _1579_ sky130_fd_sc_hd__o21ai_1
X_4733_ net125 _1508_ VGND VGND VPWR VPWR _1510_ sky130_fd_sc_hd__nor2_1
XFILLER_0_56_462 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_71_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4664_ _1439_ _1440_ VGND VGND VPWR VPWR _1441_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_24_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3615_ _0451_ _0449_ VGND VGND VPWR VPWR _0453_ sky130_fd_sc_hd__and2b_1
X_4595_ _1347_ _1348_ _1364_ VGND VGND VPWR VPWR _1374_ sky130_fd_sc_hd__and3_1
X_3546_ net156 _0334_ _0338_ _0199_ VGND VGND VPWR VPWR _0384_ sky130_fd_sc_hd__a31o_1
X_3477_ _0313_ _0314_ VGND VGND VPWR VPWR _0315_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_50_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5078_ clknet_3_1__leaf_clk _0072_ net202 VGND VGND VPWR VPWR slte0.opA\[16\] sky130_fd_sc_hd__dfrtp_4
X_4029_ _0858_ _0859_ VGND VGND VPWR VPWR _0860_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_47_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_443 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_495 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3400_ net141 _0234_ _0237_ VGND VGND VPWR VPWR _0238_ sky130_fd_sc_hd__o21ba_1
X_4380_ _1177_ _1175_ _1014_ VGND VGND VPWR VPWR _1178_ sky130_fd_sc_hd__o21a_1
X_3331_ _0171_ _0172_ VGND VGND VPWR VPWR _0173_ sky130_fd_sc_hd__and2b_1
XFILLER_0_21_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3262_ _2493_ _2499_ VGND VGND VPWR VPWR _2500_ sky130_fd_sc_hd__xnor2_2
X_3193_ _2399_ VGND VGND VPWR VPWR _2433_ sky130_fd_sc_hd__inv_2
X_5001_ _1763_ _1772_ _1272_ VGND VGND VPWR VPWR _1782_ sky130_fd_sc_hd__o21bai_1
XFILLER_0_72_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_259 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2977_ _2164_ _2165_ _2166_ _2162_ _2161_ VGND VGND VPWR VPWR _2222_ sky130_fd_sc_hd__o2111a_1
XFILLER_0_16_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_156 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4716_ _1481_ _1480_ _1272_ VGND VGND VPWR VPWR _1494_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_71_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_21_90 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4647_ net146 _1422_ VGND VGND VPWR VPWR _1424_ sky130_fd_sc_hd__nand2_1
Xfanout2 _1191_ VGND VGND VPWR VPWR net266 sky130_fd_sc_hd__clkbuf_4
X_4578_ net176 _1355_ _1357_ VGND VGND VPWR VPWR _1358_ sky130_fd_sc_hd__a21oi_1
X_3529_ _0364_ _0366_ VGND VGND VPWR VPWR _0367_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_30_170 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_26_13 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2900_ _1804_ _1808_ VGND VGND VPWR VPWR _2146_ sky130_fd_sc_hd__and2b_1
XFILLER_0_85_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3880_ _0710_ _0666_ _0625_ VGND VGND VPWR VPWR _0714_ sky130_fd_sc_hd__nor3b_1
X_2831_ _2017_ _2063_ VGND VGND VPWR VPWR _2078_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_5_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2762_ _1994_ _2007_ _2008_ VGND VGND VPWR VPWR _2009_ sky130_fd_sc_hd__a21oi_1
X_4501_ _1270_ _1285_ _1284_ _1277_ VGND VGND VPWR VPWR _1288_ sky130_fd_sc_hd__a211o_1
XFILLER_0_41_413 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_284 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2693_ _1894_ _1939_ VGND VGND VPWR VPWR _1940_ sky130_fd_sc_hd__xor2_2
XFILLER_0_13_148 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4432_ _1224_ _1225_ VGND VGND VPWR VPWR _1226_ sky130_fd_sc_hd__nor2_1
XFILLER_0_6_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4363_ slte0.opA\[2\] _1160_ VGND VGND VPWR VPWR _1162_ sky130_fd_sc_hd__or2_1
X_3314_ _0155_ _0137_ _0138_ VGND VGND VPWR VPWR _0157_ sky130_fd_sc_hd__and3_1
X_4294_ _1082_ _1085_ _1094_ VGND VGND VPWR VPWR _1095_ sky130_fd_sc_hd__or3_2
X_3245_ net76 _2482_ VGND VGND VPWR VPWR _2483_ sky130_fd_sc_hd__xor2_1
X_3176_ _2378_ _2382_ _2415_ net57 VGND VGND VPWR VPWR _2416_ sky130_fd_sc_hd__a22o_1
Xrebuffer12 _1821_ VGND VGND VPWR VPWR net219 sky130_fd_sc_hd__buf_1
XFILLER_0_17_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_44_262 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_4_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_12_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_79_181 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_398 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_23_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_10_118 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3030_ _2226_ _2264_ _2272_ VGND VGND VPWR VPWR _2274_ sky130_fd_sc_hd__or3_1
XFILLER_0_53_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4981_ _1752_ _1761_ VGND VGND VPWR VPWR _1762_ sky130_fd_sc_hd__or2_1
X_3932_ _0759_ _0764_ VGND VGND VPWR VPWR _0765_ sky130_fd_sc_hd__xnor2_1
X_3863_ _0694_ _0697_ VGND VGND VPWR VPWR _0698_ sky130_fd_sc_hd__xor2_2
X_2814_ _2059_ _2060_ _2011_ _2040_ VGND VGND VPWR VPWR _2061_ sky130_fd_sc_hd__o22a_1
XFILLER_0_73_379 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3794_ _0553_ _0583_ VGND VGND VPWR VPWR _0630_ sky130_fd_sc_hd__and2b_1
X_2745_ _1987_ _1991_ VGND VGND VPWR VPWR _1992_ sky130_fd_sc_hd__and2b_1
X_2676_ net96 _1895_ _1896_ VGND VGND VPWR VPWR _1923_ sky130_fd_sc_hd__o21a_1
X_4415_ slte0.opA\[6\] _1209_ VGND VGND VPWR VPWR _1210_ sky130_fd_sc_hd__and2_1
X_4346_ _1018_ _1144_ _1145_ VGND VGND VPWR VPWR _1146_ sky130_fd_sc_hd__and3_1
X_4277_ _1079_ VGND VGND VPWR VPWR _0054_ sky130_fd_sc_hd__clkbuf_1
X_3228_ net237 _2143_ _2466_ _1532_ VGND VGND VPWR VPWR _0011_ sky130_fd_sc_hd__a22o_1
X_3159_ _2398_ _2399_ VGND VGND VPWR VPWR _2400_ sky130_fd_sc_hd__nor2_1
XFILLER_0_49_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_37_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_32_210 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer3 _1823_ VGND VGND VPWR VPWR net210 sky130_fd_sc_hd__clkbuf_1
X_2530_ net221 _1685_ net106 VGND VGND VPWR VPWR _1695_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_11_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4200_ _1019_ _1020_ VGND VGND VPWR VPWR _0036_ sky130_fd_sc_hd__nor2_1
XFILLER_0_48_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4131_ _0956_ _0957_ VGND VGND VPWR VPWR _0958_ sky130_fd_sc_hd__and2_1
X_4062_ _0890_ _0891_ net224 _2201_ VGND VGND VPWR VPWR _0027_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_3_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3013_ net83 _1801_ net90 VGND VGND VPWR VPWR _2257_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_3_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_19_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4964_ _1728_ _1735_ _1743_ _1744_ VGND VGND VPWR VPWR _1745_ sky130_fd_sc_hd__a211o_1
XFILLER_0_80_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3915_ _0631_ _0702_ _0748_ VGND VGND VPWR VPWR _0749_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_46_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_4895_ _1295_ _1673_ _1674_ net89 _1431_ VGND VGND VPWR VPWR _0099_ sky130_fd_sc_hd__a32o_1
X_3846_ net141 _0396_ _0680_ VGND VGND VPWR VPWR _0681_ sky130_fd_sc_hd__a21o_1
XFILLER_0_80_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3777_ _0302_ _0326_ VGND VGND VPWR VPWR _0614_ sky130_fd_sc_hd__or2_1
XFILLER_0_14_232 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2728_ net209 _1973_ _1974_ VGND VGND VPWR VPWR _1975_ sky130_fd_sc_hd__a21o_1
X_2659_ _1905_ VGND VGND VPWR VPWR _1906_ sky130_fd_sc_hd__buf_6
Xfanout112 net113 VGND VGND VPWR VPWR net112 sky130_fd_sc_hd__buf_4
Xfanout101 vec\[1\]\[4\] VGND VGND VPWR VPWR net101 sky130_fd_sc_hd__buf_6
X_4329_ _1107_ _1108_ _1110_ _1113_ VGND VGND VPWR VPWR _1129_ sky130_fd_sc_hd__o211a_1
Xfanout123 vec\[0\]\[15\] VGND VGND VPWR VPWR net123 sky130_fd_sc_hd__clkbuf_4
Xfanout134 vec\[0\]\[11\] VGND VGND VPWR VPWR net134 sky130_fd_sc_hd__buf_4
Xfanout145 net146 VGND VGND VPWR VPWR net145 sky130_fd_sc_hd__clkbuf_2
Xfanout156 net157 VGND VGND VPWR VPWR net156 sky130_fd_sc_hd__buf_4
Xfanout167 net168 VGND VGND VPWR VPWR net167 sky130_fd_sc_hd__clkbuf_4
Xfanout189 net190 VGND VGND VPWR VPWR net189 sky130_fd_sc_hd__clkbuf_4
Xfanout178 net181 VGND VGND VPWR VPWR net178 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_37_313 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_281 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_20_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_18_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_34_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3700_ _0494_ _0503_ VGND VGND VPWR VPWR _0538_ sky130_fd_sc_hd__xnor2_1
X_4680_ _0116_ _1219_ _1456_ VGND VGND VPWR VPWR _1457_ sky130_fd_sc_hd__o21ai_2
X_3631_ _0454_ _0467_ _0468_ VGND VGND VPWR VPWR _0469_ sky130_fd_sc_hd__a21o_1
XFILLER_0_70_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3562_ _0393_ _0398_ VGND VGND VPWR VPWR _0400_ sky130_fd_sc_hd__nor2_1
XFILLER_0_3_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2513_ _1512_ VGND VGND VPWR VPWR _1522_ sky130_fd_sc_hd__buf_4
XFILLER_0_59_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3493_ _0217_ _0330_ VGND VGND VPWR VPWR _0331_ sky130_fd_sc_hd__or2b_1
X_4114_ net129 _0756_ _0940_ VGND VGND VPWR VPWR _0942_ sky130_fd_sc_hd__or3_1
X_5094_ clknet_3_1__leaf_clk _0088_ net197 VGND VGND VPWR VPWR vec\[0\]\[14\] sky130_fd_sc_hd__dfstp_2
X_4045_ _0830_ _0834_ VGND VGND VPWR VPWR _0875_ sky130_fd_sc_hd__nand2_1
XFILLER_0_78_235 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_452 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4947_ net71 _1727_ VGND VGND VPWR VPWR _1728_ sky130_fd_sc_hd__nand2_1
XFILLER_0_74_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4878_ net98 _1639_ VGND VGND VPWR VPWR _1658_ sky130_fd_sc_hd__or2_1
XFILLER_0_61_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3829_ _0629_ _0664_ VGND VGND VPWR VPWR _0665_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_61_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_6_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_69_268 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_15 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_22 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2993_ _2176_ _2178_ VGND VGND VPWR VPWR _2238_ sky130_fd_sc_hd__and2_1
X_4801_ _1981_ _1554_ _1577_ VGND VGND VPWR VPWR _1578_ sky130_fd_sc_hd__or3_1
X_4732_ net124 _1508_ VGND VGND VPWR VPWR _1509_ sky130_fd_sc_hd__and2_1
XFILLER_0_71_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_23 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_16_349 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4663_ _1409_ _1426_ _1424_ _1423_ VGND VGND VPWR VPWR _1440_ sky130_fd_sc_hd__a31oi_1
XFILLER_0_43_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3614_ _0449_ _0451_ VGND VGND VPWR VPWR _0452_ sky130_fd_sc_hd__and2b_1
XFILLER_0_43_157 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4594_ _1369_ _1371_ _1367_ VGND VGND VPWR VPWR _1373_ sky130_fd_sc_hd__o21a_1
X_3545_ _0382_ _0339_ VGND VGND VPWR VPWR _0383_ sky130_fd_sc_hd__nor2_1
X_3476_ _0288_ _0290_ VGND VGND VPWR VPWR _0314_ sky130_fd_sc_hd__xor2_2
XFILLER_0_43_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5077_ clknet_3_1__leaf_clk _0071_ net197 VGND VGND VPWR VPWR slte0.opA\[15\] sky130_fd_sc_hd__dfrtp_1
X_4028_ _0791_ _0826_ _0754_ VGND VGND VPWR VPWR _0859_ sky130_fd_sc_hd__o21ai_1
XFILLER_0_47_441 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_34_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_411 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_15_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_26 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_296 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3330_ _0147_ _0162_ _0170_ VGND VGND VPWR VPWR _0172_ sky130_fd_sc_hd__nand3_1
X_3261_ _2435_ _2494_ _2498_ VGND VGND VPWR VPWR _2499_ sky130_fd_sc_hd__o21ai_2
X_5000_ net61 _1774_ VGND VGND VPWR VPWR _1781_ sky130_fd_sc_hd__nand2_1
XFILLER_0_56_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3192_ _2362_ _2400_ VGND VGND VPWR VPWR _2432_ sky130_fd_sc_hd__and2_1
XFILLER_0_56_77 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2976_ _2219_ _2220_ VGND VGND VPWR VPWR _2221_ sky130_fd_sc_hd__nor2_1
X_4715_ net54 _1194_ _1389_ _1219_ VGND VGND VPWR VPWR _1493_ sky130_fd_sc_hd__a22o_1
XPHY_EDGE_ROW_12_Left_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4646_ net146 _1422_ VGND VGND VPWR VPWR _1423_ sky130_fd_sc_hd__nor2_1
XFILLER_0_44_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4577_ net176 _1356_ VGND VGND VPWR VPWR _1357_ sky130_fd_sc_hd__nor2_1
X_3528_ _0304_ _0365_ VGND VGND VPWR VPWR _0366_ sky130_fd_sc_hd__xnor2_1
X_3459_ _0268_ _0277_ VGND VGND VPWR VPWR _0297_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_79_385 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_271 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2830_ _2075_ _2076_ VGND VGND VPWR VPWR _2077_ sky130_fd_sc_hd__xor2_2
XFILLER_0_42_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2761_ _1995_ _2006_ VGND VGND VPWR VPWR _2008_ sky130_fd_sc_hd__nor2_1
X_2692_ _1911_ _1937_ _1938_ VGND VGND VPWR VPWR _1939_ sky130_fd_sc_hd__a21o_1
X_4500_ _1284_ _1286_ VGND VGND VPWR VPWR _1287_ sky130_fd_sc_hd__nand2_1
XANTENNA_1 net265 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_4431_ slte0.opA\[7\] _1222_ VGND VGND VPWR VPWR _1225_ sky130_fd_sc_hd__nor2_1
XFILLER_0_41_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4362_ slte0.opA\[2\] _1160_ VGND VGND VPWR VPWR _1161_ sky130_fd_sc_hd__nand2_1
X_3313_ _0137_ _0138_ _0155_ VGND VGND VPWR VPWR _0156_ sky130_fd_sc_hd__a21oi_2
XFILLER_0_67_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4293_ _1089_ _1092_ _1093_ VGND VGND VPWR VPWR _1094_ sky130_fd_sc_hd__or3_2
X_3244_ _2444_ _2445_ _2481_ VGND VGND VPWR VPWR _2482_ sky130_fd_sc_hd__o21ai_1
X_3175_ net60 _1826_ _2380_ VGND VGND VPWR VPWR _2415_ sky130_fd_sc_hd__a21boi_1
Xrebuffer13 net219 VGND VGND VPWR VPWR net220 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_76_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_8_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2959_ _2180_ _2182_ VGND VGND VPWR VPWR _2204_ sky130_fd_sc_hd__nor2_1
XFILLER_0_4_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4629_ _1392_ _1393_ VGND VGND VPWR VPWR _1406_ sky130_fd_sc_hd__nor2_1
XFILLER_0_67_300 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_244 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4980_ _1238_ _1750_ VGND VGND VPWR VPWR _1761_ sky130_fd_sc_hd__and2b_1
XFILLER_0_85_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3931_ _0761_ _0763_ VGND VGND VPWR VPWR _0764_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_58_355 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3862_ _0640_ _0695_ _0696_ VGND VGND VPWR VPWR _0697_ sky130_fd_sc_hd__a21o_1
X_2813_ _2018_ _2038_ VGND VGND VPWR VPWR _2060_ sky130_fd_sc_hd__xor2_1
X_3793_ _0230_ _0612_ _0628_ VGND VGND VPWR VPWR _0629_ sky130_fd_sc_hd__o21ai_2
XFILLER_0_5_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2744_ net106 net221 _1989_ _1990_ VGND VGND VPWR VPWR _1991_ sky130_fd_sc_hd__a31o_1
X_2675_ _1920_ _1921_ VGND VGND VPWR VPWR _1922_ sky130_fd_sc_hd__xor2_2
XFILLER_0_14_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_53 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4414_ _1197_ _1206_ _1208_ VGND VGND VPWR VPWR _1209_ sky130_fd_sc_hd__mux2_1
X_4345_ _1024_ net176 VGND VGND VPWR VPWR _1145_ sky130_fd_sc_hd__nor2_1
X_4276_ net191 domain\[0\] _1442_ VGND VGND VPWR VPWR _1079_ sky130_fd_sc_hd__mux2_1
X_3227_ _2440_ _2465_ VGND VGND VPWR VPWR _2466_ sky130_fd_sc_hd__xor2_1
X_3158_ _2370_ _2357_ _2397_ VGND VGND VPWR VPWR _2399_ sky130_fd_sc_hd__nor3_1
X_3089_ net168 _2294_ _2331_ VGND VGND VPWR VPWR _2332_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_76_152 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_76_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_76_130 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_70_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer4 _0483_ VGND VGND VPWR VPWR net211 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_11_439 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_2_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4130_ net126 _0865_ _0728_ VGND VGND VPWR VPWR _0957_ sky130_fd_sc_hd__or3_1
XFILLER_0_48_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4061_ _0754_ _0861_ _0889_ _2199_ VGND VGND VPWR VPWR _0891_ sky130_fd_sc_hd__a31o_1
XFILLER_0_64_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3012_ _2254_ _2255_ VGND VGND VPWR VPWR _2256_ sky130_fd_sc_hd__and2_1
X_4963_ net68 _1741_ VGND VGND VPWR VPWR _1744_ sky130_fd_sc_hd__nor2_1
X_3914_ _0699_ _0701_ VGND VGND VPWR VPWR _0748_ sky130_fd_sc_hd__or2_1
XFILLER_0_80_98 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_46_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4894_ _1655_ _1661_ _1672_ VGND VGND VPWR VPWR _1674_ sky130_fd_sc_hd__or3_1
X_3845_ net141 _0247_ VGND VGND VPWR VPWR _0680_ sky130_fd_sc_hd__nor2_1
X_3776_ _0230_ _0612_ VGND VGND VPWR VPWR _0613_ sky130_fd_sc_hd__xor2_2
XFILLER_0_6_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2727_ _1961_ _1972_ VGND VGND VPWR VPWR _1974_ sky130_fd_sc_hd__and2_1
XFILLER_0_73_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2658_ _1899_ _1904_ VGND VGND VPWR VPWR _1905_ sky130_fd_sc_hd__and2_4
Xfanout113 net117 VGND VGND VPWR VPWR net113 sky130_fd_sc_hd__clkbuf_2
Xfanout102 vec\[1\]\[3\] VGND VGND VPWR VPWR net102 sky130_fd_sc_hd__clkbuf_4
X_2589_ net71 net66 VGND VGND VPWR VPWR _1836_ sky130_fd_sc_hd__nand2_2
X_4328_ _1124_ _1126_ _1127_ VGND VGND VPWR VPWR _1128_ sky130_fd_sc_hd__a21o_1
Xfanout124 net125 VGND VGND VPWR VPWR net124 sky130_fd_sc_hd__buf_4
Xfanout135 net137 VGND VGND VPWR VPWR net135 sky130_fd_sc_hd__clkbuf_4
Xfanout146 vec\[0\]\[7\] VGND VGND VPWR VPWR net146 sky130_fd_sc_hd__clkbuf_4
Xfanout168 net169 VGND VGND VPWR VPWR net168 sky130_fd_sc_hd__clkbuf_2
X_4259_ slte0.opB\[12\] _1065_ _2141_ VGND VGND VPWR VPWR _1066_ sky130_fd_sc_hd__mux2_1
Xfanout157 net158 VGND VGND VPWR VPWR net157 sky130_fd_sc_hd__buf_2
Xfanout179 net181 VGND VGND VPWR VPWR net179 sky130_fd_sc_hd__clkbuf_4
XFILLER_0_69_428 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_185 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_339 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_60_361 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_0_Left_86 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_68_472 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_7_208 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_28_325 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_70_114 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3630_ _0466_ _0465_ VGND VGND VPWR VPWR _0468_ sky130_fd_sc_hd__and2b_1
X_3561_ _0393_ _0398_ VGND VGND VPWR VPWR _0399_ sky130_fd_sc_hd__xnor2_2
X_2512_ net188 net170 _1462_ _1472_ VGND VGND VPWR VPWR _1512_ sky130_fd_sc_hd__and4_1
XFILLER_0_59_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_11_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3492_ net144 net142 VGND VGND VPWR VPWR _0330_ sky130_fd_sc_hd__nand2_1
XFILLER_0_75_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4113_ _0756_ _0940_ net129 VGND VGND VPWR VPWR _0941_ sky130_fd_sc_hd__o21ai_1
X_5093_ clknet_3_3__leaf_clk _0087_ net197 VGND VGND VPWR VPWR vec\[0\]\[13\] sky130_fd_sc_hd__dfstp_1
X_4044_ _0871_ _0873_ VGND VGND VPWR VPWR _0874_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_78_269 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4946_ _1724_ _1726_ VGND VGND VPWR VPWR _1727_ sky130_fd_sc_hd__nor2_1
X_4877_ _1655_ _1656_ VGND VGND VPWR VPWR _1657_ sky130_fd_sc_hd__nor2_1
X_3828_ _0578_ _0663_ VGND VGND VPWR VPWR _0664_ sky130_fd_sc_hd__xor2_2
XFILLER_0_61_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3759_ _0592_ _0593_ _0594_ _0595_ VGND VGND VPWR VPWR _0596_ sky130_fd_sc_hd__a31o_1
XPHY_EDGE_ROW_18_Left_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XPHY_EDGE_ROW_27_Left_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_69_225 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_65_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_80_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_52_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_36_Left_122 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_52_158 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_501 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_60_180 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_45_Left_131 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_45_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4800_ net110 _1576_ VGND VGND VPWR VPWR _1577_ sky130_fd_sc_hd__xnor2_1
X_2992_ _2209_ _2236_ VGND VGND VPWR VPWR _2237_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_28_144 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4731_ _1505_ _1507_ VGND VGND VPWR VPWR _1508_ sky130_fd_sc_hd__xnor2_1
X_4662_ _1437_ _1438_ VGND VGND VPWR VPWR _1439_ sky130_fd_sc_hd__nand2_1
XPHY_EDGE_ROW_54_Left_140 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_9_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3613_ _0419_ _0450_ VGND VGND VPWR VPWR _0451_ sky130_fd_sc_hd__and2_1
XFILLER_0_71_489 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_233 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4593_ net190 net158 _1492_ _1372_ VGND VGND VPWR VPWR _0077_ sky130_fd_sc_hd__o22a_1
XFILLER_0_43_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_255 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_3_277 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3544_ _0381_ VGND VGND VPWR VPWR _0382_ sky130_fd_sc_hd__clkbuf_2
X_3475_ _0309_ _0311_ _0312_ VGND VGND VPWR VPWR _0313_ sky130_fd_sc_hd__a21oi_2
X_5076_ clknet_3_1__leaf_clk _0070_ net197 VGND VGND VPWR VPWR slte0.opA\[14\] sky130_fd_sc_hd__dfrtp_1
X_4027_ _0852_ _0857_ VGND VGND VPWR VPWR _0858_ sky130_fd_sc_hd__xor2_1
X_4929_ _1709_ _1707_ _1482_ VGND VGND VPWR VPWR _1710_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_47_497 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_15_350 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_30_320 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_397 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_57_228 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_25_125 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_445 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_53_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_258 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3260_ _2497_ VGND VGND VPWR VPWR _2498_ sky130_fd_sc_hd__inv_2
X_3191_ _2430_ VGND VGND VPWR VPWR _2431_ sky130_fd_sc_hd__inv_2
XFILLER_0_56_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_72_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_48_206 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_29_442 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2975_ net56 net59 VGND VGND VPWR VPWR _2220_ sky130_fd_sc_hd__xnor2_4
X_4714_ net188 net131 _1492_ _1491_ VGND VGND VPWR VPWR _0086_ sky130_fd_sc_hd__o22a_1
XFILLER_0_44_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4645_ _1418_ _1420_ VGND VGND VPWR VPWR _1422_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_31_139 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4576_ net76 net71 net69 net66 net182 net181 VGND VGND VPWR VPWR _1356_ sky130_fd_sc_hd__mux4_1
XFILLER_0_12_353 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3527_ _0317_ _0318_ VGND VGND VPWR VPWR _0365_ sky130_fd_sc_hd__xor2_1
X_3458_ _0285_ _0294_ _0295_ VGND VGND VPWR VPWR _0296_ sky130_fd_sc_hd__a21oi_1
X_3389_ net151 _0205_ net157 VGND VGND VPWR VPWR _0227_ sky130_fd_sc_hd__o21ai_2
X_5059_ clknet_3_1__leaf_clk _0053_ net196 VGND VGND VPWR VPWR slte0.opB\[15\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_35_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_35_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_62_275 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_448 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_389 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_38_272 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_5_317 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_53_231 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2760_ _1995_ _2006_ VGND VGND VPWR VPWR _2007_ sky130_fd_sc_hd__nand2_1
X_2691_ _1935_ _1936_ VGND VGND VPWR VPWR _1938_ sky130_fd_sc_hd__nor2_1
X_4430_ _1223_ VGND VGND VPWR VPWR _1224_ sky130_fd_sc_hd__inv_2
XANTENNA_2 net266 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_150 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4361_ _1154_ _1159_ VGND VGND VPWR VPWR _1160_ sky130_fd_sc_hd__xnor2_1
X_3312_ _0153_ _0154_ VGND VGND VPWR VPWR _0155_ sky130_fd_sc_hd__or2b_1
X_4292_ _1021_ _1083_ _1084_ VGND VGND VPWR VPWR _1093_ sky130_fd_sc_hd__and3_1
XFILLER_0_67_99 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3243_ _2442_ _2446_ VGND VGND VPWR VPWR _2481_ sky130_fd_sc_hd__nand2_1
XFILLER_0_83_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3174_ _2412_ _2413_ VGND VGND VPWR VPWR _2414_ sky130_fd_sc_hd__or2_1
XFILLER_0_83_65 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xrebuffer14 _2097_ VGND VGND VPWR VPWR net268 sky130_fd_sc_hd__dlygate4sd1_1
XFILLER_0_17_401 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2958_ _2187_ _2191_ _2185_ VGND VGND VPWR VPWR _2203_ sky130_fd_sc_hd__a21boi_1
XFILLER_0_17_456 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_17_467 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2889_ _2130_ _2131_ _2132_ _2135_ VGND VGND VPWR VPWR _2136_ sky130_fd_sc_hd__a31oi_1
X_4628_ net54 _1402_ _1404_ _1296_ VGND VGND VPWR VPWR _1405_ sky130_fd_sc_hd__a22o_1
XFILLER_0_44_286 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4559_ net77 net74 net72 net69 net186 net180 VGND VGND VPWR VPWR _1340_ sky130_fd_sc_hd__mux4_1
XFILLER_0_79_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_67_356 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_67_345 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_2_309 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput50 net50 VGND VGND VPWR VPWR sin[7] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_53_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3930_ _0762_ _0309_ net137 VGND VGND VPWR VPWR _0763_ sky130_fd_sc_hd__mux2_1
XFILLER_0_53_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_53_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3861_ _0651_ _0653_ VGND VGND VPWR VPWR _0696_ sky130_fd_sc_hd__nor2_1
XFILLER_0_85_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_73_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_3792_ _0609_ _0611_ VGND VGND VPWR VPWR _0628_ sky130_fd_sc_hd__or2_1
X_2812_ _2057_ _2058_ VGND VGND VPWR VPWR _2059_ sky130_fd_sc_hd__and2_1
X_2743_ net103 _1988_ VGND VGND VPWR VPWR _1990_ sky130_fd_sc_hd__nor2_1
XFILLER_0_5_169 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2674_ _1876_ _1878_ VGND VGND VPWR VPWR _1921_ sky130_fd_sc_hd__xor2_2
X_4413_ net178 _1207_ _1145_ _1155_ _1089_ VGND VGND VPWR VPWR _1208_ sky130_fd_sc_hd__a221o_1
X_4344_ net183 net170 VGND VGND VPWR VPWR _1144_ sky130_fd_sc_hd__nor2_1
X_4275_ _1078_ VGND VGND VPWR VPWR _0053_ sky130_fd_sc_hd__clkbuf_1
X_3226_ _2462_ _2464_ VGND VGND VPWR VPWR _2465_ sky130_fd_sc_hd__xor2_2
X_3157_ _2370_ _2357_ _2397_ VGND VGND VPWR VPWR _2398_ sky130_fd_sc_hd__o21a_1
X_3088_ _2295_ _2330_ VGND VGND VPWR VPWR _2331_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_76_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_475 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_234 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_13_492 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_23_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_67_197 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xrebuffer5 _0472_ VGND VGND VPWR VPWR net212 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_2_117 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4060_ _0754_ _0861_ _0889_ VGND VGND VPWR VPWR _0890_ sky130_fd_sc_hd__a21oi_1
X_3011_ net98 _2252_ _2253_ VGND VGND VPWR VPWR _2255_ sky130_fd_sc_hd__or3_1
XFILLER_0_64_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_80_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4962_ _1742_ VGND VGND VPWR VPWR _1743_ sky130_fd_sc_hd__inv_2
X_3913_ _0674_ _0746_ VGND VGND VPWR VPWR _0747_ sky130_fd_sc_hd__xor2_2
X_4893_ _1655_ _1661_ _1672_ VGND VGND VPWR VPWR _1673_ sky130_fd_sc_hd__o21ai_1
X_3844_ net137 net130 _0642_ _0678_ VGND VGND VPWR VPWR _0679_ sky130_fd_sc_hd__a31o_1
XFILLER_0_6_412 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3775_ _0609_ _0611_ VGND VGND VPWR VPWR _0612_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_54_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_2726_ _1961_ _1972_ VGND VGND VPWR VPWR _1973_ sky130_fd_sc_hd__xor2_1
X_2657_ net105 net100 VGND VGND VPWR VPWR _1904_ sky130_fd_sc_hd__or2_1
XFILLER_0_66_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_1_161 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
Xfanout103 vec\[1\]\[3\] VGND VGND VPWR VPWR net103 sky130_fd_sc_hd__buf_2
X_2588_ net68 net64 VGND VGND VPWR VPWR _1835_ sky130_fd_sc_hd__xor2_4
X_4327_ slte0.opB\[7\] _1109_ slte0.opB\[6\] _1125_ VGND VGND VPWR VPWR _1127_ sky130_fd_sc_hd__a22o_1
Xfanout136 net137 VGND VGND VPWR VPWR net136 sky130_fd_sc_hd__buf_4
Xfanout125 vec\[0\]\[14\] VGND VGND VPWR VPWR net125 sky130_fd_sc_hd__clkbuf_4
Xfanout147 net149 VGND VGND VPWR VPWR net147 sky130_fd_sc_hd__buf_4
Xfanout114 net115 VGND VGND VPWR VPWR net114 sky130_fd_sc_hd__buf_2
Xfanout169 domain\[1\] VGND VGND VPWR VPWR net169 sky130_fd_sc_hd__buf_2
X_4258_ net4 _1064_ VGND VGND VPWR VPWR _1065_ sky130_fd_sc_hd__xnor2_1
Xfanout158 vec\[0\]\[3\] VGND VGND VPWR VPWR net158 sky130_fd_sc_hd__clkbuf_2
X_3209_ _2219_ _2447_ VGND VGND VPWR VPWR _2448_ sky130_fd_sc_hd__nor2_1
X_4189_ net265 _1010_ _1011_ _1012_ VGND VGND VPWR VPWR _0033_ sky130_fd_sc_hd__a31o_1
XFILLER_0_49_142 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_77_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_49_164 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_37_337 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_45_381 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_248 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_16_Right_16 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_55_134 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_83_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_70_137 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3560_ _0395_ _0396_ _0397_ VGND VGND VPWR VPWR _0398_ sky130_fd_sc_hd__a21oi_2
XPHY_EDGE_ROW_25_Right_25 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_11_215 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_437 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2511_ _1442_ _1492_ VGND VGND VPWR VPWR _0000_ sky130_fd_sc_hd__nand2_1
XFILLER_0_51_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3491_ net165 VGND VGND VPWR VPWR _0329_ sky130_fd_sc_hd__inv_2
XFILLER_0_75_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4112_ _0901_ _0904_ VGND VGND VPWR VPWR _0940_ sky130_fd_sc_hd__nor2_1
X_5092_ clknet_3_3__leaf_clk _0086_ net197 VGND VGND VPWR VPWR vec\[0\]\[12\] sky130_fd_sc_hd__dfstp_1
XFILLER_0_75_66 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4043_ _0729_ _0872_ VGND VGND VPWR VPWR _0873_ sky130_fd_sc_hd__nor2_1
XPHY_EDGE_ROW_34_Right_34 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4945_ _1711_ _1723_ _1722_ _1218_ VGND VGND VPWR VPWR _1726_ sky130_fd_sc_hd__a211oi_1
XFILLER_0_59_473 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_74_421 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4876_ net95 _1653_ VGND VGND VPWR VPWR _1656_ sky130_fd_sc_hd__nor2_1
X_3827_ _0660_ _0662_ VGND VGND VPWR VPWR _0663_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_6_253 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_43_Right_43 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_6_264 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3758_ net119 net117 net121 VGND VGND VPWR VPWR _0595_ sky130_fd_sc_hd__and3b_1
XFILLER_0_42_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2709_ _1954_ _1955_ VGND VGND VPWR VPWR _1956_ sky130_fd_sc_hd__and2b_1
X_3689_ _0525_ _0526_ VGND VGND VPWR VPWR _0527_ sky130_fd_sc_hd__or2_1
XPHY_EDGE_ROW_52_Right_52 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_101 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_61_Right_61 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_37_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_429 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XPHY_EDGE_ROW_70_Right_70 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2991_ _2233_ _2235_ VGND VGND VPWR VPWR _2236_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_28_112 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_46 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_61_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4730_ _1493_ _1506_ _1238_ VGND VGND VPWR VPWR _1507_ sky130_fd_sc_hd__o21ba_1
X_4661_ net143 _1436_ VGND VGND VPWR VPWR _1438_ sky130_fd_sc_hd__or2_1
XFILLER_0_43_104 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_457 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3612_ net166 net160 VGND VGND VPWR VPWR _0450_ sky130_fd_sc_hd__or2_1
XFILLER_0_24_373 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4592_ _1369_ _1371_ VGND VGND VPWR VPWR _1372_ sky130_fd_sc_hd__xor2_1
X_3543_ net163 net156 VGND VGND VPWR VPWR _0381_ sky130_fd_sc_hd__and2_1
XFILLER_0_10_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3474_ net135 net130 _0307_ VGND VGND VPWR VPWR _0312_ sky130_fd_sc_hd__and3_1
X_5075_ clknet_3_1__leaf_clk _0069_ net197 VGND VGND VPWR VPWR slte0.opA\[13\] sky130_fd_sc_hd__dfrtp_1
X_4026_ _0855_ _0856_ VGND VGND VPWR VPWR _0857_ sky130_fd_sc_hd__nand2_1
XFILLER_0_47_465 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4928_ _1681_ _1688_ _1692_ _1693_ VGND VGND VPWR VPWR _1709_ sky130_fd_sc_hd__a31o_1
X_4859_ _1620_ _1624_ _1206_ VGND VGND VPWR VPWR _1638_ sky130_fd_sc_hd__a21o_1
XFILLER_0_62_435 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xclkbuf_3_0__f_clk clknet_0_clk VGND VGND VPWR VPWR clknet_3_0__leaf_clk sky130_fd_sc_hd__clkbuf_16
XFILLER_0_30_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_61_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_21_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3190_ _2427_ _2429_ VGND VGND VPWR VPWR _2430_ sky130_fd_sc_hd__xnor2_1
XFILLER_0_72_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2974_ net57 net63 VGND VGND VPWR VPWR _2219_ sky130_fd_sc_hd__nand2_1
XFILLER_0_8_304 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_8_359 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4713_ _1488_ _1490_ VGND VGND VPWR VPWR _1491_ sky130_fd_sc_hd__nor2_1
XFILLER_0_21_82 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4644_ _1206_ _1419_ VGND VGND VPWR VPWR _1420_ sky130_fd_sc_hd__or2_1
X_4575_ net54 _1084_ _1354_ _1018_ VGND VGND VPWR VPWR _1355_ sky130_fd_sc_hd__a22oi_2
X_3526_ _0361_ _0362_ _0363_ VGND VGND VPWR VPWR _0364_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_24_192 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_12_365 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_3457_ _0292_ _0293_ VGND VGND VPWR VPWR _0295_ sky130_fd_sc_hd__and2b_1
X_3388_ _0220_ _0225_ VGND VGND VPWR VPWR _0226_ sky130_fd_sc_hd__and2b_1
XPHY_EDGE_ROW_2_Right_2 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_5058_ clknet_3_1__leaf_clk _0052_ net196 VGND VGND VPWR VPWR slte0.opB\[14\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_79_321 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4009_ _0795_ _0798_ _0839_ VGND VGND VPWR VPWR _0840_ sky130_fd_sc_hd__o21a_1
XFILLER_0_67_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_1_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_47_240 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XPHY_EDGE_ROW_73_Left_159 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_30_162 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold50 slte0.opA\[12\] VGND VGND VPWR VPWR net257 sky130_fd_sc_hd__dlygate4sd3_1
XPHY_EDGE_ROW_82_Left_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_85_357 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_5_329 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2690_ _1935_ _1936_ VGND VGND VPWR VPWR _1937_ sky130_fd_sc_hd__xor2_2
XFILLER_0_13_129 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XANTENNA_3 net28 VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
XFILLER_0_41_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4360_ _1094_ _1158_ VGND VGND VPWR VPWR _1159_ sky130_fd_sc_hd__nor2_1
X_3311_ _0150_ _0152_ VGND VGND VPWR VPWR _0154_ sky130_fd_sc_hd__or2_1
X_4291_ _1087_ _1091_ VGND VGND VPWR VPWR _1092_ sky130_fd_sc_hd__nor2_1
X_3242_ _2478_ _2479_ VGND VGND VPWR VPWR _2480_ sky130_fd_sc_hd__nor2_1
X_3173_ _1820_ _2220_ _2411_ VGND VGND VPWR VPWR _2413_ sky130_fd_sc_hd__and3_1
XFILLER_0_83_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_16_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_13_6 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_49_505 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_29_273 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
X_2957_ _2139_ _2192_ VGND VGND VPWR VPWR _2202_ sky130_fd_sc_hd__or2_4
X_2888_ _1941_ _1978_ VGND VGND VPWR VPWR _2135_ sky130_fd_sc_hd__xor2_1
XFILLER_0_8_189 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_44_243 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_32_416 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4627_ _1145_ _1339_ _1403_ VGND VGND VPWR VPWR _1404_ sky130_fd_sc_hd__a21o_1
XFILLER_0_25_490 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4558_ net66 net64 net61 net55 net187 net177 VGND VGND VPWR VPWR _1339_ sky130_fd_sc_hd__mux4_2
X_3509_ net138 net134 VGND VGND VPWR VPWR _0347_ sky130_fd_sc_hd__nand2_2
X_4489_ _1196_ _1275_ slte0.opA\[13\] VGND VGND VPWR VPWR _1277_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_23_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_31_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xoutput40 net40 VGND VGND VPWR VPWR sin[12] sky130_fd_sc_hd__clkbuf_4
Xoutput51 net51 VGND VGND VPWR VPWR sin[8] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_302 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_85_121 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_165 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3860_ _0651_ _0653_ VGND VGND VPWR VPWR _0695_ sky130_fd_sc_hd__nand2_1
X_3791_ _0616_ _0618_ _0613_ _0615_ VGND VGND VPWR VPWR _0627_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_26_221 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2811_ _2020_ _2033_ VGND VGND VPWR VPWR _2058_ sky130_fd_sc_hd__xor2_2
X_2742_ _1685_ _1988_ VGND VGND VPWR VPWR _1989_ sky130_fd_sc_hd__or2b_1
XFILLER_0_81_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_78_11 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2673_ _1916_ _1918_ _1919_ VGND VGND VPWR VPWR _1920_ sky130_fd_sc_hd__a21o_1
X_4412_ net171 _2195_ VGND VGND VPWR VPWR _1207_ sky130_fd_sc_hd__nor2_1
X_4343_ _1142_ _1095_ VGND VGND VPWR VPWR _1143_ sky130_fd_sc_hd__or2b_1
X_4274_ slte0.opB\[15\] _1077_ _2141_ VGND VGND VPWR VPWR _1078_ sky130_fd_sc_hd__mux2_1
X_3225_ _2431_ _2435_ _2463_ VGND VGND VPWR VPWR _2464_ sky130_fd_sc_hd__o21ai_2
X_3156_ _2350_ _2396_ VGND VGND VPWR VPWR _2397_ sky130_fd_sc_hd__xor2_1
X_3087_ _2328_ _2329_ VGND VGND VPWR VPWR _2330_ sky130_fd_sc_hd__nor2_1
XFILLER_0_43_91 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3989_ _0792_ _0779_ _0820_ VGND VGND VPWR VPWR _0821_ sky130_fd_sc_hd__o21a_1
XFILLER_0_13_471 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_40_290 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_305 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_55_316 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_82_146 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
Xrebuffer6 _1623_ VGND VGND VPWR VPWR net213 sky130_fd_sc_hd__clkbuf_1
XFILLER_0_48_69 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_3_27 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3010_ _2252_ _2253_ net98 VGND VGND VPWR VPWR _2254_ sky130_fd_sc_hd__o21ai_2
X_4961_ net68 _1741_ VGND VGND VPWR VPWR _1742_ sky130_fd_sc_hd__nand2_1
XFILLER_0_58_110 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3912_ _0743_ _0745_ VGND VGND VPWR VPWR _0746_ sky130_fd_sc_hd__xnor2_2
X_4892_ _1670_ _1671_ VGND VGND VPWR VPWR _1672_ sky130_fd_sc_hd__nor2_1
XFILLER_0_73_113 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_3843_ net134 _0641_ VGND VGND VPWR VPWR _0678_ sky130_fd_sc_hd__nor2_1
XFILLER_0_13_94 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3774_ _0232_ _0301_ _0610_ VGND VGND VPWR VPWR _0611_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_54_360 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2725_ _1963_ _1970_ _1971_ VGND VGND VPWR VPWR _1972_ sky130_fd_sc_hd__a21o_1
XFILLER_0_14_224 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2656_ _1898_ _1902_ VGND VGND VPWR VPWR _1903_ sky130_fd_sc_hd__and2_1
X_2587_ _1803_ _1833_ VGND VGND VPWR VPWR _1834_ sky130_fd_sc_hd__nor2_1
Xfanout104 vec\[1\]\[3\] VGND VGND VPWR VPWR net104 sky130_fd_sc_hd__buf_2
XFILLER_0_59_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4326_ slte0.opB\[6\] _1125_ slte0.opB\[5\] _1122_ VGND VGND VPWR VPWR _1126_ sky130_fd_sc_hd__o22a_1
Xfanout126 net128 VGND VGND VPWR VPWR net126 sky130_fd_sc_hd__buf_4
Xfanout137 vec\[0\]\[10\] VGND VGND VPWR VPWR net137 sky130_fd_sc_hd__buf_4
Xfanout115 net116 VGND VGND VPWR VPWR net115 sky130_fd_sc_hd__clkbuf_2
X_4257_ _1057_ _1063_ VGND VGND VPWR VPWR _1064_ sky130_fd_sc_hd__nand2_1
Xfanout148 net149 VGND VGND VPWR VPWR net148 sky130_fd_sc_hd__clkbuf_4
Xfanout159 net161 VGND VGND VPWR VPWR net159 sky130_fd_sc_hd__buf_2
X_4188_ net24 _2142_ VGND VGND VPWR VPWR _1012_ sky130_fd_sc_hd__and2_1
X_3208_ _2442_ _2446_ VGND VGND VPWR VPWR _2447_ sky130_fd_sc_hd__xnor2_1
X_3139_ _2307_ _2308_ _2379_ VGND VGND VPWR VPWR _2380_ sky130_fd_sc_hd__o21a_1
XFILLER_0_77_430 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_295 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_64_168 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_45_393 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_20_216 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_60_396 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_0_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_83_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_68_485 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_50_37 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_70_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3490_ _0215_ _0327_ VGND VGND VPWR VPWR _0328_ sky130_fd_sc_hd__xor2_1
XFILLER_0_3_449 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2510_ _1482_ VGND VGND VPWR VPWR _1492_ sky130_fd_sc_hd__clkbuf_4
XFILLER_0_59_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_59_57 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4111_ _0937_ _0938_ VGND VGND VPWR VPWR _0939_ sky130_fd_sc_hd__nand2_1
X_5091_ clknet_3_4__leaf_clk _0085_ net199 VGND VGND VPWR VPWR vec\[0\]\[11\] sky130_fd_sc_hd__dfstp_1
X_4042_ _0835_ _0829_ VGND VGND VPWR VPWR _0872_ sky130_fd_sc_hd__and2b_1
XFILLER_0_78_227 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4944_ _1218_ _1722_ _1723_ _1711_ VGND VGND VPWR VPWR _1724_ sky130_fd_sc_hd__o211a_1
XFILLER_0_24_93 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4875_ net95 _1653_ VGND VGND VPWR VPWR _1655_ sky130_fd_sc_hd__and2_2
XFILLER_0_74_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3826_ _0580_ _0608_ _0661_ VGND VGND VPWR VPWR _0662_ sky130_fd_sc_hd__a21oi_2
X_3757_ net118 net112 VGND VGND VPWR VPWR _0594_ sky130_fd_sc_hd__or2b_2
XFILLER_0_61_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2708_ _1950_ _1946_ VGND VGND VPWR VPWR _1955_ sky130_fd_sc_hd__xnor2_2
X_3688_ net166 net163 VGND VGND VPWR VPWR _0526_ sky130_fd_sc_hd__and2b_1
X_2639_ _1884_ _1885_ VGND VGND VPWR VPWR _1886_ sky130_fd_sc_hd__xnor2_2
XFILLER_0_2_493 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4309_ slte0.opA\[7\] VGND VGND VPWR VPWR _1109_ sky130_fd_sc_hd__inv_2
XFILLER_0_4_81 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_65_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_25_308 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_80_469 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_20_29 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_33_374 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_61_14 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2990_ _2157_ _2175_ _2234_ VGND VGND VPWR VPWR _2235_ sky130_fd_sc_hd__o21ba_1
XFILLER_0_68_293 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_71_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4660_ net143 _1436_ VGND VGND VPWR VPWR _1437_ sky130_fd_sc_hd__nand2_2
XFILLER_0_56_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_9_48 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3611_ _0199_ _0446_ _0448_ _0447_ net159 VGND VGND VPWR VPWR _0449_ sky130_fd_sc_hd__o32a_1
XFILLER_0_43_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4591_ _1351_ _1352_ _1370_ VGND VGND VPWR VPWR _1371_ sky130_fd_sc_hd__a21oi_1
X_3542_ net154 _0378_ _0379_ _0206_ VGND VGND VPWR VPWR _0380_ sky130_fd_sc_hd__o22ai_2
XFILLER_0_51_160 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3473_ _0202_ _0310_ VGND VGND VPWR VPWR _0311_ sky130_fd_sc_hd__and2_1
X_5074_ clknet_3_1__leaf_clk _0068_ net197 VGND VGND VPWR VPWR slte0.opA\[12\] sky130_fd_sc_hd__dfrtp_1
X_4025_ _0670_ _0671_ _0750_ _0853_ _0707_ VGND VGND VPWR VPWR _0856_ sky130_fd_sc_hd__a2111o_1
XFILLER_0_19_124 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_47_433 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4927_ _1681_ _1688_ _1692_ _1693_ _1707_ VGND VGND VPWR VPWR _1708_ sky130_fd_sc_hd__a311o_1
XFILLER_0_34_116 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4858_ net116 _1387_ _1636_ VGND VGND VPWR VPWR _1637_ sky130_fd_sc_hd__a21o_1
XFILLER_0_51_80 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_62_403 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3809_ net119 net113 VGND VGND VPWR VPWR _0645_ sky130_fd_sc_hd__nand2_2
XFILLER_0_34_149 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_62_458 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4789_ net146 net143 net184 VGND VGND VPWR VPWR _1565_ sky130_fd_sc_hd__mux2_1
XFILLER_0_38_477 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_80_288 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_0_205 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_6
XFILLER_0_21_333 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_0_249 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
XFILLER_0_72_79 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_2973_ _1875_ _2217_ VGND VGND VPWR VPWR _2218_ sky130_fd_sc_hd__xnor2_2
X_4712_ _1486_ _1489_ VGND VGND VPWR VPWR _1490_ sky130_fd_sc_hd__and2_1
XFILLER_0_29_499 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
X_4643_ _1405_ _1406_ VGND VGND VPWR VPWR _1419_ sky130_fd_sc_hd__and2b_1
X_4574_ net64 net61 net187 VGND VGND VPWR VPWR _1354_ sky130_fd_sc_hd__mux2_1
X_3525_ _0359_ _0360_ VGND VGND VPWR VPWR _0363_ sky130_fd_sc_hd__nor2_1
X_3456_ _0292_ _0293_ VGND VGND VPWR VPWR _0294_ sky130_fd_sc_hd__xnor2_1
X_3387_ net147 net141 _0222_ _0224_ VGND VGND VPWR VPWR _0225_ sky130_fd_sc_hd__a31o_1
XFILLER_0_41_3 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_5057_ clknet_3_1__leaf_clk _0051_ net196 VGND VGND VPWR VPWR slte0.opB\[13\] sky130_fd_sc_hd__dfrtp_1
X_4008_ _0793_ _0799_ VGND VGND VPWR VPWR _0839_ sky130_fd_sc_hd__or2b_1
XFILLER_0_47_263 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_35_425 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
Xhold40 net41 VGND VGND VPWR VPWR net247 sky130_fd_sc_hd__dlygate4sd3_1
Xhold51 net45 VGND VGND VPWR VPWR net258 sky130_fd_sc_hd__dlygate4sd3_1
XANTENNA_4 clknet_3_6__leaf_clk VGND VGND VPWR VPWR sky130_fd_sc_hd__diode_2
X_3310_ _0150_ _0152_ VGND VGND VPWR VPWR _0153_ sky130_fd_sc_hd__and2_1
XFILLER_0_67_35 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4290_ net170 _1090_ VGND VGND VPWR VPWR _1091_ sky130_fd_sc_hd__or2_1
X_3241_ _2334_ _2448_ _2477_ VGND VGND VPWR VPWR _2479_ sky130_fd_sc_hd__nor3_1
X_3172_ _1820_ _2220_ _2411_ VGND VGND VPWR VPWR _2412_ sky130_fd_sc_hd__a21oi_1
XFILLER_0_8_102 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2956_ _2193_ _2200_ net260 _2201_ VGND VGND VPWR VPWR _0004_ sky130_fd_sc_hd__a2bb2o_1
XFILLER_0_32_71 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_2887_ _2011_ _2040_ _2061_ _2129_ _2133_ VGND VGND VPWR VPWR _2134_ sky130_fd_sc_hd__a221o_1
X_4626_ _1324_ _1340_ _1343_ _1462_ VGND VGND VPWR VPWR _1403_ sky130_fd_sc_hd__a22o_1
XFILLER_0_12_141 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4557_ net190 net164 _1492_ _1338_ VGND VGND VPWR VPWR _0075_ sky130_fd_sc_hd__o22a_1
X_3508_ net165 _0343_ VGND VGND VPWR VPWR _0346_ sky130_fd_sc_hd__xnor2_1
X_4488_ slte0.opA\[13\] _1196_ _1275_ VGND VGND VPWR VPWR _1276_ sky130_fd_sc_hd__and3_1
X_3439_ _0275_ _0276_ VGND VGND VPWR VPWR _0277_ sky130_fd_sc_hd__xnor2_1
X_5109_ clknet_3_5__leaf_clk _0103_ net203 VGND VGND VPWR VPWR vec\[1\]\[11\] sky130_fd_sc_hd__dfrtp_1
XFILLER_0_23_417 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
XFILLER_0_50_236 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_4
Xoutput41 net41 VGND VGND VPWR VPWR sin[13] sky130_fd_sc_hd__clkbuf_4
Xoutput52 net52 VGND VGND VPWR VPWR sin[9] sky130_fd_sc_hd__clkbuf_4
Xoutput30 net30 VGND VGND VPWR VPWR cos[5] sky130_fd_sc_hd__clkbuf_4
XFILLER_0_58_347 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_85_177 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_3790_ _0620_ _0625_ VGND VGND VPWR VPWR _0626_ sky130_fd_sc_hd__nor2_1
X_2810_ _2043_ _2044_ _2055_ _2056_ VGND VGND VPWR VPWR _2057_ sky130_fd_sc_hd__a31o_1
X_2741_ net96 net94 VGND VGND VPWR VPWR _1988_ sky130_fd_sc_hd__nand2_1
XFILLER_0_41_203 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_3
X_4411_ _1179_ VGND VGND VPWR VPWR _1206_ sky130_fd_sc_hd__clkbuf_4
X_2672_ net82 net75 _1915_ VGND VGND VPWR VPWR _1919_ sky130_fd_sc_hd__and3_1
XFILLER_0_78_45 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
XFILLER_0_22_461 VGND VGND VPWR VPWR sky130_fd_sc_hd__decap_8
X_4342_ slte0.opA\[16\] _1140_ _1141_ VGND VGND VPWR VPWR _1142_ sky130_fd_sc_hd__o21ai_4
X_4273_ net7 _1076_ VGND VGND VPWR VPWR _1077_ sky130_fd_sc_hd__xor2_1
X_3224_ _2429_ _2427_ VGND VGND VPWR VPWR _2463_ sky130_fd_sc_hd__or2b_1
.ends
